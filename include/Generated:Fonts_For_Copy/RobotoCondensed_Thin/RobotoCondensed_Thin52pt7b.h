#ifndef _ROBOTOCONDENSED_THIN52PT7B_H_
#define _ROBOTOCONDENSED_THIN52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin52pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0xA0, 0x00, 0x03, 0xC0, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC2, 0x85, 0x08, 0x00, 0x60, 0x10, 0x00,
  0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x40, 0x20, 0x00, 0x40, 0x20, 0x00,
  0x40, 0x20, 0x00, 0x40, 0x20, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00,
  0x80, 0x40, 0x00, 0x80, 0x40, 0x7F, 0xFF, 0xFF, 0x00, 0x80, 0x40, 0x01,
  0x80, 0x40, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x00, 0x80, 0x01,
  0x00, 0x80, 0x01, 0x00, 0x80, 0x01, 0x00, 0x80, 0x03, 0x01, 0x80, 0x03,
  0x01, 0x80, 0x02, 0x01, 0x00, 0x02, 0x01, 0x00, 0x02, 0x01, 0x00, 0xFF,
  0xFF, 0xFC, 0x06, 0x01, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x04,
  0x02, 0x00, 0x04, 0x02, 0x00, 0x04, 0x02, 0x00, 0x04, 0x02, 0x00, 0x0C,
  0x06, 0x00, 0x0C, 0x06, 0x00, 0x08, 0x04, 0x00, 0x08, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0xFF, 0x00, 0x60, 0x38, 0x18, 0x01, 0x86, 0x00, 0x10, 0x80,
  0x03, 0x10, 0x00, 0x26, 0x00, 0x06, 0xC0, 0x00, 0xD0, 0x00, 0x0A, 0x00,
  0x01, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x06, 0x80, 0x00, 0xD8, 0x00, 0x11, 0x00, 0x06, 0x30, 0x01,
  0x81, 0x80, 0x60, 0x1F, 0xF8, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x40, 0x20,
  0x00, 0x0C, 0x02, 0x00, 0x40, 0x80, 0x30, 0x0C, 0x08, 0x03, 0x00, 0x80,
  0x80, 0x30, 0x10, 0x08, 0x03, 0x03, 0x00, 0x80, 0x30, 0x20, 0x08, 0x03,
  0x06, 0x00, 0xC0, 0x20, 0x40, 0x04, 0x02, 0x0C, 0x00, 0x60, 0x60, 0x80,
  0x03, 0x0C, 0x18, 0x00, 0x1F, 0x81, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x08, 0x1F, 0x80, 0x01, 0x83, 0x0C, 0x00, 0x10, 0x60, 0x60,
  0x02, 0x04, 0x02, 0x00, 0x60, 0xC0, 0x30, 0x04, 0x0C, 0x03, 0x00, 0xC0,
  0x80, 0x10, 0x08, 0x08, 0x01, 0x01, 0x80, 0x80, 0x10, 0x10, 0x08, 0x01,
  0x03, 0x00, 0xC0, 0x30, 0x20, 0x0C, 0x03, 0x02, 0x00, 0x40, 0x20, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x18, 0x30, 0x00, 0x60, 0x30,
  0x00, 0x80, 0x20, 0x03, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x20, 0x00,
  0x80, 0xC0, 0x01, 0x83, 0x00, 0x01, 0x0C, 0x00, 0x03, 0x30, 0x00, 0x02,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x26, 0x00, 0x00, 0x84,
  0x00, 0x02, 0x0C, 0x00, 0x0C, 0x0C, 0x01, 0x10, 0x0C, 0x02, 0x40, 0x08,
  0x04, 0x80, 0x18, 0x1B, 0x00, 0x18, 0x34, 0x00, 0x18, 0x48, 0x00, 0x10,
  0x90, 0x00, 0x33, 0x20, 0x00, 0x34, 0x60, 0x00, 0x38, 0xC0, 0x00, 0x20,
  0x80, 0x00, 0xE1, 0x80, 0x03, 0x61, 0x80, 0x08, 0x41, 0xC0, 0x60, 0x40,
  0xFF, 0x80, 0xC0, 0x10, 0x00, 0x00, 0x55, 0x57, 0xF0, 0x00, 0x80, 0xC0,
  0xC0, 0x40, 0x40, 0x60, 0x20, 0x30, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x03,
  0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x30,
  0x18, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x00,
  0xC0, 0x20, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x80, 0x10, 0x02,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x08,
  0x03, 0x00, 0x40, 0x10, 0x04, 0x01, 0x80, 0x60, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03,
  0x00, 0x80, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x20, 0x10, 0x0C, 0x02,
  0x01, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x1E, 0x06, 0x07,
  0x78, 0x63, 0xC0, 0xF6, 0xE0, 0x01, 0xF8, 0x00, 0x06, 0x00, 0x00, 0xB0,
  0x00, 0x19, 0x80, 0x03, 0x0C, 0x00, 0x20, 0x40, 0x06, 0x06, 0x00, 0xC0,
  0x30, 0x08, 0x01, 0x81, 0x80, 0x08, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x03, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x11, 0x13, 0x33,
  0x36, 0x64, 0xFF, 0xC0, 0xDC, 0x00, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x38, 0x38, 0x0C, 0x01, 0x81, 0x00, 0x10, 0x60, 0x03, 0x08,
  0x00, 0x23, 0x00, 0x06, 0x40, 0x00, 0x48, 0x00, 0x09, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x34, 0x00, 0x06, 0x80, 0x00, 0x90, 0x00, 0x13, 0x00,
  0x06, 0x20, 0x00, 0x86, 0x00, 0x30, 0x40, 0x04, 0x0C, 0x01, 0x80, 0xE0,
  0x60, 0x07, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x60, 0x3C, 0x1D, 0x9C, 0x3E,
  0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x0C, 0x0E, 0x01, 0x00, 0x30, 0x20, 0x01, 0x86, 0x00, 0x08,
  0x40, 0x00, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0xC8, 0x00, 0x04, 0x80, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x30, 0x18, 0x0C, 0x01, 0x83, 0x00, 0x18, 0xC0, 0x01, 0x98, 0x00,
  0x32, 0x00, 0x02, 0xC0, 0x00, 0x58, 0x00, 0x0B, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x6C, 0x00, 0x08, 0x80, 0x03, 0x1C, 0x00, 0xC0, 0xC0, 0x70,
  0x0F, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x05, 0x80, 0x00, 0x26, 0x00, 0x01, 0x98,
  0x00, 0x04, 0x60, 0x00, 0x31, 0x80, 0x00, 0x86, 0x00, 0x06, 0x18, 0x00,
  0x10, 0x60, 0x00, 0xC1, 0x80, 0x06, 0x06, 0x00, 0x10, 0x18, 0x00, 0xC0,
  0x60, 0x02, 0x01, 0x80, 0x18, 0x06, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60,
  0x18, 0x01, 0x80, 0x60, 0x06, 0x03, 0x00, 0x18, 0x08, 0x00, 0x60, 0x60,
  0x01, 0x81, 0x00, 0x06, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x1F,
  0xFF, 0xC2, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0xFC, 0x01, 0x70,
  0xE0, 0x30, 0x07, 0x0C, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0xE0, 0x00, 0x34, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00,
  0x13, 0x00, 0x06, 0x20, 0x00, 0x86, 0x00, 0x30, 0x60, 0x0C, 0x06, 0x03,
  0x00, 0x7F, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x83, 0xF0, 0x11, 0xE3, 0x86, 0x60, 0x18, 0xD8, 0x01, 0x9E, 0x00,
  0x1B, 0x80, 0x01, 0x60, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x14, 0x00, 0x02, 0x80, 0x00, 0xD8, 0x00, 0x19, 0x00, 0x02, 0x30, 0x00,
  0xC2, 0x00, 0x30, 0x60, 0x04, 0x03, 0x03, 0x80, 0x3F, 0xC0, 0x00, 0x40,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x0C, 0x06, 0x01, 0x80, 0x30, 0x30, 0x01, 0x86, 0x00,
  0x0C, 0x60, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x64, 0x00, 0x06, 0xC0,
  0x00, 0x64, 0x00, 0x06, 0x40, 0x00, 0x64, 0x00, 0x04, 0x60, 0x00, 0x42,
  0x00, 0x08, 0x30, 0x01, 0x81, 0x80, 0x30, 0x07, 0x1E, 0x00, 0x3F, 0x80,
  0x0E, 0x06, 0x01, 0x80, 0x18, 0x20, 0x00, 0xC4, 0x00, 0x04, 0xC0, 0x00,
  0x68, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x02, 0xC0, 0x00, 0x24, 0x00, 0x06, 0x60,
  0x00, 0xC3, 0x00, 0x18, 0x1C, 0x07, 0x00, 0x7F, 0xC0, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x30, 0x38, 0x0C, 0x01, 0x83, 0x00, 0x18,
  0x40, 0x01, 0x18, 0x00, 0x32, 0x00, 0x06, 0xC0, 0x00, 0x50, 0x00, 0x0A,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x01, 0xA0, 0x00, 0x76,
  0x00, 0x0A, 0x40, 0x03, 0xCC, 0x00, 0xD8, 0xC0, 0x33, 0x0E, 0x1C, 0x60,
  0x7E, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0xFD, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFD, 0x00, 0x77, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x33, 0x33, 0x33, 0x26, 0x4C, 0x00, 0x00,
  0x40, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x07, 0xF0, 0x18, 0x18, 0x30,
  0x04, 0x20, 0x06, 0x60, 0x02, 0x40, 0x02, 0x40, 0x03, 0x40, 0x03, 0xC0,
  0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x03, 0x00, 0x00, 0x01, 0x00, 0x60, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00,
  0x41, 0x00, 0x07, 0xC0, 0x04, 0x30, 0x01, 0xC6, 0x00, 0x63, 0x00, 0x30,
  0x10, 0x02, 0x20, 0x06, 0x01, 0x80, 0x26, 0x00, 0x40, 0x18, 0x02, 0x60,
  0x08, 0x01, 0x80, 0x24, 0x00, 0x80, 0x10, 0x02, 0x40, 0x18, 0x01, 0x00,
  0x34, 0x01, 0x00, 0x10, 0x03, 0xC0, 0x10, 0x01, 0x00, 0x3C, 0x03, 0x00,
  0x10, 0x03, 0xC0, 0x30, 0x01, 0x00, 0x3C, 0x02, 0x00, 0x10, 0x03, 0xC0,
  0x20, 0x01, 0x00, 0x2C, 0x02, 0x00, 0x10, 0x02, 0xC0, 0x20, 0x01, 0x00,
  0x2C, 0x02, 0x00, 0x30, 0x02, 0xC0, 0x20, 0x03, 0x00, 0x6C, 0x02, 0x00,
  0x30, 0x04, 0xC0, 0x20, 0x07, 0x00, 0x44, 0x03, 0x00, 0x70, 0x0C, 0x40,
  0x10, 0x0D, 0x00, 0x84, 0x01, 0x01, 0x90, 0x18, 0x60, 0x08, 0x30, 0x83,
  0x06, 0x00, 0xFE, 0x07, 0xE0, 0x20, 0x01, 0x00, 0x10, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x05, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x01, 0x20, 0x00, 0x01, 0x10, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x42, 0x00,
  0x00, 0x61, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x10, 0x20, 0x00, 0x18, 0x10,
  0x00, 0x08, 0x08, 0x00, 0x04, 0x06, 0x00, 0x06, 0x01, 0x00, 0x02, 0x00,
  0x80, 0x01, 0x00, 0x60, 0x01, 0x80, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x60, 0x01, 0x00, 0x20, 0x00, 0x80, 0x10, 0x00, 0x60, 0x18,
  0x00, 0x10, 0x0C, 0x00, 0x08, 0x07, 0xFF, 0xFE, 0x06, 0x00, 0x01, 0x03,
  0x00, 0x00, 0x81, 0x00, 0x00, 0x60, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x08,
  0x40, 0x00, 0x04, 0x20, 0x00, 0x03, 0x30, 0x00, 0x00, 0x90, 0x00, 0x00,
  0x48, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x08, 0xFF, 0xF0, 0x08, 0x01, 0xC0,
  0x80, 0x03, 0x08, 0x00, 0x18, 0x80, 0x00, 0x88, 0x00, 0x0C, 0x80, 0x00,
  0x48, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00,
  0x04, 0x80, 0x00, 0x48, 0x00, 0x0C, 0x80, 0x00, 0x88, 0x00, 0x18, 0x80,
  0x03, 0x08, 0x01, 0xE0, 0xFF, 0xFC, 0x08, 0x00, 0x70, 0x80, 0x01, 0x88,
  0x00, 0x0C, 0x80, 0x00, 0x68, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x28, 0x00, 0x02, 0x80, 0x00, 0x68, 0x00, 0x0C, 0x80, 0x01, 0x88, 0x00,
  0xF0, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x60, 0x1C,
  0x06, 0x00, 0x18, 0x10, 0x00, 0x30, 0xC0, 0x00, 0x46, 0x00, 0x01, 0x90,
  0x00, 0x02, 0x40, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x34, 0x00, 0x00, 0xD0, 0x00, 0x02, 0x60, 0x00, 0x08, 0xC0,
  0x00, 0x41, 0x00, 0x03, 0x07, 0x00, 0x18, 0x06, 0x01, 0xC0, 0x0F, 0xFC,
  0x00, 0x02, 0x00, 0x00, 0xFF, 0xF0, 0x04, 0x00, 0xF0, 0x20, 0x00, 0xC1,
  0x00, 0x03, 0x08, 0x00, 0x0C, 0x40, 0x00, 0x32, 0x00, 0x00, 0xD0, 0x00,
  0x02, 0x80, 0x00, 0x14, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00,
  0x00, 0xD0, 0x00, 0x0C, 0x80, 0x00, 0xC4, 0x00, 0x0C, 0x20, 0x00, 0xC1,
  0x00, 0x7C, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x03, 0xFF, 0xFE, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF0, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x03, 0xFF, 0xFE, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1C, 0x03, 0x80, 0x60,
  0x01, 0x81, 0x80, 0x01, 0x86, 0x00, 0x01, 0x88, 0x00, 0x03, 0x30, 0x00,
  0x02, 0x40, 0x00, 0x06, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x28, 0x00, 0x00, 0x58, 0x00, 0x00, 0x90, 0x00, 0x01, 0x30, 0x00,
  0x02, 0x20, 0x00, 0x04, 0x60, 0x00, 0x38, 0x60, 0x00, 0xC0, 0x70, 0x07,
  0x00, 0x3F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x05, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00, 0x06, 0x60, 0x00,
  0x84, 0x00, 0x30, 0xC0, 0x0C, 0x0E, 0x03, 0x00, 0x7F, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x12, 0x00, 0x00, 0xC8, 0x00, 0x06, 0x20, 0x00, 0x30,
  0x80, 0x01, 0x82, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x20, 0x01, 0x80, 0x80,
  0x0C, 0x02, 0x00, 0x60, 0x08, 0x03, 0x00, 0x20, 0x18, 0x00, 0x80, 0x40,
  0x02, 0x03, 0x00, 0x08, 0x18, 0x00, 0x20, 0xC0, 0x00, 0x86, 0x00, 0x02,
  0x3C, 0x00, 0x08, 0x90, 0x00, 0x24, 0x20, 0x00, 0xA0, 0xC0, 0x03, 0x01,
  0x80, 0x08, 0x02, 0x00, 0x20, 0x0C, 0x00, 0x80, 0x18, 0x02, 0x00, 0x30,
  0x08, 0x00, 0x40, 0x20, 0x01, 0x80, 0x80, 0x03, 0x02, 0x00, 0x06, 0x08,
  0x00, 0x08, 0x20, 0x00, 0x30, 0x80, 0x00, 0x62, 0x00, 0x00, 0x88, 0x00,
  0x03, 0x20, 0x00, 0x06, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0F,
  0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x40, 0x00, 0x00, 0x5A, 0x00, 0x00, 0x02, 0xD8, 0x00, 0x00, 0x26,
  0x40, 0x00, 0x01, 0x32, 0x00, 0x00, 0x19, 0x98, 0x00, 0x00, 0x8C, 0x40,
  0x00, 0x04, 0x62, 0x00, 0x00, 0x63, 0x18, 0x00, 0x02, 0x18, 0x40, 0x00,
  0x10, 0xC3, 0x00, 0x01, 0x86, 0x08, 0x00, 0x08, 0x30, 0x40, 0x00, 0xC1,
  0x83, 0x00, 0x04, 0x0C, 0x08, 0x00, 0x20, 0x60, 0x40, 0x03, 0x03, 0x03,
  0x00, 0x10, 0x18, 0x08, 0x00, 0x80, 0xC0, 0x60, 0x0C, 0x06, 0x01, 0x00,
  0x40, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x01, 0x01, 0x00,
  0x60, 0x08, 0x18, 0x03, 0x00, 0x60, 0x80, 0x18, 0x01, 0x04, 0x00, 0xC0,
  0x08, 0x60, 0x06, 0x00, 0x62, 0x00, 0x30, 0x01, 0x10, 0x01, 0x80, 0x0D,
  0x80, 0x0C, 0x00, 0x28, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x80, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x68, 0x00, 0x01, 0xB0, 0x00, 0x06, 0x40, 0x00, 0x19, 0x80, 0x00,
  0x63, 0x00, 0x01, 0x84, 0x00, 0x06, 0x18, 0x00, 0x18, 0x20, 0x00, 0x60,
  0xC0, 0x01, 0x81, 0x00, 0x06, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x10,
  0x01, 0x80, 0x60, 0x06, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x04, 0x01,
  0x80, 0x08, 0x06, 0x00, 0x30, 0x18, 0x00, 0x40, 0x60, 0x01, 0x81, 0x80,
  0x02, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x60, 0x00, 0x21, 0x80, 0x00,
  0xC6, 0x00, 0x01, 0x18, 0x00, 0x06, 0x60, 0x00, 0x09, 0x80, 0x00, 0x16,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x38, 0x07, 0x00, 0xC0, 0x03, 0x03, 0x00,
  0x03, 0x04, 0x00, 0x03, 0x18, 0x00, 0x02, 0x20, 0x00, 0x06, 0xC0, 0x00,
  0x05, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xB0, 0x00, 0x01, 0x20, 0x00, 0x06, 0x60, 0x00, 0x08, 0x40, 0x00,
  0x30, 0xC0, 0x00, 0xC0, 0xC0, 0x03, 0x00, 0x60, 0x1C, 0x00, 0x7F, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0xFF, 0xF8, 0x08, 0x00, 0xF0, 0x80, 0x01, 0x88,
  0x00, 0x0C, 0x80, 0x00, 0x48, 0x00, 0x06, 0x80, 0x00, 0x28, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x28, 0x00, 0x06, 0x80, 0x00, 0x68, 0x00,
  0x0C, 0x80, 0x01, 0x88, 0x01, 0xF0, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0x00, 0xE0, 0x0C, 0x00,
  0x30, 0x18, 0x00, 0x18, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x20, 0x00,
  0x06, 0x60, 0x00, 0x02, 0x60, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00,
  0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00,
  0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x02, 0x60, 0x00, 0x02, 0x20, 0x00,
  0x06, 0x30, 0x00, 0x04, 0x10, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x0C, 0x00,
  0x30, 0x03, 0x00, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x18, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0xFF, 0xF8, 0x04, 0x00, 0x78, 0x20, 0x00, 0x61,
  0x00, 0x01, 0x88, 0x00, 0x04, 0x40, 0x00, 0x12, 0x00, 0x00, 0x90, 0x00,
  0x06, 0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00, 0x00, 0x28,
  0x00, 0x01, 0x40, 0x00, 0x1A, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80, 0x00,
  0x44, 0x00, 0x06, 0x20, 0x00, 0x61, 0x00, 0x1E, 0x0F, 0xFF, 0x80, 0x40,
  0x04, 0x02, 0x00, 0x30, 0x10, 0x00, 0x80, 0x80, 0x06, 0x04, 0x00, 0x10,
  0x20, 0x00, 0xC1, 0x00, 0x03, 0x08, 0x00, 0x18, 0x40, 0x00, 0x62, 0x00,
  0x01, 0x10, 0x00, 0x0C, 0x80, 0x00, 0x24, 0x00, 0x01, 0xA0, 0x00, 0x05,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0xE0, 0x1C, 0x06, 0x00, 0x18, 0x30, 0x00, 0x31, 0x80, 0x00, 0x44, 0x00,
  0x01, 0x90, 0x00, 0x02, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x09, 0x00, 0x00, 0x66, 0x00, 0x03, 0x0E, 0x00, 0x18, 0x0E, 0x01, 0xC0,
  0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x40, 0x00, 0x0D, 0x00, 0x00, 0x34, 0x00, 0x00, 0x98, 0x00,
  0x02, 0x20, 0x00, 0x18, 0xC0, 0x00, 0xC1, 0x80, 0x06, 0x03, 0x80, 0x70,
  0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0xA0, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x22, 0x00, 0x00, 0x31, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x08, 0x20, 0x00, 0x0C, 0x10, 0x00, 0x06, 0x0C, 0x00,
  0x02, 0x02, 0x00, 0x03, 0x01, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x80, 0x20,
  0x00, 0x40, 0x10, 0x00, 0x60, 0x0C, 0x00, 0x20, 0x06, 0x00, 0x10, 0x01,
  0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0x60, 0x04, 0x00, 0x10, 0x06, 0x00,
  0x08, 0x02, 0x00, 0x06, 0x01, 0x00, 0x01, 0x01, 0x80, 0x00, 0x80, 0x80,
  0x00, 0x60, 0x40, 0x00, 0x10, 0x60, 0x00, 0x08, 0x20, 0x00, 0x06, 0x10,
  0x00, 0x01, 0x08, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x64, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x05, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x14, 0x00, 0x06, 0x80, 0x00, 0xA0, 0x00, 0x24, 0x00, 0x05, 0x00,
  0x01, 0x20, 0x00, 0x6C, 0x00, 0x19, 0x80, 0x02, 0x20, 0x00, 0xCC, 0x00,
  0x11, 0x00, 0x04, 0x20, 0x00, 0x88, 0x00, 0x21, 0x00, 0x0C, 0x60, 0x03,
  0x0C, 0x00, 0x41, 0x00, 0x18, 0x60, 0x02, 0x08, 0x00, 0x81, 0x00, 0x10,
  0x40, 0x04, 0x08, 0x01, 0x83, 0x00, 0x20, 0x60, 0x08, 0x08, 0x03, 0x03,
  0x00, 0x40, 0x40, 0x18, 0x08, 0x06, 0x02, 0x00, 0x80, 0x40, 0x30, 0x18,
  0x04, 0x02, 0x01, 0x00, 0x40, 0x60, 0x18, 0x08, 0x02, 0x03, 0x00, 0xC0,
  0xC0, 0x10, 0x10, 0x02, 0x06, 0x00, 0xC0, 0x80, 0x10, 0x20, 0x02, 0x04,
  0x00, 0xC1, 0x00, 0x10, 0x60, 0x06, 0x18, 0x00, 0x83, 0x00, 0x10, 0xC0,
  0x06, 0x10, 0x00, 0x84, 0x00, 0x10, 0x80, 0x04, 0x20, 0x00, 0x8C, 0x00,
  0x33, 0x00, 0x06, 0x60, 0x00, 0x98, 0x00, 0x32, 0x00, 0x04, 0x80, 0x00,
  0x90, 0x00, 0x24, 0x00, 0x04, 0x80, 0x01, 0xE0, 0x00, 0x2C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x04,
  0x20, 0x00, 0x0C, 0x30, 0x00, 0x08, 0x10, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x0C, 0x00, 0x20, 0x04, 0x00, 0x60, 0x06, 0x00, 0x40, 0x02, 0x00, 0xC0,
  0x03, 0x00, 0x80, 0x01, 0x01, 0x00, 0x00, 0x83, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x64, 0x00, 0x00, 0x28, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x28, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x46, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0x83, 0x00, 0x01, 0x81, 0x00, 0x03, 0x01, 0x80,
  0x02, 0x00, 0xC0, 0x06, 0x00, 0x40, 0x04, 0x00, 0x60, 0x0C, 0x00, 0x20,
  0x18, 0x00, 0x30, 0x10, 0x00, 0x10, 0x30, 0x00, 0x18, 0x20, 0x00, 0x0C,
  0x60, 0x00, 0x04, 0x40, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x98, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x20, 0x60, 0x00, 0x30, 0x18, 0x00, 0x10, 0x04, 0x00,
  0x18, 0x03, 0x00, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x04, 0x00, 0x10,
  0x06, 0x00, 0x0C, 0x02, 0x00, 0x02, 0x03, 0x00, 0x01, 0x81, 0x00, 0x00,
  0x41, 0x80, 0x00, 0x30, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x06, 0x40, 0x00,
  0x01, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xFC,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0xFE, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x07, 0xFC, 0x01, 0x00, 0x07, 0x00, 0x0A, 0x00,
  0x14, 0x00, 0x6C, 0x00, 0x88, 0x03, 0x10, 0x04, 0x30, 0x08, 0x20, 0x30,
  0x40, 0x40, 0xC0, 0x80, 0x83, 0x01, 0x84, 0x01, 0x08, 0x02, 0x30, 0x06,
  0x40, 0x04, 0x80, 0x08, 0xFF, 0xFF, 0xE0, 0xC1, 0x86, 0x0C, 0x18, 0x20,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x01, 0x80, 0x60, 0xC0, 0x0C, 0x60, 0x01,
  0x10, 0x00, 0x6C, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0xFF, 0xE1, 0xE0, 0x08, 0xC0,
  0x02, 0x60, 0x00, 0xB0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00,
  0xA0, 0x00, 0x28, 0x00, 0x1A, 0x00, 0x0E, 0xC0, 0x02, 0x90, 0x03, 0x27,
  0x03, 0x88, 0x7F, 0x83, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x01, 0x00, 0x87, 0xFC,
  0x23, 0x01, 0x89, 0x00, 0x32, 0x80, 0x04, 0xE0, 0x01, 0xB0, 0x00, 0x2C,
  0x00, 0x0A, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xB0, 0x00, 0x2C,
  0x00, 0x1B, 0x80, 0x04, 0xB0, 0x03, 0x27, 0x01, 0x88, 0x7F, 0xC0, 0x01,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x01, 0x80, 0xE0, 0xC0, 0x0C, 0x60, 0x01,
  0x90, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0xF0, 0x00, 0x34, 0x00, 0x09, 0x00, 0x02, 0x60, 0x01, 0x8C, 0x00, 0xC1,
  0xC0, 0x60, 0x1F, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x07, 0xF8,
  0x47, 0x03, 0x93, 0x00, 0x34, 0x80, 0x05, 0x60, 0x00, 0xD0, 0x00, 0x34,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x40, 0x00, 0x50, 0x00, 0x16,
  0x00, 0x0C, 0x80, 0x07, 0x30, 0x03, 0x47, 0x01, 0x90, 0x7F, 0x84, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x7F, 0xC0, 0x38, 0x1C, 0x0C, 0x00, 0xC1, 0x00,
  0x0C, 0x40, 0x00, 0x98, 0x00, 0x13, 0x00, 0x03, 0x40, 0x00, 0x28, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x43, 0x00, 0x18, 0x38, 0x06, 0x01, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x7F, 0xF0, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x11, 0xC0, 0xE4, 0xC0, 0x0D,
  0x20, 0x01, 0x58, 0x00, 0x34, 0x00, 0x0D, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x50, 0x00, 0x14, 0x00, 0x0D, 0x80, 0x03, 0x20, 0x01, 0xCC,
  0x00, 0xD1, 0xC0, 0x64, 0x1F, 0xE1, 0x00, 0x80, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x22, 0x00, 0x08, 0xC0, 0x06,
  0x18, 0x03, 0x03, 0xC3, 0x80, 0x3F, 0x80, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x3F, 0xC4, 0x30,
  0x32, 0x20, 0x0D, 0x20, 0x02, 0xB0, 0x01, 0x50, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x7C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02,
  0x06, 0x06, 0x1C, 0xF0, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x34, 0x00, 0x32, 0x00, 0x31,
  0x00, 0x30, 0x80, 0x30, 0x40, 0x10, 0x20, 0x10, 0x10, 0x10, 0x08, 0x18,
  0x04, 0x18, 0x02, 0x18, 0x01, 0x18, 0x00, 0x9E, 0x00, 0x59, 0x00, 0x38,
  0xC0, 0x18, 0x30, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01, 0x81, 0x00, 0x60,
  0x80, 0x10, 0x40, 0x0C, 0x20, 0x03, 0x10, 0x00, 0xC8, 0x00, 0x24, 0x00,
  0x1A, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x40, 0x00, 0x40, 0x41, 0xFE, 0x03, 0xFC, 0x23, 0x01, 0x83,
  0x03, 0x13, 0x00, 0x42, 0x00, 0xC9, 0x00, 0x12, 0x00, 0x35, 0x00, 0x0B,
  0x00, 0x0B, 0x80, 0x07, 0x00, 0x05, 0x80, 0x03, 0x80, 0x02, 0xC0, 0x00,
  0x80, 0x01, 0xE0, 0x00, 0x40, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x70, 0x00,
  0x10, 0x00, 0x38, 0x00, 0x08, 0x00, 0x1C, 0x00, 0x04, 0x00, 0x0E, 0x00,
  0x02, 0x00, 0x07, 0x00, 0x01, 0x00, 0x03, 0x80, 0x00, 0x80, 0x01, 0xC0,
  0x00, 0x40, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x70, 0x00, 0x10, 0x00, 0x38,
  0x00, 0x08, 0x00, 0x1C, 0x00, 0x04, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x07,
  0x00, 0x01, 0x00, 0x03, 0x80, 0x00, 0x80, 0x01, 0xC0, 0x00, 0x40, 0x00,
  0xE0, 0x00, 0x20, 0x00, 0x70, 0x00, 0x10, 0x00, 0x30, 0x00, 0x00, 0x41,
  0xFE, 0x21, 0x81, 0x91, 0x00, 0x69, 0x00, 0x15, 0x80, 0x0A, 0x80, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x30, 0x18, 0x0C, 0x01, 0x83, 0x00, 0x18, 0xC0, 0x01, 0x98,
  0x00, 0x12, 0x00, 0x02, 0xC0, 0x00, 0x78, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x06, 0x80,
  0x00, 0x98, 0x00, 0x13, 0x00, 0x06, 0x30, 0x01, 0x83, 0x00, 0x60, 0x30,
  0x18, 0x03, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x00, 0x21, 0xFF, 0x09, 0xC0,
  0x62, 0xC0, 0x0C, 0xA0, 0x01, 0x30, 0x00, 0x6C, 0x00, 0x0B, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x06,
  0xE0, 0x01, 0x2C, 0x00, 0xC9, 0xC0, 0x62, 0x1F, 0xF0, 0x80, 0x40, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x11, 0xC0, 0xE4, 0xC0, 0x0D, 0x20, 0x01, 0x58, 0x00, 0x34,
  0x00, 0x0D, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x50, 0x00, 0x14,
  0x00, 0x05, 0x80, 0x03, 0x20, 0x01, 0xCC, 0x00, 0xD1, 0xC0, 0x64, 0x1F,
  0xE1, 0x00, 0x80, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x10, 0xFE, 0x30, 0x4C, 0x0B, 0x01, 0x40, 0x28, 0x06,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x0C, 0x03, 0x0C,
  0x00, 0xC4, 0x00, 0x36, 0x00, 0x0A, 0x00, 0x05, 0x80, 0x02, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x02, 0xC0, 0x01, 0x30, 0x01,
  0x0E, 0x03, 0x81, 0xFF, 0x00, 0x18, 0x00, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFF, 0xE0, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x03, 0xF0,
  0x04, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0D,
  0x00, 0x06, 0xC0, 0x05, 0x20, 0x06, 0x9C, 0x0E, 0x43, 0xFC, 0x20, 0x20,
  0x00, 0x40, 0x00, 0x34, 0x00, 0x02, 0x60, 0x00, 0x62, 0x00, 0x06, 0x20,
  0x00, 0x43, 0x00, 0x0C, 0x10, 0x00, 0xC1, 0x00, 0x08, 0x18, 0x01, 0x80,
  0x80, 0x18, 0x08, 0x01, 0x00, 0xC0, 0x30, 0x04, 0x03, 0x00, 0x40, 0x20,
  0x06, 0x06, 0x00, 0x20, 0x60, 0x02, 0x04, 0x00, 0x30, 0xC0, 0x01, 0x0C,
  0x00, 0x10, 0x80, 0x01, 0x98, 0x00, 0x09, 0x80, 0x00, 0x90, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00,
  0x0D, 0x00, 0x0C, 0x00, 0x34, 0x00, 0x30, 0x00, 0x98, 0x01, 0xE0, 0x06,
  0x60, 0x04, 0x80, 0x18, 0x80, 0x12, 0x00, 0x62, 0x00, 0x4C, 0x01, 0x0C,
  0x03, 0x30, 0x0C, 0x30, 0x08, 0x40, 0x30, 0x40, 0x21, 0x00, 0xC1, 0x00,
  0x86, 0x02, 0x06, 0x06, 0x18, 0x18, 0x18, 0x10, 0x20, 0x60, 0x20, 0x40,
  0x81, 0x80, 0x83, 0x03, 0x04, 0x03, 0x08, 0x04, 0x30, 0x0C, 0x20, 0x10,
  0xC0, 0x10, 0x80, 0x63, 0x00, 0x46, 0x01, 0x88, 0x01, 0x90, 0x02, 0x60,
  0x06, 0x40, 0x09, 0x80, 0x0B, 0x00, 0x36, 0x00, 0x2C, 0x00, 0x50, 0x00,
  0xA0, 0x01, 0x40, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0xC0, 0x00, 0xD8, 0x00, 0x62, 0x00, 0x10, 0xC0, 0x0C,
  0x10, 0x02, 0x06, 0x01, 0x80, 0xC0, 0xC0, 0x10, 0x20, 0x06, 0x18, 0x00,
  0xC4, 0x00, 0x12, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1E,
  0x00, 0x04, 0x80, 0x03, 0x30, 0x00, 0x86, 0x00, 0x40, 0x80, 0x30, 0x30,
  0x08, 0x04, 0x06, 0x01, 0x83, 0x00, 0x30, 0x80, 0x04, 0x60, 0x01, 0x90,
  0x00, 0x3C, 0x00, 0x0C, 0x40, 0x00, 0x34, 0x00, 0x02, 0x60, 0x00, 0x22,
  0x00, 0x06, 0x20, 0x00, 0x43, 0x00, 0x04, 0x10, 0x00, 0xC1, 0x00, 0x08,
  0x18, 0x00, 0x80, 0x80, 0x18, 0x08, 0x01, 0x00, 0xC0, 0x10, 0x04, 0x03,
  0x00, 0x40, 0x20, 0x06, 0x02, 0x00, 0x20, 0x60, 0x02, 0x04, 0x00, 0x30,
  0x40, 0x01, 0x0C, 0x00, 0x10, 0x80, 0x01, 0x88, 0x00, 0x09, 0x80, 0x00,
  0x90, 0x00, 0x0D, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x03, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x10, 0x03, 0x80,
  0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x18,
  0x07, 0x80, 0x38, 0x00, 0x60, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x07, 0x00, 0x70, 0x0C, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0xE0, 0x08, 0x00, 0x1F, 0x00, 0x00,
  0x63, 0x80, 0x05, 0x81, 0x80, 0x0A, 0x01, 0x80, 0x1C, 0x01, 0x80, 0x70,
  0x01, 0x80, 0xA0, 0x01, 0xC6, 0x00, 0x00, 0xF8,
};

const GFXglyph RobotoCondensed_Thin52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 2, 38, 10, 4, -37 },
  { 11, 7, 10, 13, 4, -39 },
  { 20, 24, 37, 25, 2, -37 },
  { 131, 19, 49, 25, 3, -43 },
  { 248, 28, 39, 34, 3, -38 },
  { 385, 23, 39, 28, 3, -38 },
  { 498, 2, 10, 9, 3, -39 },
  { 501, 9, 53, 14, 4, -41 },
  { 561, 10, 53, 15, 1, -41 },
  { 628, 20, 20, 22, 1, -37 },
  { 678, 22, 27, 26, 2, -31 },
  { 753, 4, 10, 10, 2, -4 },
  { 758, 10, 1, 14, 2, -17 },
  { 760, 3, 3, 11, 4, -2 },
  { 762, 15, 40, 18, 1, -37 },
  { 837, 19, 39, 25, 3, -38 },
  { 930, 11, 37, 25, 4, -37 },
  { 981, 20, 38, 25, 3, -38 },
  { 1076, 19, 39, 25, 3, -38 },
  { 1169, 22, 37, 25, 2, -37 },
  { 1271, 19, 38, 25, 4, -37 },
  { 1362, 19, 38, 25, 3, -37 },
  { 1453, 20, 37, 25, 2, -37 },
  { 1546, 20, 39, 25, 3, -38 },
  { 1644, 19, 38, 25, 3, -38 },
  { 1735, 3, 27, 9, 3, -26 },
  { 1746, 4, 32, 9, 2, -26 },
  { 1762, 18, 20, 24, 2, -27 },
  { 1807, 18, 11, 26, 4, -22 },
  { 1832, 18, 20, 24, 3, -27 },
  { 1877, 16, 39, 20, 2, -38 },
  { 1955, 36, 48, 42, 3, -36 },
  { 2171, 25, 37, 27, 1, -37 },
  { 2287, 20, 37, 28, 5, -37 },
  { 2380, 22, 39, 30, 4, -38 },
  { 2488, 21, 37, 30, 5, -37 },
  { 2586, 19, 37, 26, 5, -37 },
  { 2674, 19, 37, 26, 5, -37 },
  { 2762, 23, 39, 31, 4, -38 },
  { 2875, 22, 37, 32, 5, -37 },
  { 2977, 1, 37, 13, 6, -37 },
  { 2982, 19, 38, 25, 2, -37 },
  { 3073, 22, 37, 29, 5, -37 },
  { 3175, 17, 37, 24, 5, -37 },
  { 3254, 29, 37, 39, 5, -37 },
  { 3389, 22, 37, 32, 5, -37 },
  { 3491, 23, 39, 30, 4, -38 },
  { 3604, 20, 37, 28, 5, -37 },
  { 3697, 24, 45, 30, 3, -38 },
  { 3832, 21, 37, 30, 5, -37 },
  { 3930, 22, 39, 27, 3, -38 },
  { 4038, 24, 37, 27, 2, -37 },
  { 4149, 22, 38, 30, 4, -37 },
  { 4254, 25, 37, 27, 1, -37 },
  { 4370, 37, 37, 41, 2, -37 },
  { 4542, 24, 37, 27, 2, -37 },
  { 4653, 25, 37, 27, 1, -37 },
  { 4769, 23, 37, 27, 2, -37 },
  { 4876, 7, 50, 11, 4, -42 },
  { 4920, 14, 40, 18, 2, -37 },
  { 4990, 7, 50, 11, 0, -42 },
  { 5034, 15, 18, 19, 2, -37 },
  { 5068, 19, 1, 19, 0, 0 },
  { 5071, 6, 7, 14, 4, -39 },
  { 5077, 18, 29, 24, 3, -28 },
  { 5143, 18, 40, 25, 4, -39 },
  { 5233, 18, 29, 23, 3, -28 },
  { 5299, 18, 40, 25, 3, -39 },
  { 5389, 19, 29, 23, 2, -28 },
  { 5458, 13, 40, 15, 2, -40 },
  { 5523, 18, 39, 25, 3, -28 },
  { 5611, 17, 39, 25, 4, -39 },
  { 5694, 2, 37, 10, 4, -37 },
  { 5704, 8, 48, 11, -2, -37 },
  { 5752, 17, 39, 22, 4, -39 },
  { 5835, 2, 39, 10, 4, -39 },
  { 5845, 33, 28, 40, 4, -28 },
  { 5961, 17, 28, 25, 4, -28 },
  { 6021, 19, 29, 25, 3, -28 },
  { 6090, 18, 39, 25, 4, -28 },
  { 6178, 18, 39, 25, 3, -28 },
  { 6266, 11, 28, 16, 4, -28 },
  { 6305, 17, 29, 23, 3, -28 },
  { 6367, 12, 36, 15, 1, -35 },
  { 6421, 17, 28, 25, 4, -27 },
  { 6481, 20, 27, 22, 1, -27 },
  { 6549, 30, 27, 34, 2, -27 },
  { 6651, 18, 27, 22, 2, -27 },
  { 6712, 20, 38, 22, 1, -27 },
  { 6807, 19, 27, 22, 2, -27 },
  { 6872, 13, 52, 15, 2, -41 },
  { 6957, 1, 44, 10, 5, -37 },
  { 6963, 12, 52, 15, 1, -41 },
  { 7041, 23, 8, 31, 4, -19 },
};

const GFXfont RobotoCondensed_Thin52pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin52pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin52pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _ROBOTOCONDENSED_THIN52PT7B_H_
