#ifndef _ROBOTOCONDENSED_THIN16PT7B_H_
#define _ROBOTOCONDENSED_THIN16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x90, 0xB8, 0x24, 0x48, 0x93, 0xA2, 0x89, 0x12, 0x24, 0x78,
  0x91, 0x20, 0x00, 0x01, 0xE8, 0x61, 0x82, 0x06, 0x06, 0x04, 0x10, 0x61,
  0x78, 0x00, 0xE0, 0x49, 0x25, 0x12, 0x8E, 0x80, 0x40, 0x40, 0x2E, 0x24,
  0x92, 0x41, 0x20, 0xE0, 0x70, 0x91, 0x22, 0x45, 0x04, 0x18, 0x49, 0x8B,
  0x0A, 0x13, 0xD0, 0xE0, 0x29, 0x29, 0x24, 0x92, 0x48, 0x92, 0x20, 0x09,
  0x12, 0x49, 0x24, 0x92, 0x52, 0x00, 0x10, 0x21, 0xF0, 0x82, 0x88, 0x80,
  0x00, 0x82, 0x1E, 0x20, 0x82, 0x00, 0xE0, 0x40, 0x80, 0x08, 0x44, 0x21,
  0x10, 0x84, 0x22, 0x10, 0x80, 0x00, 0x72, 0x28, 0x61, 0x86, 0x18, 0x61,
  0x86, 0x18, 0x9C, 0x3D, 0x11, 0x11, 0x11, 0x11, 0x11, 0x72, 0x20, 0x41,
  0x08, 0x21, 0x04, 0x21, 0x04, 0x3E, 0x7A, 0x10, 0x41, 0x04, 0x60, 0x81,
  0x04, 0x18, 0x5E, 0x08, 0x61, 0x8A, 0x29, 0x24, 0xA2, 0xF8, 0x20, 0x82,
  0x79, 0x04, 0x10, 0x78, 0x10, 0x41, 0x06, 0x18, 0x5E, 0x31, 0x08, 0x20,
  0xFA, 0x18, 0x61, 0x86, 0x18, 0x5E, 0x7C, 0x10, 0x82, 0x08, 0x41, 0x04,
  0x20, 0x84, 0x10, 0x7A, 0x18, 0x61, 0x85, 0xE8, 0xA1, 0x86, 0x18, 0x5E,
  0x72, 0x28, 0x61, 0x86, 0x18, 0x5F, 0x04, 0x20, 0x9C, 0x81, 0x81, 0xC0,
  0x09, 0xB1, 0x83, 0x04, 0x78, 0x07, 0x80, 0x83, 0x06, 0x36, 0x40, 0x74,
  0x42, 0x10, 0x88, 0x84, 0x00, 0x00, 0x00, 0x1F, 0x84, 0x09, 0x01, 0x27,
  0x19, 0x03, 0x22, 0x64, 0x4C, 0x89, 0x91, 0x32, 0x46, 0x77, 0x40, 0x04,
  0x00, 0xC0, 0x07, 0x80, 0x08, 0x18, 0x14, 0x14, 0x24, 0x24, 0x22, 0x5E,
  0x42, 0x41, 0x41, 0x01, 0xF9, 0x0A, 0x14, 0x28, 0x57, 0x21, 0x41, 0x83,
  0x06, 0x15, 0xC0, 0x3C, 0x86, 0x0C, 0x08, 0x10, 0x20, 0x40, 0x81, 0x05,
  0x09, 0xE0, 0xB9, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x15,
  0xC0, 0xBA, 0x08, 0x20, 0x82, 0xE8, 0x20, 0x82, 0x08, 0x2E, 0xBA, 0x08,
  0x20, 0x82, 0xE8, 0x20, 0x82, 0x08, 0x20, 0x3C, 0x86, 0x04, 0x08, 0x10,
  0x21, 0xC0, 0x83, 0x05, 0x09, 0xE0, 0x81, 0x06, 0x0C, 0x18, 0x37, 0xE0,
  0xC1, 0x83, 0x06, 0x0C, 0x00, 0x7F, 0xE0, 0x00, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x62, 0xE0, 0x83, 0x0A, 0x24, 0x89, 0x14, 0x34, 0x48, 0x89, 0x0A,
  0x14, 0x10, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x2E, 0x80,
  0x70, 0x3C, 0x0E, 0x85, 0xA1, 0x68, 0x59, 0x26, 0x49, 0x92, 0x63, 0x18,
  0xC6, 0x21, 0x81, 0x86, 0x8D, 0x19, 0x32, 0x62, 0xC5, 0x87, 0x0E, 0x0C,
  0x10, 0x3C, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x05, 0x09, 0xE0,
  0xF9, 0x0A, 0x0C, 0x18, 0x30, 0xAE, 0x40, 0x81, 0x02, 0x04, 0x00, 0x3C,
  0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x05, 0x09, 0xE0, 0x40, 0x40,
  0xF9, 0x0A, 0x0C, 0x18, 0x30, 0xAE, 0x44, 0x85, 0x0A, 0x0C, 0x10, 0x79,
  0x0A, 0x04, 0x08, 0x0E, 0x02, 0x02, 0x02, 0x06, 0x0B, 0xE0, 0x7E, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x00, 0x81, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x05, 0x09, 0xE0, 0x01, 0x41, 0x41,
  0x42, 0x42, 0x22, 0x24, 0x24, 0x14, 0x18, 0x18, 0x08, 0x04, 0x31, 0x86,
  0x30, 0xC5, 0x18, 0xA5, 0x24, 0x94, 0x92, 0x8A, 0x51, 0x8C, 0x30, 0x82,
  0x10, 0x40, 0x83, 0x09, 0x12, 0x42, 0x82, 0x04, 0x14, 0x48, 0x8A, 0x10,
  0x10, 0x81, 0x41, 0x42, 0x22, 0x24, 0x14, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x00, 0x7A, 0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x40, 0x82, 0x03, 0xE0,
  0xAA, 0xAA, 0xAA, 0xA8, 0x08, 0x88, 0x44, 0x42, 0x22, 0x21, 0x10, 0x55,
  0x55, 0x55, 0x54, 0x46, 0x69, 0x91, 0x78, 0x90, 0x74, 0x42, 0x17, 0xC6,
  0x31, 0xF0, 0x82, 0x08, 0x3E, 0x86, 0x18, 0x61, 0x86, 0x18, 0x7E, 0x74,
  0x61, 0x08, 0x42, 0x11, 0x70, 0x00, 0x42, 0xF8, 0xC6, 0x31, 0x8C, 0x62,
  0xE0, 0x74, 0x63, 0xF8, 0x42, 0x10, 0x78, 0x74, 0x44, 0x44, 0x44, 0x44,
  0x40, 0x74, 0x63, 0x18, 0xC6, 0x31, 0x78, 0x42, 0xF0, 0x84, 0x21, 0x7C,
  0xC6, 0x31, 0x8C, 0x63, 0x00, 0x9F, 0xF0, 0x20, 0x12, 0x49, 0x24, 0x92,
  0x50, 0x82, 0x08, 0x22, 0x92, 0x8A, 0x30, 0xA2, 0x48, 0xA2, 0xFF, 0xF0,
  0xFB, 0xE1, 0x18, 0x46, 0x11, 0x84, 0x61, 0x18, 0x46, 0x11, 0x80, 0x00,
  0xBE, 0x63, 0x18, 0xC6, 0x31, 0x80, 0x7A, 0x18, 0x61, 0x86, 0x18, 0x61,
  0x78, 0xFA, 0x18, 0x61, 0x86, 0x18, 0x61, 0xFA, 0x08, 0x20, 0x74, 0x63,
  0x18, 0xC6, 0x31, 0x78, 0x42, 0x00, 0xE8, 0x88, 0x88, 0x88, 0x80, 0x74,
  0x61, 0x83, 0x04, 0x21, 0xF0, 0x04, 0x64, 0x44, 0x44, 0x44, 0x20, 0x84,
  0x63, 0x18, 0xC6, 0x31, 0x70, 0x01, 0x14, 0x51, 0x28, 0xA2, 0x8C, 0x10,
  0x08, 0xC4, 0x66, 0x52, 0xA9, 0x53, 0x29, 0x94, 0xC4, 0x02, 0x00, 0x45,
  0x12, 0x8C, 0x10, 0xA2, 0x91, 0x44, 0x01, 0x14, 0x51, 0x28, 0xA2, 0x84,
  0x10, 0x42, 0x08, 0x78, 0x44, 0x42, 0x21, 0x10, 0x70, 0x24, 0x44, 0x44,
  0x48, 0x04, 0x44, 0x44, 0x20, 0xFF, 0xFC, 0x04, 0x22, 0x22, 0x21, 0x22,
  0x22, 0x24, 0x80, 0x61, 0x26, 0x38,
};

const GFXglyph RobotoCondensed_Thin16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 12, 3, 1, -12 },
  { 3, 2, 3, 4, 1, -12 },
  { 4, 7, 12, 8, 1, -12 },
  { 15, 6, 14, 8, 1, -13 },
  { 26, 9, 12, 10, 1, -12 },
  { 40, 7, 12, 9, 1, -12 },
  { 51, 1, 3, 3, 1, -12 },
  { 52, 3, 17, 4, 1, -13 },
  { 59, 3, 17, 4, 0, -13 },
  { 66, 7, 6, 7, 0, -12 },
  { 72, 6, 8, 8, 1, -9 },
  { 78, 1, 3, 3, 1, -1 },
  { 79, 3, 1, 4, 1, -6 },
  { 80, 1, 1, 3, 1, -1 },
  { 81, 5, 13, 6, 0, -12 },
  { 90, 6, 12, 8, 1, -12 },
  { 99, 4, 12, 8, 1, -12 },
  { 105, 6, 12, 8, 1, -12 },
  { 114, 6, 12, 8, 1, -12 },
  { 123, 6, 12, 8, 1, -12 },
  { 132, 6, 12, 8, 1, -12 },
  { 141, 6, 12, 8, 1, -12 },
  { 150, 6, 12, 8, 1, -12 },
  { 159, 6, 12, 8, 1, -12 },
  { 168, 6, 12, 8, 1, -12 },
  { 177, 1, 8, 3, 1, -8 },
  { 178, 1, 10, 3, 1, -8 },
  { 180, 5, 6, 7, 1, -8 },
  { 184, 6, 3, 8, 1, -7 },
  { 187, 5, 6, 7, 1, -8 },
  { 191, 5, 12, 6, 1, -12 },
  { 199, 11, 15, 13, 1, -11 },
  { 220, 8, 12, 8, 0, -12 },
  { 232, 7, 12, 9, 1, -12 },
  { 243, 7, 12, 9, 1, -12 },
  { 254, 7, 12, 9, 1, -12 },
  { 265, 6, 12, 8, 1, -12 },
  { 274, 6, 12, 8, 1, -12 },
  { 283, 7, 12, 10, 1, -12 },
  { 294, 7, 12, 10, 1, -12 },
  { 305, 1, 12, 4, 1, -12 },
  { 307, 5, 12, 8, 1, -12 },
  { 315, 7, 12, 9, 1, -12 },
  { 326, 6, 12, 7, 1, -12 },
  { 335, 10, 12, 12, 1, -12 },
  { 350, 7, 12, 10, 1, -12 },
  { 361, 7, 12, 9, 1, -12 },
  { 372, 7, 12, 8, 1, -12 },
  { 383, 7, 14, 9, 1, -12 },
  { 396, 7, 12, 9, 1, -12 },
  { 407, 7, 12, 8, 1, -12 },
  { 418, 8, 12, 8, 0, -12 },
  { 430, 7, 12, 9, 1, -12 },
  { 441, 8, 12, 8, 0, -12 },
  { 453, 11, 12, 13, 1, -12 },
  { 470, 7, 12, 8, 1, -12 },
  { 481, 8, 12, 8, 0, -12 },
  { 493, 7, 12, 8, 1, -12 },
  { 504, 2, 15, 3, 1, -13 },
  { 508, 4, 13, 5, 1, -12 },
  { 515, 2, 15, 3, 0, -13 },
  { 519, 4, 6, 6, 1, -12 },
  { 522, 6, 1, 6, 0, 0 },
  { 523, 2, 2, 4, 1, -12 },
  { 524, 5, 9, 7, 1, -9 },
  { 530, 6, 12, 8, 1, -12 },
  { 539, 5, 9, 7, 1, -9 },
  { 545, 5, 12, 8, 1, -12 },
  { 553, 5, 9, 7, 1, -9 },
  { 559, 4, 12, 5, 1, -12 },
  { 565, 5, 12, 8, 1, -9 },
  { 573, 5, 12, 8, 1, -12 },
  { 581, 1, 12, 3, 1, -12 },
  { 583, 3, 15, 3, -1, -12 },
  { 589, 6, 12, 7, 1, -12 },
  { 598, 1, 12, 3, 1, -12 },
  { 600, 10, 9, 12, 1, -9 },
  { 612, 5, 9, 8, 1, -9 },
  { 618, 6, 9, 8, 1, -9 },
  { 625, 6, 12, 8, 1, -9 },
  { 634, 5, 12, 8, 1, -9 },
  { 642, 4, 9, 5, 1, -9 },
  { 647, 5, 9, 7, 1, -9 },
  { 653, 4, 11, 5, 0, -11 },
  { 659, 5, 9, 8, 1, -9 },
  { 665, 6, 9, 7, 0, -9 },
  { 672, 9, 9, 11, 1, -9 },
  { 683, 6, 9, 7, 0, -9 },
  { 690, 6, 12, 7, 0, -9 },
  { 699, 5, 9, 7, 1, -9 },
  { 705, 4, 15, 5, 1, -12 },
  { 713, 1, 14, 3, 1, -12 },
  { 715, 4, 15, 5, 0, -12 },
  { 723, 7, 3, 10, 1, -6 },
};

const GFXfont RobotoCondensed_Thin16pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin16pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin16pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _ROBOTOCONDENSED_THIN16PT7B_H_
