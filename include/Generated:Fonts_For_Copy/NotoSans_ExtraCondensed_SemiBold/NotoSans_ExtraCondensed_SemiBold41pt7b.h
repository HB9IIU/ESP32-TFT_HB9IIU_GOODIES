#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD41PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xDF, 0x7D, 0xF7, 0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x00, 0x00, 0x0C, 0x7F, 0xFF, 0xFF, 0x78, 0xF8,
  0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7D, 0xE3, 0xEF, 0x0F,
  0x78, 0x7B, 0xC3, 0x80, 0x03, 0x8F, 0x00, 0xE3, 0xC0, 0x38, 0xF0, 0x1E,
  0x38, 0x07, 0x8E, 0x01, 0xE3, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x3C, 0x70, 0x0F, 0x1C, 0x03, 0xC7, 0x00,
  0xE1, 0xC0, 0x38, 0xF0, 0x0E, 0x3C, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0x87, 0x0E, 0x01, 0xC3, 0x80, 0x71, 0xE0, 0x1C, 0x78,
  0x07, 0x1E, 0x01, 0xC7, 0x00, 0xF1, 0xC0, 0x3C, 0x70, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x7F, 0x81, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x7D,
  0x8C, 0xF3, 0x01, 0xE6, 0x03, 0xCC, 0x07, 0x98, 0x0F, 0xB0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x1B, 0xE0,
  0x33, 0xE0, 0x63, 0xC0, 0xC7, 0xC1, 0x9F, 0xC3, 0x3D, 0xFF, 0xFB, 0xFF,
  0xE7, 0xFF, 0x81, 0xFC, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xF8, 0x07, 0x80, 0x3F, 0xC0, 0x78, 0x07, 0xFC,
  0x07, 0x00, 0x79, 0xE0, 0xF0, 0x07, 0x1E, 0x0E, 0x00, 0x71, 0xE1, 0xE0,
  0x0F, 0x0E, 0x1E, 0x00, 0xF0, 0xE1, 0xC0, 0x0F, 0x0E, 0x3C, 0x00, 0xF0,
  0xE3, 0xC0, 0x0F, 0x0E, 0x38, 0x00, 0x71, 0xE7, 0x8F, 0x07, 0x1E, 0x71,
  0xF8, 0x79, 0xEF, 0x3F, 0xC7, 0xFC, 0xF3, 0xDE, 0x3F, 0xCE, 0x79, 0xE1,
  0xF9, 0xE7, 0x8E, 0x0E, 0x1E, 0x70, 0xE0, 0x01, 0xC7, 0x0F, 0x00, 0x3C,
  0x70, 0xF0, 0x03, 0x87, 0x0F, 0x00, 0x78, 0x70, 0xF0, 0x07, 0x87, 0x0E,
  0x00, 0x70, 0x78, 0xE0, 0x0F, 0x07, 0x9E, 0x00, 0xF0, 0x39, 0xE0, 0x0E,
  0x03, 0xFC, 0x01, 0xE0, 0x1F, 0xC0, 0x1C, 0x01, 0xF8, 0x01, 0xC0, 0x00,
  0x3F, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x1E,
  0x00, 0xF8, 0xF0, 0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xF3, 0xE0, 0x07,
  0x9E, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xFC, 0x3E, 0x3F, 0xE1, 0xF3, 0xEF, 0x8F, 0x1F, 0x3E, 0xF9, 0xF1,
  0xF7, 0xCF, 0x87, 0xFC, 0x7C, 0x1F, 0xE3, 0xE0, 0xFF, 0x1F, 0x03, 0xF0,
  0xF8, 0x1F, 0x87, 0xE1, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xBF, 0x07, 0xF0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFD, 0xEF, 0x7B, 0xC0, 0x07,
  0xC1, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1E, 0x07,
  0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x0F,
  0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0xF0, 0x1E, 0x03, 0xC0, 0xF0,
  0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x3C,
  0x1E, 0x0F, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x07, 0x38,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x1F, 0xC0, 0x7F, 0xC0,
  0xF7, 0xC7, 0xC7, 0xC7, 0x87, 0x02, 0x08, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x3E, 0x7C,
  0xF9, 0xE7, 0xCF, 0x9E, 0x3C, 0x79, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x31, 0xEF, 0xFF, 0xFD, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC,
  0x3E, 0x3E, 0x7C, 0x3E, 0x7C, 0x1E, 0x7C, 0x1E, 0x78, 0x1F, 0x78, 0x1F,
  0x78, 0x1F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x7C, 0x1E,
  0x7C, 0x3E, 0x7C, 0x3E, 0x3E, 0x3C, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8,
  0x07, 0xF0, 0x01, 0xF0, 0x3F, 0x07, 0xF0, 0xFF, 0x1F, 0xF3, 0xFF, 0x7D,
  0xFF, 0x9F, 0x71, 0xF2, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x03, 0xC0,
  0x1F, 0xF0, 0x3F, 0xF8, 0xFF, 0xFC, 0x7E, 0xFC, 0x30, 0x3E, 0x20, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80,
  0x3F, 0xF0, 0x7F, 0xF8, 0xFF, 0xFC, 0x7C, 0xFE, 0x30, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0xC0, 0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x07, 0x7C, 0x07, 0xBE, 0x03, 0x9F, 0x03, 0xCF, 0x81,
  0xC7, 0xC0, 0xE3, 0xE0, 0xF1, 0xF0, 0x70, 0xF8, 0x78, 0x7C, 0x38, 0x3E,
  0x3C, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xFF, 0x0F, 0xFF,
  0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0xC0, 0xFD, 0xFF,
  0xF3, 0xFF, 0xE7, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x38, 0x03, 0xFE, 0x07,
  0xFE, 0x0F, 0xFE, 0x1F, 0xC6, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0xF0, 0x7B, 0xF8, 0x7F, 0xFC, 0x7F,
  0xFE, 0xFE, 0x3E, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78,
  0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x7C, 0x1F, 0x7C, 0x1E, 0x3E, 0x3E, 0x3F,
  0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xFE, 0x7E, 0x3E, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x7C,
  0x1E, 0x3C, 0x3E, 0x3E, 0x7C, 0x1F, 0xFC, 0x0F, 0xF8, 0x07, 0xE0, 0x0F,
  0xF0, 0x1F, 0xF8, 0x3E, 0x7C, 0x7C, 0x3E, 0x78, 0x1F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0x7C, 0x1F, 0x7F, 0x7E, 0x3F,
  0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x03, 0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x7F, 0xFC, 0x7C, 0x3E, 0x78, 0x3E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x3F, 0x7E,
  0x7F, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xDF, 0x06, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xFC, 0x3F, 0xF8, 0x3F,
  0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7B, 0xFF, 0xFF, 0x78, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x31, 0xEF, 0xFF, 0xFD, 0xE0, 0x3C, 0xFD,
  0xFB, 0xF3, 0xC3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0xF9, 0xF3, 0xC7, 0x9F, 0x3E, 0x78, 0xF3, 0xC0, 0x00, 0x01,
  0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x80, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00,
  0x80, 0x00, 0x07, 0x00, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x7D, 0xF8, 0x81,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x01,
  0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0xF8, 0x07, 0xC0, 0xF0,
  0x01, 0xE0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x1C, 0x78, 0x1F, 0x0F, 0x3C,
  0x3F, 0xE3, 0x9C, 0x3F, 0xF1, 0xDE, 0x1E, 0x78, 0xFF, 0x1E, 0x3C, 0x7F,
  0x8F, 0x1E, 0x3F, 0x87, 0x0F, 0x1F, 0xC7, 0x87, 0x8F, 0xE3, 0xC3, 0xC7,
  0xF1, 0xE1, 0xE3, 0xF8, 0xF0, 0xF1, 0xFC, 0x78, 0x70, 0xEE, 0x1C, 0x78,
  0x77, 0x0F, 0x3E, 0x7B, 0xC7, 0xFF, 0xF9, 0xE1, 0xF9, 0xFC, 0x70, 0x7C,
  0x7C, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x03, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xDE, 0x00, 0x7D, 0xE0, 0x07,
  0x9E, 0x00, 0x79, 0xF0, 0x0F, 0x9F, 0x00, 0xF8, 0xF0, 0x0F, 0x8F, 0x00,
  0xF0, 0xF8, 0x0F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x07, 0x81, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xE0, 0x3E, 0x3E, 0x03,
  0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x1F, 0x7C, 0x01, 0xFF, 0xC0,
  0x1F, 0xF8, 0x01, 0xF0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE,
  0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E,
  0xF8, 0x3E, 0xF8, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE,
  0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xE0, 0x00, 0xF0, 0x03, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFE,
  0x3F, 0x02, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x02, 0x1F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFE,
  0x03, 0xFE, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x87,
  0xE7, 0xC1, 0xFB, 0xE0, 0x7D, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0xFB, 0xE0, 0x7D, 0xF0, 0x7E, 0xF8, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F,
  0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0xFF,
  0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xEF, 0x8F, 0xC0, 0x23, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xDF, 0x00, 0xF7, 0xC0, 0x3D,
  0xF0, 0x0F, 0x3E, 0x03, 0xCF, 0xC0, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F,
  0xFF, 0xC0, 0xFF, 0xE0, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x78, 0xFF, 0xFF, 0xFF, 0xFC, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x0F, 0xCF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x3E, 0x0F,
  0xBF, 0xEF, 0xF3, 0xFC, 0xFE, 0x00, 0xF8, 0x0F, 0xFC, 0x0F, 0xBE, 0x0F,
  0xDF, 0x07, 0xCF, 0x87, 0xC7, 0xC3, 0xE3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF9,
  0xF0, 0x7D, 0xF8, 0x3E, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFD, 0xF0, 0x7C, 0xF8, 0x3E, 0x7E, 0x1F, 0x1F,
  0x0F, 0x8F, 0x87, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C,
  0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xFF, 0x80, 0xF8, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x03, 0xDF, 0xEF, 0x01, 0xEF, 0xF7, 0x80, 0xFF, 0xFB, 0xC0, 0x7F, 0xFD,
  0xE0, 0x7B, 0xFE, 0x78, 0x3D, 0xFF, 0x3C, 0x1E, 0xFF, 0x9E, 0x0E, 0x7F,
  0xCF, 0x0F, 0x3F, 0xE3, 0xC7, 0x9F, 0xF1, 0xE3, 0xCF, 0xF8, 0xF3, 0xC7,
  0xFC, 0x39, 0xE3, 0xFE, 0x1E, 0xF1, 0xFF, 0x0F, 0x70, 0xFF, 0x87, 0xF8,
  0x7F, 0xC1, 0xFC, 0x3F, 0xE0, 0xFE, 0x1F, 0xF0, 0x7E, 0x0F, 0xF8, 0x3F,
  0x07, 0xFC, 0x0F, 0x83, 0xFE, 0x07, 0xC1, 0xFF, 0x03, 0xC0, 0xF8, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xF7, 0x81, 0xFE, 0xF8, 0x3F, 0xCF,
  0x07, 0xF9, 0xF0, 0xFF, 0x3E, 0x1F, 0xE3, 0xC3, 0xFC, 0x7C, 0x7F, 0x87,
  0x8F, 0xF0, 0xF9, 0xFE, 0x0F, 0x3F, 0xC1, 0xF7, 0xF8, 0x3E, 0xFF, 0x03,
  0xDF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0xE0, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xE0, 0xFC, 0x7C,
  0x07, 0xC7, 0xC0, 0x3E, 0x7C, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03,
  0xEF, 0x80, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7E, 0x07, 0xC3, 0xF0,
  0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0xFF,
  0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x87, 0xDF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x87, 0xFF,
  0x1F, 0xBF, 0xFF, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0x83, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xE0, 0x0F,
  0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xE0, 0xFC, 0x7C, 0x07, 0xC7,
  0xC0, 0x3E, 0x7C, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xE7, 0x80,
  0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7E, 0x07, 0xC3, 0xF0, 0xFC, 0x3F,
  0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F,
  0x87, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F,
  0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xC7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF,
  0xE0, 0xFF, 0xE0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x1F, 0x0F, 0x8F, 0x87,
  0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x07,
  0xDF, 0x03, 0xEF, 0x81, 0xF8, 0x03, 0xC0, 0x1F, 0xF0, 0x7F, 0xF9, 0xFF,
  0xE7, 0xFF, 0xCF, 0x81, 0x9F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0xC0, 0x7D, 0xE0, 0xFB, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x07,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xFC, 0x1F, 0x3F, 0xFF, 0x9F, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0x80, 0xF8,
  0x01, 0xFF, 0x80, 0x1E, 0x78, 0x03, 0xE7, 0x80, 0x3E, 0x7C, 0x03, 0xE7,
  0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x0F, 0x0F,
  0x00, 0xF1, 0xF0, 0x0F, 0x1F, 0x00, 0xF9, 0xE0, 0x07, 0x9E, 0x00, 0x79,
  0xE0, 0x07, 0xBE, 0x00, 0x7B, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0xF8, 0x07, 0x80, 0x3F, 0xE0, 0x1F, 0x01, 0xFF, 0x80, 0xFC, 0x07, 0xDE,
  0x03, 0xF0, 0x1F, 0x78, 0x0F, 0xC0, 0x79, 0xF0, 0x3F, 0x01, 0xE7, 0xC0,
  0xFE, 0x0F, 0x9F, 0x07, 0xF8, 0x3E, 0x3C, 0x1F, 0xE0, 0xF8, 0xF0, 0x7F,
  0x83, 0xC3, 0xC1, 0xEE, 0x0F, 0x0F, 0x87, 0x38, 0x7C, 0x3E, 0x3C, 0xF1,
  0xF0, 0x78, 0xF3, 0xC7, 0xC1, 0xE3, 0xCF, 0x1E, 0x07, 0x8F, 0x3C, 0x78,
  0x1F, 0x3C, 0x73, 0xE0, 0x7D, 0xE1, 0xEF, 0x80, 0xF7, 0x87, 0xBE, 0x03,
  0xDE, 0x1E, 0xF0, 0x0F, 0x78, 0x7B, 0xC0, 0x3D, 0xE0, 0xEF, 0x00, 0xF7,
  0x03, 0xBC, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0,
  0xFE, 0x00, 0x7F, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x1F,
  0x80, 0x7C, 0x0F, 0xDF, 0x03, 0xE3, 0xE0, 0xF8, 0xF8, 0x7C, 0x1E, 0x1F,
  0x07, 0xC7, 0x80, 0xF3, 0xE0, 0x3C, 0xF8, 0x0F, 0xBC, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3E, 0xF0, 0x0F, 0x3E,
  0x07, 0xCF, 0x81, 0xF1, 0xE0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xE7,
  0xC0, 0xF9, 0xF0, 0x3F, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xDF, 0x01, 0xF7,
  0xC0, 0xF9, 0xF0, 0x3E, 0x3E, 0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x7C,
  0x78, 0x1F, 0x3E, 0x03, 0xCF, 0x80, 0xFB, 0xC0, 0x3F, 0xF0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80,
  0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xEF, 0x00, 0x79, 0xE0, 0x0F, 0x3E, 0x03,
  0xC3, 0xC0, 0x78, 0x7C, 0x1F, 0x07, 0x83, 0xC0, 0xF0, 0xF8, 0x0F, 0x1E,
  0x01, 0xE7, 0xC0, 0x1E, 0xF0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0x03, 0xC0, 0x3F, 0xF0, 0xFF, 0xE1,
  0xFF, 0xE1, 0x87, 0xC2, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x03,
  0xFC, 0x7F, 0xF9, 0xFF, 0xF7, 0xFB, 0xEF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xFB, 0xE7, 0xF7, 0xFD, 0xE7, 0xFB, 0xC7,
  0xE7, 0x80, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x60, 0xF9, 0xF8, 0xFB, 0xFC,
  0xFF, 0xFE, 0xFE, 0x7E, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x3E, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFB, 0xFC, 0xF1, 0xF8, 0x03, 0x80, 0xFF, 0xCF, 0xFC, 0x7F, 0xE7, 0xE7,
  0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x04, 0xFF,
  0xE3, 0xFF, 0x1F, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x06, 0x1F,
  0x1F, 0x9F, 0x3F, 0xDF, 0x7F, 0xFF, 0x7E, 0xFF, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F,
  0x7E, 0xFF, 0x7F, 0xFF, 0x3F, 0xDF, 0x1F, 0x8F, 0x03, 0x00, 0x3F, 0xC0,
  0xFF, 0xC3, 0xFF, 0xC7, 0xC7, 0xCF, 0x07, 0xBE, 0x0F, 0x78, 0x1E, 0xF0,
  0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x13, 0xFB, 0xE3, 0xFF, 0xC3,
  0xFF, 0x83, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xE1, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x03, 0xFF, 0x3F, 0xF9, 0xFF, 0xCF,
  0xFE, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0x00, 0x1F, 0x9F, 0x3F,
  0xDF, 0x7F, 0xFF, 0x7E, 0xFF, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0x7F, 0xFF, 0x7F,
  0xFF, 0x3F, 0xDF, 0x1F, 0x9F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x80, 0x3E, 0x70, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F,
  0x80, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x61, 0xF7, 0xF3, 0xEF, 0xF7, 0xFF, 0xFF,
  0xF7, 0xFF, 0x87, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0x80,
  0x77, 0xFF, 0xF7, 0x98, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x1F, 0x1F, 0x1F,
  0x0F, 0x06, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x9F, 0xFE, 0xFE, 0xFC,
  0xF8, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x3E, 0xF0, 0x7C, 0xF0,
  0x78, 0xF0, 0xF8, 0xF1, 0xF0, 0xF1, 0xE0, 0xF3, 0xE0, 0xF7, 0xC0, 0xF7,
  0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xF9, 0xF0, 0xF1,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0,
  0x3E, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xE0, 0x38, 0x79, 0xFC, 0x7F, 0x3D, 0xFF, 0x7F, 0xDF, 0xFF, 0xBF, 0xFF,
  0xF7, 0xFD, 0xFF, 0xE1, 0xF8, 0x7F, 0xF0, 0xFC, 0x3F, 0xF0, 0x7C, 0x0F,
  0xF8, 0x1E, 0x07, 0xFC, 0x0F, 0x03, 0xFE, 0x07, 0x81, 0xFF, 0x03, 0xC0,
  0xFF, 0x81, 0xE0, 0x7F, 0xC0, 0xF0, 0x3F, 0xE0, 0x78, 0x1F, 0xF0, 0x3C,
  0x0F, 0xF8, 0x1E, 0x07, 0xFC, 0x0F, 0x03, 0xFE, 0x07, 0x81, 0xFF, 0x03,
  0xC0, 0xFF, 0x81, 0xE0, 0x7F, 0xC0, 0xF0, 0x3F, 0xE0, 0x78, 0x1E, 0x00,
  0x61, 0xE7, 0xF3, 0xDF, 0xF7, 0xFF, 0xFF, 0xF7, 0xFF, 0x87, 0xFF, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0x80, 0x03, 0x80, 0x1F, 0xF0, 0x3F,
  0xF8, 0x7F, 0xFC, 0x7E, 0x7C, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x1E, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1E, 0xF8, 0x1E, 0xF8, 0x3E, 0x7C, 0x3E, 0x7F, 0xFC, 0x3F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0x00, 0xE0, 0xF1, 0xF8, 0xFB, 0xFC, 0xFF,
  0xFE, 0xFE, 0x7E, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x3E, 0xFF, 0xFE, 0xFF, 0xFE, 0xFB,
  0xFC, 0xF9, 0xF8, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07,
  0x00, 0x1F, 0x9F, 0x3F, 0xDF, 0x7F, 0xFF, 0x7E, 0xFF, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC,
  0x3F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xDF, 0x1F, 0x9F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0xFE, 0x3F, 0xCF, 0xFB, 0xFF, 0xFF,
  0xFE, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x00, 0x03, 0x00, 0xFF, 0x8F, 0xFC, 0xFF, 0xEF, 0xC6, 0x7C, 0x0B, 0xE0,
  0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xF0, 0x3D, 0xFF, 0xEF, 0xFF, 0x7F,
  0xF1, 0xFF, 0x00, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0xFF, 0xBF,
  0xF7, 0xFE, 0xFF, 0xC7, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xFF,
  0x3F, 0xE3, 0xFC, 0x3F, 0x80, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF8,
  0x3E, 0xF8, 0xFD, 0xFF, 0xFB, 0xFF, 0xF3, 0xFC, 0xE3, 0xF1, 0xC0, 0xF8,
  0x0F, 0xBC, 0x07, 0x9E, 0x03, 0xCF, 0x83, 0xE7, 0xC1, 0xF1, 0xE0, 0xF0,
  0xF0, 0x78, 0x7C, 0x7C, 0x3E, 0x3E, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7,
  0x80, 0xF7, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x07, 0x78, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x1F,
  0x03, 0xDE, 0x0F, 0xC0, 0xF7, 0x83, 0xF0, 0x7D, 0xF0, 0xFE, 0x1F, 0x7C,
  0x3F, 0x87, 0x8F, 0x0E, 0xE1, 0xE3, 0xC7, 0xB8, 0x78, 0xF1, 0xEE, 0x3E,
  0x3E, 0x7B, 0xCF, 0x8F, 0x9C, 0xF3, 0xC1, 0xE7, 0x1C, 0xF0, 0x79, 0xC7,
  0x3C, 0x1E, 0xF1, 0xDF, 0x07, 0xBC, 0x77, 0x81, 0xFF, 0x1D, 0xE0, 0x3F,
  0x87, 0xF8, 0x0F, 0xE1, 0xFE, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0xC0,
  0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x1F,
  0x7C, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x1E, 0x7C, 0x1F, 0x78, 0x0F, 0xF8,
  0x0F, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x78, 0x1E, 0x7C, 0x3E, 0x3C, 0x3E, 0x3E,
  0x7C, 0x3E, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xBC, 0x07, 0x9F, 0x03,
  0xCF, 0x83, 0xE7, 0xC1, 0xF1, 0xE0, 0xF0, 0xF8, 0x78, 0x7C, 0x7C, 0x1E,
  0x3E, 0x0F, 0x1E, 0x07, 0xCF, 0x03, 0xEF, 0x80, 0xF7, 0xC0, 0x7B, 0xC0,
  0x3D, 0xE0, 0x0E, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x09, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x3E, 0x07,
  0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0x7C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xF0, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x03, 0xF0, 0xFE,
  0x0F, 0x80, 0xFE, 0x0F, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x07,
  0xF0, 0x7F, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F,
  0x01, 0xF8, 0x0F, 0xF0, 0x1F, 0x07, 0xF0, 0xFE, 0x1F, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x03, 0xE0, 0xFE, 0x0F, 0xC0, 0xF8, 0x08, 0x00, 0x08, 0x01, 0x7F, 0x01,
  0xFF, 0xE3, 0xFF, 0xFF, 0xE3, 0xFF, 0x80, 0xFE, 0x80, 0x08,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 29, 10, 2, -29 },
  { 23, 13, 10, 17, 2, -29 },
  { 40, 18, 29, 20, 1, -29 },
  { 106, 15, 33, 19, 2, -31 },
  { 168, 28, 30, 30, 1, -30 },
  { 273, 21, 30, 22, 1, -30 },
  { 352, 5, 10, 9, 2, -29 },
  { 359, 10, 35, 13, 2, -29 },
  { 403, 10, 35, 13, 1, -29 },
  { 447, 15, 15, 18, 1, -31 },
  { 476, 16, 19, 18, 1, -24 },
  { 514, 7, 10, 10, 1, -5 },
  { 523, 10, 4, 12, 1, -13 },
  { 528, 6, 6, 10, 2, -6 },
  { 533, 15, 30, 16, 1, -30 },
  { 590, 16, 30, 18, 1, -30 },
  { 650, 12, 29, 18, 2, -29 },
  { 694, 16, 30, 18, 1, -30 },
  { 754, 16, 30, 18, 1, -30 },
  { 814, 17, 29, 18, 1, -29 },
  { 876, 15, 29, 18, 2, -29 },
  { 931, 16, 30, 18, 1, -30 },
  { 991, 16, 29, 18, 1, -29 },
  { 1049, 16, 30, 18, 1, -30 },
  { 1109, 16, 30, 18, 1, -30 },
  { 1169, 6, 22, 10, 2, -22 },
  { 1186, 7, 27, 10, 1, -22 },
  { 1210, 16, 19, 18, 1, -24 },
  { 1248, 16, 12, 18, 1, -20 },
  { 1272, 16, 19, 18, 1, -24 },
  { 1310, 14, 30, 14, 0, -30 },
  { 1363, 25, 33, 29, 2, -30 },
  { 1467, 20, 29, 20, 0, -29 },
  { 1540, 16, 29, 21, 3, -29 },
  { 1598, 16, 30, 19, 2, -30 },
  { 1658, 17, 29, 22, 3, -29 },
  { 1720, 12, 29, 17, 3, -29 },
  { 1764, 12, 29, 17, 3, -29 },
  { 1808, 18, 30, 23, 2, -30 },
  { 1876, 17, 29, 23, 3, -29 },
  { 1938, 10, 29, 12, 1, -29 },
  { 1975, 10, 37, 10, -2, -29 },
  { 2022, 17, 29, 20, 3, -29 },
  { 2084, 12, 29, 16, 3, -29 },
  { 2128, 25, 29, 31, 3, -29 },
  { 2219, 19, 29, 25, 3, -29 },
  { 2288, 20, 30, 24, 2, -30 },
  { 2363, 15, 29, 19, 3, -29 },
  { 2418, 20, 37, 24, 2, -30 },
  { 2511, 17, 29, 20, 3, -29 },
  { 2573, 15, 30, 17, 1, -30 },
  { 2630, 15, 29, 17, 1, -29 },
  { 2685, 17, 29, 23, 3, -29 },
  { 2747, 20, 29, 20, 0, -29 },
  { 2820, 30, 29, 30, 0, -29 },
  { 2929, 18, 29, 18, 0, -29 },
  { 2995, 18, 29, 18, 0, -29 },
  { 3061, 14, 29, 16, 1, -29 },
  { 3112, 9, 36, 13, 3, -29 },
  { 3153, 16, 30, 16, 0, -30 },
  { 3213, 9, 36, 13, 1, -29 },
  { 3254, 19, 17, 20, 1, -29 },
  { 3295, 17, 2, 17, 0, 4 },
  { 3300, 8, 6, 12, 2, -31 },
  { 3306, 15, 23, 18, 1, -23 },
  { 3350, 16, 31, 20, 2, -31 },
  { 3412, 13, 23, 16, 2, -23 },
  { 3450, 16, 31, 20, 2, -31 },
  { 3512, 15, 23, 18, 2, -23 },
  { 3556, 13, 31, 12, 0, -31 },
  { 3607, 16, 33, 20, 2, -23 },
  { 3673, 15, 31, 20, 2, -31 },
  { 3732, 5, 31, 10, 2, -31 },
  { 3752, 8, 41, 10, -1, -31 },
  { 3793, 16, 31, 18, 3, -31 },
  { 3855, 5, 31, 9, 2, -31 },
  { 3875, 25, 23, 30, 2, -23 },
  { 3947, 15, 23, 20, 2, -23 },
  { 3991, 16, 23, 19, 2, -23 },
  { 4037, 16, 33, 20, 2, -23 },
  { 4103, 16, 33, 20, 2, -23 },
  { 4169, 11, 23, 14, 2, -23 },
  { 4201, 13, 23, 15, 1, -23 },
  { 4239, 11, 27, 12, 1, -27 },
  { 4277, 15, 22, 20, 2, -22 },
  { 4319, 17, 22, 17, 0, -22 },
  { 4366, 26, 22, 27, 0, -22 },
  { 4438, 16, 22, 17, 0, -22 },
  { 4482, 17, 32, 17, 0, -22 },
  { 4550, 12, 22, 14, 1, -22 },
  { 4583, 12, 36, 14, 1, -29 },
  { 4637, 4, 41, 17, 7, -31 },
  { 4658, 12, 36, 14, 2, -29 },
  { 4712, 16, 7, 18, 1, -18 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold41pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD41PT7B_H_
