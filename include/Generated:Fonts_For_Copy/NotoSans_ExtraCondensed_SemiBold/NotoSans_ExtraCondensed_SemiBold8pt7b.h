#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD8PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold8pt7bBitmaps[] PROGMEM = {
  0x00, 0xEA, 0x30, 0xB4, 0x66, 0xF6, 0xF6, 0x5F, 0x1A, 0x80, 0x52, 0xCA,
  0x9D, 0x35, 0xA0, 0x66, 0x6B, 0xBF, 0xC0, 0x5A, 0x94, 0x95, 0x58, 0x5E,
  0x80, 0x4B, 0xA0, 0x60, 0xC0, 0xC0, 0x25, 0x25, 0x00, 0x76, 0xDA, 0xC0,
  0x3C, 0x92, 0x40, 0x74, 0x95, 0xC0, 0xE4, 0xB3, 0xC0, 0x2D, 0xDE, 0x40,
  0x73, 0x13, 0xC0, 0x6B, 0xDA, 0xC0, 0xE4, 0x94, 0x80, 0x75, 0xBB, 0xC0,
  0x76, 0xB2, 0xC0, 0xC3, 0xC1, 0x80, 0x2F, 0x10, 0xFC, 0x8D, 0xC0, 0xC5,
  0x20, 0x80, 0x32, 0x6F, 0xBB, 0xA0, 0xC0, 0x66, 0x66, 0x99, 0xD7, 0x7B,
  0x80, 0x74, 0x88, 0x46, 0xD6, 0xDB, 0x80, 0xEB, 0xB0, 0xEB, 0xA0, 0x34,
  0x8B, 0x57, 0xB6, 0xFB, 0x40, 0xD5, 0x70, 0xFF, 0xBB, 0x6D, 0x40, 0xAA,
  0xB0, 0x99, 0xBF, 0xFD, 0xB7, 0xFB, 0x40, 0x65, 0x99, 0x57, 0xDA, 0xE9,
  0x00, 0x65, 0x99, 0x57, 0x10, 0xD7, 0x6D, 0x40, 0x73, 0x33, 0xC0, 0xE9,
  0x24, 0x80, 0xB6, 0xDB, 0xC0, 0x99, 0xA6, 0x66, 0xA6, 0xDB, 0x5E, 0x59,
  0x20, 0xA6, 0x64, 0x6B, 0xBA, 0x64, 0x44, 0xE5, 0x29, 0xC0, 0xEA, 0xAC,
  0x91, 0x22, 0x40, 0xD5, 0x5C, 0x46, 0x69, 0xE0, 0xC0, 0xEE, 0xF0, 0x88,
  0xE9, 0x9E, 0x72, 0x30, 0x27, 0xDA, 0xC0, 0xFE, 0x30, 0x5D, 0x50, 0xF6,
  0xB3, 0xC0, 0x93, 0xDB, 0x40, 0xBC, 0xBF, 0x89, 0xAC, 0xAB, 0xFC, 0xFD,
  0x6B, 0x50, 0xF6, 0xD0, 0x76, 0xB0, 0xE9, 0x9E, 0x88, 0xF6, 0xB2, 0x40,
  0xF2, 0x40, 0xF8, 0xE0, 0x6A, 0x40, 0xB6, 0xB0, 0xB5, 0xA0, 0xAD, 0x56,
  0xA0, 0xA9, 0x50, 0xB5, 0xA5, 0x80, 0xE9, 0x70, 0x69, 0x64, 0x98, 0xFF,
  0x89, 0x34, 0xB0, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 3, 2, 3, 0, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 3, 6, 4, 0, -6 },
  { 10, 6, 6, 6, 0, -6 },
  { 15, 4, 6, 4, 0, -6 },
  { 18, 1, 2, 2, 0, -6 },
  { 19, 2, 7, 2, 0, -6 },
  { 21, 2, 7, 2, 0, -6 },
  { 23, 3, 3, 3, 0, -6 },
  { 25, 3, 4, 4, 0, -5 },
  { 27, 2, 2, 2, 0, -1 },
  { 28, 2, 1, 2, 0, -3 },
  { 29, 2, 1, 2, 0, -1 },
  { 30, 3, 6, 3, 0, -6 },
  { 33, 3, 6, 4, 0, -6 },
  { 36, 3, 6, 4, 0, -6 },
  { 39, 3, 6, 4, 0, -6 },
  { 42, 3, 6, 4, 0, -6 },
  { 45, 3, 6, 4, 0, -6 },
  { 48, 3, 6, 4, 0, -6 },
  { 51, 3, 6, 4, 0, -6 },
  { 54, 3, 6, 4, 0, -6 },
  { 57, 3, 6, 4, 0, -6 },
  { 60, 3, 6, 4, 0, -6 },
  { 63, 2, 4, 2, 0, -4 },
  { 64, 2, 5, 2, 0, -4 },
  { 66, 3, 4, 4, 0, -5 },
  { 68, 3, 2, 4, 0, -4 },
  { 69, 3, 4, 4, 0, -5 },
  { 71, 3, 6, 3, 0, -6 },
  { 74, 5, 7, 6, 0, -6 },
  { 79, 4, 6, 4, 0, -6 },
  { 82, 3, 6, 4, 1, -6 },
  { 85, 4, 6, 4, 0, -6 },
  { 88, 3, 6, 4, 1, -6 },
  { 91, 2, 6, 3, 1, -6 },
  { 93, 2, 6, 3, 1, -6 },
  { 95, 4, 6, 4, 0, -6 },
  { 98, 3, 6, 5, 1, -6 },
  { 101, 2, 6, 2, 0, -6 },
  { 103, 1, 8, 2, 0, -6 },
  { 104, 3, 6, 4, 1, -6 },
  { 107, 2, 6, 3, 1, -6 },
  { 109, 4, 6, 6, 1, -6 },
  { 112, 3, 6, 5, 1, -6 },
  { 115, 4, 6, 5, 0, -6 },
  { 118, 3, 6, 4, 1, -6 },
  { 121, 4, 7, 5, 0, -6 },
  { 125, 3, 6, 4, 1, -6 },
  { 128, 3, 6, 3, 0, -6 },
  { 131, 3, 6, 3, 0, -6 },
  { 134, 3, 6, 4, 1, -6 },
  { 137, 4, 6, 4, 0, -6 },
  { 140, 6, 6, 6, 0, -6 },
  { 145, 4, 6, 4, 0, -6 },
  { 148, 4, 6, 4, 0, -6 },
  { 151, 3, 6, 3, 0, -6 },
  { 154, 2, 7, 3, 0, -6 },
  { 156, 3, 6, 3, 0, -6 },
  { 159, 2, 7, 3, 0, -6 },
  { 161, 4, 4, 4, 0, -6 },
  { 163, 3, 1, 3, 0, 0 },
  { 164, 2, 1, 2, 0, -6 },
  { 165, 3, 4, 4, 0, -4 },
  { 167, 4, 6, 4, 0, -6 },
  { 170, 3, 4, 3, 0, -4 },
  { 172, 3, 6, 4, 0, -6 },
  { 175, 3, 4, 4, 0, -4 },
  { 177, 2, 6, 2, 0, -6 },
  { 179, 3, 6, 4, 0, -4 },
  { 182, 3, 6, 4, 0, -6 },
  { 185, 1, 6, 2, 0, -6 },
  { 186, 1, 8, 2, 0, -6 },
  { 187, 4, 6, 4, 0, -6 },
  { 190, 1, 6, 2, 0, -6 },
  { 191, 5, 4, 6, 0, -4 },
  { 194, 3, 4, 4, 0, -4 },
  { 196, 3, 4, 4, 0, -4 },
  { 198, 4, 6, 4, 0, -4 },
  { 201, 3, 6, 4, 0, -4 },
  { 204, 3, 4, 3, 0, -4 },
  { 206, 3, 4, 3, 0, -4 },
  { 208, 2, 5, 2, 0, -5 },
  { 210, 3, 4, 4, 0, -4 },
  { 212, 3, 4, 3, 0, -4 },
  { 214, 5, 4, 5, 0, -4 },
  { 217, 3, 4, 3, 0, -4 },
  { 219, 3, 6, 3, 0, -4 },
  { 222, 3, 4, 3, 0, -4 },
  { 224, 3, 7, 3, 0, -6 },
  { 227, 1, 8, 3, 1, -6 },
  { 228, 3, 7, 3, 0, -6 },
  { 231, 3, 1, 4, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold8pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD8PT7B_H_
