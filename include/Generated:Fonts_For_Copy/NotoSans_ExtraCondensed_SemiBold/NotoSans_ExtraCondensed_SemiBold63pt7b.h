#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD63PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold63pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0x7F, 0x07, 0xF7,
  0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7E, 0x07, 0xF7, 0xE0, 0x7F,
  0x7E, 0x07, 0xF7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07,
  0xE7, 0xE0, 0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x1F,
  0x83, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F,
  0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF0, 0x7E, 0x03, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x1F, 0x80,
  0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0xF8, 0x3F, 0x01, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x07,
  0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0xF8, 0x3E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x03,
  0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFD, 0xC7, 0xCF, 0xE3, 0x81,
  0x1F, 0xC7, 0x00, 0x3F, 0x0E, 0x00, 0x7E, 0x1C, 0x00, 0xFC, 0x38, 0x01,
  0xFC, 0x70, 0x03, 0xF8, 0xE0, 0x07, 0xF9, 0xC0, 0x07, 0xFB, 0x80, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0x7F, 0x80, 0x0E, 0x7F, 0x00, 0x1C, 0x7F, 0x00, 0x38, 0xFE, 0x00, 0x71,
  0xFC, 0x00, 0xE3, 0xF8, 0x01, 0xC7, 0xF8, 0x03, 0x8F, 0xDC, 0x07, 0x3F,
  0xBE, 0x0E, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x1F, 0x00,
  0x07, 0xE3, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0x00, 0x7C,
  0x1F, 0x00, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8,
  0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x83, 0xF0,
  0x00, 0x3F, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x3E, 0x00, 0x03,
  0xF0, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x87, 0xC0, 0x00, 0x3F, 0x07,
  0xE3, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0xFC, 0x0E, 0x01, 0xF0, 0x7C, 0x3E,
  0x0F, 0xE0, 0x7C, 0x1F, 0x1F, 0x8F, 0xFE, 0x1F, 0x07, 0xC7, 0xC3, 0xFF,
  0x87, 0xE3, 0xF1, 0xF1, 0xFF, 0xF0, 0xFD, 0xF8, 0xFC, 0x7E, 0xFC, 0x3F,
  0xFE, 0x3E, 0x3F, 0x1F, 0x87, 0xFF, 0x1F, 0x8F, 0x83, 0xE0, 0xFF, 0x87,
  0xE3, 0xE0, 0xF8, 0x1F, 0xC1, 0xF0, 0xF8, 0x3F, 0x00, 0x80, 0xFC, 0x7E,
  0x0F, 0xC0, 0x00, 0x3E, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0xFC,
  0x00, 0x07, 0xE1, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7E, 0x0F, 0xC0, 0x00,
  0xFC, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0x81,
  0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0x83,
  0xF0, 0x00, 0x7C, 0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x3E, 0x00,
  0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x03, 0xE0, 0x07, 0xEF, 0xC0, 0x01, 0xF8,
  0x01, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F,
  0x83, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xFC,
  0x1F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1,
  0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0xFE, 0x1F, 0xFF, 0x03,
  0xFC, 0x7F, 0xFF, 0x07, 0xF9, 0xFF, 0xFF, 0x0F, 0xE3, 0xFC, 0xFE, 0x1F,
  0xCF, 0xF1, 0xFE, 0x3F, 0x9F, 0xE1, 0xFE, 0xFF, 0x3F, 0x81, 0xFD, 0xFC,
  0x7F, 0x03, 0xFF, 0xF8, 0xFE, 0x03, 0xFF, 0xE1, 0xFC, 0x03, 0xFF, 0xC3,
  0xF8, 0x07, 0xFF, 0x87, 0xF0, 0x07, 0xFE, 0x0F, 0xE0, 0x07, 0xFC, 0x1F,
  0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xBF, 0xC0, 0xFF, 0xFC, 0x3F, 0xC0, 0xFF, 0xE0, 0x3F, 0xC0, 0x0C,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07,
  0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x1F, 0x80, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F,
  0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x18, 0x1F, 0x03, 0x3E, 0x3E, 0x3E, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xEF, 0xC0,
  0x1F, 0xDF, 0xC0, 0x7F, 0x1F, 0xC1, 0xFE, 0x3F, 0xC3, 0xF8, 0x3F, 0x01,
  0xE0, 0x7C, 0x01, 0xC0, 0x60, 0x00, 0x80, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC7, 0xF3, 0xFC, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F, 0x0F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1E, 0x3F, 0x9F, 0xEF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFE, 0x3F, 0x0C,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F,
  0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFE, 0x7F, 0x00, 0xFE, 0x7F,
  0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7F,
  0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F,
  0x81, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xC0, 0x0F,
  0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xF7, 0xF7, 0xF9, 0xFF, 0xFE, 0x7F, 0x7F,
  0x1F, 0xCF, 0x87, 0xF1, 0xC1, 0xFC, 0x20, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x00, 0x30, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7E,
  0x07, 0xFC, 0x3C, 0x01, 0xFC, 0x18, 0x01, 0xFE, 0x10, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x07,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3E, 0x03, 0xFC, 0x38, 0x01, 0xFE, 0x10,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0xC0, 0x03, 0xFE, 0xF0, 0x07, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x00, 0x68, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xF7, 0xF0, 0x00, 0x7D, 0xFC, 0x00,
  0x3E, 0x7F, 0x00, 0x0F, 0x9F, 0xC0, 0x07, 0xC7, 0xF0, 0x01, 0xF1, 0xFC,
  0x00, 0xF8, 0x7F, 0x00, 0x3E, 0x1F, 0xC0, 0x1F, 0x87, 0xF0, 0x07, 0xC1,
  0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xF0, 0x1F,
  0x01, 0xFC, 0x0F, 0xC0, 0x7F, 0x03, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0,
  0x7E, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x18, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xD8, 0x00, 0xFF, 0x3C, 0x03, 0xFE,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x7E, 0x3F, 0xE0, 0x7E, 0x7F, 0xF0, 0xFE, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xE3, 0xFE, 0xFF, 0x81, 0xFE,
  0xFF, 0x80, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0xFF,
  0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0xC1, 0xFE, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x08, 0x00,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x3F, 0xE7, 0xFC, 0x7F, 0x81, 0xFE, 0x7F, 0x00, 0xFE,
  0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE,
  0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0x81, 0xFC,
  0x1F, 0xC3, 0xFC, 0x1F, 0xF7, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xE7, 0xF8, 0x3F, 0xC3, 0xFC, 0x7F, 0x81, 0xFE,
  0x7F, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0xFE, 0x7F, 0xE3, 0xFE,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x7F, 0xC3, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x01, 0xFC,
  0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0x7F, 0x81, 0xFF, 0x7F, 0xC7, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0x7F, 0x1F, 0xFE, 0x7E, 0x0F, 0xFC, 0x7E, 0x03, 0xF8, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x18, 0x06, 0x07, 0xE3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC,
  0xFF, 0x1F, 0x83, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC7, 0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE,
  0x3F, 0x1F, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC7, 0x81, 0xFF, 0x30, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x81, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0x81,
  0xF8, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x02, 0x00, 0x7C, 0x3F, 0x00, 0xFF,
  0xE1, 0xF8, 0xF8, 0x0F, 0xFF, 0xC3, 0xE7, 0xE0, 0x7F, 0xFF, 0x0F, 0x9F,
  0x81, 0xFF, 0xF8, 0x3F, 0x7C, 0x0F, 0xC3, 0xE0, 0xFD, 0xF0, 0x7E, 0x0F,
  0x81, 0xFF, 0xC1, 0xF8, 0x3E, 0x07, 0xFF, 0x07, 0xC0, 0xF8, 0x1F, 0xF8,
  0x3F, 0x03, 0xE0, 0x7F, 0xE0, 0xFC, 0x0F, 0x81, 0xFF, 0x83, 0xF0, 0x3E,
  0x07, 0xFE, 0x0F, 0x80, 0xF8, 0x1F, 0xF8, 0x3E, 0x07, 0xE0, 0x7F, 0xE0,
  0xF8, 0x1F, 0x81, 0xFF, 0x83, 0xE0, 0x7E, 0x07, 0xFE, 0x0F, 0x81, 0xF8,
  0x1F, 0xF8, 0x3E, 0x07, 0xE0, 0xFF, 0xE0, 0xFC, 0x1F, 0x83, 0xEF, 0x83,
  0xF0, 0x7E, 0x0F, 0xBE, 0x07, 0xC3, 0xF8, 0x3E, 0xFC, 0x1F, 0x8F, 0xF1,
  0xF3, 0xF0, 0x7F, 0xFB, 0xFF, 0xCF, 0xC0, 0xFF, 0xEF, 0xFE, 0x1F, 0x03,
  0xFF, 0x1F, 0xF8, 0x7E, 0x07, 0xF8, 0x3F, 0x81, 0xF8, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x02, 0x00, 0x07, 0xFC, 0x00, 0x78, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xFC,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xE7, 0xE0,
  0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80,
  0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x01,
  0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x03,
  0xFC, 0xFF, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3,
  0xFC, 0x0F, 0xFD, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03,
  0xFB, 0xFC, 0x01, 0xFD, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80,
  0xFF, 0x3F, 0xC3, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x7F,
  0x80, 0xFF, 0xBF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x1F, 0xF0, 0x1C, 0x1F, 0xF0, 0x02, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x04, 0x3F, 0xF8, 0x1E, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFC, 0x3F, 0xC7, 0xFF, 0xC7, 0xF8, 0x0F, 0xF8, 0xFF, 0x00, 0xFF, 0x9F,
  0xE0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03,
  0xFD, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xFB,
  0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x0F, 0xF1, 0xFE, 0x07,
  0xFE, 0x3F, 0xCF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0xFF, 0xE0, 0x3E, 0x1F, 0xF8, 0x00, 0x41, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x07, 0xF7, 0xF8, 0x00, 0x7F, 0x7F, 0x80,
  0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xF3, 0xFE, 0x00, 0x7F,
  0x1F, 0xF0, 0x07, 0xF1, 0xFF, 0x80, 0x7F, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xC3, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF8, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01,
  0xFC, 0x07, 0xF8, 0x0F, 0xF7, 0xFF, 0xEF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFC,
  0x7F, 0xF0, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07,
  0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x0F, 0xF1, 0xFE,
  0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x03, 0xFC,
  0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x87, 0xFC, 0x0F, 0xF0,
  0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF9, 0xFE, 0x00,
  0xFF, 0x3F, 0xC0, 0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0x7F,
  0x80, 0x7F, 0xCF, 0xF0, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F,
  0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F,
  0x83, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE,
  0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x7F,
  0x9F, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xFF, 0xF0,
  0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF7, 0xE0, 0x01, 0xFF, 0xFF, 0xEF, 0xC0, 0x07, 0xEF, 0xFF, 0xDF,
  0x80, 0x0F, 0xDF, 0xFF, 0xBF, 0x00, 0x1F, 0xBF, 0xFF, 0x3F, 0x00, 0x3F,
  0x7F, 0xFE, 0x7E, 0x00, 0xFC, 0xFF, 0xFC, 0xFC, 0x01, 0xF9, 0xFF, 0xF9,
  0xF8, 0x03, 0xF3, 0xFF, 0xF1, 0xF8, 0x0F, 0xC7, 0xFF, 0xE3, 0xF0, 0x1F,
  0x8F, 0xFF, 0xC7, 0xE0, 0x3F, 0x1F, 0xFF, 0x8F, 0xE0, 0x7E, 0x3F, 0xFF,
  0x0F, 0xC1, 0xF8, 0x7F, 0xFE, 0x1F, 0x83, 0xF0, 0xFF, 0xFC, 0x3F, 0x07,
  0xE1, 0xFF, 0xF8, 0x3F, 0x1F, 0x83, 0xFF, 0xF0, 0x7E, 0x3F, 0x07, 0xFF,
  0xE0, 0xFC, 0x7E, 0x0F, 0xFF, 0xC1, 0xF8, 0xFC, 0x1F, 0xFF, 0x81, 0xFB,
  0xF0, 0x3F, 0xFF, 0x03, 0xF7, 0xE0, 0x7F, 0xFE, 0x07, 0xEF, 0xC0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xC0, 0x0F, 0xE0, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0xFC, 0x01, 0xFF,
  0xFB, 0xF8, 0x07, 0xFF, 0xEF, 0xE0, 0x1F, 0xFF, 0x9F, 0xC0, 0x7F, 0xFE,
  0x7F, 0x01, 0xFF, 0xF8, 0xFE, 0x07, 0xFF, 0xE3, 0xF8, 0x1F, 0xFF, 0x87,
  0xE0, 0x7F, 0xFE, 0x1F, 0xC1, 0xFF, 0xF8, 0x7F, 0x07, 0xFF, 0xE0, 0xFE,
  0x1F, 0xFF, 0x83, 0xF8, 0x7F, 0xFE, 0x07, 0xF1, 0xFF, 0xF8, 0x1F, 0xC7,
  0xFF, 0xE0, 0x7F, 0x1F, 0xFF, 0x80, 0xFE, 0x7F, 0xFE, 0x03, 0xF9, 0xFF,
  0xF8, 0x07, 0xF7, 0xFF, 0xE0, 0x1F, 0xDF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F,
  0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFF, 0x7F, 0x80,
  0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x07, 0xF7, 0xF8, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x1F, 0xDF, 0xE0, 0x00,
  0x3F, 0xBF, 0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF,
  0x3F, 0x80, 0x01, 0xFE, 0x7F, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF1,
  0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x87,
  0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0x1F, 0xFE,
  0xFF, 0x03, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFE,
  0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x07, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F,
  0x9F, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFB, 0xFC,
  0x00, 0x07, 0xF7, 0xF8, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x1F, 0xDF, 0xE0,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0x3F, 0x80, 0x01, 0xFE, 0x7F, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x07,
  0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xC7, 0xFF, 0x87, 0xF8,
  0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC,
  0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0xC0,
  0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3,
  0xFC, 0x07, 0xF8, 0x7F, 0x81, 0xFF, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x0F, 0xF0, 0xFE,
  0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0xFF,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFE,
  0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8,
  0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF,
  0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFE, 0x00, 0x3C, 0x00, 0x07, 0xFF,
  0x00, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x9F, 0xF8, 0x7E, 0x7F, 0x80, 0x31, 0xFE, 0x00, 0x47, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xBF, 0x83, 0xFE, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x03,
  0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xF8, 0x3F, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFF, 0x7F,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFC,
  0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xF1, 0xF8,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0xFC, 0xFC, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF7, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x9F, 0xC0, 0x07, 0xFC,
  0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0xF0,
  0x03, 0xF8, 0x7F, 0x00, 0x7F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xE1, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0x83, 0xF8, 0x03, 0xFF, 0x80,
  0x7F, 0x07, 0xF0, 0x0F, 0xDF, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xBE, 0x01,
  0xFC, 0x0F, 0xE0, 0x3F, 0x7C, 0x07, 0xF8, 0x1F, 0xC0, 0x7C, 0xFC, 0x0F,
  0xE0, 0x3F, 0x81, 0xF9, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF3, 0xF0, 0x3F,
  0x80, 0x7F, 0x07, 0xE7, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xC7, 0xC0, 0xFE,
  0x01, 0xFC, 0x1F, 0x8F, 0xC3, 0xF8, 0x03, 0xF8, 0x7E, 0x1F, 0x87, 0xF0,
  0x07, 0xF0, 0xFC, 0x3F, 0x0F, 0xE0, 0x07, 0xE1, 0xF8, 0x7E, 0x1F, 0xC0,
  0x0F, 0xE3, 0xF0, 0xFC, 0x3F, 0x80, 0x1F, 0xC7, 0xE0, 0xFC, 0xFE, 0x00,
  0x3F, 0x9F, 0x81, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x03, 0xF3, 0xF8, 0x00,
  0x7E, 0x7E, 0x07, 0xE7, 0xF0, 0x00, 0xFC, 0xFC, 0x0F, 0xCF, 0xE0, 0x01,
  0xFD, 0xF8, 0x0F, 0x9F, 0xC0, 0x03, 0xFB, 0xE0, 0x1F, 0x7F, 0x00, 0x07,
  0xF7, 0xC0, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x1F, 0xE3, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC1, 0xFC, 0x03, 0xFC,
  0x1F, 0xC0, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFE,
  0x07, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE,
  0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x3F,
  0x9F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE,
  0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F,
  0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xF8, 0x01,
  0xFC, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xE7, 0xF8,
  0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x3F,
  0xC1, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x0F,
  0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xF9, 0xFC, 0x00,
  0x3F, 0x9F, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0x7F, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x01,
  0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0,
  0x3F, 0x00, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x3F,
  0x81, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x1F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x7F, 0x00,
  0x1F, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE0, 0xF0, 0x3F, 0xC3, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x0F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xDF, 0xF0, 0x7F, 0x7F, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFF, 0x03, 0xFD, 0xFE, 0x3F, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF,
  0xBF, 0x3F, 0xFC, 0x7C, 0x7F, 0xF1, 0xF0, 0xFF, 0x07, 0xC0, 0x60, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x0F, 0x80, 0xFE, 0x3F, 0xE0, 0xFE, 0x7F, 0xF0,
  0xFE, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xE7, 0xFC,
  0xFF, 0x81, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFE,
  0xFF, 0x01, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0xE7, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFD, 0xFF, 0xF8, 0xFC, 0xFF, 0xF8, 0xFC, 0x7F, 0xF0, 0xFC, 0x3F, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xC7, 0x87, 0xF8, 0x04,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x23, 0xFC, 0x03, 0x1F, 0xFD, 0xF8, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x07, 0xC1, 0xFC, 0x0F, 0xF8,
  0xFE, 0x0F, 0xFE, 0x7F, 0x0F, 0xFF, 0xBF, 0x8F, 0xFF, 0xDF, 0xC7, 0xFF,
  0xFF, 0xE7, 0xFC, 0x7F, 0xF3, 0xFC, 0x0F, 0xFB, 0xFC, 0x07, 0xFD, 0xFE,
  0x01, 0xFE, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0xBF, 0x80, 0x1F, 0xDF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x03,
  0xFD, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0x3F, 0x80, 0xFF, 0x9F, 0xE0,
  0x7F, 0xCF, 0xF8, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFC, 0xFC, 0x1F, 0xFC, 0x7E, 0x07, 0xFC, 0x3F, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFC, 0x3F, 0x81, 0xFC,
  0x3F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0x7E,
  0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x02,
  0x3F, 0xC0, 0x0C, 0x1F, 0xF0, 0x7C, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x03, 0xFC, 0x20, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xC7,
  0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x80,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x0F,
  0xC1, 0xFF, 0xC7, 0xE1, 0xFF, 0xF7, 0xF1, 0xFF, 0xFB, 0xF8, 0xFF, 0xFF,
  0xFC, 0xFF, 0x8F, 0xFE, 0x7F, 0x81, 0xFF, 0x7F, 0x80, 0xFF, 0xBF, 0xC0,
  0x3F, 0xDF, 0xC0, 0x1F, 0xEF, 0xE0, 0x0F, 0xF7, 0xF0, 0x03, 0xFB, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0xBF, 0x80, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x1F, 0xF3, 0xFC, 0x1F,
  0xF9, 0xFF, 0xBF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0x7F, 0x0F, 0xFF,
  0xBF, 0x83, 0xFF, 0x9F, 0xC0, 0xFF, 0x0F, 0xE0, 0x0C, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x8C, 0x00, 0x3F, 0xC7, 0xC0, 0x7F, 0xC3,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xF0, 0x3F,
  0x8F, 0xF8, 0x7F, 0x7F, 0xF8, 0xFE, 0xFF, 0xF9, 0xFB, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xF8, 0x3F, 0xDF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x03, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xF9, 0xFE,
  0xFF, 0xEF, 0xFE, 0xFF, 0xCF, 0xFC, 0xFF, 0x8F, 0xE0, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0xFD, 0xFC, 0x01, 0xFC, 0xFE,
  0x01, 0xFC, 0x7F, 0x01, 0xFE, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0xFE, 0x0F,
  0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x7F, 0x80,
  0xFE, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0xBF, 0xC0, 0x1F, 0xDF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xEF, 0xE0, 0x3F, 0xE7, 0xF0, 0x1F, 0xE3,
  0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC,
  0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x1F,
  0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xFD,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80,
  0x1F, 0x03, 0xE1, 0xFF, 0x81, 0xFF, 0x0F, 0xCF, 0xFF, 0x0F, 0xFE, 0x3F,
  0x7F, 0xFE, 0x7F, 0xFC, 0xFD, 0xFF, 0xFB, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFE, 0xFF, 0xFC, 0xFF, 0xBF, 0xE0, 0xFF, 0xC1, 0xFE, 0xFF,
  0x01, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0x00,
  0x7F, 0xFE, 0x01, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0x07, 0xFF, 0xE0,
  0x1F, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0xFE, 0x01, 0xFC, 0x01,
  0xFF, 0xF8, 0x07, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x1F, 0xFF, 0x80,
  0x7F, 0x00, 0x7F, 0xFE, 0x01, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0x07,
  0xFF, 0xE0, 0x1F, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0xFE, 0x01,
  0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x1F,
  0xFF, 0x80, 0x7F, 0x00, 0x7F, 0xFE, 0x01, 0xFC, 0x01, 0xFF, 0xF8, 0x07,
  0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0x81, 0xF0,
  0xFF, 0xC3, 0xF3, 0xFF, 0xC7, 0xEF, 0xFF, 0xCF, 0xDF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xBF, 0xFB, 0xFF, 0x7F, 0xC1, 0xFE, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0x87, 0xF8, 0x7F,
  0x81, 0xFE, 0x3F, 0x80, 0x7F, 0x3F, 0xC0, 0x3F, 0x9F, 0xC0, 0x1F, 0xEF,
  0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00,
  0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0x8F, 0xE0,
  0x1F, 0xC7, 0xF0, 0x1F, 0xE3, 0xFC, 0x0F, 0xE0, 0xFF, 0x9F, 0xF0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x3F, 0xE0,
  0xFC, 0x7F, 0xF0, 0xFC, 0xFF, 0xF8, 0xFD, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0xFF, 0xC3, 0xFC, 0xFF, 0x81, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFE,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFE, 0xFF, 0xF8, 0xFE, 0x7F, 0xF0,
  0xFE, 0x3F, 0xC0, 0xFE, 0x07, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xFF, 0x0F, 0xC1, 0xFF, 0xC7, 0xE1, 0xFF, 0xF7,
  0xF1, 0xFF, 0xFB, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0x8F, 0xFE, 0x7F, 0x81,
  0xFF, 0x3F, 0x80, 0xFF, 0xBF, 0xC0, 0x3F, 0xDF, 0xC0, 0x1F, 0xEF, 0xE0,
  0x0F, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE,
  0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0xDF, 0xE0, 0x1F,
  0xEF, 0xF0, 0x1F, 0xF3, 0xFC, 0x1F, 0xF9, 0xFF, 0xBF, 0xFC, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0x7F, 0x0F, 0xFF, 0xBF, 0x83, 0xFF, 0x9F, 0xC0, 0xFF,
  0x0F, 0xE0, 0x0C, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF8, 0x3F, 0xF8, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF,
  0xFF, 0xBF, 0xC1, 0xE7, 0xF0, 0x0C, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xC0, 0xFF, 0xF0, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x0C, 0x00, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xDF, 0x9F, 0xFF, 0x3F, 0x1F, 0xFC, 0x7E, 0x1F, 0xF0, 0xFC, 0x03,
  0x00, 0x00, 0xFF, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF0, 0x03, 0xF9,
  0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0xE3, 0xF8, 0x07,
  0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x1F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x00,
  0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0x7E,
  0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFC,
  0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xBF, 0x80,
  0x7F, 0xC0, 0x3F, 0x9F, 0xC0, 0x3F, 0xE0, 0x1F, 0xCF, 0xE0, 0x1F, 0xF0,
  0x0F, 0xE7, 0xF0, 0x0F, 0xF8, 0x07, 0xF1, 0xFC, 0x0F, 0xFE, 0x03, 0xF0,
  0xFE, 0x07, 0xFF, 0x03, 0xF8, 0x7F, 0x03, 0xEF, 0x81, 0xFC, 0x3F, 0x81,
  0xF7, 0xC0, 0xFE, 0x1F, 0xC0, 0xFB, 0xE0, 0x7E, 0x07, 0xF0, 0x7D, 0xF0,
  0x3F, 0x03, 0xF8, 0x7E, 0x7C, 0x3F, 0x81, 0xFC, 0x3E, 0x3E, 0x1F, 0xC0,
  0xFE, 0x1F, 0x1F, 0x0F, 0xE0, 0x3F, 0x0F, 0x8F, 0x87, 0xE0, 0x1F, 0xC7,
  0xC7, 0xC7, 0xF0, 0x0F, 0xE7, 0xE3, 0xF3, 0xF8, 0x07, 0xF3, 0xE0, 0xF9,
  0xFC, 0x03, 0xF9, 0xF0, 0x7C, 0xFC, 0x00, 0xFC, 0xF8, 0x3E, 0x7E, 0x00,
  0x7E, 0x7C, 0x1F, 0x3F, 0x00, 0x3F, 0x3E, 0x0F, 0xBF, 0x80, 0x1F, 0xDF,
  0x07, 0xDF, 0xC0, 0x07, 0xFF, 0x03, 0xEF, 0xC0, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x7F, 0x9F, 0xC0, 0x3F, 0x8F, 0xE0, 0x3F, 0x83, 0xF8, 0x1F,
  0xC1, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC7,
  0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xDF, 0xC0,
  0x0F, 0xEF, 0xE0, 0x07, 0xF3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFF,
  0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xE1, 0xFE, 0x07, 0xF0, 0xFE, 0x03,
  0xF8, 0x7F, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x7F, 0x80, 0x3F, 0xC0, 0xFF,
  0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE,
  0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0xE3, 0xF8, 0x07, 0xF0, 0xFE, 0x01,
  0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F,
  0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x1F, 0xC0,
  0x1F, 0x87, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0x7F, 0x3F,
  0x80, 0x0F, 0xCF, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x1F,
  0xBF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x02, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x1F,
  0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0x80,
  0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC,
  0x01, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x9F, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x80, 0x07, 0xFC, 0x40, 0x00,
  0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 8, 46, 16, 4, -45 },
  { 47, 20, 16, 26, 3, -45 },
  { 87, 29, 45, 31, 1, -45 },
  { 251, 23, 52, 28, 3, -48 },
  { 401, 42, 47, 46, 2, -46 },
  { 648, 31, 47, 33, 2, -46 },
  { 831, 8, 16, 14, 3, -45 },
  { 847, 15, 55, 19, 3, -45 },
  { 951, 15, 55, 19, 1, -45 },
  { 1055, 23, 24, 27, 2, -48 },
  { 1124, 25, 30, 28, 2, -37 },
  { 1218, 10, 15, 15, 2, -7 },
  { 1237, 15, 6, 18, 2, -20 },
  { 1249, 9, 10, 15, 3, -9 },
  { 1261, 23, 45, 25, 1, -45 },
  { 1391, 24, 47, 28, 2, -46 },
  { 1532, 18, 45, 28, 3, -45 },
  { 1634, 24, 46, 28, 2, -46 },
  { 1772, 24, 47, 28, 2, -46 },
  { 1913, 26, 45, 28, 1, -45 },
  { 2060, 23, 46, 28, 3, -45 },
  { 2193, 24, 47, 28, 2, -46 },
  { 2334, 24, 45, 28, 2, -45 },
  { 2469, 24, 47, 28, 2, -46 },
  { 2610, 24, 47, 28, 2, -46 },
  { 2751, 8, 36, 16, 4, -35 },
  { 2787, 10, 43, 16, 2, -35 },
  { 2841, 25, 29, 28, 2, -37 },
  { 2932, 25, 18, 28, 2, -31 },
  { 2989, 25, 29, 28, 2, -37 },
  { 3080, 21, 47, 22, 0, -46 },
  { 3204, 38, 50, 44, 3, -45 },
  { 3442, 31, 45, 31, 0, -45 },
  { 3617, 25, 45, 32, 4, -45 },
  { 3758, 25, 47, 30, 3, -46 },
  { 3905, 27, 45, 34, 4, -45 },
  { 4057, 20, 45, 27, 4, -45 },
  { 4170, 20, 45, 26, 4, -45 },
  { 4283, 28, 47, 35, 3, -46 },
  { 4448, 27, 45, 36, 4, -45 },
  { 4600, 15, 45, 19, 2, -45 },
  { 4685, 15, 58, 16, -3, -45 },
  { 4794, 27, 45, 31, 4, -45 },
  { 4946, 20, 45, 25, 4, -45 },
  { 5059, 39, 45, 47, 4, -45 },
  { 5279, 30, 45, 38, 4, -45 },
  { 5448, 31, 47, 36, 3, -46 },
  { 5631, 24, 45, 30, 4, -45 },
  { 5766, 31, 57, 36, 3, -46 },
  { 5987, 27, 45, 31, 4, -45 },
  { 6139, 22, 47, 26, 2, -46 },
  { 6269, 24, 45, 26, 1, -45 },
  { 6404, 27, 46, 35, 4, -45 },
  { 6560, 30, 45, 30, 0, -45 },
  { 6729, 47, 45, 46, 0, -45 },
  { 6994, 28, 45, 28, 0, -45 },
  { 7152, 28, 45, 28, 0, -45 },
  { 7310, 23, 45, 25, 1, -45 },
  { 7440, 14, 55, 20, 4, -45 },
  { 7537, 23, 45, 25, 1, -45 },
  { 7667, 14, 55, 20, 2, -45 },
  { 7764, 29, 26, 31, 1, -45 },
  { 7859, 27, 5, 26, 0, 5 },
  { 7876, 13, 10, 19, 3, -48 },
  { 7893, 22, 36, 28, 2, -35 },
  { 7992, 24, 49, 31, 4, -48 },
  { 8139, 21, 36, 24, 2, -35 },
  { 8234, 25, 49, 31, 2, -48 },
  { 8388, 24, 36, 28, 2, -35 },
  { 8496, 19, 48, 18, 1, -48 },
  { 8610, 25, 50, 31, 2, -35 },
  { 8767, 23, 48, 30, 4, -48 },
  { 8905, 8, 47, 15, 3, -47 },
  { 8952, 12, 62, 15, -1, -47 },
  { 9045, 25, 48, 28, 4, -48 },
  { 9195, 7, 48, 14, 4, -48 },
  { 9237, 38, 35, 46, 4, -35 },
  { 9404, 23, 35, 30, 4, -35 },
  { 9505, 25, 36, 30, 2, -35 },
  { 9618, 24, 50, 31, 4, -35 },
  { 9768, 25, 50, 31, 2, -35 },
  { 9925, 16, 35, 21, 4, -35 },
  { 9995, 19, 36, 23, 2, -35 },
  { 10081, 17, 43, 19, 1, -42 },
  { 10173, 23, 35, 30, 4, -34 },
  { 10274, 26, 34, 26, 0, -34 },
  { 10385, 41, 34, 41, 0, -34 },
  { 10560, 25, 34, 25, 0, -34 },
  { 10667, 26, 49, 26, 0, -34 },
  { 10827, 19, 34, 21, 1, -34 },
  { 10908, 19, 55, 22, 1, -45 },
  { 11039, 7, 63, 27, 10, -48 },
  { 11095, 19, 55, 22, 2, -45 },
  { 11226, 25, 10, 28, 2, -27 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold63pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD63PT7B_H_
