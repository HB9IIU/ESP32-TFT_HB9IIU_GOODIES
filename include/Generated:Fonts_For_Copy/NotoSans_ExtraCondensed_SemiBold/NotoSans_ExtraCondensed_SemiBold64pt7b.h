#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD64PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold64pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18,
  0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFD, 0xFE, 0x0F, 0xE7, 0xF0,
  0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3,
  0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFC, 0x0F, 0xE7, 0xE0, 0x7F, 0x3F, 0x01,
  0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF0, 0x00, 0x3E, 0x0F,
  0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xFC, 0x1F, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07,
  0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7E, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x3E, 0x0F, 0x80,
  0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xFC, 0x1F, 0x01, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x07, 0xC0,
  0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x03,
  0xE0, 0xFC, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0xF8, 0x3F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xDF, 0xCF, 0xF3, 0x83, 0x9F, 0xC7, 0x01,
  0x3F, 0x8E, 0x00, 0x7E, 0x1C, 0x00, 0xFC, 0x38, 0x01, 0xFC, 0x70, 0x03,
  0xF8, 0xE0, 0x07, 0xF9, 0xC0, 0x07, 0xFB, 0x80, 0x0F, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0E,
  0xFF, 0x00, 0x1C, 0xFF, 0x00, 0x38, 0xFE, 0x00, 0x70, 0xFC, 0x00, 0xE1,
  0xF8, 0x01, 0xC3, 0xF0, 0x03, 0x87, 0xF0, 0x07, 0x1F, 0xF8, 0x0E, 0x3F,
  0xFE, 0x1D, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0xFC,
  0x00, 0x1F, 0x87, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0x00,
  0x7C, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x1F, 0x00, 0x03, 0xF0,
  0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0xC1, 0xF8,
  0x1F, 0x00, 0x01, 0xF8, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0xF8,
  0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x87, 0xE0, 0x00,
  0x1F, 0x83, 0xF0, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x3F, 0x07, 0xE0, 0x3E,
  0x0F, 0xC7, 0xC1, 0xFF, 0x07, 0xC1, 0xF0, 0xF8, 0x7F, 0xF0, 0xFC, 0x3E,
  0x3F, 0x1F, 0xFE, 0x1F, 0x8F, 0xC7, 0xC7, 0xFF, 0xE1, 0xFF, 0xF1, 0xF8,
  0xFC, 0xFC, 0x3F, 0xFE, 0x3F, 0x1F, 0x0F, 0xC3, 0xFF, 0x87, 0xC7, 0xE1,
  0xF8, 0x3F, 0xE1, 0xF8, 0xFC, 0x3F, 0x03, 0xF8, 0x3E, 0x1F, 0x83, 0xE0,
  0x00, 0x07, 0xC3, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x0F, 0x80, 0x00,
  0x3E, 0x0F, 0x81, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x3F, 0x00, 0x01, 0xF8,
  0x3E, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xF8,
  0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xF0, 0x7C,
  0x00, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x01, 0xF0, 0x0F, 0xC3, 0xF0, 0x00,
  0x7E, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x8F, 0x80, 0x01, 0xF0,
  0x03, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0x80, 0x07,
  0xFF, 0x80, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x01, 0xFC, 0x1F, 0xFF, 0x81, 0xFC, 0x3F, 0xFF,
  0xC1, 0xFC, 0x7F, 0x9F, 0xC3, 0xFC, 0x7F, 0x9F, 0xE3, 0xFC, 0xFF, 0x0F,
  0xE3, 0xF8, 0xFF, 0x07, 0xF3, 0xF8, 0xFE, 0x07, 0xFF, 0xF8, 0xFE, 0x03,
  0xFF, 0xF0, 0xFE, 0x03, 0xFF, 0xF0, 0xFE, 0x01, 0xFF, 0xE0, 0xFE, 0x00,
  0xFF, 0xE0, 0xFE, 0x00, 0xFF, 0xC0, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF3, 0xFC, 0x0F, 0xFF, 0xE3, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0x00, 0x30,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F,
  0x80, 0x3F, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x40, 0x7C, 0x04, 0x78, 0x7C, 0x1C, 0x7F, 0x7C, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F,
  0xEF, 0xE0, 0x0F, 0xE7, 0xF0, 0x1F, 0xC7, 0xF0, 0x3F, 0x83, 0xF8, 0x1F,
  0x83, 0xF0, 0x07, 0x01, 0xE0, 0x03, 0x01, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC7, 0xF3,
  0xFC, 0xFF, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x7F, 0x1F, 0xC7, 0xF1, 0xF8,
  0x7E, 0x1F, 0x8F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x3F, 0x9F, 0xEF, 0xFF, 0xFF,
  0xFD, 0xFE, 0xFF, 0x3F, 0x06, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xE7, 0xFC, 0x3F, 0xC1, 0xFC,
  0x3F, 0x81, 0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x00, 0xFE,
  0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x7F, 0x80, 0xFE,
  0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0xC1, 0xFC, 0x1F, 0xE3, 0xFC,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xC0,
  0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F,
  0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFD, 0xFD, 0xFE, 0x7F,
  0xFF, 0x1F, 0xCF, 0x87, 0xF1, 0xC1, 0xFC, 0x20, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F,
  0x87, 0xFC, 0x3E, 0x03, 0xFE, 0x18, 0x01, 0xFE, 0x10, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0x07, 0xFE, 0x3C, 0x01, 0xFE, 0x10,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0xF0, 0x07, 0xFE, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xDF, 0xC0, 0x00, 0xFB, 0xF8, 0x00, 0x3E, 0x7F, 0x00, 0x07,
  0xCF, 0xE0, 0x01, 0xF1, 0xFC, 0x00, 0x3E, 0x3F, 0x80, 0x0F, 0x87, 0xF0,
  0x01, 0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0x83, 0xF8, 0x03, 0xF0,
  0x7F, 0x00, 0x7C, 0x0F, 0xE0, 0x1F, 0x81, 0xFC, 0x03, 0xE0, 0x3F, 0x80,
  0xFC, 0x07, 0xF0, 0x1F, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x03,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0xF8, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x10, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xD0, 0x00, 0x7F, 0xB0, 0x01, 0xFF,
  0x78, 0x07, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xF0, 0x10, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x02, 0x00, 0x3F, 0x0F, 0xF0, 0x1F, 0x8F, 0xFC, 0x0F,
  0xCF, 0xFF, 0x0F, 0xEF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9,
  0xFF, 0x83, 0xFC, 0xFF, 0x80, 0xFF, 0x7F, 0xC0, 0x7F, 0xBF, 0xC0, 0x1F,
  0xDF, 0xE0, 0x0F, 0xEF, 0xF0, 0x07, 0xF7, 0xF8, 0x03, 0xFB, 0xFC, 0x01,
  0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0,
  0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF8, 0x07, 0xF1, 0xFC, 0x07, 0xF8, 0xFF,
  0x03, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0x07,
  0xF8, 0xFF, 0x01, 0xFC, 0x7F, 0x00, 0xFF, 0x3F, 0x80, 0x3F, 0x9F, 0xC0,
  0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x07, 0xF0, 0xFE,
  0x03, 0xF8, 0x7F, 0x03, 0xFC, 0x3F, 0xC1, 0xFC, 0x0F, 0xF1, 0xFE, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x0F, 0xF9, 0xFF, 0x07, 0xF8, 0x7F, 0xC7, 0xF8, 0x1F, 0xE3, 0xF8, 0x07,
  0xFB, 0xFC, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x03, 0xFB, 0xFC, 0x01, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0xE7, 0xFE, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x3F, 0xC7, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x01, 0xFE, 0x7F, 0x00, 0xFE,
  0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x01, 0xFF,
  0x7F, 0x81, 0xFF, 0x7F, 0xEF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0x7F, 0x0F, 0xFE, 0x7F, 0x07, 0xFC, 0x7F, 0x01, 0xF0, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x18, 0x0F, 0x0F, 0xE3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC,
  0xFF, 0x1F, 0x80, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0xFF, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE,
  0x3F, 0x1F, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xF8, 0x3F, 0xE7,
  0x00, 0xFF, 0x10, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x7F, 0xF0, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x07, 0xF8, 0x0F,
  0x87, 0xE0, 0x3F, 0xFE, 0x1F, 0x8F, 0x80, 0xFF, 0xFC, 0x3F, 0x3F, 0x03,
  0xFF, 0xF8, 0x3E, 0x7E, 0x0F, 0xF7, 0xF0, 0x7C, 0xF8, 0x1F, 0x87, 0xE0,
  0xF9, 0xF0, 0x7E, 0x0F, 0xC1, 0xFF, 0xE0, 0xFC, 0x1F, 0x83, 0xFF, 0xC1,
  0xF0, 0x3F, 0x07, 0xFF, 0x03, 0xE0, 0x7E, 0x0F, 0xFE, 0x0F, 0xC0, 0xFC,
  0x1F, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0xF8, 0x3F, 0x03, 0xF0, 0x7F, 0xF0,
  0x7E, 0x07, 0xE0, 0xFF, 0xE0, 0xFC, 0x0F, 0xC1, 0xFF, 0xC1, 0xF8, 0x1F,
  0x03, 0xFF, 0x83, 0xF0, 0x3E, 0x07, 0xDF, 0x07, 0xE0, 0xFC, 0x0F, 0xBE,
  0x0F, 0xC1, 0xF8, 0x1F, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0xFC, 0x1F, 0x87,
  0xF0, 0xF9, 0xF8, 0x3F, 0x1F, 0xE3, 0xF3, 0xF0, 0x3F, 0xFB, 0xFF, 0xC3,
  0xE0, 0x7F, 0xF3, 0xFF, 0x87, 0xC0, 0x7F, 0xC7, 0xFE, 0x0F, 0xC0, 0x7F,
  0x07, 0xF8, 0x1F, 0x80, 0x38, 0x03, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xC0,
  0x00, 0xFF, 0x80, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFC,
  0x3F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8,
  0x1F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xF0,
  0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0,
  0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0,
  0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80,
  0x01, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFC, 0x07, 0xFE,
  0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x01,
  0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC,
  0x01, 0xFE, 0xFF, 0x00, 0x7F, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xC0, 0xFF, 0xCF, 0xF0,
  0x0F, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x1F, 0xEF, 0xF0, 0x0F, 0xFB, 0xFC, 0x1F, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F,
  0xF0, 0x7C, 0x3F, 0xE0, 0x0E, 0x1F, 0xE0, 0x01, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x04, 0x3F, 0xF8, 0x1E, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x3F, 0xF8, 0xFF,
  0x00, 0xFF, 0x8F, 0xF0, 0x07, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03,
  0xFC, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF,
  0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF,
  0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03,
  0xFC, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x0F, 0xF8, 0xFF, 0x03, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0x81, 0xFF, 0x80, 0x1C, 0x1F, 0xF0, 0x00,
  0x20, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF,
  0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0x7F,
  0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0xC0,
  0x1F, 0xE1, 0xFF, 0x80, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xF8, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF0, 0x1F, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFE, 0x7F, 0xF8,
  0xFF, 0xF1, 0xFF, 0x83, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x07,
  0xFB, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x3F, 0xCF, 0xE0, 0x0F, 0xF1, 0xFC,
  0x03, 0xFE, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x1F, 0xE0, 0xFE, 0x03, 0xFC,
  0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x07, 0xF8, 0x0F, 0xE1,
  0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0x8F, 0xF8, 0x07, 0xF1, 0xFE, 0x00,
  0xFE, 0x7F, 0x80, 0x1F, 0xCF, 0xF0, 0x03, 0xFB, 0xFC, 0x00, 0x7F, 0x7F,
  0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xDF, 0xE0, 0x0F, 0xF1, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x3F,
  0x83, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF,
  0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xC1, 0xFC,
  0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x07, 0xF8, 0xFE, 0x00, 0xFF,
  0x1F, 0xC0, 0x0F, 0xF3, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x3F, 0xEF, 0xE0,
  0x03, 0xFD, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xEF, 0xC0, 0x03, 0xF7, 0xFF,
  0xDF, 0x80, 0x07, 0xEF, 0xFF, 0xBF, 0x00, 0x0F, 0xDF, 0xFF, 0x7F, 0x00,
  0x3F, 0xBF, 0xFE, 0x7E, 0x00, 0x7E, 0x7F, 0xFC, 0xFC, 0x00, 0xFC, 0xFF,
  0xF9, 0xF8, 0x01, 0xF9, 0xFF, 0xF3, 0xF8, 0x07, 0xE3, 0xFF, 0xE3, 0xF0,
  0x0F, 0xCF, 0xFF, 0xE7, 0xE0, 0x1F, 0x9F, 0xFF, 0xCF, 0xC0, 0x7F, 0x3F,
  0xFF, 0x8F, 0xC0, 0xFC, 0x7F, 0xFF, 0x1F, 0x81, 0xF8, 0xFF, 0xFE, 0x3F,
  0x03, 0xF1, 0xFF, 0xFC, 0x7F, 0x0F, 0xC3, 0xFF, 0xF8, 0x7E, 0x1F, 0x87,
  0xFF, 0xF0, 0xFC, 0x3F, 0x0F, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0xFF, 0xC3,
  0xF9, 0xF8, 0x3F, 0xFF, 0x83, 0xF3, 0xF0, 0x7F, 0xFF, 0x07, 0xE7, 0xE0,
  0xFF, 0xFE, 0x0F, 0xDF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xF8,
  0x1F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xF0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xE0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xC0, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xDF, 0xC0, 0x3F, 0xFE, 0xFE, 0x01,
  0xFF, 0xF7, 0xF0, 0x0F, 0xFF, 0x9F, 0xC0, 0x7F, 0xFC, 0xFE, 0x03, 0xFF,
  0xE3, 0xF8, 0x1F, 0xFF, 0x1F, 0xC0, 0xFF, 0xF8, 0xFF, 0x07, 0xFF, 0xC3,
  0xF8, 0x3F, 0xFE, 0x1F, 0xC1, 0xFF, 0xF8, 0x7F, 0x0F, 0xFF, 0xC3, 0xF8,
  0x7F, 0xFE, 0x0F, 0xE3, 0xFF, 0xF0, 0x7F, 0x1F, 0xFF, 0x83, 0xFC, 0xFF,
  0xFC, 0x0F, 0xE3, 0xFF, 0xE0, 0x7F, 0x1F, 0xFF, 0x01, 0xFC, 0xFF, 0xF8,
  0x0F, 0xE7, 0xFF, 0xC0, 0x7F, 0xBF, 0xFE, 0x01, 0xFD, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x1F, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0x80, 0x0F, 0xF0,
  0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFE, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xBF, 0x80, 0x00,
  0xFE, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x0F,
  0xF1, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x87, 0xFC, 0x01, 0xFF,
  0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0x03, 0xFE,
  0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x0F, 0xFE, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x1F, 0xFC, 0x0F, 0xF8, 0x0F,
  0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F,
  0x9F, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0xFE, 0x7F, 0x80,
  0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x87, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x07,
  0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xF8,
  0x1F, 0xF8, 0xFF, 0x01, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC,
  0x7F, 0x80, 0x3F, 0x8F, 0xF0, 0x07, 0xF1, 0xFE, 0x00, 0xFE, 0x3F, 0xC0,
  0x1F, 0xC7, 0xF8, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x1F, 0xE0, 0x1F, 0xE3,
  0xFC, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x8F, 0xF0, 0x3F, 0xE1, 0xFE, 0x3F,
  0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xF0, 0xFE,
  0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0xFF,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE,
  0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8,
  0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFC, 0x01, 0xFF,
  0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xE0, 0x3C, 0x7F, 0x80,
  0x18, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xD8, 0x00, 0x7F,
  0xBC, 0x01, 0xFF, 0x7F, 0x87, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00,
  0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xF7, 0xF0,
  0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xF0, 0x0F, 0xF3, 0xFF, 0x03, 0xFE,
  0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x8F,
  0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xF0,
  0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03,
  0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x3F,
  0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0x80,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0x9F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xF8, 0x00, 0xFE, 0x7F, 0x00,
  0x1F, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xF8, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xC3, 0xF8, 0x03,
  0xEF, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xDF, 0x00, 0x7F, 0x0F, 0xF0, 0x1F,
  0xBF, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0x7E,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFD, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xF9,
  0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xE3, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xC7,
  0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0x8F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x1F,
  0x83, 0xF8, 0x07, 0xF0, 0x7E, 0x3F, 0x07, 0xF0, 0x0F, 0xE1, 0xFC, 0x3F,
  0x1F, 0xE0, 0x0F, 0xE3, 0xF0, 0x7E, 0x3F, 0x80, 0x1F, 0xC7, 0xE0, 0xFC,
  0x7F, 0x00, 0x3F, 0x8F, 0xC1, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0x83, 0xF1,
  0xFC, 0x00, 0x7E, 0x7F, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0xFC, 0x07, 0xEF,
  0xE0, 0x01, 0xFD, 0xF8, 0x0F, 0xDF, 0xC0, 0x03, 0xFB, 0xF0, 0x1F, 0xBF,
  0x80, 0x07, 0xF7, 0xE0, 0x3F, 0x7F, 0x00, 0x07, 0xEF, 0xC0, 0x3E, 0xFE,
  0x00, 0x0F, 0xDF, 0x00, 0x7D, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFB, 0xF0,
  0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xF3, 0xF8, 0x01,
  0xFE, 0x3F, 0xC0, 0x1F, 0xE1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0xC1,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xF8, 0x07, 0xF0,
  0x7F, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0,
  0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xDF, 0xC0, 0x03, 0xF8,
  0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x07, 0xF0,
  0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x81, 0xFE,
  0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0xC3, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x1F,
  0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00,
  0xFE, 0x3F, 0x80, 0x1F, 0xE3, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x1F, 0xC1,
  0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x3F,
  0x9F, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFC, 0x3F,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x80,
  0x3F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x81, 0xFC,
  0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0xFE, 0x7F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x81,
  0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xC0, 0x01, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x81, 0xF9, 0xFF, 0x83, 0x80, 0xFF, 0x04, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFB, 0xFB, 0xFE, 0x07, 0xF7, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xEF, 0xF1, 0xFF,
  0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0x3F, 0x3F, 0xFE, 0x7E, 0x3F, 0xF8, 0xFC,
  0x3F, 0xC1, 0xF8, 0x0E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0xFF, 0xE0, 0xFE, 0x7F, 0xF8, 0x7F,
  0x7F, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFC, 0x1F, 0xE7,
  0xFC, 0x07, 0xF3, 0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0x7F,
  0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFE, 0x00, 0xFE, 0xFF,
  0x00, 0xFF, 0x7F, 0xC0, 0x7F, 0x3F, 0xF0, 0x7F, 0x9F, 0xFE, 0xFF, 0xCF,
  0xFF, 0xFF, 0xC7, 0xEF, 0xFF, 0xE3, 0xF3, 0xFF, 0xE1, 0xF8, 0xFF, 0xE0,
  0xFC, 0x3F, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF,
  0x81, 0x87, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x13, 0xFE, 0x03, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x7F, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x07, 0xF0, 0xFE, 0x0F, 0xFE, 0x7F, 0x0F, 0xFF, 0xBF, 0x87,
  0xFF, 0xDF, 0xC7, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFE, 0x1F, 0xF9,
  0xFE, 0x07, 0xFD, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x00, 0x3F,
  0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0,
  0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0x7F,
  0x80, 0x7F, 0x9F, 0xC0, 0x3F, 0xCF, 0xF0, 0x3F, 0xE7, 0xFE, 0x7F, 0xF1,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFE, 0xFC, 0x3F, 0xFE, 0x7E, 0x0F, 0xFE, 0x3F,
  0x03, 0xFE, 0x1F, 0x80, 0x38, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xE3,
  0xFC, 0x3F, 0xC1, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x7E, 0x7F, 0x00,
  0x7E, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x02, 0x3F, 0xE0, 0x0E, 0x1F, 0xF8,
  0x7E, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFC,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFE, 0x60,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x1F, 0x83, 0xFF, 0x8F, 0xC3, 0xFF,
  0xE7, 0xE1, 0xFF, 0xF3, 0xF1, 0xFF, 0xFD, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF,
  0x87, 0xFE, 0x7F, 0x81, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF,
  0xC0, 0x1F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFB, 0xF8, 0x01,
  0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0xC0,
  0x3F, 0xDF, 0xE0, 0x1F, 0xE7, 0xF0, 0x1F, 0xF3, 0xFC, 0x0F, 0xF9, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0x7F, 0x0F, 0xFF, 0xBF, 0x83,
  0xFF, 0x9F, 0xC0, 0xFF, 0x8F, 0xE0, 0x0C, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x8C, 0x00, 0x3F, 0xC7, 0x80, 0x3F, 0xE3, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF0,
  0x7F, 0x3F, 0xF8, 0xFE, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xF7, 0xFF, 0xF7,
  0xFF, 0xFF, 0xEF, 0xFC, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFE, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0x7F, 0x7F, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x03, 0xE0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x07,
  0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0xFF, 0x0F, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFF,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0xFD,
  0xFC, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFF,
  0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x3F,
  0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x9F,
  0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xEF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F,
  0xF7, 0xF0, 0x1F, 0xF3, 0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x83,
  0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC,
  0x3F, 0x80, 0xFF, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xE7, 0xF0, 0x07,
  0xF3, 0xF8, 0x03, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x1F, 0xC0, 0x3F, 0xC1, 0xF8,
  0xFF, 0xE0, 0xFF, 0xC3, 0xF3, 0xFF, 0xE3, 0xFF, 0xC7, 0xEF, 0xFF, 0xCF,
  0xFF, 0xCF, 0xDF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xF0, 0xFF, 0xE1, 0xFF, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0xFF, 0x01, 0xFF,
  0x01, 0xFD, 0xFE, 0x03, 0xFE, 0x03, 0xFB, 0xFC, 0x07, 0xF8, 0x07, 0xFF,
  0xF0, 0x07, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F,
  0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0x00, 0xFF,
  0xFE, 0x00, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFC, 0x03, 0xFF, 0xF8, 0x03,
  0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xE0, 0x1F,
  0xFF, 0xC0, 0x1F, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0x80, 0x7F, 0xFF, 0x00,
  0x7F, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFC, 0x03,
  0xFF, 0xF8, 0x03, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xF0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0x80,
  0x7F, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0x01, 0xFF, 0xFC,
  0x01, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0xFC, 0x1F, 0xC1,
  0xF8, 0xFF, 0xE3, 0xF3, 0xFF, 0xE7, 0xEF, 0xFF, 0xEF, 0xDF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xBF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFE, 0x0F,
  0xF0, 0xFF, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0xE0, 0x0F, 0xE7, 0xF0,
  0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xDF, 0xC0,
  0x0F, 0xF7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F,
  0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF8, 0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0xFF,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0xFC,
  0x1F, 0xC0, 0x7E, 0x3F, 0xF8, 0x3F, 0x3F, 0xFE, 0x1F, 0x9F, 0xFF, 0x8F,
  0xDF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0x07, 0xF9, 0xFF, 0x01, 0xFC,
  0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x1F, 0xDF, 0xC0, 0x0F,
  0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFD, 0xFC,
  0x00, 0xFE, 0xFF, 0x00, 0x7F, 0x7F, 0x80, 0x3F, 0xBF, 0xC0, 0x3F, 0xDF,
  0xF0, 0x1F, 0xCF, 0xFC, 0x1F, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF1,
  0xFD, 0xFF, 0xF8, 0xFE, 0xFF, 0xF8, 0x7F, 0x3F, 0xF8, 0x3F, 0x8F, 0xF8,
  0x1F, 0xC0, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x1F, 0x83, 0xFF, 0x8F, 0xC3, 0xFF, 0xE7, 0xE1, 0xFF, 0xF3,
  0xF1, 0xFF, 0xFD, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0x87, 0xFE, 0x7F, 0x81,
  0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xC0, 0x1F, 0xEF, 0xE0,
  0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE,
  0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F,
  0xE7, 0xF0, 0x1F, 0xF3, 0xFC, 0x0F, 0xF9, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xBF, 0x83, 0xFF, 0x9F, 0xC0, 0xFF,
  0x8F, 0xE0, 0x0C, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0xF8, 0x1F, 0xFE, 0x1F, 0xBF, 0x1F, 0xDF, 0x9F, 0xEF, 0xDF, 0xF7,
  0xEF, 0xFB, 0xFF, 0xFD, 0xFF, 0xC2, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xF8, 0xFF, 0xFF, 0x9F,
  0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xC0, 0x67, 0xF0, 0x04, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F,
  0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF,
  0xE0, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF,
  0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0,
  0x0C, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x7F, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xBF, 0x3F, 0xFE,
  0x7E, 0x3F, 0xF8, 0xFC, 0x3F, 0xE1, 0xF8, 0x06, 0x00, 0x00, 0xFF, 0x00,
  0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x03, 0xFD, 0xFC, 0x00, 0xFF, 0x7F,
  0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFE,
  0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F,
  0x83, 0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0xC0,
  0x1F, 0xC7, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x3F,
  0x80, 0x0F, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xBF, 0x80, 0x3F,
  0xC0, 0x1F, 0xDF, 0xC0, 0x3F, 0xE0, 0x0F, 0xEF, 0xE0, 0x1F, 0xF0, 0x07,
  0xF7, 0xF0, 0x0F, 0xFC, 0x07, 0xF1, 0xFC, 0x07, 0xFE, 0x03, 0xF8, 0xFE,
  0x03, 0xFF, 0x01, 0xFC, 0x7F, 0x03, 0xFF, 0x80, 0xFE, 0x3F, 0x81, 0xFF,
  0xC0, 0x7E, 0x1F, 0xC0, 0xFB, 0xF0, 0x7F, 0x07, 0xF0, 0x7C, 0xF8, 0x3F,
  0x83, 0xF8, 0x3E, 0x7C, 0x1F, 0xC1, 0xFC, 0x1F, 0x3E, 0x0F, 0xE0, 0xFE,
  0x1F, 0x9F, 0x07, 0xE0, 0x3F, 0x0F, 0x8F, 0xC7, 0xF0, 0x1F, 0xC7, 0xC7,
  0xE3, 0xF8, 0x0F, 0xE3, 0xE1, 0xF1, 0xFC, 0x07, 0xF1, 0xF0, 0xF8, 0xFC,
  0x03, 0xF9, 0xF8, 0x7C, 0x7E, 0x00, 0xFC, 0xFC, 0x3E, 0x7F, 0x00, 0x7E,
  0x7C, 0x1F, 0x3F, 0x80, 0x3F, 0xBE, 0x0F, 0xDF, 0xC0, 0x1F, 0xDF, 0x03,
  0xEF, 0xC0, 0x0F, 0xEF, 0x81, 0xF7, 0xE0, 0x03, 0xF7, 0xC0, 0xFB, 0xF0,
  0x01, 0xFB, 0xE0, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xCF, 0xE0,
  0x1F, 0xC7, 0xF8, 0x1F, 0xE1, 0xFC, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F,
  0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xF7, 0xF8, 0x03, 0xF9,
  0xFC, 0x03, 0xF8, 0xFF, 0x01, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x7F, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x3F,
  0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xDF, 0xC0, 0x07,
  0xF7, 0xF0, 0x03, 0xFD, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0x8F, 0xE0,
  0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x7F, 0x07,
  0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0xFE,
  0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF0, 0x07, 0xF1,
  0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03,
  0xF3, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xEF, 0xC0,
  0x01, 0xFB, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xF0, 0x01, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0xBF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x1F, 0xFE,
  0x80, 0x03, 0xFC, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 8, 47, 16, 4, -46 },
  { 48, 21, 17, 27, 3, -46 },
  { 93, 29, 46, 31, 1, -46 },
  { 260, 23, 53, 29, 3, -49 },
  { 413, 43, 47, 47, 2, -46 },
  { 666, 32, 47, 34, 2, -46 },
  { 854, 8, 17, 14, 3, -46 },
  { 871, 15, 56, 20, 3, -46 },
  { 976, 16, 56, 20, 1, -46 },
  { 1088, 24, 24, 27, 2, -49 },
  { 1160, 25, 31, 29, 2, -38 },
  { 1257, 10, 15, 15, 2, -7 },
  { 1276, 15, 7, 19, 2, -21 },
  { 1290, 9, 10, 16, 3, -9 },
  { 1302, 24, 46, 25, 1, -46 },
  { 1440, 24, 47, 29, 2, -46 },
  { 1581, 18, 46, 29, 3, -46 },
  { 1685, 24, 46, 29, 2, -46 },
  { 1823, 24, 47, 29, 2, -46 },
  { 1964, 27, 46, 29, 1, -46 },
  { 2120, 23, 47, 29, 3, -46 },
  { 2256, 25, 47, 29, 2, -46 },
  { 2403, 25, 46, 29, 2, -46 },
  { 2547, 25, 47, 29, 2, -46 },
  { 2694, 24, 47, 29, 2, -46 },
  { 2835, 8, 36, 16, 4, -35 },
  { 2871, 10, 43, 16, 2, -35 },
  { 2925, 25, 30, 29, 2, -38 },
  { 3019, 25, 19, 29, 2, -32 },
  { 3079, 25, 30, 29, 2, -38 },
  { 3173, 21, 47, 22, 0, -46 },
  { 3297, 39, 51, 44, 3, -46 },
  { 3546, 32, 46, 32, 0, -46 },
  { 3730, 26, 46, 33, 4, -46 },
  { 3880, 25, 47, 30, 3, -46 },
  { 4027, 28, 46, 35, 4, -46 },
  { 4188, 19, 46, 27, 5, -46 },
  { 4298, 19, 46, 26, 5, -46 },
  { 4408, 29, 47, 36, 3, -46 },
  { 4579, 27, 46, 36, 5, -46 },
  { 4735, 16, 46, 19, 2, -46 },
  { 4827, 15, 59, 16, -3, -46 },
  { 4938, 27, 46, 31, 5, -46 },
  { 5094, 20, 46, 25, 4, -46 },
  { 5209, 39, 46, 48, 5, -46 },
  { 5434, 29, 46, 39, 5, -46 },
  { 5601, 31, 47, 37, 3, -46 },
  { 5784, 24, 46, 30, 4, -46 },
  { 5922, 31, 57, 37, 3, -46 },
  { 6143, 27, 46, 32, 4, -46 },
  { 6299, 23, 47, 27, 2, -46 },
  { 6435, 24, 46, 26, 1, -46 },
  { 6573, 27, 47, 35, 4, -46 },
  { 6732, 31, 46, 31, 0, -46 },
  { 6911, 47, 46, 47, 0, -46 },
  { 7182, 28, 46, 29, 0, -46 },
  { 7343, 28, 46, 28, 0, -46 },
  { 7504, 23, 46, 25, 1, -46 },
  { 7637, 14, 56, 20, 4, -46 },
  { 7735, 23, 46, 25, 1, -46 },
  { 7868, 14, 56, 20, 2, -46 },
  { 7966, 29, 27, 32, 1, -46 },
  { 8064, 27, 5, 27, 0, 5 },
  { 8081, 13, 10, 19, 3, -49 },
  { 8098, 23, 36, 29, 2, -35 },
  { 8202, 25, 50, 31, 4, -49 },
  { 8359, 21, 36, 24, 2, -35 },
  { 8454, 25, 50, 31, 2, -49 },
  { 8611, 24, 36, 28, 2, -35 },
  { 8719, 19, 49, 18, 1, -49 },
  { 8836, 25, 50, 31, 2, -35 },
  { 8993, 23, 49, 31, 4, -49 },
  { 9134, 8, 48, 15, 3, -48 },
  { 9182, 12, 63, 15, -1, -48 },
  { 9277, 25, 49, 29, 4, -49 },
  { 9431, 7, 49, 15, 4, -49 },
  { 9474, 39, 35, 46, 4, -35 },
  { 9645, 23, 35, 31, 4, -35 },
  { 9746, 26, 36, 30, 2, -35 },
  { 9863, 25, 50, 31, 4, -35 },
  { 10020, 25, 50, 31, 2, -35 },
  { 10177, 17, 35, 21, 4, -35 },
  { 10252, 19, 36, 23, 2, -35 },
  { 10338, 17, 43, 19, 1, -42 },
  { 10430, 23, 36, 31, 4, -35 },
  { 10534, 26, 35, 27, 0, -35 },
  { 10648, 41, 35, 42, 0, -35 },
  { 10828, 25, 35, 26, 0, -35 },
  { 10938, 26, 50, 27, 0, -35 },
  { 11101, 19, 35, 22, 1, -35 },
  { 11185, 19, 56, 23, 1, -46 },
  { 11318, 7, 64, 27, 10, -49 },
  { 11374, 19, 56, 23, 2, -46 },
  { 11507, 25, 9, 29, 2, -27 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold64pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD64PT7B_H_
