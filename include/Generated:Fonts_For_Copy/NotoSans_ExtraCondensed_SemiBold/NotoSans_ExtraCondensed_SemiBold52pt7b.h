#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD52PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold52pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xC2, 0x00, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0x78,
  0x1E, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x87,
  0x80, 0x1F, 0x0F, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0xF0,
  0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC1, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0xF0, 0xF8, 0x01, 0xE1, 0xE0, 0x03,
  0xC3, 0xC0, 0x07, 0x87, 0x80, 0x1F, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x78,
  0x7C, 0x00, 0xF0, 0xF8, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF8, 0x3E, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0xF8,
  0x01, 0xE1, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00,
  0x3E, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0xF0, 0xF8, 0x01, 0xE1, 0xF0, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xEF, 0xCF, 0xCC, 0x13,
  0xF1, 0x80, 0x7E, 0x30, 0x0F, 0xC6, 0x01, 0xF8, 0xC0, 0x1F, 0x18, 0x03,
  0xF3, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x67, 0xE0,
  0x0C, 0xFC, 0x01, 0x8F, 0x80, 0x31, 0xF0, 0x06, 0x3F, 0x00, 0xC7, 0xF8,
  0x19, 0xFF, 0xE3, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x0F,
  0xFE, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xF0,
  0x03, 0xFE, 0x00, 0x7C, 0x01, 0xFF, 0xC0, 0x1E, 0x00, 0x7F, 0xF0, 0x0F,
  0x80, 0x1E, 0x3E, 0x03, 0xC0, 0x0F, 0x8F, 0x81, 0xF0, 0x03, 0xE1, 0xE0,
  0x7C, 0x00, 0xF8, 0x78, 0x1E, 0x00, 0x3C, 0x1E, 0x0F, 0x80, 0x0F, 0x07,
  0xC3, 0xE0, 0x03, 0xC1, 0xF0, 0xF0, 0x00, 0xF0, 0x7C, 0x7C, 0x00, 0x3C,
  0x1F, 0x1E, 0x00, 0x0F, 0x07, 0x87, 0x80, 0x03, 0xE1, 0xE3, 0xE1, 0xE0,
  0xF8, 0x78, 0xF0, 0xFE, 0x3E, 0x3E, 0x7C, 0x7F, 0xC7, 0x8F, 0x9F, 0x3F,
  0xF9, 0xFF, 0xC7, 0x8F, 0xBE, 0x3F, 0xF3, 0xE7, 0xC7, 0x8F, 0xF8, 0xF1,
  0xF1, 0xF1, 0xFC, 0x3C, 0x78, 0x7C, 0x1C, 0x1F, 0x1E, 0x1F, 0x00, 0x07,
  0x87, 0x87, 0xC0, 0x03, 0xE1, 0xE0, 0xF0, 0x00, 0xF8, 0x78, 0x3C, 0x00,
  0x3C, 0x1E, 0x0F, 0x00, 0x1F, 0x07, 0x83, 0xC0, 0x07, 0x81, 0xE1, 0xF0,
  0x01, 0xE0, 0x78, 0x7C, 0x00, 0xF8, 0x1E, 0x1F, 0x00, 0x3C, 0x07, 0xC7,
  0xC0, 0x1F, 0x01, 0xF1, 0xE0, 0x07, 0xC0, 0x3F, 0xF8, 0x01, 0xE0, 0x0F,
  0xFC, 0x00, 0xF8, 0x01, 0xFF, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x00, 0x30,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x07, 0xF3, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x1F, 0x00,
  0x1F, 0x87, 0xC0, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xE7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xF0, 0x7E, 0x1F, 0xFC, 0x1F, 0x8F, 0xFF, 0x87, 0xE7, 0xF7, 0xF1,
  0xF9, 0xF8, 0xFC, 0x7C, 0x7E, 0x1F, 0xBF, 0x1F, 0x87, 0xFF, 0xCF, 0xC0,
  0xFF, 0xE3, 0xF0, 0x1F, 0xF8, 0xFC, 0x07, 0xFE, 0x3F, 0x00, 0xFF, 0x0F,
  0xE0, 0x1F, 0xC1, 0xF8, 0x0F, 0xF0, 0x7F, 0x07, 0xFE, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0xFE, 0x1F, 0xFF, 0x1F, 0x81, 0xFF,
  0x07, 0xF0, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xBE, 0x78, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07,
  0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F,
  0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x03,
  0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F,
  0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x04, 0x0F, 0x02, 0x78, 0xF1, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0,
  0x0F, 0xDF, 0x01, 0xF9, 0xF8, 0x3F, 0x8F, 0xC1, 0xF0, 0xF8, 0x0E, 0x07,
  0x00, 0x20, 0x40, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x3F, 0x3F, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7C, 0x7C, 0xFC, 0xF8, 0xF8, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x08,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F,
  0xFF, 0x81, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xC7, 0xF3, 0xF0, 0x7E, 0x7E,
  0x0F, 0xCF, 0xC0, 0xF9, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xF7, 0xC0,
  0x7E, 0xFC, 0x0F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x3F, 0x1F, 0xC7, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x10,
  0x00, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F, 0xF1,
  0xFF, 0xCF, 0xFF, 0x7E, 0xFF, 0xF3, 0xF7, 0x8F, 0xCC, 0x3F, 0x10, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0xC0, 0x01, 0xFF, 0x80, 0xFF,
  0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF9, 0xFF, 0xFF, 0x9E, 0x07, 0xF1, 0x80,
  0x7E, 0x20, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF,
  0xF8, 0xFF, 0xFF, 0x9E, 0x07, 0xF1, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xFF,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE,
  0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07,
  0xBF, 0x00, 0x1E, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xCF, 0xC0, 0x1F, 0x3F,
  0x00, 0x78, 0xFC, 0x03, 0xE3, 0xF0, 0x0F, 0x0F, 0xC0, 0x7C, 0x3F, 0x01,
  0xE0, 0xFC, 0x0F, 0x83, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3F, 0x07, 0xC0,
  0xFC, 0x3E, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x08, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0xE0, 0x03, 0xF7, 0x01, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF,
  0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x7C,
  0x0F, 0xCF, 0xF0, 0xFD, 0xFF, 0x8F, 0xBF, 0xFC, 0xFF, 0xFF, 0xCF, 0xF1,
  0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC,
  0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0xFC, 0x07, 0xE7,
  0xC0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x3F, 0x0F, 0xC3, 0xFF, 0xFC,
  0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x20,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC7, 0xF1, 0xFC, 0x7E, 0x0F, 0xE7, 0xC0, 0x7E, 0xFC,
  0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xE7, 0xC0, 0x7E, 0x7E, 0x07, 0xC7,
  0xE0, 0xFC, 0x3F, 0x1F, 0xC3, 0xFB, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0,
  0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFB, 0xF8, 0x7F, 0x1F,
  0xC7, 0xE0, 0xFC, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0xFE,
  0x07, 0xE7, 0xF9, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x7F, 0xF8,
  0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0x87, 0xF7, 0xE0, 0x7E,
  0xFC, 0x0F, 0xDF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF8, 0x3F, 0xBF, 0x8F, 0xF7, 0xFF, 0xFE, 0x7F, 0xF7, 0xCF, 0xFC, 0xF8,
  0xFF, 0x9F, 0x07, 0xC7, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x0F,
  0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x01,
  0x80, 0x00, 0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF7, 0xC2, 0x00, 0x08, 0x3E, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x7E, 0x7E, 0x7E, 0x7C,
  0x7C, 0x7C, 0xF8, 0xF8, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x08, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0,
  0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0xFC, 0x1F, 0xFF,
  0x9F, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xFC, 0xE0, 0xFE, 0x40, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x3E, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x1F,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0xF0,
  0x3E, 0x3E, 0x07, 0xFE, 0x3E, 0x3C, 0x0F, 0xFE, 0x1E, 0x7C, 0x1F, 0xFE,
  0x1E, 0x7C, 0x3F, 0x1E, 0x1F, 0x78, 0x3E, 0x1E, 0x1F, 0x78, 0x7C, 0x3E,
  0x0F, 0x78, 0x7C, 0x3E, 0x0F, 0xF8, 0x7C, 0x3E, 0x0F, 0xF8, 0x78, 0x3E,
  0x0F, 0xF8, 0x78, 0x3E, 0x0F, 0xF8, 0x78, 0x3E, 0x0F, 0xF8, 0x78, 0x3E,
  0x1F, 0xF8, 0x78, 0x3E, 0x1F, 0xF8, 0x78, 0x3E, 0x1F, 0xF8, 0x78, 0x3E,
  0x1E, 0xF8, 0x7C, 0x7E, 0x1E, 0x78, 0x7C, 0x7E, 0x3E, 0x78, 0x3F, 0xEF,
  0xFC, 0x78, 0x3F, 0xE7, 0xF8, 0x7C, 0x1F, 0xC7, 0xF8, 0x7C, 0x0F, 0x83,
  0xE0, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x80, 0x07, 0xF0, 0x03,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xF7, 0xE0, 0x00, 0x7C,
  0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00,
  0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8,
  0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x0F, 0xC0,
  0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFE, 0x01, 0xFC,
  0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF1, 0xFC, 0x00,
  0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xFB, 0xF8,
  0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xC1, 0xFE, 0xFC, 0x07, 0xEF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7E,
  0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFC, 0x1F, 0xEF, 0xC0,
  0x7E, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC1, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0x81, 0xC3, 0xF8, 0x02,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x02, 0x1F, 0xE0, 0x30, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x10, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3,
  0xF0, 0xFF, 0x8F, 0xC0, 0xFF, 0x3F, 0x01, 0xFC, 0xFC, 0x03, 0xF3, 0xF0,
  0x0F, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x3F,
  0xBF, 0x00, 0xFE, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0xFE, 0x3F,
  0x1F, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0,
  0x0C, 0x1F, 0xC0, 0x04, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0x7E, 0x07, 0xFF, 0x7E, 0x07, 0xFF, 0x7E, 0x07,
  0xFF, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x80,
  0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0xE0, 0x3F, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x04,
  0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xF1, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0,
  0x7E, 0x03, 0xF0, 0x3F, 0xBF, 0xFD, 0xFF, 0xCF, 0xFE, 0x7F, 0xE3, 0xFE,
  0x07, 0x00, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F, 0x3F, 0x01,
  0xF8, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x0F, 0xC1, 0xFC, 0x3F, 0x07, 0xE0,
  0xFC, 0x3F, 0x83, 0xF0, 0xFC, 0x0F, 0xC7, 0xF0, 0x3F, 0x3F, 0x80, 0xFC,
  0xFE, 0x03, 0xF7, 0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x0F, 0xE7, 0xE0, 0x3F, 0x1F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0,
  0xFE, 0x0F, 0xC3, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F,
  0x0F, 0xC0, 0xFE, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xF3, 0xF0, 0x0F, 0xCF,
  0xC0, 0x3F, 0xBF, 0x00, 0xFE, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF7, 0xC0, 0x1F,
  0x7F, 0xEF, 0x80, 0x3E, 0xFF, 0xDF, 0x00, 0x7D, 0xFF, 0xBE, 0x00, 0xFB,
  0xFF, 0x3E, 0x03, 0xE7, 0xFE, 0x7C, 0x07, 0xCF, 0xFC, 0xF8, 0x0F, 0x9F,
  0xF9, 0xF0, 0x3E, 0x3F, 0xF1, 0xF0, 0x7C, 0x7F, 0xE3, 0xE0, 0xF8, 0xFF,
  0xC7, 0xC1, 0xF1, 0xFF, 0x8F, 0xC7, 0xC3, 0xFF, 0x0F, 0x8F, 0x87, 0xFE,
  0x1F, 0x1F, 0x0F, 0xFC, 0x3E, 0x3C, 0x1F, 0xF8, 0x3E, 0xF8, 0x3F, 0xF0,
  0x7D, 0xF0, 0x7F, 0xE0, 0xFB, 0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x81,
  0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x0F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xE0, 0x3F, 0xF0, 0x1F, 0xC0, 0x7F, 0xE0, 0x3F,
  0x00, 0xFF, 0xC0, 0x7E, 0x01, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFB, 0xE0, 0x3F, 0xFB, 0xF0, 0x3F, 0xF9, 0xF0,
  0x3F, 0xF9, 0xF8, 0x3F, 0xF9, 0xF8, 0x3F, 0xF8, 0xF8, 0x3F, 0xF8, 0xFC,
  0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7E, 0x3F, 0xF8, 0x7E, 0x3F, 0xF8, 0x3F,
  0x3F, 0xF8, 0x3F, 0x3F, 0xF8, 0x1F, 0x3F, 0xF8, 0x1F, 0xBF, 0xF8, 0x0F,
  0xBF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xE0,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xC0, 0x0F, 0xC7, 0xF0, 0x03,
  0xF9, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xE0,
  0x01, 0xF9, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x80,
  0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x8F,
  0xC0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0xFF, 0x01, 0xFC, 0x1F, 0xE1, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xF8, 0x7F, 0xBF, 0x07,
  0xF7, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F,
  0xDF, 0x87, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC,
  0x3F, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xE0, 0xFE,
  0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xC0, 0x0F, 0xC7, 0xF0, 0x03, 0xF9,
  0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01,
  0xF9, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x07,
  0xE7, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x8F, 0xC0,
  0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xE1, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7E, 0x1F,
  0xE3, 0xF0, 0x3F, 0x9F, 0x81, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F,
  0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x3F,
  0x9F, 0x81, 0xF8, 0xFC, 0x3F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0,
  0xFC, 0x7F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1,
  0xF8, 0x7E, 0x0F, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xFC, 0xFC, 0x07, 0xE7,
  0xE0, 0x3F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x80, 0x00,
  0xF0, 0x01, 0xFF, 0x81, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF,
  0xE7, 0xF0, 0x7B, 0xF8, 0x04, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x7E, 0xF8,
  0x3F, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x0F, 0xFE,
  0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xF0,
  0x1F, 0xDF, 0xE0, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x40, 0x00, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03,
  0xF3, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00,
  0x7E, 0x1F, 0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x1F, 0x81, 0xF8,
  0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F,
  0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00,
  0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0,
  0x03, 0xE3, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8,
  0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xE0, 0x07,
  0xE7, 0xE0, 0x0F, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0xC0, 0x3F, 0x1F, 0x80,
  0x7F, 0x80, 0x7E, 0x3F, 0x00, 0xFF, 0x00, 0xFC, 0x7E, 0x01, 0xFE, 0x01,
  0xF8, 0x7C, 0x03, 0xFE, 0x03, 0xF0, 0xFC, 0x0F, 0xFC, 0x07, 0xC1, 0xF8,
  0x1F, 0x78, 0x1F, 0x83, 0xF0, 0x3E, 0xF0, 0x3F, 0x07, 0xE0, 0x7D, 0xE0,
  0x7E, 0x07, 0xC0, 0xF3, 0xE0, 0xFC, 0x0F, 0xC3, 0xE7, 0xC1, 0xF0, 0x1F,
  0x87, 0xCF, 0x87, 0xE0, 0x3F, 0x0F, 0x9F, 0x0F, 0xC0, 0x7E, 0x1F, 0x1E,
  0x1F, 0x80, 0x7C, 0x3C, 0x3E, 0x3F, 0x00, 0xFC, 0xF8, 0x7C, 0x7C, 0x01,
  0xF9, 0xF0, 0xF9, 0xF8, 0x03, 0xF3, 0xE1, 0xF3, 0xF0, 0x07, 0xE7, 0xC1,
  0xE7, 0xE0, 0x07, 0xCF, 0x83, 0xEF, 0xC0, 0x0F, 0xBE, 0x07, 0xDF, 0x80,
  0x1F, 0x7C, 0x0F, 0xBE, 0x00, 0x3F, 0xF8, 0x1F, 0x7C, 0x00, 0x7F, 0xF0,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x7E, 0x03, 0xF8,
  0xFC, 0x07, 0xE1, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7E, 0x03,
  0xF0, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F,
  0xBF, 0x00, 0x1F, 0x7E, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0x9F, 0x80,
  0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF9, 0xFC, 0x03, 0xF3, 0xF0,
  0x07, 0xEF, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x7E, 0xFC, 0x01, 0xF9, 0xF8,
  0x03, 0xF3, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xE0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x1F, 0x07, 0xC0, 0x3F, 0x1F,
  0x80, 0x7E, 0x3F, 0x00, 0x7C, 0x7C, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0,
  0x01, 0xF7, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xE7,
  0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0xC3, 0xE0, 0x0F, 0x81, 0xF0, 0x1F, 0x81,
  0xF0, 0x1F, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x7E, 0x00,
  0x7C, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC1,
  0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x03, 0xFF,
  0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0x07, 0xF1, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x07,
  0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0x7C, 0xFF, 0x9F, 0x1F,
  0xC3, 0xC1, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC1, 0xC0, 0xFC, 0xFF,
  0x0F, 0xDF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0x9F, 0xEF, 0xF0,
  0x7E, 0xFE, 0x07, 0xEF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x7E, 0xFF, 0x07, 0xEF, 0xFD, 0xFE, 0xFF, 0xFF,
  0xCF, 0xBF, 0xFC, 0xF9, 0xFF, 0x8F, 0x8F, 0xF0, 0x00, 0x08, 0x00, 0x00,
  0x70, 0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF1, 0xFE, 0x71,
  0xFC, 0x08, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFE, 0x02, 0x3F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F,
  0xE0, 0x01, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x38, 0x3F, 0x0F, 0xF3, 0xF1,
  0xFF, 0xBF, 0x3F, 0xFD, 0xF3, 0xFF, 0xFF, 0x7F, 0x9F, 0xF7, 0xF0, 0x7F,
  0x7E, 0x07, 0xF7, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7E,
  0x03, 0xF7, 0xE0, 0x7F, 0x7F, 0x07, 0xF7, 0xF9, 0xFF, 0x3F, 0xFF, 0xF1,
  0xFF, 0xDF, 0x1F, 0xF9, 0xF0, 0x7F, 0x1F, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7E, 0x1F,
  0x9F, 0x81, 0xF3, 0xF0, 0x3E, 0x7C, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x02, 0x3F, 0xC7, 0xC7, 0xFF, 0xF8,
  0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x7C,
  0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xE6, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0xFF, 0x1F, 0x1F,
  0xF9, 0xF3, 0xFF, 0xDF, 0x3F, 0xFF, 0xF7, 0xF9, 0xFF, 0x7F, 0x07, 0xF7,
  0xE0, 0x7F, 0x7E, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xE0,
  0x3F, 0x7E, 0x07, 0xF7, 0xF0, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xDF, 0x1F,
  0xFF, 0xF1, 0xFF, 0xBF, 0x07, 0xF3, 0xF0, 0x08, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x40, 0x07, 0xE7, 0x00, 0xFE,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x1F, 0xFC,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x0E, 0x0F, 0xCF, 0xF1, 0xFB, 0xFF, 0x3F, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFF, 0xDF, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0x7B, 0xFF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC7, 0xFF, 0xFB, 0xFE, 0xFF, 0xBF, 0xCF, 0xE0, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x7E, 0x03, 0xF3, 0xF0,
  0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x1F, 0x87, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1,
  0xF8, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF7, 0xE0, 0x1F, 0xBF,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F,
  0xF7, 0xE0, 0x7F, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F,
  0x87, 0xE0, 0xFC, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x7E,
  0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3C, 0x01, 0xE0, 0xF8, 0xFF, 0x07, 0xF8, 0xF9, 0xFF, 0x8F,
  0xFC, 0xFB, 0xFF, 0xDF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xBF, 0xFD,
  0xFE, 0xFE, 0x0F, 0xF0, 0x7E, 0xFE, 0x0F, 0xF0, 0x7E, 0xFE, 0x07, 0xE0,
  0x7F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0,
  0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0,
  0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0,
  0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0,
  0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0,
  0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0,
  0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x1C, 0x1F,
  0x1F, 0xE3, 0xE7, 0xFE, 0x7D, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0x3F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7E, 0x00, 0xF0, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xC7, 0xF1, 0xFC, 0x1F,
  0x8F, 0xC0, 0x7E, 0x7E, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8,
  0x07, 0xEF, 0xC0, 0x1F, 0x7E, 0x00, 0xFB, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xE7, 0xC0,
  0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0xDF, 0xE0,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x30,
  0x00, 0x00, 0x3C, 0x0F, 0x8F, 0xF0, 0xF9, 0xFF, 0x8F, 0xBF, 0xFC, 0xFF,
  0xFF, 0xCF, 0xF8, 0xFE, 0xFF, 0x07, 0xEF, 0xE0, 0x7E, 0xFE, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xEF, 0xF0,
  0x7E, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFD, 0xFF, 0xCF, 0xDF, 0xF8, 0xFC,
  0x7F, 0x0F, 0xC1, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF,
  0x1F, 0x1F, 0xF9, 0xF1, 0xFF, 0xDF, 0x3F, 0xFF, 0xF7, 0xF9, 0xFF, 0x7F,
  0x07, 0xF7, 0xE0, 0x7F, 0x7E, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xF7, 0xE0, 0x3F, 0x7E, 0x07, 0xF7, 0xF0, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF,
  0xDF, 0x1F, 0xFF, 0xF1, 0xFF, 0xBF, 0x07, 0xF3, 0xF0, 0x08, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3B, 0xE3, 0xFF, 0x9F, 0xFE, 0x7E, 0xFB, 0xFB,
  0xFF, 0xEF, 0xFC, 0xBF, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x3F, 0xF8, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xDF, 0x83, 0xBE, 0x01, 0x7C, 0x00, 0xF8, 0x01, 0xF8,
  0x03, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC,
  0x07, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xC7, 0xFE,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x03, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x8F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x0F,
  0xFC, 0x1F, 0xF0, 0x08, 0x00, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFB,
  0xFF, 0xFF, 0x7F, 0xFB, 0xE7, 0xFF, 0x7C, 0xFF, 0xCF, 0x8F, 0xF1, 0xF0,
  0x30, 0x00, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03,
  0xF7, 0xE0, 0x3F, 0x1F, 0x01, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7C, 0x3F,
  0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0x80, 0xF8, 0x7C,
  0x07, 0xC7, 0xE0, 0x3E, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E,
  0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xBE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xDF, 0x01, 0xFE, 0x03,
  0xE7, 0xE0, 0x7F, 0x81, 0xF9, 0xF8, 0x1F, 0xE0, 0x7E, 0x7E, 0x07, 0xF8,
  0x1F, 0x8F, 0x81, 0xFE, 0x07, 0xC3, 0xE0, 0xFF, 0x83, 0xF0, 0xFC, 0x3D,
  0xF0, 0xFC, 0x3F, 0x0F, 0x3C, 0x3F, 0x0F, 0xC3, 0xCF, 0x0F, 0x81, 0xF0,
  0xF3, 0xC3, 0xE0, 0x7E, 0x7C, 0xF1, 0xF8, 0x1F, 0x9F, 0x3E, 0x7E, 0x07,
  0xE7, 0x8F, 0x9F, 0x80, 0xF9, 0xE1, 0xE7, 0xC0, 0x3E, 0x78, 0x79, 0xF0,
  0x0F, 0x9E, 0x1E, 0xFC, 0x03, 0xE7, 0x87, 0xBF, 0x00, 0xFF, 0xE1, 0xEF,
  0x80, 0x1F, 0xF0, 0x7B, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x0F,
  0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC1, 0xF8, 0x7E,
  0x0F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x3E, 0x01, 0xFB, 0xF0,
  0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x3F, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x0F, 0xC7,
  0xE0, 0x7E, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE3, 0xF0, 0x3F, 0x1F,
  0x80, 0xFD, 0xFC, 0x07, 0xF0, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80,
  0x7E, 0xFC, 0x03, 0xE7, 0xE0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7,
  0xE0, 0x7C, 0x1F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F,
  0x80, 0xF8, 0x7C, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x00, 0xF9, 0xF0, 0x07,
  0xCF, 0x80, 0x3E, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E,
  0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7E, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x0F,
  0xFC, 0x1F, 0xF0, 0x3F, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x01, 0xFE, 0x03,
  0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0xE0,
  0x7F, 0xC0, 0x1F, 0x80, 0xFF, 0x07, 0xFE, 0x0F, 0xE0, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x3F,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x0B,
  0xFF, 0x80, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFE, 0x00, 0x7F, 0x90, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 38, 13, 3, -37 },
  { 35, 16, 13, 22, 3, -37 },
  { 61, 23, 37, 25, 1, -37 },
  { 168, 19, 42, 24, 2, -39 },
  { 268, 34, 38, 38, 2, -38 },
  { 430, 26, 39, 27, 1, -38 },
  { 557, 6, 13, 12, 3, -37 },
  { 567, 13, 45, 16, 2, -37 },
  { 641, 12, 45, 16, 1, -37 },
  { 709, 20, 20, 22, 1, -40 },
  { 759, 20, 25, 23, 2, -31 },
  { 822, 8, 13, 12, 2, -6 },
  { 835, 13, 6, 15, 1, -17 },
  { 845, 7, 8, 13, 3, -7 },
  { 852, 19, 37, 20, 1, -37 },
  { 940, 19, 39, 23, 2, -38 },
  { 1033, 14, 37, 23, 3, -37 },
  { 1098, 19, 38, 23, 2, -38 },
  { 1189, 19, 39, 23, 2, -38 },
  { 1282, 22, 37, 23, 1, -37 },
  { 1384, 19, 38, 23, 2, -37 },
  { 1475, 20, 39, 23, 2, -38 },
  { 1573, 21, 37, 23, 1, -37 },
  { 1671, 20, 39, 23, 2, -38 },
  { 1769, 19, 39, 23, 2, -38 },
  { 1862, 7, 30, 13, 3, -29 },
  { 1889, 8, 36, 13, 2, -29 },
  { 1925, 21, 25, 23, 1, -31 },
  { 1991, 21, 15, 23, 1, -26 },
  { 2031, 20, 25, 23, 2, -31 },
  { 2094, 17, 39, 18, 0, -38 },
  { 2177, 32, 42, 36, 2, -38 },
  { 2345, 26, 37, 26, 0, -37 },
  { 2466, 20, 37, 26, 4, -37 },
  { 2559, 21, 39, 24, 2, -38 },
  { 2662, 22, 37, 28, 4, -37 },
  { 2764, 16, 37, 22, 4, -37 },
  { 2838, 15, 37, 21, 4, -37 },
  { 2908, 24, 39, 29, 2, -38 },
  { 3025, 22, 37, 29, 4, -37 },
  { 3127, 13, 37, 16, 1, -37 },
  { 3188, 13, 48, 13, -3, -37 },
  { 3266, 22, 37, 25, 4, -37 },
  { 3368, 16, 37, 20, 4, -37 },
  { 3442, 31, 37, 39, 4, -37 },
  { 3586, 24, 37, 32, 4, -37 },
  { 3697, 26, 39, 30, 2, -38 },
  { 3824, 19, 37, 25, 4, -37 },
  { 3912, 26, 47, 30, 2, -38 },
  { 4065, 21, 37, 26, 4, -37 },
  { 4163, 18, 39, 22, 2, -38 },
  { 4251, 20, 37, 21, 1, -37 },
  { 4344, 22, 38, 29, 3, -37 },
  { 4449, 25, 37, 25, 0, -37 },
  { 4565, 39, 37, 38, 0, -37 },
  { 4746, 23, 37, 23, 0, -37 },
  { 4853, 23, 37, 23, 0, -37 },
  { 4960, 19, 37, 20, 1, -37 },
  { 5048, 12, 45, 16, 3, -37 },
  { 5116, 19, 37, 20, 1, -37 },
  { 5204, 12, 45, 16, 1, -37 },
  { 5272, 24, 22, 26, 1, -37 },
  { 5338, 22, 4, 22, 0, 4 },
  { 5349, 11, 8, 15, 2, -40 },
  { 5360, 18, 30, 23, 2, -29 },
  { 5428, 20, 41, 25, 3, -40 },
  { 5531, 17, 30, 20, 2, -29 },
  { 5595, 20, 41, 25, 2, -40 },
  { 5698, 19, 30, 23, 2, -29 },
  { 5770, 16, 40, 15, 0, -40 },
  { 5850, 20, 41, 25, 2, -29 },
  { 5953, 19, 40, 25, 3, -40 },
  { 6048, 6, 39, 12, 3, -39 },
  { 6078, 10, 51, 12, -1, -39 },
  { 6142, 21, 40, 23, 3, -40 },
  { 6247, 6, 40, 12, 3, -40 },
  { 6277, 32, 29, 38, 3, -29 },
  { 6393, 19, 29, 25, 3, -29 },
  { 6462, 21, 30, 25, 2, -29 },
  { 6541, 20, 41, 25, 3, -29 },
  { 6644, 20, 41, 25, 2, -29 },
  { 6747, 14, 29, 17, 3, -29 },
  { 6798, 15, 30, 19, 2, -29 },
  { 6855, 14, 35, 16, 1, -34 },
  { 6917, 19, 29, 25, 3, -28 },
  { 6986, 21, 28, 22, 0, -28 },
  { 7060, 34, 28, 34, 0, -28 },
  { 7179, 21, 28, 21, 0, -28 },
  { 7253, 21, 40, 22, 0, -28 },
  { 7358, 16, 28, 18, 1, -28 },
  { 7414, 15, 45, 18, 1, -37 },
  { 7499, 5, 52, 22, 9, -40 },
  { 7532, 15, 45, 18, 2, -37 },
  { 7617, 21, 8, 23, 1, -22 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold52pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD52PT7B_H_
