#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD45PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold45pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xF9, 0xE0, 0x00, 0x00, 0x0F, 0xBE, 0xFF, 0xFF,
  0xBE, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F,
  0x9E, 0x1F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF0, 0x01, 0xC3,
  0xC0, 0x3C, 0x38, 0x03, 0xC3, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C,
  0x78, 0x03, 0x87, 0x80, 0x38, 0x78, 0x03, 0x87, 0x07, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x78, 0xF0, 0x07, 0x0F, 0x00,
  0x70, 0xF0, 0x0F, 0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x1E, 0x0F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xE1, 0xE0, 0x1E, 0x1C,
  0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xC3,
  0xC0, 0x1C, 0x3C, 0x01, 0xC3, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0xF0, 0x0F, 0xFE, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0xFD, 0x86,
  0xF9, 0x80, 0xF9, 0x80, 0xF9, 0x80, 0xF9, 0x80, 0xFD, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF,
  0x01, 0x9F, 0x01, 0x9F, 0x01, 0x8F, 0x01, 0x8F, 0x81, 0x8F, 0xC1, 0x9F,
  0xF9, 0xBF, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF8, 0x07, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x04, 0x00, 0x00, 0x01,
  0xFC, 0x01, 0xE0, 0x1F, 0xE0, 0x0F, 0x00, 0xFF, 0x80, 0xF0, 0x0F, 0xBE,
  0x07, 0x80, 0x78, 0xF0, 0x3C, 0x03, 0xC7, 0x83, 0xC0, 0x1E, 0x3C, 0x1E,
  0x00, 0xF1, 0xE0, 0xF0, 0x07, 0x8F, 0x0F, 0x00, 0x3C, 0x78, 0x78, 0x01,
  0xE3, 0xC7, 0x80, 0x0F, 0x1E, 0x3C, 0x00, 0x78, 0xF1, 0xE1, 0xC3, 0xC7,
  0x9E, 0x3F, 0x9E, 0x3C, 0xF3, 0xFE, 0xFB, 0xE7, 0x9F, 0xF3, 0xFE, 0x79,
  0xE7, 0x9F, 0xF3, 0xCF, 0x1E, 0x7F, 0x3C, 0x78, 0xF0, 0x61, 0xE3, 0xC7,
  0x80, 0x0F, 0x1C, 0x3C, 0x00, 0xF1, 0xE1, 0xE0, 0x07, 0x8F, 0x0F, 0x00,
  0x3C, 0x38, 0x78, 0x03, 0xC1, 0xC3, 0xC0, 0x1E, 0x0F, 0x1E, 0x01, 0xE0,
  0x78, 0xF0, 0x0F, 0x03, 0xC7, 0x80, 0x78, 0x1F, 0x78, 0x07, 0x80, 0x7F,
  0xC0, 0x3C, 0x01, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x40, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xE3,
  0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3C, 0x3C,
  0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF7, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE1, 0xF8,
  0xFF, 0xE3, 0xF3, 0xF7, 0xC7, 0xC7, 0xC7, 0xCF, 0x9F, 0x8F, 0xDF, 0x3E,
  0x0F, 0xFC, 0x7C, 0x0F, 0xF8, 0xF8, 0x1F, 0xF1, 0xF0, 0x1F, 0xC3, 0xF0,
  0x1F, 0x87, 0xE0, 0x7F, 0x07, 0xE3, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFE, 0x7E, 0x0F, 0xF0, 0x7E, 0xFF, 0xFF, 0xDF, 0x7D, 0xF7,
  0x9E, 0x79, 0xE7, 0x80, 0x03, 0xE0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3E,
  0x07, 0x81, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x81, 0xF0,
  0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0xF8, 0x0F,
  0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x81, 0xF0,
  0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x78, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07,
  0xC0, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x06, 0x1C, 0x33, 0xEE, 0x79, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xF8, 0x01, 0xFE, 0x01, 0xEF, 0x01, 0xF7, 0xC1, 0xF1, 0xF0, 0xF8, 0xF8,
  0x18, 0x30, 0x04, 0x10, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3C, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7C, 0xFB, 0xFF, 0xF7, 0xCF, 0x80, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00,
  0x80, 0x07, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xF3, 0xF1,
  0xF0, 0xF8, 0xF8, 0x7E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x03,
  0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D,
  0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0x9F, 0x0F, 0xCF, 0x87, 0xC7, 0xE7,
  0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0xF8,
  0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x8F, 0xFC, 0xFF, 0xEF, 0xDF, 0xFC,
  0xF9, 0xC7, 0xC4, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0x80, 0x07, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xCF, 0xFF,
  0xF3, 0xE1, 0xF8, 0xC0, 0x7C, 0x20, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xC0, 0x0F, 0xFC, 0x0F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1,
  0xC1, 0xF8, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xF0, 0x03,
  0xF7, 0x07, 0xF3, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x77, 0xC0,
  0x1E, 0xF8, 0x03, 0x9F, 0x00, 0xF3, 0xE0, 0x1C, 0x7C, 0x07, 0x8F, 0x80,
  0xE1, 0xF0, 0x3C, 0x3E, 0x07, 0x87, 0xC1, 0xE0, 0xF8, 0x3C, 0x1F, 0x0F,
  0x03, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE,
  0x30, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0x30, 0x01, 0xFF,
  0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE1, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x87, 0x07,
  0xDF, 0xC3, 0xFF, 0xF1, 0xEF, 0xFC, 0xFF, 0xFF, 0x7E, 0x1F, 0xBF, 0x07,
  0xDF, 0x03, 0xEF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xBF, 0x07, 0xCF, 0x83, 0xE7, 0xE3, 0xF1, 0xFF, 0xF0,
  0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0x01,
  0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0x87, 0xE7, 0xC0, 0xF9, 0xF0,
  0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF8, 0xF8, 0x7C, 0x3F, 0x3F,
  0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0xFC, 0xFC, 0x7E, 0x1F, 0x9F, 0x03, 0xE7, 0xC0, 0xFF, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7D, 0xF0, 0x3E, 0x7E, 0x1F,
  0x9F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0xC0,
  0x03, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xF1, 0xF9, 0xF0,
  0x7C, 0xF8, 0x3F, 0x7C, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x3F, 0x7E, 0x1F, 0xBF, 0xFF,
  0xCF, 0xFD, 0xE3, 0xFE, 0xF0, 0xFE, 0xF8, 0x18, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0xE1,
  0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x00, 0x73, 0xEF, 0xFF,
  0xFF, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0xFB, 0xFF, 0xFE, 0xF8, 0x38, 0xF9, 0xFB, 0xF7, 0xEF, 0x8F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xEF, 0xDF,
  0x3E, 0x7C, 0xFB, 0xE7, 0xCF, 0x9E, 0x3C, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x3F, 0xE1, 0xFF, 0xE7, 0xFF, 0xE7, 0xFF, 0xCE,
  0x0F, 0xC8, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x0F,
  0x07, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x3C, 0x0F, 0xC3, 0xCF, 0x07,
  0xFE, 0x3D, 0xE1, 0xFF, 0xC7, 0xBC, 0x3C, 0x78, 0xF7, 0x0F, 0x0F, 0x1F,
  0xE1, 0xE1, 0xE1, 0xFC, 0x3C, 0x3C, 0x3F, 0x8F, 0x07, 0x87, 0xF1, 0xE0,
  0xF0, 0xFE, 0x3C, 0x3E, 0x1F, 0xC7, 0x87, 0x83, 0xF8, 0xF0, 0xF0, 0xFF,
  0x1E, 0x1E, 0x1F, 0xE3, 0xC3, 0xC3, 0xFC, 0x3C, 0x7C, 0x77, 0x87, 0xFF,
  0xFE, 0xF0, 0x7F, 0x7F, 0x8F, 0x0F, 0xE7, 0xE1, 0xE0, 0x70, 0x78, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFB, 0xC0, 0x03, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8,
  0x01, 0xF3, 0xE0, 0x07, 0xC7, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03,
  0xE1, 0xF0, 0x0F, 0x87, 0xE0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xC0, 0x7C,
  0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xE7, 0xE0, 0x0F, 0x9F, 0x80, 0x3E, 0x7C,
  0x00, 0xFD, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0xF8, 0x3F, 0xBE, 0x07, 0xEF,
  0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0,
  0x7E, 0xF8, 0x3F, 0x3F, 0xFF, 0xCF, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFF,
  0x3E, 0x1F, 0xEF, 0x81, 0xFB, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFB, 0xE1,
  0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x30,
  0x00, 0x7F, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0x87, 0xF0, 0xE3,
  0xF0, 0x08, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE,
  0x02, 0x1F, 0xC3, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0x8F,
  0xF9, 0xF0, 0x3F, 0x3E, 0x03, 0xF7, 0xC0, 0x7E, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x0F,
  0xDF, 0x01, 0xFB, 0xE0, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFC,
  0x3F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF,
  0xEF, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBE, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x0C, 0x00,
  0x0F, 0xFC, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFE, 0x0E,
  0x3F, 0x80, 0x23, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC1,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7E, 0x01, 0xF7,
  0xE0, 0x1F, 0x3F, 0x01, 0xF3, 0xF0, 0x1F, 0x1F, 0xC3, 0xF1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xC0, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xE1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x83, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x3F, 0xFF, 0xFF, 0xEF, 0xFB, 0xFC, 0xFE, 0x00,
  0xF8, 0x07, 0xFF, 0x00, 0xFB, 0xE0, 0x3F, 0x7C, 0x0F, 0xCF, 0x81, 0xF9,
  0xF0, 0x7E, 0x3E, 0x0F, 0x87, 0xC3, 0xF0, 0xF8, 0x7C, 0x1F, 0x1F, 0x83,
  0xE7, 0xE0, 0x7C, 0xFC, 0x0F, 0xBF, 0x01, 0xF7, 0xE0, 0x3E, 0xF8, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFB, 0xE0, 0x7E, 0x7E, 0x0F,
  0x8F, 0xC1, 0xF0, 0xFC, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0xF8, 0x3F, 0x1F,
  0x03, 0xE3, 0xE0, 0x7E, 0x7C, 0x07, 0xCF, 0x80, 0xFD, 0xF0, 0x1F, 0xBE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3D, 0xFF, 0xBC, 0x03, 0xDF, 0xFB,
  0xC0, 0x7D, 0xFF, 0xBE, 0x07, 0xDF, 0xFB, 0xE0, 0x79, 0xFF, 0x9E, 0x07,
  0x9F, 0xF9, 0xE0, 0xF9, 0xFF, 0x9F, 0x0F, 0x1F, 0xF9, 0xF0, 0xF1, 0xFF,
  0x8F, 0x0F, 0x1F, 0xF8, 0xF1, 0xF1, 0xFF, 0x8F, 0x9E, 0x1F, 0xF8, 0x79,
  0xE1, 0xFF, 0x87, 0xBE, 0x1F, 0xF8, 0x7B, 0xC1, 0xFF, 0x87, 0xFC, 0x1F,
  0xF8, 0x3F, 0xC1, 0xFF, 0x83, 0xFC, 0x1F, 0xF8, 0x3F, 0x81, 0xFF, 0x83,
  0xF8, 0x1F, 0xF8, 0x1F, 0x81, 0xFF, 0x81, 0xF0, 0x1F, 0xF8, 0x1F, 0x01,
  0xFF, 0x81, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xDE, 0x07, 0xFE, 0xF8, 0x3F, 0xF7, 0xC1, 0xFF,
  0x9F, 0x0F, 0xFC, 0xF8, 0x7F, 0xE3, 0xE3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8,
  0xFF, 0xC3, 0xE7, 0xFE, 0x1F, 0x3F, 0xF0, 0x7D, 0xFF, 0x83, 0xEF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x30, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0xFE, 0x1F, 0xC3, 0xF0, 0x3F, 0x1F,
  0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0xBF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00,
  0xF9, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x0F, 0xC0, 0xFC, 0x3F, 0xCF, 0xF0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0xFF,
  0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0x9F, 0xF7, 0xC1, 0xFB,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFB, 0xE0, 0xFD, 0xF1, 0xFE, 0xFF, 0xFE, 0x7F,
  0xFE, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0xFE, 0x1F, 0xC3,
  0xF0, 0x3F, 0x1F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF0, 0x03, 0xE7, 0xC0,
  0x0F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0x00,
  0x3E, 0x7C, 0x00, 0xF9, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x8F, 0xC0, 0xFC,
  0x3F, 0xCF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0x8F, 0xF1,
  0xF0, 0x7F, 0x3E, 0x07, 0xE7, 0xC0, 0xFC, 0xF8, 0x0F, 0x9F, 0x01, 0xF3,
  0xE0, 0x3E, 0x7C, 0x0F, 0xCF, 0x81, 0xF9, 0xF0, 0x7E, 0x3E, 0x1F, 0xC7,
  0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7C, 0x7C, 0x0F,
  0x8F, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F,
  0x07, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0xBE,
  0x03, 0xF7, 0xC0, 0x3F, 0x01, 0xC0, 0x1F, 0xF0, 0xFF, 0xFB, 0xFF, 0xF7,
  0xFF, 0xFF, 0xC7, 0xBF, 0x01, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFE, 0x03, 0xFF, 0xDF, 0xDF, 0xFF,
  0xBF, 0xFE, 0x7F, 0xF8, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x07, 0xFF, 0x80, 0xFD, 0xF0, 0x1F, 0x3F, 0x8F, 0xE7, 0xFF, 0xF8, 0x7F,
  0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xE7,
  0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x07, 0xC3, 0xE0,
  0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0x81, 0xE0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x00, 0xF0, 0x7C, 0x03,
  0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1E, 0x00, 0x78, 0xF8, 0x01, 0xE3,
  0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3C, 0x00, 0x3D, 0xF0, 0x00, 0xF7, 0xC0,
  0x03, 0xDF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0xFC, 0x01, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x03, 0xFF, 0x80,
  0x7E, 0x03, 0xF7, 0xC0, 0x7F, 0x01, 0xF3, 0xE0, 0x3F, 0x80, 0xF9, 0xF0,
  0x1F, 0xC0, 0x7C, 0xF8, 0x0F, 0xE0, 0x3E, 0x7E, 0x07, 0x78, 0x1F, 0x1F,
  0x07, 0xBC, 0x1F, 0x0F, 0x83, 0xDE, 0x0F, 0x87, 0xC1, 0xEF, 0x07, 0xC3,
  0xE0, 0xF7, 0x83, 0xE1, 0xF0, 0x7B, 0xE1, 0xF0, 0x7C, 0x7C, 0xF1, 0xF0,
  0x3E, 0x3C, 0x78, 0xF8, 0x1F, 0x1E, 0x3C, 0x7C, 0x0F, 0x8F, 0x1E, 0x3E,
  0x07, 0xC7, 0x8F, 0x9F, 0x01, 0xF7, 0xC7, 0xDF, 0x80, 0xFB, 0xC1, 0xEF,
  0x80, 0x7D, 0xE0, 0xF7, 0xC0, 0x3E, 0xF0, 0x7B, 0xE0, 0x1F, 0x78, 0x3D,
  0xF0, 0x07, 0xBC, 0x1E, 0xF8, 0x03, 0xFC, 0x07, 0x78, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x1F, 0xC0,
  0x7F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x7C, 0x03,
  0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xC3, 0xF0, 0x7C, 0x1F, 0x0F, 0xC1, 0xF0,
  0xF8, 0x0F, 0x8F, 0x80, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7D, 0xF0, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x1F, 0x8F,
  0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC7, 0xE0,
  0x7E, 0x7C, 0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xC0, 0x3E, 0x7C,
  0x03, 0xE7, 0xE0, 0x7E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3F, 0x0F, 0x81,
  0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0xF9, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7D, 0xE0, 0x07, 0x9F, 0x00, 0xF8,
  0xF0, 0x0F, 0x0F, 0x81, 0xF0, 0xF8, 0x1E, 0x07, 0xC3, 0xE0, 0x7C, 0x3C,
  0x03, 0xC7, 0xC0, 0x3E, 0x7C, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x3F, 0x0F, 0x83,
  0xE0, 0xF0, 0x3C, 0x0E, 0x03, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE,
  0x1E, 0x3F, 0x10, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x03, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xDF, 0x7E, 0x1F, 0x7C, 0x1F,
  0xFC, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x7C, 0x3F, 0x7F, 0xFF,
  0x7F, 0xEF, 0x3F, 0xEF, 0x1F, 0x87, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x78, 0x3E, 0xFF, 0x1F, 0x7F, 0xCF, 0xFF, 0xE7, 0xFB, 0xFB,
  0xF0, 0x7D, 0xF8, 0x3E, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xF7, 0xF1, 0xFB, 0xFF, 0xFD,
  0xEF, 0xFC, 0xF3, 0xFC, 0x78, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0xF1, 0xFF,
  0xCF, 0xFE, 0x7F, 0xF9, 0xF8, 0x27, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x0D, 0xFF, 0xF3, 0xFF, 0xC7,
  0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x83, 0xC7,
  0xC7, 0xF3, 0xE7, 0xFD, 0xF3, 0xFF, 0xFB, 0xFF, 0xFD, 0xF0, 0x7F, 0xF8,
  0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x81, 0xFF, 0xC1, 0xFB, 0xF1, 0xFD, 0xFF, 0xFE, 0x7F, 0xEF, 0x3F,
  0xE7, 0x87, 0xE3, 0xC0, 0x03, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC,
  0x7E, 0x3E, 0x7C, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x06, 0x3F, 0xFE,
  0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0xFF, 0x83,
  0xFE, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x07,
  0xFF, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC1, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x0F, 0xF3, 0xCF, 0xF9,
  0xE7, 0xFF, 0xF7, 0xFF, 0xFB, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x83,
  0xF7, 0xE3, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xDF, 0x0F, 0xCF, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFD, 0x80, 0xFC,
  0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0xF0, 0xFB, 0xFC, 0xFF, 0xFE, 0xF7,
  0xFE, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x39, 0xFF, 0xFF, 0x7D, 0xE0,
  0x00, 0x00, 0x07, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF0, 0x07, 0x07, 0xC7,
  0xE3, 0xF0, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x3F, 0xFF, 0x7F, 0xBF, 0x9F, 0xC7, 0x80,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x07, 0xDF,
  0x07, 0xEF, 0x83, 0xE7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF1, 0xF0, 0xF9, 0xF0,
  0x7C, 0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFC, 0xF8, 0x7C, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F,
  0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xFD, 0xF0, 0x3E, 0xF8, 0x1F, 0xFC, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xF0, 0x1E, 0x1E, 0x7F, 0x8F, 0xF3, 0xDF, 0xFB, 0xFF, 0x7B, 0xFF, 0x7F,
  0xEF, 0xFF, 0xFF, 0xFD, 0xF8, 0x7F, 0x0F, 0xFE, 0x0F, 0xE1, 0xFF, 0xC0,
  0xF8, 0x1F, 0xF8, 0x1F, 0x03, 0xFF, 0x03, 0xE0, 0x7F, 0xE0, 0x7C, 0x0F,
  0xFC, 0x0F, 0x81, 0xFF, 0x81, 0xF0, 0x3F, 0xF0, 0x3E, 0x07, 0xFE, 0x07,
  0xC0, 0xFF, 0xC0, 0xF8, 0x1F, 0xF8, 0x1F, 0x03, 0xFF, 0x03, 0xE0, 0x7F,
  0xE0, 0x7C, 0x0F, 0xFC, 0x0F, 0x81, 0xFF, 0x81, 0xF0, 0x3F, 0xF0, 0x3E,
  0x07, 0xFE, 0x07, 0xC0, 0xFF, 0xC0, 0xF8, 0x1F, 0xF8, 0x1F, 0x03, 0xE0,
  0x00, 0xF0, 0xF3, 0xFC, 0xF7, 0xFE, 0xF7, 0xFE, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0x03, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xF7,
  0xF3, 0xE0, 0xFB, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xEF, 0x83, 0xE7, 0xE3, 0xF1, 0xFF,
  0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0xF0, 0x79, 0xFE,
  0x3D, 0xFF, 0x9E, 0xFF, 0xCF, 0xF7, 0xF7, 0xE0, 0xFB, 0xF0, 0x7D, 0xF0,
  0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07,
  0xFF, 0x83, 0xEF, 0xE3, 0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xF7, 0xF8, 0xF9,
  0xF8, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x0F, 0xF3, 0xCF, 0xF9, 0xE7, 0xFF, 0xF7, 0xFF, 0xFB,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xF7, 0xE3, 0xFB, 0xFF, 0xFC,
  0xFF, 0xFE, 0x7F, 0xDF, 0x0F, 0xCF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFE, 0x7F, 0xCF, 0xFB, 0xFF,
  0x7F, 0xFE, 0x7F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x7F, 0xE3, 0xFF, 0xDF, 0xFE,
  0x7E, 0x7B, 0xE0, 0x2F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01,
  0xF0, 0x07, 0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0xFC, 0x7F,
  0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xF1, 0x3F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFF, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xFC, 0x7F, 0xFF, 0xFF, 0x7F, 0xEF, 0x7F, 0xCF, 0x1F, 0x8F, 0xFC, 0x07,
  0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x07, 0xE7, 0xC0, 0xF8, 0x7C, 0x1F,
  0x0F, 0x83, 0xE1, 0xF0, 0x78, 0x1E, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C,
  0x0F, 0x8F, 0x00, 0xF3, 0xE0, 0x1E, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xE0,
  0x07, 0xBC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xFB, 0xE0,
  0xFE, 0x07, 0xDF, 0x07, 0xF0, 0x7C, 0xF8, 0x3F, 0x83, 0xE7, 0xC1, 0xFC,
  0x1F, 0x1E, 0x0E, 0xF0, 0xF8, 0xF8, 0x77, 0x87, 0xC7, 0xC7, 0xBC, 0x7C,
  0x3E, 0x3D, 0xE3, 0xE1, 0xF1, 0xE7, 0x1F, 0x07, 0xCE, 0x3C, 0xF8, 0x3E,
  0x71, 0xE7, 0x81, 0xF7, 0x8F, 0x7C, 0x0F, 0xBC, 0x7B, 0xE0, 0x3D, 0xE3,
  0xDF, 0x01, 0xEF, 0x0E, 0xF0, 0x0F, 0x78, 0x77, 0x80, 0x7F, 0x83, 0xBC,
  0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x03,
  0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0x7C, 0x07, 0xE0, 0x7C, 0x0F,
  0xCF, 0x87, 0xE3, 0xE1, 0xF0, 0xFC, 0x7C, 0x1F, 0x3E, 0x07, 0xCF, 0x80,
  0xFB, 0xE0, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x07, 0xCF, 0x81, 0xF3, 0xE0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x87, 0xE7,
  0xC0, 0xFB, 0xF0, 0x3F, 0xFC, 0x07, 0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E,
  0x07, 0xE3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x78, 0x1F,
  0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x07, 0x8F, 0x00, 0xF3, 0xE0, 0x1F,
  0x7C, 0x03, 0xEF, 0x80, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x00,
  0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x1F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x87, 0xFC,
  0x3F, 0xC1, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3E, 0x01, 0xF0, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x03, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x03, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7F, 0x81, 0xFE, 0x01,
  0xF0, 0x7F, 0x87, 0xFC, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F,
  0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x5F, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xE0, 0x1F, 0xE8, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 32, 11, 3, -32 },
  { 25, 15, 11, 19, 2, -32 },
  { 46, 20, 32, 22, 1, -32 },
  { 126, 16, 37, 20, 2, -34 },
  { 200, 29, 33, 33, 2, -33 },
  { 320, 23, 33, 24, 1, -33 },
  { 415, 6, 11, 10, 2, -32 },
  { 424, 11, 39, 14, 2, -32 },
  { 478, 11, 39, 14, 1, -32 },
  { 532, 17, 17, 19, 1, -34 },
  { 569, 18, 22, 20, 1, -27 },
  { 619, 8, 11, 11, 1, -5 },
  { 630, 11, 5, 13, 1, -15 },
  { 637, 7, 6, 11, 2, -6 },
  { 643, 16, 32, 18, 1, -32 },
  { 707, 17, 33, 20, 2, -33 },
  { 778, 13, 32, 20, 2, -32 },
  { 830, 17, 33, 20, 1, -33 },
  { 901, 17, 33, 20, 1, -33 },
  { 972, 19, 32, 20, 1, -32 },
  { 1048, 16, 32, 20, 2, -32 },
  { 1112, 17, 33, 20, 2, -33 },
  { 1183, 18, 32, 20, 1, -32 },
  { 1255, 18, 33, 20, 1, -33 },
  { 1330, 17, 33, 20, 1, -33 },
  { 1401, 6, 25, 11, 3, -25 },
  { 1420, 7, 31, 11, 2, -25 },
  { 1448, 18, 21, 20, 1, -27 },
  { 1496, 18, 13, 20, 1, -22 },
  { 1526, 18, 21, 20, 1, -27 },
  { 1574, 15, 33, 16, 0, -33 },
  { 1636, 27, 36, 31, 2, -32 },
  { 1758, 22, 32, 22, 0, -32 },
  { 1846, 18, 32, 23, 3, -32 },
  { 1918, 18, 33, 21, 2, -33 },
  { 1993, 19, 32, 24, 3, -32 },
  { 2069, 14, 32, 19, 3, -32 },
  { 2125, 14, 32, 19, 3, -32 },
  { 2181, 20, 33, 25, 2, -33 },
  { 2264, 19, 32, 26, 3, -32 },
  { 2340, 11, 32, 14, 1, -32 },
  { 2384, 10, 41, 11, -2, -32 },
  { 2436, 19, 32, 22, 3, -32 },
  { 2512, 14, 32, 18, 3, -32 },
  { 2568, 28, 32, 34, 3, -32 },
  { 2680, 21, 32, 27, 3, -32 },
  { 2764, 22, 33, 26, 2, -33 },
  { 2855, 17, 32, 21, 3, -32 },
  { 2923, 22, 41, 26, 2, -33 },
  { 3036, 19, 32, 22, 3, -32 },
  { 3112, 15, 33, 19, 2, -33 },
  { 3174, 17, 32, 19, 1, -32 },
  { 3242, 19, 32, 25, 3, -32 },
  { 3318, 22, 32, 22, 0, -32 },
  { 3406, 33, 32, 33, 0, -32 },
  { 3538, 20, 32, 20, 0, -32 },
  { 3618, 20, 32, 20, 0, -32 },
  { 3698, 16, 32, 18, 1, -32 },
  { 3762, 10, 39, 14, 3, -32 },
  { 3811, 16, 32, 18, 1, -32 },
  { 3875, 10, 39, 14, 1, -32 },
  { 3924, 20, 19, 22, 1, -32 },
  { 3972, 19, 3, 19, 0, 4 },
  { 3980, 9, 7, 13, 2, -34 },
  { 3988, 16, 25, 20, 1, -25 },
  { 4038, 17, 34, 22, 3, -34 },
  { 4111, 14, 25, 17, 2, -25 },
  { 4155, 17, 34, 22, 2, -34 },
  { 4228, 16, 25, 20, 2, -25 },
  { 4278, 14, 34, 13, 0, -34 },
  { 4338, 17, 36, 22, 2, -25 },
  { 4415, 16, 34, 22, 3, -34 },
  { 4483, 6, 34, 10, 2, -34 },
  { 4509, 9, 45, 10, -1, -34 },
  { 4560, 17, 34, 20, 3, -34 },
  { 4633, 5, 34, 10, 3, -34 },
  { 4655, 27, 25, 33, 3, -25 },
  { 4740, 16, 25, 22, 3, -25 },
  { 4790, 17, 25, 21, 2, -25 },
  { 4844, 17, 36, 22, 3, -25 },
  { 4921, 17, 36, 22, 2, -25 },
  { 4998, 11, 25, 15, 3, -25 },
  { 5033, 14, 25, 16, 1, -25 },
  { 5077, 12, 30, 14, 1, -30 },
  { 5122, 16, 24, 22, 3, -24 },
  { 5170, 19, 24, 19, 0, -24 },
  { 5227, 29, 24, 29, 0, -24 },
  { 5314, 18, 24, 18, 0, -24 },
  { 5368, 19, 35, 19, 0, -24 },
  { 5452, 13, 24, 15, 1, -24 },
  { 5491, 13, 39, 16, 1, -32 },
  { 5555, 5, 45, 19, 7, -34 },
  { 5584, 13, 39, 16, 2, -32 },
  { 5648, 18, 7, 20, 1, -19 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold45pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD45PT7B_H_
