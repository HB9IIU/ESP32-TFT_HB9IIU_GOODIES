#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD31PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0xEE, 0xE0, 0x00, 0xFF, 0xFF,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0x0E, 0x70, 0x39,
  0xC0, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x73, 0x81, 0x8C, 0x06, 0x30, 0x18, 0xC3, 0xFF, 0xEF, 0xFF, 0xBF,
  0xFE, 0x39, 0xC0, 0xC7, 0x03, 0x18, 0x0C, 0x60, 0x33, 0x81, 0xCE, 0x00,
  0x06, 0x00, 0x60, 0x06, 0x01, 0xFC, 0x3F, 0xE7, 0xFE, 0x76, 0x2F, 0x60,
  0xF6, 0x0F, 0x60, 0x7E, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x07, 0xE0, 0x6E,
  0x06, 0xF0, 0x67, 0x86, 0xEF, 0x7E, 0xFF, 0xC7, 0xF8, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x3C, 0x07, 0x03, 0xF0, 0x70, 0x19, 0xC3, 0x81, 0xCE,
  0x18, 0x0E, 0x71, 0xC0, 0x73, 0x8E, 0x03, 0x8C, 0x60, 0x1C, 0xE7, 0x00,
  0xE7, 0x38, 0x87, 0x3B, 0x9F, 0x19, 0xDD, 0xFC, 0xFC, 0xCE, 0xE3, 0xEE,
  0x63, 0x00, 0x77, 0x18, 0x03, 0x38, 0xE0, 0x39, 0xC7, 0x01, 0xCE, 0x38,
  0x1C, 0x31, 0x80, 0xE1, 0x8C, 0x06, 0x0E, 0xE0, 0x70, 0x3F, 0x03, 0x81,
  0xF0, 0x1F, 0x80, 0x7F, 0x80, 0xFF, 0x03, 0xCE, 0x07, 0x9E, 0x0F, 0x38,
  0x0E, 0x70, 0x1D, 0xE0, 0x3F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF8, 0xF7,
  0xF9, 0xDE, 0x73, 0xBC, 0xFF, 0x70, 0xFC, 0xE0, 0xF9, 0xE1, 0xE3, 0xC3,
  0xE7, 0xFF, 0xE7, 0xFF, 0xC7, 0xF3, 0xC0, 0xFF, 0xFF, 0xFF, 0x0F, 0x0E,
  0x1C, 0x1C, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xF0,
  0x70, 0x70, 0x70, 0x70, 0x70, 0x78, 0x38, 0x38, 0x3C, 0x1C, 0x1C, 0x0E,
  0x07, 0xE0, 0xE1, 0xC1, 0xC3, 0x87, 0x87, 0x0E, 0x1C, 0x3C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x3C, 0x70, 0xE1, 0xC7, 0x8E, 0x3C, 0x71, 0xE3,
  0x80, 0x0E, 0x01, 0xC0, 0x38, 0x47, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8,
  0x3B, 0x87, 0x79, 0xC7, 0x08, 0x80, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x7B, 0xDE, 0xE7, 0x3B, 0x9C, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFE, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x1F, 0x83,
  0xFC, 0x7F, 0xC7, 0x9E, 0x70, 0xE7, 0x0E, 0xF0, 0xEF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0E, 0x70, 0xE7,
  0x0E, 0x79, 0xE7, 0xFC, 0x3F, 0xC1, 0xF8, 0x07, 0x0F, 0x1F, 0x3F, 0x7F,
  0xF7, 0x67, 0x47, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x3F, 0x87, 0xFC, 0xFF, 0xE6, 0x1E, 0x40,
  0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07,
  0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0x8F, 0xFC, 0x7F, 0xE4, 0x1E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x1E, 0x03, 0xC3, 0xF8, 0x3F, 0x03, 0xFC, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x81, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0x01,
  0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0x70, 0x1B, 0x81, 0xDC,
  0x0C, 0xE0, 0xE7, 0x06, 0x38, 0x71, 0xC3, 0x0E, 0x38, 0x71, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F,
  0xC7, 0xFC, 0x7F, 0xC7, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7F,
  0x07, 0xFC, 0x7F, 0xE2, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x1E, 0xC1, 0xEF, 0xFC, 0xFF, 0xC7, 0xF0, 0x0F, 0xE1, 0xFE, 0x3F,
  0xE3, 0xC0, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF7, 0xCE, 0xFC, 0xFF,
  0xEF, 0x8E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x0F, 0x79,
  0xE7, 0xFE, 0x3F, 0xC1, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00,
  0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C,
  0x03, 0xC0, 0x1F, 0x83, 0xFC, 0x7F, 0xE7, 0x0E, 0xF0, 0xEF, 0x0E, 0x70,
  0xE7, 0x9E, 0x3F, 0xC3, 0xF8, 0x1F, 0x03, 0xFC, 0x7B, 0xE7, 0x1E, 0xF0,
  0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xF0, 0xF7, 0xFE, 0x7F, 0xC1, 0xF8, 0x1F,
  0x83, 0xFC, 0x7F, 0xCF, 0x1E, 0xF0, 0xEF, 0x0E, 0xE0, 0xFE, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF1, 0xF7, 0xFF, 0x7F, 0xF3, 0xEE, 0x00, 0xE0, 0x0E, 0x01,
  0xE0, 0x1E, 0x03, 0xC7, 0xF8, 0x7F, 0x87, 0xE0, 0xEF, 0xFF, 0x60, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x73, 0xDE, 0xF3, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3D, 0xEF, 0x73, 0x9D, 0xCE, 0x00, 0x00, 0x10, 0x07, 0x01, 0xF0,
  0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x0E, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x1F, 0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0x80,
  0xE0, 0x08, 0x00, 0x7F, 0x3F, 0xE7, 0xFD, 0x0F, 0x01, 0xC0, 0x70, 0x1C,
  0x0F, 0x03, 0x81, 0xE0, 0xF0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0xF8, 0x1E, 0x07, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xE0,
  0x3C, 0x1E, 0x0E, 0x01, 0xC3, 0x80, 0x1C, 0x70, 0x01, 0x9C, 0x3F, 0x3B,
  0x8F, 0xE7, 0x63, 0x9C, 0xEC, 0x63, 0x8F, 0x8C, 0x71, 0xF3, 0x8E, 0x3E,
  0x71, 0xC7, 0xCE, 0x39, 0xF9, 0xC7, 0x3F, 0x1D, 0xE7, 0x63, 0xFF, 0xCE,
  0x3C, 0xF1, 0xC1, 0x08, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x04, 0x03,
  0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x60, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x7F, 0x00, 0xEE, 0x01, 0xDC, 0x03, 0xBC, 0x0F, 0x78, 0x1E, 0x70,
  0x38, 0xE0, 0x71, 0xE0, 0xE3, 0xC3, 0xC3, 0x87, 0xFF, 0x0F, 0xFF, 0x1F,
  0xFE, 0x78, 0x3C, 0xF0, 0x39, 0xE0, 0x7B, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xC0, 0xFF, 0x87, 0xFF, 0x3F, 0xF9, 0xE1, 0xEF, 0x0F, 0x78, 0x7B, 0xC3,
  0xDE, 0x1E, 0xF1, 0xE7, 0xFF, 0x3F, 0xE1, 0xFF, 0xCF, 0x0F, 0x78, 0x7B,
  0xC1, 0xDE, 0x0F, 0xF0, 0x77, 0x87, 0xBC, 0x3D, 0xFF, 0xCF, 0xFE, 0x7F,
  0xC0, 0x07, 0xF0, 0xFF, 0xC7, 0xFC, 0x78, 0x23, 0xC0, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01,
  0xC0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x84, 0x3F, 0xE1, 0xFF, 0x03,
  0xF8, 0xFF, 0x87, 0xFE, 0x3F, 0xF9, 0xE3, 0xEF, 0x0F, 0x78, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xBC, 0x7D, 0xFF, 0xCF, 0xFC, 0x7F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3F, 0xEF, 0xFB, 0xFE, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFB, 0xFE, 0xFF, 0xBC, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x07, 0xF8, 0x3F,
  0xF1, 0xFF, 0xCF, 0x82, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0x0F, 0xFC, 0x3F, 0x70, 0xFD, 0xC0, 0x77, 0x01, 0xDE,
  0x07, 0x78, 0x1C, 0xF0, 0x73, 0xC1, 0xC7, 0xFF, 0x1F, 0xFC, 0x1F, 0xE0,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1C,
  0xFF, 0xFF, 0x7C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x7C, 0xFF, 0xFF, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0xFE,
  0xFE, 0xFC, 0xF0, 0x7F, 0x87, 0xBC, 0x3D, 0xE3, 0xCF, 0x1E, 0x79, 0xE3,
  0xCF, 0x1E, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0x79,
  0xC3, 0xCF, 0x1E, 0x38, 0xF1, 0xE7, 0x8F, 0x3C, 0x3D, 0xE1, 0xEF, 0x07,
  0xF8, 0x3C, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xDC, 0x0F, 0xFB, 0x83, 0xBF, 0x70,
  0x77, 0xFE, 0x0E, 0xFE, 0xE3, 0x9F, 0xDC, 0x73, 0xFB, 0x8E, 0x7F, 0x39,
  0xCF, 0xE7, 0x71, 0xFC, 0xEE, 0x3F, 0x9D, 0xC7, 0xF1, 0xF0, 0xFE, 0x3E,
  0x1F, 0xC7, 0xC3, 0xF8, 0xF8, 0x7F, 0x0E, 0x0F, 0xE1, 0xC1, 0xC0, 0xF8,
  0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xC3, 0xFB, 0x87,
  0xF7, 0x8F, 0xF7, 0x1F, 0xEF, 0x3F, 0xCE, 0x7F, 0x9C, 0xFF, 0x3D, 0xFE,
  0x3B, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x03, 0xFE, 0x07, 0xC0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF1, 0xE1,
  0xE7, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xB8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0xBC, 0x0F, 0x78,
  0x1E, 0xF0, 0x38, 0xF0, 0xF1, 0xFF, 0xC1, 0xFF, 0x80, 0xFC, 0x00, 0xFF,
  0x8F, 0xFC, 0xFF, 0xEF, 0x1E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x1E, 0xF3, 0xEF, 0xFC, 0xFF, 0x8F, 0xF0, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0xF0, 0x3F, 0xF0,
  0xFF, 0xF1, 0xE1, 0xE7, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xB8, 0x0F, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xEE, 0x01, 0xDC, 0x07,
  0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3C, 0xF0, 0xF1, 0xFF, 0xC1, 0xFF, 0x81,
  0xFE, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0xFF,
  0x87, 0xFE, 0x3F, 0xF9, 0xE3, 0xCF, 0x0F, 0x78, 0x7B, 0xC3, 0xDE, 0x1E,
  0xF0, 0xF7, 0x8F, 0x3F, 0xF9, 0xFF, 0x8F, 0xF8, 0x79, 0xC3, 0xCF, 0x1E,
  0x78, 0xF1, 0xE7, 0x8F, 0x3C, 0x39, 0xE1, 0xEF, 0x0F, 0x78, 0x3C, 0x1F,
  0xC7, 0xFD, 0xFF, 0x7C, 0x2F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x3F,
  0x0F, 0xFF, 0xEF, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xDE, 0x3E, 0xFF, 0xE3,
  0xFE, 0x0F, 0xE0, 0xF0, 0x1F, 0xE0, 0x3D, 0xC0, 0x73, 0x80, 0xE7, 0x83,
  0xCF, 0x07, 0x8E, 0x0E, 0x1C, 0x1C, 0x38, 0x78, 0x78, 0xF0, 0x71, 0xC0,
  0xE3, 0x81, 0xC7, 0x03, 0xDE, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1D,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x38, 0x1F,
  0xE0, 0x70, 0x3F, 0xC1, 0xF0, 0x73, 0x83, 0xE0, 0xE7, 0x07, 0xC1, 0xCE,
  0x0F, 0x87, 0x9E, 0x1B, 0x0F, 0x3C, 0x76, 0x1C, 0x38, 0xEE, 0x38, 0x71,
  0xDC, 0x70, 0xE3, 0xB9, 0xE1, 0xEE, 0x73, 0xC3, 0xDC, 0x67, 0x83, 0xB8,
  0xEE, 0x07, 0x71, 0xDC, 0x0E, 0xE3, 0xF8, 0x1D, 0x87, 0xF0, 0x3B, 0x07,
  0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xE0, 0x7C,
  0x00, 0x78, 0x79, 0xE1, 0xE3, 0x87, 0x0F, 0x3C, 0x3C, 0xE0, 0x73, 0x81,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0xC0,
  0x3F, 0x01, 0xFE, 0x07, 0x38, 0x3C, 0xE0, 0xF3, 0xC3, 0x87, 0x1E, 0x1E,
  0x70, 0x7B, 0xC0, 0xF0, 0xF0, 0x3D, 0xC1, 0xE7, 0x87, 0x9E, 0x1C, 0x38,
  0xF0, 0xF3, 0xC3, 0xCE, 0x07, 0x78, 0x1F, 0xE0, 0x3F, 0x00, 0xFC, 0x03,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xFF, 0xDF, 0xFB, 0xFF, 0x01,
  0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01,
  0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xFF,
  0xFF, 0xF8, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0xFF, 0xFF, 0xF8, 0x07,
  0x00, 0x1C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x77, 0x01, 0xCE, 0x0E,
  0x38, 0x38, 0x71, 0xC1, 0xC7, 0x03, 0xB8, 0x0E, 0xE0, 0x3C, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0x1F, 0x8F, 0xF8, 0xFF, 0x10,
  0xF0, 0x1E, 0x01, 0xC0, 0x39, 0xFF, 0x7F, 0xFF, 0x1F, 0xC3, 0xF0, 0x7E,
  0x1F, 0xE3, 0xFF, 0xFB, 0xF7, 0x3C, 0xE0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x78, 0xEF, 0xCF, 0xFE, 0xF1, 0xEF,
  0x0E, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF,
  0x0E, 0xF1, 0xEF, 0xFE, 0xEF, 0xCE, 0x78, 0x0F, 0x8F, 0xF3, 0xFD, 0xE1,
  0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x70, 0x1E,
  0x17, 0xFC, 0xFF, 0x1F, 0x80, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x71, 0xE7, 0x3F, 0x77, 0xFF, 0x78, 0xF7, 0x0F, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x77, 0x0F, 0x78,
  0xF7, 0xFF, 0x3F, 0x71, 0xF7, 0x1F, 0x83, 0xFC, 0x7F, 0xE7, 0x0E, 0x70,
  0xEF, 0x0E, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x70,
  0x07, 0x82, 0x7F, 0xE3, 0xFE, 0x1F, 0xC0, 0x07, 0x07, 0xF1, 0xF8, 0xF2,
  0x3C, 0x0F, 0x03, 0xC0, 0xFC, 0xFF, 0x3F, 0xC3, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x1E, 0x73, 0xF7, 0x7F, 0xF7, 0x8F, 0x70, 0xFF, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0x70, 0xF7, 0x8F, 0x7F, 0xF3,
  0xF7, 0x1E, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x40, 0xF7, 0xFE, 0x7F, 0xE7,
  0xF8, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x3C,
  0xEF, 0xDF, 0xFF, 0xC7, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xEF, 0xEE,
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x1C, 0x3C,
  0x70, 0xE0, 0x00, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x77, 0xEF, 0xDF,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x0F, 0xE1, 0xEE, 0x1C, 0xE3, 0xCE, 0x78, 0xE7, 0x0E, 0xF0, 0xEF, 0x0F,
  0xF0, 0xFF, 0x0F, 0x78, 0xE3, 0x8E, 0x3C, 0xE1, 0xCE, 0x1E, 0xE0, 0xEE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0x8F,
  0x9D, 0xFB, 0xFB, 0xFF, 0xFF, 0x78, 0xF9, 0xEF, 0x1E, 0x1F, 0xE3, 0xC3,
  0xF8, 0x38, 0x7F, 0x07, 0x0F, 0xE0, 0xE1, 0xFC, 0x1C, 0x3F, 0x83, 0x87,
  0xF0, 0x70, 0xFE, 0x0E, 0x1F, 0xC1, 0xC3, 0xF8, 0x38, 0x7F, 0x07, 0x0F,
  0xE0, 0xE1, 0xE0, 0xE7, 0x9D, 0xFB, 0xFF, 0xF8, 0xFF, 0x0F, 0xE1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xE0, 0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0x8F, 0x70, 0xFF, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0x70, 0xF7, 0x8F,
  0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0xE7, 0x8E, 0xFC, 0xFF, 0xEF, 0x1E, 0xF0,
  0xEF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0,
  0xEF, 0x1E, 0xFF, 0xEE, 0xFC, 0xE7, 0x8E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x1E, 0x73, 0xF7, 0x7F, 0xF7, 0x8F, 0x70,
  0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0x70,
  0xF7, 0x8F, 0x7F, 0xF3, 0xF7, 0x1E, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0xE7, 0xEF, 0xFF, 0xFF, 0xF0, 0xF0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x3F, 0x3F,
  0xFF, 0xFC, 0x2E, 0x07, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0xC1, 0xE0, 0x70,
  0x3C, 0x1F, 0xFF, 0xFE, 0xFE, 0x00, 0x18, 0x0C, 0x0E, 0x07, 0xFF, 0xFF,
  0xFC, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x3C, 0x1F, 0xC7, 0xE3, 0xF0, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0xE3,
  0xFF, 0xFB, 0xF7, 0x3E, 0xE0, 0xF0, 0x7F, 0x83, 0x9C, 0x1C, 0xE1, 0xE7,
  0x8F, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x3D, 0xE0, 0xEE, 0x07, 0x70, 0x3B,
  0x81, 0xDC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0xF0, 0x7F,
  0x0F, 0x0F, 0x70, 0xF0, 0xE7, 0x0F, 0x8E, 0x79, 0xF8, 0xE7, 0x9D, 0x9E,
  0x39, 0xD9, 0xE3, 0x99, 0x9C, 0x39, 0x9D, 0xC3, 0xB9, 0xDC, 0x3F, 0x9D,
  0xC1, 0xF9, 0xF8, 0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF0,
  0xF8, 0x0F, 0x0F, 0x00, 0xF0, 0xF7, 0x8F, 0x78, 0xE3, 0x9E, 0x3D, 0xC1,
  0xFC, 0x1F, 0x80, 0xF8, 0x0F, 0x00, 0xF8, 0x1F, 0x81, 0xFC, 0x3D, 0xC3,
  0x9E, 0x78, 0xE7, 0x0F, 0xF0, 0xF0, 0xF0, 0x7F, 0x83, 0x9C, 0x1C, 0xF1,
  0xE7, 0x8F, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x3D, 0xE0, 0xEE, 0x07, 0x70,
  0x3B, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x3C, 0x1E, 0x0E, 0x0F, 0x07, 0x07,
  0x83, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x87, 0xC7, 0xE3, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x8F, 0x87, 0x83, 0xE0, 0x78, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3C, 0x1F, 0x87, 0xC1, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xF0, 0x7C, 0x3F, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0xC0, 0xF8, 0x3C, 0x3E, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x78, 0xFC, 0x7C, 0x3C, 0x00, 0x7C, 0x1F, 0xFF, 0xFF, 0xF8,
  0x3E,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 22, 8, 2, -22 },
  { 12, 9, 8, 13, 2, -22 },
  { 21, 14, 22, 15, 1, -22 },
  { 60, 12, 26, 14, 1, -24 },
  { 99, 21, 22, 23, 1, -22 },
  { 157, 15, 22, 16, 1, -22 },
  { 199, 3, 8, 7, 2, -22 },
  { 202, 8, 27, 9, 1, -22 },
  { 229, 7, 27, 9, 1, -22 },
  { 253, 11, 12, 13, 1, -24 },
  { 270, 12, 14, 14, 1, -18 },
  { 291, 5, 8, 7, 1, -4 },
  { 296, 7, 3, 9, 1, -10 },
  { 299, 4, 4, 8, 2, -4 },
  { 301, 12, 22, 12, 0, -22 },
  { 334, 12, 22, 14, 1, -22 },
  { 367, 8, 22, 14, 2, -22 },
  { 389, 12, 22, 14, 1, -22 },
  { 422, 12, 22, 14, 1, -22 },
  { 455, 13, 22, 14, 0, -22 },
  { 491, 12, 22, 14, 1, -22 },
  { 524, 12, 22, 14, 1, -22 },
  { 557, 12, 22, 14, 1, -22 },
  { 590, 12, 22, 14, 1, -22 },
  { 623, 12, 22, 14, 1, -22 },
  { 656, 4, 17, 8, 2, -17 },
  { 665, 5, 21, 8, 1, -17 },
  { 679, 12, 14, 14, 1, -18 },
  { 700, 12, 9, 14, 1, -15 },
  { 714, 12, 14, 14, 1, -18 },
  { 735, 10, 22, 11, 0, -22 },
  { 763, 19, 25, 22, 1, -22 },
  { 823, 15, 22, 15, 0, -22 },
  { 865, 13, 22, 16, 2, -22 },
  { 901, 13, 22, 15, 1, -22 },
  { 937, 13, 22, 17, 2, -22 },
  { 973, 10, 22, 13, 2, -22 },
  { 1001, 10, 22, 13, 2, -22 },
  { 1029, 14, 22, 17, 1, -22 },
  { 1068, 13, 22, 18, 2, -22 },
  { 1104, 8, 22, 9, 1, -22 },
  { 1126, 8, 28, 8, -2, -22 },
  { 1154, 13, 22, 15, 2, -22 },
  { 1190, 10, 22, 12, 2, -22 },
  { 1218, 19, 22, 23, 2, -22 },
  { 1271, 15, 22, 19, 2, -22 },
  { 1313, 15, 22, 18, 1, -22 },
  { 1355, 12, 22, 15, 2, -22 },
  { 1388, 15, 27, 18, 1, -22 },
  { 1439, 13, 22, 15, 2, -22 },
  { 1475, 11, 22, 13, 1, -22 },
  { 1506, 12, 22, 13, 0, -22 },
  { 1539, 13, 22, 17, 2, -22 },
  { 1575, 15, 22, 15, 0, -22 },
  { 1617, 23, 22, 23, 0, -22 },
  { 1681, 14, 22, 14, 0, -22 },
  { 1720, 14, 22, 14, 0, -22 },
  { 1759, 11, 22, 12, 1, -22 },
  { 1790, 7, 27, 10, 2, -22 },
  { 1814, 12, 22, 12, 0, -22 },
  { 1847, 7, 27, 10, 1, -22 },
  { 1871, 14, 13, 15, 1, -22 },
  { 1894, 13, 2, 13, 0, 3 },
  { 1898, 7, 5, 9, 1, -24 },
  { 1903, 11, 17, 14, 1, -17 },
  { 1927, 12, 24, 15, 2, -24 },
  { 1963, 10, 17, 12, 1, -17 },
  { 1985, 12, 24, 15, 1, -24 },
  { 2021, 12, 17, 14, 1, -17 },
  { 2047, 10, 24, 9, 0, -24 },
  { 2077, 12, 24, 15, 1, -17 },
  { 2113, 11, 24, 15, 2, -24 },
  { 2146, 4, 23, 7, 2, -23 },
  { 2158, 7, 30, 7, -1, -23 },
  { 2185, 12, 24, 14, 2, -24 },
  { 2221, 3, 24, 7, 2, -24 },
  { 2230, 19, 17, 22, 2, -17 },
  { 2271, 11, 17, 15, 2, -17 },
  { 2295, 12, 17, 15, 1, -17 },
  { 2321, 12, 24, 15, 2, -17 },
  { 2357, 12, 24, 15, 1, -17 },
  { 2393, 8, 17, 10, 2, -17 },
  { 2410, 9, 17, 11, 1, -17 },
  { 2430, 9, 20, 9, 0, -20 },
  { 2453, 11, 17, 15, 2, -17 },
  { 2477, 13, 17, 13, 0, -17 },
  { 2505, 20, 17, 20, 0, -17 },
  { 2548, 12, 17, 13, 0, -17 },
  { 2574, 13, 24, 13, 0, -17 },
  { 2613, 9, 17, 11, 1, -17 },
  { 2633, 9, 27, 11, 1, -22 },
  { 2664, 3, 31, 13, 5, -24 },
  { 2676, 9, 27, 11, 1, -22 },
  { 2707, 12, 4, 14, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold31pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD31PT7B_H_
