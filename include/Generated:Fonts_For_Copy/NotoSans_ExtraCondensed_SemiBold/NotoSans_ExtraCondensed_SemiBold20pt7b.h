#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD20PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0x48, 0x2F, 0xC0, 0xEF, 0x3C, 0xF3, 0xCC, 0x19,
  0x0D, 0x86, 0xC3, 0x67, 0xF8, 0x98, 0x48, 0x64, 0xFF, 0xFF, 0xCD, 0x84,
  0xC2, 0x61, 0x20, 0x10, 0x71, 0xFF, 0xBD, 0x1A, 0x3C, 0x3C, 0x1C, 0x2C,
  0x5C, 0xBF, 0xFF, 0x04, 0x08, 0xF0, 0xC6, 0xCC, 0x36, 0x61, 0x32, 0x09,
  0xB0, 0x6D, 0xB3, 0x6B, 0xCE, 0xDB, 0x06, 0x98, 0x64, 0xC3, 0x26, 0x11,
  0xB1, 0x8D, 0x8C, 0x38, 0x3E, 0x06, 0xC0, 0xD8, 0x1B, 0x03, 0x60, 0x78,
  0x0E, 0x03, 0xE6, 0x6F, 0xCC, 0xF3, 0x8E, 0x31, 0xC7, 0xF8, 0x79, 0xC0,
  0xFB, 0x6C, 0x39, 0x98, 0xCE, 0x63, 0x18, 0xC6, 0x31, 0x8E, 0x31, 0x86,
  0x38, 0xE3, 0x0C, 0x61, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x98, 0xCC, 0xE0,
  0x30, 0x63, 0x7F, 0xF3, 0x8D, 0xB3, 0x00, 0x10, 0x20, 0x40, 0x8F, 0xFF,
  0xC4, 0x08, 0x10, 0x20, 0xFF, 0x68, 0xFF, 0x5F, 0x80, 0x07, 0x06, 0x06,
  0x0C, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x60, 0x60, 0xE0, 0x7C,
  0xFB, 0x3E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1F, 0x77, 0xCF, 0x00,
  0x1C, 0xF7, 0xFF, 0x5C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x70, 0xFD,
  0xFE, 0x38, 0x30, 0xE1, 0xC3, 0x0E, 0x38, 0x61, 0x87, 0x0F, 0xFF, 0xC0,
  0xFD, 0xFC, 0x18, 0x30, 0xE3, 0x9C, 0x3E, 0x0E, 0x0C, 0x1C, 0x7F, 0xDF,
  0x00, 0x06, 0x07, 0x03, 0x83, 0xC1, 0x61, 0xB0, 0x98, 0xCC, 0x46, 0x7F,
  0xFF, 0xE0, 0xC0, 0x60, 0x30, 0xFD, 0xFB, 0x06, 0x0C, 0x1F, 0x3F, 0x07,
  0x06, 0x0C, 0x1C, 0x7F, 0xDF, 0x00, 0x3E, 0xFD, 0x86, 0x0C, 0x1F, 0xBF,
  0xE3, 0xC7, 0x8F, 0x1F, 0x37, 0xE7, 0x80, 0xFF, 0xFF, 0x03, 0x07, 0x06,
  0x06, 0x0E, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x38, 0x30, 0x7D, 0xDF, 0x1E,
  0x3E, 0xEF, 0x8E, 0x3E, 0xCF, 0x8F, 0x1E, 0x3F, 0xEF, 0x80, 0x7D, 0xFB,
  0x1E, 0x3C, 0x78, 0xF3, 0xFF, 0x76, 0x0C, 0x38, 0x6F, 0xDF, 0x00, 0xFF,
  0x80, 0x00, 0x5F, 0x80, 0xFF, 0x80, 0x00, 0x1F, 0xED, 0x80, 0x02, 0x0C,
  0x7B, 0xCE, 0x1C, 0x0E, 0x07, 0x06, 0x04, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x80, 0xC0, 0xF0, 0x3C, 0x0F, 0x0E, 0x38, 0xE0, 0xC0, 0x80, 0xFC,
  0xF8, 0x38, 0x70, 0xC3, 0x86, 0x18, 0x30, 0x60, 0x01, 0x83, 0x06, 0x00,
  0x1F, 0x83, 0x0C, 0x60, 0x66, 0x73, 0xCF, 0xBD, 0x9B, 0xD9, 0xBD, 0x9B,
  0xD9, 0xBD, 0xBB, 0xCE, 0xEC, 0x4C, 0x60, 0x07, 0x04, 0x3F, 0x80, 0x60,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x37, 0x0C, 0xC3, 0x30, 0xCC, 0x7F, 0x9F,
  0xE6, 0x19, 0x86, 0xE1, 0xF8, 0x70, 0xFE, 0xFF, 0xE3, 0xE3, 0xE3, 0xE6,
  0xFC, 0xFF, 0xE3, 0xE3, 0xE3, 0xE7, 0xFF, 0xFE, 0x08, 0x3F, 0x7E, 0x60,
  0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0x71, 0x7F, 0x3F, 0xFE,
  0x7F, 0xB9, 0xDC, 0x7E, 0x3F, 0x1F, 0x87, 0xC7, 0xE3, 0xF1, 0xF8, 0xDC,
  0xEF, 0xE7, 0xE0, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x3F, 0x7E, 0xE1, 0xC3,
  0x87, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x38, 0xE3, 0x8F, 0xFF, 0xE3, 0x8E,
  0x38, 0xE3, 0x80, 0x3F, 0xBF, 0xDC, 0x1C, 0x0E, 0x06, 0x03, 0x1F, 0x8F,
  0xC1, 0xF0, 0xF8, 0x6E, 0x37, 0xF9, 0xFC, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0xFF, 0xFF, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0C, 0xF6,
  0x66, 0x66, 0x66, 0x66, 0x66, 0xFF, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0xF7, 0x00, 0xE3, 0xF3, 0xB9, 0x9D, 0xCE, 0xC7,
  0xE3, 0xE1, 0xF8, 0xEC, 0x77, 0x39, 0x9C, 0xEE, 0x37, 0x1C, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0xFF, 0xC0, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xB1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE2, 0xFD, 0xB7,
  0xED, 0xBF, 0x6D, 0xF9, 0xCF, 0xCE, 0x7E, 0x73, 0xF3, 0x1C, 0xE0, 0xFC,
  0x3F, 0x0F, 0x63, 0xF8, 0xFF, 0x3E, 0xCF, 0xB3, 0xE6, 0xF9, 0xBE, 0x3F,
  0x8F, 0xE3, 0xF8, 0x70, 0x3F, 0x1F, 0xC6, 0x3B, 0x86, 0xC1, 0xB0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF8, 0x6E, 0x19, 0x8E, 0x7F, 0x0F, 0x80, 0xFC, 0xFE,
  0xE7, 0xE7, 0xE7, 0xE7, 0xEE, 0xFE, 0xF8, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0x3F, 0x1F, 0xC6, 0x3B, 0x86, 0xC1, 0xB0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8,
  0x6E, 0x19, 0x8E, 0x7F, 0x0F, 0x80, 0x70, 0x0C, 0x03, 0x80, 0xFC, 0x7F,
  0x39, 0xDC, 0xEE, 0x77, 0x3B, 0xF9, 0xF8, 0xEC, 0x77, 0x39, 0x9C, 0xEE,
  0x37, 0x1C, 0x00, 0xFF, 0xF6, 0x0C, 0x18, 0x38, 0x3C, 0x3C, 0x18, 0x38,
  0x78, 0xFF, 0xBE, 0x00, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xEC, 0x77, 0xF1, 0xF0, 0xC1, 0xF8,
  0x66, 0x19, 0x86, 0x63, 0x1C, 0xC3, 0x30, 0xCC, 0x36, 0x0D, 0x81, 0xE0,
  0x78, 0x1C, 0x07, 0x00, 0xC3, 0x8F, 0xC7, 0x1B, 0x8E, 0x33, 0x1C, 0x66,
  0x68, 0xCC, 0xDB, 0x99, 0xB6, 0x3B, 0x6C, 0x34, 0xD8, 0x79, 0xB0, 0xF1,
  0x61, 0xE3, 0x83, 0xC7, 0x03, 0x8E, 0x00, 0xE3, 0xB1, 0x8D, 0x86, 0xC3,
  0x60, 0xE0, 0x70, 0x38, 0x3E, 0x1B, 0x0D, 0x8C, 0xE6, 0x37, 0x1C, 0xE3,
  0xB1, 0x98, 0xCE, 0xC3, 0x61, 0xB0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0xFE, 0xFE, 0x06, 0x0C, 0x0C, 0x1C, 0x18, 0x38, 0x30,
  0x30, 0x60, 0x60, 0xFF, 0xFF, 0xFE, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x1F, 0xF8, 0xE0, 0x60, 0x60, 0x30, 0x30, 0x30, 0x18, 0x18,
  0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x07, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x3F, 0xF0, 0x0C, 0x03, 0x01, 0xE0, 0x78, 0x33, 0x0C, 0xC6, 0x1B,
  0x87, 0xFF, 0xE6, 0x30, 0xFC, 0xF8, 0x38, 0x33, 0xFF, 0xF1, 0xE3, 0xCF,
  0xFF, 0xD8, 0xC0, 0xC0, 0xC0, 0xC0, 0xDC, 0xFE, 0xE7, 0xE3, 0xC3, 0xC3,
  0xC3, 0xE3, 0xE7, 0xFE, 0xDE, 0x3D, 0xFE, 0x30, 0xC3, 0x0C, 0x30, 0xE1,
  0xF7, 0xC0, 0x07, 0x07, 0x07, 0x07, 0x77, 0x7F, 0xE7, 0xC7, 0xC7, 0xC7,
  0xC7, 0xC7, 0xC7, 0xFF, 0x7B, 0x38, 0xFB, 0x1E, 0x3F, 0xFF, 0xF0, 0x60,
  0xC0, 0xFC, 0xF8, 0x3C, 0xF7, 0x1C, 0x7B, 0xE7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x00, 0x7B, 0x7F, 0xE7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7,
  0xFF, 0x7F, 0x07, 0x06, 0x8E, 0xFC, 0x78, 0xC0, 0xC0, 0xC0, 0xC0, 0xDC,
  0xFE, 0xE6, 0xE7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xDD, 0x0D,
  0xB6, 0xDB, 0x6D, 0xB0, 0x67, 0x20, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0xEC, 0xC0, 0xC0, 0xC0, 0xC0, 0xC7, 0xC6, 0xCC, 0xDC, 0xD8, 0xF8,
  0xEC, 0xCC, 0xC6, 0xC6, 0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0xDC, 0xEF, 0xFF,
  0xE7, 0x3E, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63,
  0xC6, 0x30, 0xDC, 0xFE, 0xE6, 0xE7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7,
  0xC7, 0x3C, 0x7E, 0xE6, 0xC6, 0xC7, 0xC7, 0xC7, 0xC6, 0xE6, 0x7E, 0x3C,
  0xDC, 0xFE, 0xE7, 0xE3, 0xC3, 0xC3, 0xC3, 0xE3, 0xE7, 0xFE, 0xDE, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0x7B, 0x7F, 0xE7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7,
  0xC7, 0xFF, 0x7F, 0x07, 0x07, 0x07, 0x07, 0x07, 0xDE, 0xFD, 0xCC, 0x63,
  0x18, 0xC6, 0x30, 0x7F, 0xEC, 0x30, 0xE1, 0xE3, 0x87, 0x9F, 0xEF, 0x80,
  0x30, 0xC7, 0xFF, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1F, 0x3C, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xE6, 0xFD, 0xE8, 0xC3, 0xE3, 0x67, 0x66,
  0x66, 0x76, 0x36, 0x3C, 0x3C, 0x1C, 0x1C, 0xC7, 0x1F, 0x39, 0xD9, 0x4C,
  0xCA, 0x66, 0xDB, 0x36, 0xD8, 0xF7, 0x87, 0xBC, 0x38, 0xE1, 0xC7, 0x0E,
  0x38, 0xE7, 0x66, 0x76, 0x3C, 0x3C, 0x18, 0x3C, 0x3C, 0x66, 0x66, 0xE7,
  0xC3, 0xE3, 0x67, 0x66, 0x66, 0x36, 0x3E, 0x3C, 0x3C, 0x1C, 0x18, 0x18,
  0x18, 0x38, 0x70, 0x60, 0x7D, 0xF0, 0xC6, 0x18, 0xE3, 0x1C, 0x63, 0xFF,
  0xC0, 0x1C, 0x71, 0x8E, 0x38, 0xE3, 0x9C, 0xE0, 0xC3, 0x8E, 0x38, 0xE1,
  0x87, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0x87, 0x1C, 0x71, 0xC7,
  0x0E, 0x1C, 0xC7, 0x1C, 0x71, 0xC7, 0x38, 0xE0, 0x41, 0xFB, 0x9E,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 6, 5, 8, 1, -14 },
  { 11, 9, 14, 10, 0, -14 },
  { 27, 7, 16, 9, 1, -15 },
  { 41, 13, 14, 15, 1, -14 },
  { 64, 11, 14, 11, 0, -14 },
  { 84, 3, 5, 5, 1, -14 },
  { 86, 5, 17, 6, 1, -14 },
  { 97, 5, 17, 6, 0, -14 },
  { 108, 7, 7, 9, 1, -15 },
  { 115, 7, 10, 9, 1, -12 },
  { 124, 3, 5, 5, 1, -2 },
  { 126, 4, 2, 6, 1, -6 },
  { 127, 3, 3, 5, 1, -3 },
  { 129, 8, 14, 8, 0, -14 },
  { 143, 7, 14, 9, 1, -14 },
  { 156, 6, 14, 9, 1, -14 },
  { 167, 7, 14, 9, 1, -14 },
  { 180, 7, 14, 9, 1, -14 },
  { 193, 9, 14, 9, 0, -14 },
  { 209, 7, 14, 9, 1, -14 },
  { 222, 7, 14, 9, 1, -14 },
  { 235, 8, 14, 9, 0, -14 },
  { 249, 7, 14, 9, 1, -14 },
  { 262, 7, 14, 9, 1, -14 },
  { 275, 3, 11, 5, 1, -11 },
  { 280, 3, 14, 5, 1, -11 },
  { 286, 7, 10, 9, 1, -12 },
  { 295, 7, 6, 9, 1, -10 },
  { 301, 8, 10, 9, 1, -12 },
  { 311, 7, 14, 7, 0, -14 },
  { 324, 12, 16, 14, 1, -14 },
  { 348, 10, 14, 10, 0, -14 },
  { 366, 8, 14, 10, 1, -14 },
  { 380, 8, 15, 9, 1, -15 },
  { 395, 9, 14, 11, 1, -14 },
  { 411, 7, 14, 8, 1, -14 },
  { 424, 6, 14, 8, 1, -14 },
  { 435, 9, 14, 11, 1, -14 },
  { 451, 9, 14, 11, 1, -14 },
  { 467, 4, 14, 6, 1, -14 },
  { 474, 5, 18, 5, -1, -14 },
  { 486, 9, 14, 10, 1, -14 },
  { 502, 7, 14, 8, 1, -14 },
  { 515, 13, 14, 15, 1, -14 },
  { 538, 10, 14, 12, 1, -14 },
  { 556, 10, 14, 12, 1, -14 },
  { 574, 8, 14, 9, 1, -14 },
  { 588, 10, 17, 12, 1, -14 },
  { 610, 9, 14, 10, 1, -14 },
  { 626, 7, 15, 8, 1, -15 },
  { 640, 8, 14, 8, 0, -14 },
  { 654, 9, 14, 11, 1, -14 },
  { 670, 10, 14, 10, 0, -14 },
  { 688, 15, 14, 15, 0, -14 },
  { 715, 9, 14, 9, 0, -14 },
  { 731, 9, 14, 9, 0, -14 },
  { 747, 8, 14, 8, 0, -14 },
  { 761, 5, 17, 6, 1, -14 },
  { 772, 8, 14, 8, 0, -14 },
  { 786, 4, 17, 6, 1, -14 },
  { 795, 10, 8, 10, 0, -14 },
  { 805, 8, 1, 8, 0, 2 },
  { 806, 4, 3, 6, 1, -15 },
  { 808, 7, 11, 9, 1, -11 },
  { 818, 8, 15, 10, 1, -15 },
  { 833, 6, 11, 8, 1, -11 },
  { 842, 8, 15, 10, 1, -15 },
  { 857, 7, 11, 9, 1, -11 },
  { 867, 6, 15, 6, 0, -15 },
  { 879, 8, 16, 10, 1, -11 },
  { 895, 8, 15, 10, 1, -15 },
  { 910, 3, 15, 5, 1, -15 },
  { 916, 4, 20, 5, 0, -15 },
  { 926, 8, 15, 9, 1, -15 },
  { 941, 2, 15, 5, 1, -15 },
  { 945, 12, 11, 14, 1, -11 },
  { 962, 8, 11, 10, 1, -11 },
  { 973, 8, 11, 9, 1, -11 },
  { 984, 8, 16, 10, 1, -11 },
  { 1000, 8, 16, 10, 1, -11 },
  { 1016, 5, 11, 7, 1, -11 },
  { 1023, 6, 11, 7, 1, -11 },
  { 1032, 6, 13, 6, 0, -13 },
  { 1042, 7, 11, 10, 1, -11 },
  { 1052, 8, 11, 8, 0, -11 },
  { 1063, 13, 11, 13, 0, -11 },
  { 1081, 8, 11, 8, 0, -11 },
  { 1092, 8, 16, 8, 0, -11 },
  { 1108, 6, 11, 7, 0, -11 },
  { 1117, 6, 17, 7, 0, -14 },
  { 1130, 2, 20, 9, 3, -15 },
  { 1135, 6, 17, 7, 1, -14 },
  { 1148, 8, 3, 9, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold20pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD20PT7B_H_
