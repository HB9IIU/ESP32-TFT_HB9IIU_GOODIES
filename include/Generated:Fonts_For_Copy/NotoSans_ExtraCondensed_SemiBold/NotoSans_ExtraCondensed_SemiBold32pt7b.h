#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD32PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF6, 0x00, 0x0F, 0xFF,
  0xF0, 0xF3, 0xFC, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xEE, 0x3B, 0x8E, 0x0E,
  0x30, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x31, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x18, 0xE0, 0x63, 0x0F,
  0xFF, 0xBF, 0xFE, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x31, 0xC0,
  0xC6, 0x07, 0x18, 0x00, 0x02, 0x00, 0x20, 0x0F, 0xC3, 0xFF, 0x7F, 0xE7,
  0xA6, 0xF2, 0x0F, 0x20, 0xF2, 0x07, 0xA0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x2F, 0x02, 0x70, 0x27, 0xC2, 0xFF, 0x3E, 0xFF, 0xE7,
  0xF8, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x3C, 0x07, 0x03, 0xF0, 0x38,
  0x1D, 0xC1, 0x81, 0xCE, 0x1C, 0x0E, 0x30, 0xE0, 0x71, 0x86, 0x03, 0x8E,
  0x70, 0x1C, 0x73, 0x80, 0xE3, 0xB8, 0x07, 0x19, 0xCF, 0x39, 0xCC, 0xFC,
  0xEE, 0xE7, 0xE7, 0xE7, 0x73, 0x9E, 0x33, 0x9C, 0x03, 0x9C, 0xE0, 0x1C,
  0xE7, 0x01, 0xC7, 0x38, 0x0E, 0x39, 0xC0, 0x61, 0xCE, 0x07, 0x0E, 0x70,
  0x38, 0x3B, 0x81, 0x81, 0xF8, 0x1C, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0xC0,
  0x3F, 0xC0, 0x39, 0xE0, 0x78, 0xE0, 0x78, 0xE0, 0x39, 0xE0, 0x39, 0xC0,
  0x3F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x1E, 0x7F, 0x9E, 0x7F, 0x9E,
  0xF3, 0xDE, 0xF1, 0xFC, 0xF1, 0xFC, 0xF0, 0xF8, 0xF0, 0x78, 0xF8, 0xF8,
  0x7F, 0xFC, 0x7F, 0xDE, 0x3F, 0x9F, 0xFF, 0xEE, 0xEE, 0xEE, 0x0E, 0x38,
  0xF1, 0xC3, 0x8E, 0x1C, 0x78, 0xF1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0F, 0x0E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0x70, 0xE0,
  0xE1, 0xC1, 0xC3, 0x87, 0x87, 0x0E, 0x1E, 0x3C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x78, 0xF1, 0xC3, 0x8F, 0x1C, 0x38, 0xE1, 0xC7, 0x00,
  0x0F, 0x00, 0xE0, 0x0E, 0x0E, 0x66, 0xFF, 0xEF, 0xFF, 0x0F, 0x01, 0xF8,
  0x3B, 0xC7, 0x9E, 0x31, 0xC1, 0x10, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x7B, 0xDE, 0xF7, 0x3B, 0xDC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0,
  0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00,
  0xF0, 0x00, 0x0F, 0x83, 0xFC, 0x3F, 0xE7, 0x9E, 0x78, 0xE7, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xF7, 0x0F, 0x78, 0xE7, 0x9E, 0x3F, 0xE3, 0xFC, 0x1F,
  0x80, 0x07, 0x87, 0xC7, 0xE7, 0xF7, 0xFF, 0xBF, 0x9E, 0x8F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x1F, 0x87, 0xFC, 0xFF, 0xE7, 0x1E, 0x40, 0xE0, 0x0F,
  0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0x87, 0xFC, 0xFF, 0xE6, 0x1E, 0x40, 0xF0, 0x0F, 0x00,
  0xF0, 0x0E, 0x01, 0xE0, 0x7C, 0x1F, 0x81, 0xF8, 0x1F, 0xE0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFC, 0x1F, 0xFF, 0xEF, 0xFC, 0x7F,
  0x80, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x37,
  0x83, 0xBC, 0x1D, 0xE1, 0xCF, 0x0E, 0x78, 0xE3, 0xC7, 0x1E, 0x70, 0xF3,
  0x87, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0xF8, 0x7F, 0xE7, 0xFE, 0x01, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFC, 0x1E, 0xFF, 0xEF, 0xFC,
  0x7F, 0x80, 0x07, 0xE0, 0xFE, 0x1F, 0xE3, 0xE0, 0x78, 0x07, 0x80, 0x70,
  0x07, 0x00, 0xF3, 0x8F, 0x7C, 0xFF, 0xEF, 0xDF, 0xF0, 0xFF, 0x0F, 0xF0,
  0x7F, 0x07, 0xF0, 0x77, 0x0F, 0x70, 0xF7, 0x8F, 0x3F, 0xE3, 0xFC, 0x1F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x00,
  0x1F, 0x83, 0xFE, 0x7F, 0xE7, 0x8F, 0x70, 0xFF, 0x0F, 0x70, 0xF7, 0x0F,
  0x79, 0xE3, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0xC7, 0x9E, 0xF0, 0xFF, 0x0F,
  0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0x0F, 0x7F, 0xF7, 0xFE, 0x1F, 0xC0, 0x1F,
  0x83, 0xFC, 0x7F, 0xE7, 0x9E, 0xF0, 0xEF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xF7, 0x9F, 0x7F, 0x73, 0xF7, 0x1E, 0xF0, 0x0F, 0x00,
  0xE0, 0x0E, 0x01, 0xE0, 0x3C, 0x7F, 0xC7, 0xF8, 0x7E, 0x00, 0x4F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x13, 0xDE, 0xF7, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xEF, 0x7B, 0xDC, 0xEF, 0x70, 0x00, 0x08, 0x01,
  0xC0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x1E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1C, 0x00, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x80, 0x07, 0x00, 0x3E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0x01, 0xF8, 0x3F, 0x0F, 0xE1, 0xFC, 0x0F, 0x80, 0x70, 0x02,
  0x00, 0x00, 0x3F, 0x1F, 0xF1, 0xFF, 0x31, 0xE0, 0x1E, 0x03, 0xC0, 0x78,
  0x0E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0xF0, 0x0F, 0x8F, 0x81, 0xE0, 0x3C, 0x1C, 0x01, 0xC3, 0x80,
  0x0E, 0x30, 0x7E, 0xE7, 0x1F, 0xC6, 0x71, 0xCC, 0x76, 0x38, 0xC7, 0x63,
  0x8C, 0x7E, 0x31, 0xC7, 0xE3, 0x1C, 0x7E, 0x31, 0xC7, 0xE3, 0x1C, 0x7E,
  0x39, 0xC6, 0x63, 0x9C, 0xE7, 0x3F, 0x7E, 0x71, 0xE7, 0xC7, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x02, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x0E, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x0E, 0xF0, 0x0E, 0x70, 0x1E, 0x70, 0x1E, 0x78, 0x1E,
  0x78, 0x1C, 0x78, 0x1C, 0x38, 0x3C, 0x3C, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0F, 0xF0,
  0x0F, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xE3, 0xEF, 0x0F, 0x78, 0x3F, 0xC1,
  0xFE, 0x0E, 0xF0, 0xF7, 0x9F, 0x3F, 0xF1, 0xFF, 0xCF, 0xFF, 0x78, 0x7B,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xEF, 0xFF, 0x7F,
  0xF3, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0xC7, 0xFE, 0x7C, 0x23, 0xC0, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x31,
  0xFF, 0x87, 0xFC, 0x1F, 0xC0, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x3C, 0xFC,
  0xF0, 0xFB, 0xC1, 0xEF, 0x07, 0xBC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7B, 0xC1,
  0xEF, 0x0F, 0xBC, 0x7C, 0xFF, 0xE3, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x07, 0xF0, 0x7F, 0xF3,
  0xFF, 0x9F, 0x86, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0x80, 0x0E, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xF7, 0x83, 0xDF, 0x0F, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF,
  0x80, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xC0, 0xFF, 0xFF, 0x7E, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x7E, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFE, 0xFE, 0xFC, 0x20, 0xF0,
  0x3F, 0xC1, 0xEF, 0x0F, 0x3C, 0x3C, 0xF1, 0xE3, 0xC7, 0x8F, 0x3C, 0x3C,
  0xF0, 0xF7, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xEF, 0x0F,
  0x3C, 0x3C, 0xF0, 0xF1, 0xE3, 0xC7, 0x8F, 0x0F, 0x3C, 0x3C, 0xF0, 0x7B,
  0xC1, 0xEF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x01, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xF7, 0x0E, 0xFF, 0x70, 0xEF, 0xF7, 0x0E,
  0xFF, 0x70, 0xEF, 0xF3, 0x9C, 0xFF, 0x39, 0xCF, 0xF3, 0x9C, 0xFF, 0x3B,
  0x8F, 0xF1, 0xF8, 0xFF, 0x1F, 0x8F, 0xF1, 0xF8, 0xFF, 0x1F, 0x0F, 0xF0,
  0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xE0, 0xF0, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x87, 0xF7, 0x0F,
  0xEF, 0x1F, 0xCE, 0x3F, 0x9C, 0x7F, 0x3C, 0xFE, 0x39, 0xFC, 0x7B, 0xF8,
  0x77, 0xF0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x07, 0x80, 0x07, 0xE0, 0x1F, 0xF8, 0x1F, 0xFC, 0x3E, 0x3C, 0x3C,
  0x1E, 0x78, 0x1E, 0x78, 0x0E, 0x78, 0x0F, 0x70, 0x0F, 0x70, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0F, 0x70, 0x0F, 0x78, 0x0F, 0x78,
  0x0F, 0x78, 0x1E, 0x3C, 0x1E, 0x3E, 0x3C, 0x1F, 0xFC, 0x1F, 0xF8, 0x07,
  0xF0, 0xFF, 0x0F, 0xFC, 0xFF, 0xEF, 0x3E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0xFE, 0xFF, 0xEF, 0xF8, 0xFE, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00,
  0x07, 0xE0, 0x1F, 0xF8, 0x1F, 0xFC, 0x3E, 0x3C, 0x3C, 0x1E, 0x78, 0x1E,
  0x78, 0x0F, 0x78, 0x0F, 0x70, 0x0F, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0x70, 0x0F, 0x70, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1E,
  0x3C, 0x1E, 0x3E, 0x3C, 0x1F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0x0F,
  0xFE, 0x3C, 0xFC, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3,
  0xC3, 0xCF, 0x1E, 0x3F, 0xF8, 0xFF, 0xC3, 0xFE, 0x0F, 0x3C, 0x3C, 0xF0,
  0xF1, 0xE3, 0xC7, 0x8F, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC1, 0xEF, 0x07,
  0xC0, 0x1F, 0xC7, 0xFD, 0xFF, 0xBE, 0x7F, 0x03, 0xE0, 0x3C, 0x07, 0x80,
  0x78, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x78, 0x0F, 0x00,
  0xE0, 0x1E, 0x07, 0xF1, 0xFF, 0xFD, 0xFF, 0x9F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xEF, 0x07, 0x9E, 0x1E, 0x7F, 0xF8,
  0xFF, 0xC1, 0xFE, 0x00, 0xF0, 0x0F, 0xE0, 0x3D, 0xC0, 0x7B, 0x80, 0xF7,
  0x81, 0xCF, 0x03, 0x8E, 0x0F, 0x1C, 0x1E, 0x38, 0x38, 0x78, 0x70, 0x71,
  0xE0, 0xE3, 0xC1, 0xC7, 0x03, 0xCE, 0x03, 0xBC, 0x07, 0x78, 0x0E, 0xE0,
  0x1D, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0xF0, 0x38, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0E, 0xF0, 0x3C, 0x1E,
  0x70, 0x7C, 0x1E, 0x70, 0x7C, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1C,
  0x38, 0xEE, 0x3C, 0x38, 0xEE, 0x3C, 0x38, 0xEE, 0x3C, 0x3C, 0xE7, 0x3C,
  0x3C, 0xE7, 0x38, 0x1D, 0xE7, 0x78, 0x1D, 0xC7, 0x78, 0x1D, 0xC7, 0x78,
  0x1D, 0xC3, 0x78, 0x1F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0x83, 0xF0,
  0x0F, 0x83, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xE0, 0x78, 0x3D, 0xE1,
  0xE3, 0x87, 0x8F, 0x1C, 0x3C, 0xF0, 0x73, 0xC1, 0xEE, 0x03, 0xF8, 0x0F,
  0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0xFE, 0x07,
  0xF8, 0x1E, 0xE0, 0xF3, 0xC3, 0xC7, 0x0E, 0x1E, 0x78, 0x79, 0xE0, 0xFF,
  0x03, 0xC0, 0xF0, 0x3F, 0xC0, 0xF7, 0x83, 0x9E, 0x1E, 0x38, 0x78, 0xF1,
  0xC3, 0xCF, 0x07, 0x38, 0x1E, 0xE0, 0x7F, 0x80, 0xFC, 0x03, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x0F, 0x01,
  0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xFF, 0xFF, 0xF0, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03,
  0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0xFF, 0xFF, 0xF8, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x1E, 0x00, 0x78, 0x03, 0xF0, 0x0F,
  0xC0, 0x7F, 0x01, 0xCE, 0x0F, 0x38, 0x38, 0x71, 0xE1, 0xC7, 0x03, 0x9C,
  0x0E, 0xE0, 0x3C, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0xF0, 0xE0, 0xE1, 0xE0,
  0xC0, 0x0F, 0x0F, 0xF8, 0xFF, 0x98, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x3F,
  0x3F, 0xEF, 0xFF, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0xFF, 0x7F,
  0xE7, 0xCC, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE3,
  0x0E, 0xFC, 0xEF, 0xEF, 0xFE, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0xFE, 0xEF,
  0xEE, 0x7C, 0x07, 0x07, 0xF3, 0xFD, 0xF7, 0x78, 0x1C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x85, 0xFF, 0x3F, 0xC7,
  0xF0, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x39,
  0xE7, 0xEF, 0x3F, 0xFB, 0xEF, 0xDE, 0x3E, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1E, 0xE0, 0xF7, 0x8F, 0xBF,
  0xFC, 0xFF, 0xE3, 0xE7, 0x06, 0x01, 0xFC, 0x3F, 0xE7, 0x9E, 0x70, 0xF7,
  0x0F, 0xF0, 0x7F, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x07,
  0x00, 0x78, 0x23, 0xFE, 0x3F, 0xE1, 0xFE, 0x0F, 0xC7, 0xF1, 0xF8, 0xF0,
  0x3C, 0x0F, 0x03, 0xC1, 0xFE, 0xFF, 0xBF, 0xE3, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x0E, 0x01, 0xFB, 0xCF, 0xFE, 0xFB, 0xF7, 0x8F, 0xB8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xB8, 0x3D,
  0xE3, 0xEF, 0xFF, 0x3F, 0xF8, 0xFB, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x20,
  0x79, 0xEF, 0xCF, 0xFC, 0x7F, 0xC0, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE3, 0x8E, 0xFC, 0xEF, 0xEF, 0xFE, 0xF0,
  0xEF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xEF, 0xFE, 0x00, 0x0E,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x1C, 0x3C, 0x78, 0xE0,
  0x00, 0x00, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xEB, 0xDF, 0xBE, 0x38,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x1E, 0xF1, 0xE7, 0x8E, 0x3C, 0xF1, 0xEF, 0x0F, 0x70, 0x77, 0x83, 0xBC,
  0x1F, 0xE0, 0xFF, 0x87, 0x9C, 0x3C, 0xF1, 0xE3, 0x8F, 0x1E, 0x78, 0x73,
  0xC3, 0xDE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0x83, 0x1D, 0xF9, 0xFB, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F,
  0xE1, 0xE1, 0xFC, 0x3C, 0x3F, 0x87, 0x07, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F,
  0x83, 0x83, 0xF0, 0x70, 0x7E, 0x0E, 0x0F, 0xC1, 0xC1, 0xF8, 0x38, 0x3F,
  0x07, 0x07, 0xE0, 0xE0, 0xFC, 0x1C, 0x1C, 0x03, 0x0E, 0xFC, 0xEF, 0xEF,
  0xFE, 0xF0, 0xEF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0x07, 0x00,
  0xFE, 0x0F, 0xF8, 0xFB, 0xE7, 0x8F, 0x38, 0x3B, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xF7, 0x07, 0xB8, 0x39, 0xE3, 0xC7, 0xFE,
  0x3F, 0xE0, 0x7E, 0x00, 0x03, 0x8E, 0xFC, 0xEF, 0xEF, 0x9E, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0xFF,
  0x0F, 0xF8, 0xFF, 0xFE, 0xEF, 0xEE, 0x7C, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x01, 0xFB, 0xCF, 0xFE,
  0xFB, 0xF7, 0x8F, 0xB8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xB8, 0x3D, 0xE3, 0xEF, 0xFF, 0x3F, 0xF8, 0xFB,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x03, 0xE7, 0xEF, 0xFF, 0xF8, 0xF0, 0xF0, 0xF0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x1E, 0x1F, 0xF7, 0xFB,
  0xE6, 0xE0, 0x38, 0x0F, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1E, 0x03,
  0xC0, 0xF8, 0x3B, 0xFE, 0xFF, 0xBF, 0x80, 0x1C, 0x0E, 0x07, 0x07, 0x87,
  0xFF, 0xFF, 0xFE, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0xE3, 0xF1, 0xF8, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xF0, 0xFF, 0x1F, 0xFF, 0xF7, 0xFF, 0x3E, 0x70, 0xF0, 0x7B, 0x83,
  0xDC, 0x1C, 0xF0, 0xE7, 0x8F, 0x1C, 0x78, 0xE3, 0x87, 0x9C, 0x3C, 0xE0,
  0xEF, 0x07, 0x70, 0x3B, 0x80, 0xDC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x07,
  0x80, 0xF0, 0xF8, 0x7B, 0x87, 0xC3, 0x9C, 0x3E, 0x1C, 0xF1, 0xB1, 0xE7,
  0x9D, 0x8F, 0x3C, 0xEE, 0x70, 0xE7, 0x73, 0x87, 0x3B, 0xBC, 0x3D, 0x9D,
  0xE1, 0xEC, 0x6E, 0x07, 0xE3, 0x70, 0x3F, 0x1B, 0x81, 0xF8, 0xFC, 0x0F,
  0xC7, 0xE0, 0x7C, 0x3E, 0x01, 0xE1, 0xF0, 0x0F, 0x07, 0x80, 0xF8, 0xFB,
  0xC7, 0x8E, 0x38, 0x7B, 0xC1, 0xDC, 0x0F, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x07, 0xF0, 0x3B, 0x83, 0xDE, 0x1C, 0xF1, 0xE3, 0xCF, 0x1E,
  0xF0, 0x78, 0xF0, 0x7B, 0x83, 0xDE, 0x1C, 0xF0, 0xE7, 0x8F, 0x1C, 0x78,
  0xE3, 0x87, 0x9C, 0x1D, 0xE0, 0xEF, 0x07, 0x70, 0x3F, 0x80, 0xFC, 0x07,
  0xE0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0,
  0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0,
  0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x0E, 0x0F, 0x07, 0x07, 0x83, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0x87, 0xC7, 0xE3, 0xC1, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x87, 0xC7, 0xC3, 0xC1, 0xF8, 0x3C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1E, 0x0F, 0xC3, 0xE0, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0,
  0x3E, 0x0F, 0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x78, 0x1F, 0x03, 0xF0, 0x7C, 0x7F, 0x1E, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x3F, 0x0F, 0x83, 0xC0, 0x30, 0x0F,
  0xF0, 0xFF, 0xFF, 0x9F, 0xF8, 0x1E, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 23, 8, 2, -23 },
  { 13, 10, 8, 13, 2, -23 },
  { 23, 14, 23, 16, 1, -23 },
  { 64, 12, 26, 14, 1, -24 },
  { 103, 21, 23, 23, 1, -23 },
  { 164, 16, 23, 17, 1, -23 },
  { 210, 4, 8, 7, 2, -23 },
  { 214, 7, 28, 10, 2, -23 },
  { 239, 7, 28, 10, 1, -23 },
  { 264, 12, 12, 14, 1, -24 },
  { 282, 12, 15, 14, 1, -19 },
  { 305, 5, 8, 8, 1, -4 },
  { 310, 8, 3, 9, 1, -10 },
  { 313, 4, 4, 8, 2, -4 },
  { 315, 12, 23, 13, 0, -23 },
  { 350, 12, 23, 14, 1, -23 },
  { 385, 9, 23, 14, 2, -23 },
  { 411, 12, 23, 14, 1, -23 },
  { 446, 12, 23, 14, 1, -23 },
  { 481, 13, 23, 14, 1, -23 },
  { 519, 12, 23, 14, 1, -23 },
  { 554, 12, 23, 14, 1, -23 },
  { 589, 12, 23, 14, 1, -23 },
  { 624, 12, 23, 14, 1, -23 },
  { 659, 12, 23, 14, 1, -23 },
  { 694, 4, 18, 8, 2, -18 },
  { 703, 5, 22, 8, 1, -18 },
  { 717, 13, 15, 14, 1, -19 },
  { 742, 13, 9, 14, 1, -16 },
  { 757, 13, 15, 14, 1, -19 },
  { 782, 11, 23, 11, 0, -23 },
  { 814, 20, 26, 22, 1, -23 },
  { 879, 16, 23, 16, 0, -23 },
  { 925, 13, 23, 16, 2, -23 },
  { 963, 13, 23, 15, 1, -23 },
  { 1001, 14, 23, 17, 2, -23 },
  { 1042, 10, 23, 14, 2, -23 },
  { 1071, 10, 23, 13, 2, -23 },
  { 1100, 14, 23, 18, 2, -23 },
  { 1141, 14, 23, 18, 2, -23 },
  { 1182, 8, 23, 10, 1, -23 },
  { 1205, 8, 30, 8, -2, -23 },
  { 1235, 14, 23, 16, 2, -23 },
  { 1276, 10, 23, 13, 2, -23 },
  { 1305, 20, 23, 24, 2, -23 },
  { 1363, 15, 23, 19, 2, -23 },
  { 1407, 16, 23, 18, 1, -23 },
  { 1453, 12, 23, 15, 2, -23 },
  { 1488, 16, 28, 18, 1, -23 },
  { 1544, 14, 23, 16, 2, -23 },
  { 1585, 11, 23, 13, 1, -23 },
  { 1617, 13, 23, 13, 0, -23 },
  { 1655, 14, 23, 18, 2, -23 },
  { 1696, 15, 23, 15, 0, -23 },
  { 1740, 24, 23, 24, 0, -23 },
  { 1809, 14, 23, 14, 0, -23 },
  { 1850, 14, 23, 14, 0, -23 },
  { 1891, 11, 23, 13, 1, -23 },
  { 1923, 7, 28, 10, 2, -23 },
  { 1948, 12, 23, 13, 0, -23 },
  { 1983, 7, 28, 10, 1, -23 },
  { 2008, 14, 13, 16, 1, -23 },
  { 2031, 13, 2, 13, 0, 3 },
  { 2035, 7, 6, 9, 1, -25 },
  { 2041, 11, 18, 14, 1, -18 },
  { 2066, 12, 24, 16, 2, -24 },
  { 2102, 10, 18, 12, 1, -18 },
  { 2125, 13, 24, 16, 1, -24 },
  { 2164, 12, 18, 14, 1, -18 },
  { 2191, 10, 24, 9, 0, -24 },
  { 2221, 13, 26, 16, 1, -18 },
  { 2264, 12, 24, 15, 2, -24 },
  { 2300, 4, 24, 7, 2, -24 },
  { 2312, 7, 32, 7, -1, -24 },
  { 2340, 13, 24, 14, 2, -24 },
  { 2379, 3, 24, 7, 2, -24 },
  { 2388, 19, 18, 23, 2, -18 },
  { 2431, 12, 18, 15, 2, -18 },
  { 2458, 13, 18, 15, 1, -18 },
  { 2488, 12, 26, 16, 2, -18 },
  { 2527, 13, 26, 16, 1, -18 },
  { 2570, 8, 18, 11, 2, -18 },
  { 2588, 10, 18, 12, 1, -18 },
  { 2611, 9, 21, 10, 0, -21 },
  { 2635, 12, 17, 15, 2, -17 },
  { 2661, 13, 17, 13, 0, -17 },
  { 2689, 21, 17, 21, 0, -17 },
  { 2734, 13, 17, 13, 0, -17 },
  { 2762, 13, 25, 13, 0, -17 },
  { 2803, 9, 17, 11, 1, -17 },
  { 2823, 9, 28, 11, 1, -23 },
  { 2855, 3, 31, 14, 5, -24 },
  { 2867, 10, 28, 11, 1, -23 },
  { 2902, 13, 5, 14, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold32pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD32PT7B_H_
