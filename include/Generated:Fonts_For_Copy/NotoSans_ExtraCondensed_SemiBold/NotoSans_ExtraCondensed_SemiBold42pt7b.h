#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD42PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x78, 0x00, 0x00, 0x39, 0xFF, 0xFF, 0x7D, 0xE0,
  0xF8, 0xFF, 0xE3, 0xEF, 0x8F, 0xBE, 0x3E, 0xF8, 0x79, 0xE1, 0xE7, 0x87,
  0x9E, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x80, 0x03, 0xC7, 0x00, 0x70,
  0xE0, 0x0E, 0x1C, 0x01, 0xC7, 0x80, 0x38, 0xF0, 0x0F, 0x1E, 0x01, 0xE3,
  0xC0, 0x3C, 0x70, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF0, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x00, 0x78, 0xE0, 0x0E, 0x1C,
  0x01, 0xC3, 0x83, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x3C, 0x78,
  0x07, 0x8E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x8F, 0x00, 0x71, 0xE0,
  0x0E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xE0, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x1F, 0x01, 0xFF, 0xC7, 0xFF, 0xDF, 0xFF, 0x7E, 0xDE, 0xF9,
  0x85, 0xE3, 0x03, 0xC6, 0x07, 0x8C, 0x0F, 0x98, 0x1F, 0xB0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1B, 0xE0,
  0x33, 0xC0, 0x67, 0x80, 0xCF, 0x81, 0x9F, 0xC3, 0x7F, 0xFF, 0xF7, 0xFF,
  0xCF, 0xFF, 0x03, 0xF8, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x1F, 0x80, 0x3C, 0x03, 0xFC, 0x07, 0x80, 0x3F, 0xC0, 0x78, 0x07, 0x9E,
  0x07, 0x00, 0x79, 0xE0, 0xF0, 0x07, 0x0E, 0x0F, 0x00, 0x70, 0xE0, 0xE0,
  0x0F, 0x0F, 0x1E, 0x00, 0xF0, 0xF1, 0xE0, 0x0F, 0x0F, 0x1C, 0x00, 0xF0,
  0xF3, 0xC0, 0x07, 0x0E, 0x38, 0x00, 0x70, 0xE7, 0x8F, 0x87, 0x9E, 0x79,
  0xFC, 0x79, 0xE7, 0x3F, 0xE3, 0xFC, 0xF3, 0xCE, 0x3F, 0xCF, 0x38, 0xF1,
  0xF8, 0xE7, 0x8F, 0x00, 0x1E, 0x78, 0xF0, 0x01, 0xC7, 0x8F, 0x00, 0x3C,
  0x78, 0xF0, 0x03, 0xC7, 0x8F, 0x00, 0x38, 0x78, 0xF0, 0x07, 0x87, 0x8F,
  0x00, 0x78, 0x78, 0xF0, 0x07, 0x03, 0x8F, 0x00, 0xF0, 0x3C, 0xE0, 0x0E,
  0x03, 0xFE, 0x01, 0xE0, 0x1F, 0xC0, 0x1E, 0x00, 0xFC, 0x07, 0xF0, 0x00,
  0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xE3, 0xC0, 0x1F, 0x1F,
  0x00, 0xF8, 0xF8, 0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x00, 0xF3, 0xE0, 0x07,
  0xDF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xFC, 0x3E, 0x3F, 0xF1, 0xF3, 0xEF, 0x8F, 0x9F, 0x3E, 0x7D, 0xF0,
  0xFF, 0xCF, 0x87, 0xFE, 0x7C, 0x1F, 0xE3, 0xE0, 0x7F, 0x1F, 0x03, 0xF0,
  0xFC, 0x1F, 0x83, 0xE1, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF,
  0x9F, 0x07, 0xF0, 0xFC, 0xFF, 0xFF, 0xFF, 0xBD, 0xEF, 0x7B, 0xDE, 0x03,
  0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x1F, 0x07,
  0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x0F,
  0x03, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1E,
  0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8,
  0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x07, 0xC1,
  0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x00, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x63, 0xC6, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF,
  0xFF, 0x3F, 0xF8, 0x07, 0xE0, 0x0F, 0xF0, 0x1E, 0xF8, 0x3E, 0x7C, 0x3C,
  0x7C, 0x1C, 0x38, 0x04, 0x20, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x3E, 0x7C, 0xF9, 0xE3, 0xCF, 0x9F, 0x3C, 0x78, 0xE3, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x39, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF,
  0xE3, 0xFF, 0xC7, 0xC7, 0xCF, 0x0F, 0xBE, 0x0F, 0x7C, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1E, 0x78, 0x7C, 0xF8, 0xF9, 0xFF, 0xE1, 0xFF, 0xC1,
  0xFF, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x3F, 0x07, 0xF0, 0xFF, 0x1F, 0xF3,
  0xFF, 0x7F, 0xFF, 0xDF, 0x79, 0xF3, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0xFF, 0xFE, 0x78, 0x3E, 0x30,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xF0, 0x7F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x30, 0x3E, 0x20,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x7C, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x3F, 0xE0, 0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0x78, 0x07, 0xBC, 0x03, 0x9E, 0x03, 0xCF,
  0x01, 0xC7, 0x81, 0xE3, 0xC0, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x78,
  0x3C, 0x3C, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF,
  0xE7, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x38, 0xFE, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x7D, 0x81, 0xFB, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x80,
  0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x79, 0xF8, 0x7B, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0xFE, 0x3F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xF8, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x7C, 0x1F,
  0x7C, 0x1F, 0x7C, 0x1F, 0x3E, 0x3F, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC,
  0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x87, 0xFF, 0xC7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C,
  0x1F, 0x3E, 0x0F, 0x0F, 0x8F, 0x87, 0xEF, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0,
  0x1F, 0xC0, 0x3F, 0xF0, 0x3F, 0xFC, 0x1F, 0x3F, 0x1F, 0x0F, 0xCF, 0x83,
  0xEF, 0x80, 0xF7, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0x3E,
  0x0F, 0x9F, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0x80, 0x07, 0xF0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0x7C, 0x1F, 0x7C, 0x3F, 0x7F, 0xFF, 0x3F, 0xEF, 0x3F, 0xEF, 0x0F, 0xDF,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x79, 0xFF,
  0xFF, 0x7D, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE7,
  0xFF, 0xFD, 0xF7, 0x80, 0x3C, 0x7D, 0xFB, 0xF3, 0xE7, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF9, 0xF3, 0xE7, 0xCF,
  0x3E, 0x7C, 0xF1, 0xE3, 0xCF, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03,
  0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x80, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0xE0, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFF,
  0x00, 0xFE, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xE1,
  0xFF, 0xCF, 0xFF, 0x9F, 0xFE, 0x70, 0xFD, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E,
  0x01, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0x80, 0x3C, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x01, 0xF8, 0x0F, 0x80, 0xF0, 0x03, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x00,
  0x3C, 0x78, 0x00, 0x1E, 0x78, 0x3F, 0xC7, 0xBC, 0x3F, 0xE3, 0xDC, 0x3F,
  0xF1, 0xFE, 0x1E, 0x38, 0x7F, 0x1E, 0x1C, 0x3F, 0x8F, 0x1E, 0x1F, 0xC7,
  0x0F, 0x0F, 0xC3, 0x87, 0x87, 0xE1, 0xC3, 0xC3, 0xF0, 0xE1, 0xE1, 0xF8,
  0x70, 0xF0, 0xFC, 0x38, 0x78, 0x7F, 0x1E, 0x3C, 0x7F, 0x8F, 0x3E, 0x3B,
  0xC3, 0xFB, 0xFD, 0xE1, 0xFD, 0xFC, 0x70, 0x7C, 0x7C, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x03,
  0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0xFB, 0xC0, 0x07, 0xDF, 0x00, 0x3E,
  0xF8, 0x01, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0,
  0x3C, 0x3E, 0x01, 0xE0, 0xF0, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xF8, 0x0F, 0x87,
  0xC0, 0x7C, 0x7E, 0x03, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03,
  0xEF, 0xC0, 0x1F, 0xFC, 0x00, 0x7C, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF,
  0x9F, 0xFF, 0xCF, 0x87, 0xF7, 0xC1, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8,
  0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x07, 0xCF, 0xFF, 0xE7, 0xFF, 0xC3,
  0xFF, 0xE1, 0xFF, 0xF8, 0xF8, 0xFE, 0x7C, 0x1F, 0xBE, 0x07, 0xDF, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C,
  0x1F, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0x87, 0xFF, 0x00, 0x03, 0xFE,
  0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xE3, 0xF8, 0x71, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0xC1, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0,
  0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF8,
  0xFF, 0x3E, 0x0F, 0xCF, 0x81, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03,
  0xEF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8,
  0x0F, 0xBE, 0x03, 0xEF, 0x81, 0xFB, 0xE0, 0x7C, 0xF8, 0x3F, 0x3E, 0x3F,
  0x8F, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE,
  0xFF, 0xF7, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7F, 0xFB, 0xFF, 0xDF,
  0xFE, 0xFF, 0xF7, 0xFF, 0xBE, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00,
  0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xF8, 0x1C,
  0x7E, 0x00, 0x9F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xF0, 0x1F, 0x3E, 0x03, 0xE7,
  0xE0, 0x7C, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x00,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3, 0xEF, 0xFB, 0xFE, 0xFF,
  0x3F, 0x86, 0x00, 0xF8, 0x0F, 0xFE, 0x03, 0xEF, 0x81, 0xF3, 0xE0, 0xFC,
  0xF8, 0x3E, 0x3E, 0x1F, 0x8F, 0x87, 0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E,
  0x7C, 0x0F, 0xBF, 0x03, 0xEF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0x7C, 0x0F, 0x9F, 0x83, 0xE3, 0xE0,
  0xF8, 0xF8, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E,
  0x0F, 0xCF, 0x81, 0xF3, 0xE0, 0x7E, 0xF8, 0x0F, 0xBE, 0x03, 0xF0, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xDE,
  0x01, 0xFF, 0xF7, 0x80, 0x7F, 0xFD, 0xE0, 0x3D, 0xFF, 0x7C, 0x0F, 0x7F,
  0xCF, 0x03, 0xDF, 0xFB, 0xC1, 0xE7, 0xFE, 0xF0, 0x79, 0xFF, 0xBE, 0x1E,
  0x7F, 0xE7, 0x87, 0x9F, 0xF9, 0xE3, 0xC7, 0xFE, 0x78, 0xF1, 0xFF, 0x8F,
  0x3C, 0x7F, 0xE3, 0xDE, 0x1F, 0xF8, 0xF7, 0x87, 0xFE, 0x3D, 0xE1, 0xFF,
  0x87, 0xF8, 0x7F, 0xE1, 0xFC, 0x1F, 0xF8, 0x7F, 0x07, 0xFE, 0x1F, 0xC1,
  0xFF, 0x83, 0xF0, 0x7F, 0xE0, 0xF8, 0x1F, 0xF8, 0x3E, 0x07, 0xFE, 0x0F,
  0x81, 0xF0, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xF7, 0x81,
  0xFF, 0x7C, 0x1F, 0xF3, 0xC1, 0xFF, 0x3E, 0x1F, 0xF3, 0xE1, 0xFF, 0x9F,
  0x1F, 0xF9, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF9, 0xFF, 0x87, 0x9F, 0xF8,
  0x7D, 0xFF, 0x87, 0xDF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF,
  0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F,
  0xF8, 0x07, 0xFF, 0x80, 0x3F, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0,
  0x3E, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x1F,
  0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x3E, 0x07, 0xE3, 0xF0, 0xFC, 0x1F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0xC0, 0xFF, 0xF0,
  0xFF, 0xFC, 0xFF, 0xFC, 0xF8, 0xFE, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7E,
  0xF8, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0x7E, 0x7C,
  0x03, 0xE7, 0xC0, 0x3E, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x3E, 0x07, 0xE3, 0xF0,
  0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F,
  0xFF, 0x8F, 0x9F, 0xE7, 0xC1, 0xF3, 0xE0, 0xFD, 0xF0, 0x3E, 0xF8, 0x1F,
  0x7C, 0x0F, 0xBE, 0x0F, 0xDF, 0x07, 0xCF, 0x83, 0xE7, 0xC3, 0xF3, 0xFF,
  0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3E, 0x7C, 0x1F, 0x1F, 0x0F,
  0x8F, 0x87, 0xC7, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x3E, 0x7C, 0x1F,
  0x3E, 0x07, 0xDF, 0x03, 0xEF, 0x81, 0xFF, 0xC0, 0x7C, 0x07, 0xF8, 0x3F,
  0xFC, 0xFF, 0xF9, 0xFF, 0xE7, 0xE1, 0xCF, 0x80, 0x9F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x07,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0xFB, 0xFF, 0xF7,
  0xFF, 0xCF, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xBE,
  0x0F, 0xDF, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xC0, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0x80, 0x1E, 0x7C, 0x03, 0xE7, 0xC0,
  0x3E, 0x3C, 0x03, 0xE3, 0xC0, 0x3C, 0x3E, 0x03, 0xC3, 0xE0, 0x7C, 0x1E,
  0x07, 0xC1, 0xE0, 0x78, 0x1F, 0x07, 0x81, 0xF0, 0xF8, 0x0F, 0x0F, 0x80,
  0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF9, 0xF0, 0x07, 0x9F, 0x00, 0x79, 0xE0,
  0x07, 0x9E, 0x00, 0x79, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0x80, 0x7F, 0xE0, 0x1F, 0x00,
  0xFF, 0xC0, 0x3E, 0x01, 0xE7, 0x80, 0xFC, 0x07, 0xCF, 0x81, 0xFC, 0x0F,
  0x9F, 0x03, 0xF8, 0x1F, 0x3E, 0x07, 0x70, 0x3E, 0x7C, 0x0E, 0xE0, 0x78,
  0x78, 0x3D, 0xC1, 0xF0, 0xF8, 0x7B, 0xC3, 0xE1, 0xF0, 0xF7, 0x87, 0xC3,
  0xE1, 0xEF, 0x0F, 0x87, 0xC3, 0xDE, 0x1E, 0x07, 0x8F, 0x1C, 0x3C, 0x0F,
  0x1E, 0x3C, 0xF8, 0x1F, 0x3C, 0x79, 0xF0, 0x3E, 0x78, 0xF3, 0xE0, 0x7C,
  0xF1, 0xE7, 0xC0, 0x7B, 0xC1, 0xCF, 0x00, 0xF7, 0x83, 0xFE, 0x01, 0xEF,
  0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xF0,
  0x3F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x7C, 0x07,
  0xCF, 0x81, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xE1, 0xF0, 0x3E, 0x3E,
  0x07, 0xC7, 0x80, 0x79, 0xF0, 0x0F, 0xBE, 0x00, 0xF7, 0x80, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xDE, 0x00, 0xFB, 0xE0,
  0x1F, 0x7C, 0x07, 0xC7, 0x80, 0xF8, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xF0,
  0xF8, 0x3E, 0x3E, 0x07, 0xE7, 0xC0, 0x7D, 0xF8, 0x0F, 0xC0, 0xF8, 0x07,
  0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F,
  0x0F, 0x87, 0xC0, 0xF8, 0xF8, 0x1F, 0x1E, 0x01, 0xE7, 0xC0, 0x3E, 0xF8,
  0x07, 0xDE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00,
  0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xEF, 0x00,
  0x3D, 0xE0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x78, 0x7C, 0x0F, 0x07, 0x83,
  0xE0, 0xF8, 0x78, 0x0F, 0x1F, 0x01, 0xF3, 0xC0, 0x1E, 0xF8, 0x03, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0x78,
  0x1E, 0x0F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF, 0xF1, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x0F, 0xFC, 0x7F, 0xF9, 0xFF, 0xF7,
  0xE1, 0xEF, 0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFB, 0xF7, 0xF7, 0xFF, 0xE7, 0xFB, 0xC7, 0xE3, 0x80, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x7C, 0x3E, 0xFF, 0x1F, 0x7F, 0xCF, 0xFF,
  0xE7, 0xF1, 0xFB, 0xF0, 0x7D, 0xF8, 0x3E, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFE, 0x07, 0xBF, 0x07, 0xDF, 0xC3, 0xEF, 0xFF, 0xE7, 0xFF,
  0xF3, 0xEF, 0xF1, 0xE3, 0xF0, 0x0F, 0xF0, 0xFF, 0xCF, 0xFE, 0xFF, 0xE7,
  0xC1, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x02,
  0xFF, 0xF3, 0xFF, 0x9F, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x1F, 0x9F, 0x3F, 0xDF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7C, 0x3F, 0xF8,
  0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xFC, 0x3F, 0x7F, 0xFF, 0x7F, 0xEF, 0x3F, 0xCF, 0x1F, 0x8F, 0x0F,
  0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xDF, 0x07, 0xBE, 0x0F,
  0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x13, 0xFF,
  0xE3, 0xFF, 0xC3, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC3, 0xFE,
  0x3F, 0xE1, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xFF, 0x1F,
  0xF9, 0xFF, 0xCF, 0xFE, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F,
  0x8F, 0x3F, 0xCF, 0x3F, 0xEF, 0x7F, 0xFF, 0x7C, 0x7F, 0xF8, 0x3F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC,
  0x3F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xDF, 0x1F, 0x9F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x80, 0x3E, 0x60, 0x7E, 0x7F, 0xFC, 0x7F,
  0xFC, 0x7F, 0xF0, 0x1F, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF9,
  0xF8, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x3F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x33, 0xFF, 0xFF,
  0xBC, 0x00, 0x03, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF,
  0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x06, 0x0F, 0x1F, 0x1F, 0x1F, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFE, 0xFE, 0xF8, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x1F, 0xF0, 0x3E, 0xF0, 0x7C, 0xF0,
  0x7C, 0xF0, 0xF8, 0xF1, 0xF0, 0xF1, 0xF0, 0xF3, 0xE0, 0xF7, 0xC0, 0xF7,
  0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFD, 0xF0, 0xF9, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0x3E, 0xF0,
  0x3E, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xF8, 0x7E, 0x3C, 0xFF, 0x3F, 0xCF, 0xFF, 0xEF, 0xFB, 0xFF, 0xFF, 0xFE,
  0xFE, 0x3F, 0x8F, 0xFF, 0x0F, 0xC1, 0xFF, 0xC1, 0xF0, 0x7F, 0xE0, 0x7C,
  0x1F, 0xF8, 0x1F, 0x07, 0xFE, 0x07, 0xC1, 0xFF, 0x81, 0xF0, 0x7F, 0xE0,
  0x7C, 0x1F, 0xF8, 0x1F, 0x07, 0xFE, 0x07, 0xC1, 0xFF, 0x81, 0xF0, 0x7F,
  0xE0, 0x7C, 0x1F, 0xF8, 0x1F, 0x07, 0xFE, 0x07, 0xC1, 0xFF, 0x81, 0xF0,
  0x7F, 0xE0, 0x7C, 0x1F, 0xF8, 0x1F, 0x07, 0xFE, 0x07, 0xC1, 0xFF, 0x81,
  0xF0, 0x7C, 0xF1, 0xF8, 0xF3, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x3F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0x0F, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7C, 0x3E, 0xF8, 0x1E,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E,
  0x7C, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xF1, 0xF8,
  0x7D, 0xFE, 0x3E, 0xFF, 0x9F, 0xFF, 0xCF, 0xE3, 0xF7, 0xE0, 0xFB, 0xF0,
  0x7D, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0x7E, 0x0F,
  0xBF, 0x87, 0xDF, 0xFF, 0xCF, 0xFF, 0xE7, 0xDF, 0xE3, 0xE7, 0xE1, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x8F, 0x3F,
  0xCF, 0x3F, 0xEF, 0x7F, 0xFF, 0x7C, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0x7F,
  0xFF, 0x7F, 0xFF, 0x3F, 0xDF, 0x1F, 0x9F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0xE3, 0xFC, 0xFB, 0xDF, 0x7F, 0xEF, 0xFD, 0xF8, 0x3E,
  0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x0F,
  0xE1, 0xFF, 0xDF, 0xFC, 0xFF, 0xEF, 0x83, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0x7E, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xFF, 0xEF, 0xFF, 0x7F, 0xF1, 0xFF,
  0x00, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE7, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x3F, 0xE7,
  0xFC, 0x7F, 0x87, 0xF0, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7F, 0xFF, 0x7F, 0xEF, 0x3F, 0xCF,
  0x1F, 0x8F, 0xF8, 0x0F, 0xFC, 0x07, 0xDF, 0x03, 0xEF, 0x81, 0xE7, 0xC1,
  0xF1, 0xE0, 0xF8, 0xF0, 0x7C, 0x7C, 0x3C, 0x3E, 0x1E, 0x0F, 0x1F, 0x07,
  0x8F, 0x83, 0xC7, 0x81, 0xF3, 0xC0, 0x7B, 0xE0, 0x3D, 0xF0, 0x1E, 0xF0,
  0x0F, 0x78, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xEF, 0x03, 0xF0, 0x7D, 0xE0, 0x7E,
  0x0F, 0xBE, 0x1F, 0xC1, 0xE7, 0xC3, 0xF8, 0x3C, 0xF8, 0x77, 0x0F, 0x8F,
  0x0E, 0xF1, 0xF1, 0xE1, 0xDE, 0x3C, 0x3E, 0x7B, 0xC7, 0x87, 0xCF, 0x38,
  0xF0, 0x79, 0xE7, 0x3E, 0x0F, 0x38, 0xE7, 0xC1, 0xE7, 0x1E, 0xF0, 0x3E,
  0xE3, 0xDE, 0x07, 0xFC, 0x7B, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFE,
  0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7E,
  0x0F, 0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x3E,
  0x0F, 0x8F, 0x87, 0x87, 0xC7, 0xC1, 0xE3, 0xE0, 0xFB, 0xE0, 0x7D, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x1E, 0xF0, 0x1F, 0x7C, 0x0F, 0x3E, 0x0F,
  0x8F, 0x87, 0xC7, 0xC7, 0xC1, 0xF3, 0xE0, 0xFB, 0xE0, 0x7E, 0xF8, 0x0F,
  0xBC, 0x07, 0xDF, 0x03, 0xEF, 0x81, 0xE7, 0xC1, 0xF1, 0xE0, 0xF8, 0xF8,
  0x7C, 0x7C, 0x3C, 0x3E, 0x1E, 0x0F, 0x1F, 0x07, 0xCF, 0x83, 0xE7, 0x80,
  0xF3, 0xC0, 0x7B, 0xE0, 0x3D, 0xF0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x78,
  0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x3F, 0x07,
  0xF0, 0x7F, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0xFF, 0x0F, 0xE0, 0xF8,
  0x0F, 0xE0, 0x3F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7F, 0x07,
  0xF0, 0x3F, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x0F, 0xF0, 0x7F, 0x01, 0xF0, 0xFF, 0x0F, 0xC1, 0xF0, 0x1F, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x3E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xC0, 0x00, 0x3E, 0x00, 0xBF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x03, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 30, 10, 2, -30 },
  { 24, 14, 11, 18, 2, -30 },
  { 44, 19, 30, 20, 1, -30 },
  { 116, 15, 34, 19, 2, -32 },
  { 180, 28, 30, 31, 1, -30 },
  { 285, 21, 30, 22, 1, -30 },
  { 364, 5, 11, 9, 2, -30 },
  { 371, 10, 37, 13, 2, -30 },
  { 418, 10, 37, 13, 1, -30 },
  { 465, 16, 16, 18, 1, -32 },
  { 497, 17, 20, 19, 1, -25 },
  { 540, 7, 11, 10, 1, -5 },
  { 550, 10, 5, 12, 1, -14 },
  { 557, 6, 6, 10, 2, -6 },
  { 562, 15, 30, 16, 1, -30 },
  { 619, 15, 30, 19, 2, -30 },
  { 676, 12, 30, 19, 2, -30 },
  { 721, 16, 30, 19, 1, -30 },
  { 781, 16, 30, 19, 1, -30 },
  { 841, 17, 30, 19, 1, -30 },
  { 905, 15, 30, 19, 2, -30 },
  { 962, 16, 30, 19, 1, -30 },
  { 1022, 17, 30, 19, 1, -30 },
  { 1086, 17, 30, 19, 1, -30 },
  { 1150, 16, 30, 19, 1, -30 },
  { 1210, 6, 23, 10, 2, -23 },
  { 1228, 7, 29, 10, 1, -23 },
  { 1254, 17, 20, 19, 1, -25 },
  { 1297, 17, 12, 19, 1, -21 },
  { 1323, 17, 20, 19, 1, -25 },
  { 1366, 14, 30, 15, 0, -30 },
  { 1419, 25, 33, 29, 2, -30 },
  { 1523, 21, 30, 21, 0, -30 },
  { 1602, 17, 30, 21, 3, -30 },
  { 1666, 17, 30, 20, 2, -30 },
  { 1730, 18, 30, 23, 3, -30 },
  { 1798, 13, 30, 18, 3, -30 },
  { 1847, 13, 30, 17, 3, -30 },
  { 1896, 19, 30, 23, 2, -30 },
  { 1968, 18, 30, 24, 3, -30 },
  { 2036, 11, 30, 13, 1, -30 },
  { 2078, 10, 39, 11, -2, -30 },
  { 2127, 18, 30, 21, 3, -30 },
  { 2195, 13, 30, 17, 3, -30 },
  { 2244, 26, 30, 32, 3, -30 },
  { 2342, 20, 30, 26, 3, -30 },
  { 2417, 20, 30, 24, 2, -30 },
  { 2492, 16, 30, 20, 3, -30 },
  { 2552, 20, 37, 24, 2, -30 },
  { 2645, 17, 30, 21, 3, -30 },
  { 2709, 15, 30, 18, 1, -30 },
  { 2766, 16, 30, 17, 1, -30 },
  { 2826, 17, 30, 23, 3, -30 },
  { 2890, 20, 30, 20, 0, -30 },
  { 2965, 31, 30, 31, 0, -30 },
  { 3082, 19, 30, 19, 0, -30 },
  { 3154, 19, 30, 19, 0, -30 },
  { 3226, 15, 30, 16, 1, -30 },
  { 3283, 9, 37, 13, 3, -30 },
  { 3325, 16, 30, 16, 0, -30 },
  { 3385, 9, 37, 13, 1, -30 },
  { 3427, 19, 17, 21, 1, -30 },
  { 3468, 18, 2, 18, 0, 4 },
  { 3473, 9, 7, 12, 2, -32 },
  { 3481, 15, 23, 19, 1, -23 },
  { 3525, 17, 32, 20, 2, -32 },
  { 3593, 13, 23, 16, 2, -23 },
  { 3631, 16, 32, 20, 2, -32 },
  { 3695, 15, 23, 19, 2, -23 },
  { 3739, 13, 32, 12, 0, -32 },
  { 3791, 16, 33, 20, 2, -23 },
  { 3857, 16, 32, 20, 2, -32 },
  { 3921, 5, 32, 10, 2, -32 },
  { 3941, 8, 42, 10, -1, -32 },
  { 3983, 16, 32, 19, 3, -32 },
  { 4047, 5, 32, 10, 2, -32 },
  { 4067, 26, 23, 30, 2, -23 },
  { 4142, 16, 23, 20, 2, -23 },
  { 4188, 16, 23, 20, 2, -23 },
  { 4234, 17, 33, 20, 2, -23 },
  { 4305, 16, 33, 20, 2, -23 },
  { 4371, 11, 23, 14, 3, -23 },
  { 4403, 13, 23, 15, 1, -23 },
  { 4441, 11, 28, 13, 1, -28 },
  { 4480, 16, 23, 20, 2, -23 },
  { 4526, 17, 23, 17, 0, -23 },
  { 4575, 27, 23, 27, 0, -23 },
  { 4653, 17, 23, 17, 0, -23 },
  { 4702, 17, 33, 17, 0, -23 },
  { 4773, 12, 23, 14, 1, -23 },
  { 4808, 12, 37, 15, 1, -30 },
  { 4864, 4, 42, 18, 7, -32 },
  { 4885, 12, 37, 15, 2, -30 },
  { 4941, 17, 6, 19, 1, -18 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold42pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD42PT7B_H_
