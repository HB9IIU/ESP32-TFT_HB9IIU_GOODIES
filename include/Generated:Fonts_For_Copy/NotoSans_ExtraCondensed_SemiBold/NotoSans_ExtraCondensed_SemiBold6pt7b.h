#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD6PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x5F, 0xE0, 0x7D, 0xC0, 0xEF, 0x77, 0xCB, 0xF0, 0x80,
  0xEA, 0x40, 0x95, 0x80, 0x7C, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x5A, 0xFF,
  0xD5, 0xD7, 0xD7, 0x5B, 0xA0, 0xF7, 0xFF, 0xE9, 0x20, 0xEA, 0xE0, 0xF7,
  0xA0, 0xB0, 0x39, 0x80, 0xFC, 0x8F, 0x00, 0xDA, 0xFF, 0xFE, 0x57, 0xD0,
  0xFE, 0xF0, 0xF2, 0x30, 0xF6, 0xF0, 0xFB, 0xFA, 0xF2, 0xB0, 0xBE, 0xD0,
  0xEB, 0xF8, 0xBB, 0x50, 0xAB, 0xDD, 0xBB, 0xFE, 0xD0, 0xF6, 0xB0, 0xF7,
  0x40, 0xF6, 0xB2, 0xF7, 0x50, 0xE7, 0xD5, 0xB6, 0xB0, 0xB7, 0x20, 0xBB,
  0x55, 0xE9, 0x50, 0xA9, 0x20, 0xDB, 0xEA, 0xC0, 0x95, 0xD5, 0xC0, 0x54,
  0xE0, 0xC0, 0xFC, 0x93, 0xDC, 0xEC, 0x27, 0xDE, 0xFC, 0x6E, 0x80, 0xF7,
  0xF0, 0x93, 0xDA, 0xB8, 0xBC, 0x97, 0x6A, 0xF8, 0xFB, 0xB0, 0xF6, 0x80,
  0xF7, 0x00, 0xF7, 0x40, 0xF7, 0x90, 0xE8, 0xDC, 0xBB, 0xB7, 0x80, 0xF4,
  0xDE, 0x60, 0xDC, 0xD7, 0xEC, 0x59, 0x40, 0xFC, 0xD5, 0x80, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 2, 0, -4 },
  { 2, 2, 1, 3, 0, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 2, 5, 3, 0, -5 },
  { 7, 4, 4, 4, 0, -4 },
  { 9, 3, 4, 3, 0, -4 },
  { 11, 1, 1, 1, 0, -4 },
  { 12, 2, 5, 2, 0, -4 },
  { 14, 2, 5, 2, 0, -4 },
  { 16, 2, 3, 3, 0, -5 },
  { 17, 3, 3, 3, 0, -4 },
  { 19, 1, 2, 1, 0, -1 },
  { 20, 2, 1, 2, 0, -2 },
  { 21, 1, 1, 1, 0, -1 },
  { 22, 2, 4, 2, 0, -4 },
  { 23, 2, 4, 3, 0, -4 },
  { 24, 2, 4, 3, 0, -4 },
  { 25, 2, 4, 3, 0, -4 },
  { 26, 2, 4, 3, 0, -4 },
  { 27, 3, 4, 3, 0, -4 },
  { 29, 2, 4, 3, 0, -4 },
  { 30, 2, 4, 3, 0, -4 },
  { 31, 3, 4, 3, 0, -4 },
  { 33, 3, 4, 3, 0, -4 },
  { 35, 2, 4, 3, 0, -4 },
  { 36, 1, 3, 1, 0, -3 },
  { 37, 1, 4, 1, 0, -3 },
  { 38, 3, 3, 3, 0, -4 },
  { 40, 3, 2, 3, 0, -3 },
  { 41, 3, 3, 3, 0, -4 },
  { 43, 2, 4, 2, 0, -4 },
  { 44, 4, 4, 4, 0, -4 },
  { 46, 3, 4, 3, 0, -4 },
  { 48, 3, 4, 3, 0, -4 },
  { 50, 3, 4, 3, 0, -4 },
  { 52, 3, 4, 3, 0, -4 },
  { 54, 2, 4, 3, 0, -4 },
  { 55, 2, 4, 2, 0, -4 },
  { 56, 3, 4, 3, 0, -4 },
  { 58, 3, 4, 3, 0, -4 },
  { 60, 2, 4, 2, 0, -4 },
  { 61, 1, 5, 2, 0, -4 },
  { 62, 3, 4, 3, 0, -4 },
  { 64, 2, 4, 2, 0, -4 },
  { 65, 4, 4, 5, 0, -4 },
  { 67, 3, 4, 4, 0, -4 },
  { 69, 3, 4, 3, 0, -4 },
  { 71, 3, 4, 3, 0, -4 },
  { 73, 3, 5, 3, 0, -4 },
  { 75, 3, 4, 3, 0, -4 },
  { 77, 2, 4, 3, 0, -4 },
  { 78, 2, 4, 2, 0, -4 },
  { 79, 3, 4, 3, 0, -4 },
  { 81, 3, 4, 3, 0, -4 },
  { 83, 4, 4, 4, 0, -4 },
  { 85, 3, 4, 3, 0, -4 },
  { 87, 3, 4, 3, 0, -4 },
  { 89, 2, 4, 2, 0, -4 },
  { 90, 2, 5, 2, 0, -4 },
  { 92, 2, 4, 2, 0, -4 },
  { 93, 2, 5, 2, 0, -4 },
  { 95, 3, 2, 3, 0, -4 },
  { 96, 3, 1, 3, 0, 0 },
  { 97, 2, 1, 2, 0, -5 },
  { 98, 2, 3, 3, 0, -3 },
  { 99, 3, 5, 3, 0, -5 },
  { 101, 2, 3, 2, 0, -3 },
  { 102, 3, 5, 3, 0, -5 },
  { 104, 2, 3, 3, 0, -3 },
  { 105, 2, 5, 2, 0, -5 },
  { 107, 3, 4, 3, 0, -3 },
  { 109, 3, 5, 3, 0, -5 },
  { 111, 1, 5, 1, 0, -5 },
  { 112, 1, 6, 1, 0, -5 },
  { 113, 3, 5, 3, 0, -5 },
  { 115, 1, 5, 1, 0, -5 },
  { 116, 4, 3, 4, 0, -3 },
  { 118, 3, 3, 3, 0, -3 },
  { 120, 3, 3, 3, 0, -3 },
  { 122, 3, 4, 3, 0, -3 },
  { 124, 3, 4, 3, 0, -3 },
  { 126, 2, 3, 2, 0, -3 },
  { 127, 2, 3, 2, 0, -3 },
  { 128, 2, 4, 2, 0, -4 },
  { 129, 3, 3, 3, 0, -3 },
  { 131, 2, 3, 3, 0, -3 },
  { 132, 4, 3, 4, 0, -3 },
  { 134, 2, 3, 2, 0, -3 },
  { 135, 2, 4, 3, 0, -3 },
  { 136, 2, 3, 2, 0, -3 },
  { 137, 2, 5, 2, 0, -4 },
  { 139, 1, 6, 3, 1, -5 },
  { 140, 2, 5, 2, 0, -4 },
  { 142, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold6pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD6PT7B_H_
