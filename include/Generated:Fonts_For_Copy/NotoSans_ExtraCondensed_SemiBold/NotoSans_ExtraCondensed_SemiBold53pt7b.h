#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD53PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold53pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBE, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x84, 0x00,
  0xFC, 0x3F, 0xFE, 0x1F, 0xBF, 0x0F, 0xDF, 0x87, 0xEF, 0xC3, 0xF7, 0xE1,
  0xFB, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x1F, 0x7E, 0x0F, 0xBF, 0x07, 0xCF,
  0x83, 0xE7, 0x81, 0xF3, 0xC0, 0xF8, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF8,
  0x00, 0xF0, 0xF8, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF0,
  0x01, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE1, 0xF0, 0x01, 0xE1, 0xF0,
  0x01, 0xE1, 0xF0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x03, 0xC1, 0xE0, 0x03, 0xC3, 0xE0, 0x03, 0xC3, 0xE0,
  0x03, 0xC3, 0xE0, 0x07, 0xC3, 0xC0, 0x07, 0xC3, 0xC0, 0x07, 0xC3, 0xC0,
  0x07, 0x83, 0xC0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0x0F, 0x87, 0x80, 0x0F, 0x87, 0x80, 0x0F, 0x87, 0x80,
  0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x80,
  0x0F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x03, 0xFF,
  0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xE6,
  0x1C, 0x7C, 0x60, 0x4F, 0xC6, 0x00, 0xFC, 0x60, 0x0F, 0xC6, 0x00, 0xFC,
  0x60, 0x07, 0xE6, 0x00, 0x7F, 0x60, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x6F, 0xE0, 0x06, 0x7E, 0x00, 0x63, 0xF0, 0x06, 0x3F, 0x00, 0x63,
  0xF0, 0x06, 0x3F, 0x80, 0x63, 0xEF, 0x06, 0x7E, 0xFE, 0x7F, 0xEF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xFC, 0x00, 0x78, 0x00, 0xFF, 0xC0, 0x1F,
  0x00, 0x3F, 0xF8, 0x03, 0xC0, 0x07, 0xCF, 0x80, 0xF8, 0x01, 0xF1, 0xF0,
  0x1F, 0x00, 0x3E, 0x1E, 0x03, 0xC0, 0x07, 0xC3, 0xE0, 0xF8, 0x00, 0xF8,
  0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0x83, 0xC0, 0x03, 0xE1, 0xF0, 0xF8, 0x00,
  0x7C, 0x3E, 0x1E, 0x00, 0x0F, 0x87, 0xC7, 0xC0, 0x01, 0xF0, 0xF8, 0xF8,
  0x00, 0x3E, 0x1F, 0x1E, 0x00, 0x07, 0xC3, 0xE7, 0xC3, 0xF0, 0xF8, 0x78,
  0xF8, 0xFF, 0x0F, 0x1F, 0x1E, 0x3F, 0xF1, 0xF3, 0xE7, 0xCF, 0xFE, 0x3F,
  0xF8, 0xF1, 0xF3, 0xE3, 0xFF, 0x3E, 0x3C, 0x7C, 0x3F, 0xC7, 0xCF, 0x87,
  0x83, 0xF0, 0xF1, 0xF0, 0xF8, 0x00, 0x3E, 0x3E, 0x1F, 0x00, 0x07, 0xC7,
  0xC3, 0xE0, 0x00, 0xF0, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x0F, 0x80, 0x07,
  0x83, 0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x3E, 0x00, 0x3E, 0x0F, 0x87, 0xC0,
  0x07, 0x81, 0xF0, 0xF8, 0x01, 0xF0, 0x3E, 0x1F, 0x00, 0x3E, 0x03, 0xC3,
  0xC0, 0x07, 0x80, 0x7C, 0xF8, 0x01, 0xF0, 0x0F, 0xFF, 0x00, 0x3C, 0x00,
  0xFF, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x07, 0xE1, 0xFF, 0xE1, 0xFC, 0x7F, 0xFE,
  0x3F, 0x1F, 0xCF, 0xC7, 0xE3, 0xF1, 0xFC, 0xFC, 0x7E, 0x1F, 0x9F, 0x9F,
  0xC1, 0xFF, 0xE3, 0xF8, 0x3F, 0xFC, 0x7E, 0x03, 0xFF, 0x0F, 0xE0, 0x3F,
  0xE1, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0x7F,
  0x87, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xF1, 0xFC, 0x0F, 0xFC, 0x1F, 0xC0, 0x10, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x79, 0xE0, 0x01, 0xF0,
  0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03,
  0xE0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07,
  0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x80,
  0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01,
  0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0,
  0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0x0F,
  0x0E, 0x7E, 0xF3, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7D, 0xF0, 0x0F, 0x9F, 0x81,
  0xF8, 0xFC, 0x3F, 0x0F, 0xC0, 0xF0, 0x78, 0x06, 0x06, 0x00, 0x20, 0x40,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x3F, 0x3F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C,
  0xFC, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x08, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01,
  0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xF9, 0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0x7C,
  0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07,
  0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xEF,
  0xC0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xF0, 0xFC,
  0x3F, 0x1F, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0x3F, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF8,
  0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0x7F, 0x7F, 0xFC,
  0xFF, 0xF1, 0xFB, 0xC3, 0xF3, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x7F,
  0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xC1, 0xFC, 0x38, 0x0F, 0xC2,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0xF0, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0x81, 0xFC, 0x30, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE8, 0x00,
  0xFE, 0xE0, 0x1F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF,
  0xFE, 0x07, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xF7, 0xC0, 0x03, 0xDF, 0x00, 0x1E,
  0xFC, 0x00, 0x7B, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0x3F, 0x00, 0x7C, 0xFC,
  0x01, 0xE3, 0xF0, 0x0F, 0x8F, 0xC0, 0x3C, 0x3F, 0x01, 0xF0, 0xFC, 0x07,
  0x83, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8, 0x3F, 0x07, 0xC0, 0xFC, 0x1F, 0x03,
  0xF0, 0xF8, 0x0F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC3, 0xEF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE8, 0x00, 0xFE,
  0xF0, 0x3F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x03, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x07,
  0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC1, 0xFE, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x7E, 0x0F, 0xDF, 0xF8, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xF0, 0xFE, 0xFE, 0x07, 0xEF, 0xE0,
  0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x07, 0xE7,
  0xF0, 0x7E, 0x3F, 0x0F, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC7, 0xF0, 0xFE, 0x7E, 0x07, 0xE7, 0xC0, 0x7E, 0xFC, 0x03, 0xE7, 0xC0,
  0x7E, 0x7C, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE3, 0xF0, 0xFC, 0x3F,
  0x9F, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFB, 0xFC, 0x7F, 0x1F, 0xC7, 0xE0, 0xFE,
  0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xE7, 0xFB,
  0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0x40, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8,
  0x7F, 0xFF, 0x87, 0xF1, 0xFC, 0xFE, 0x0F, 0xCF, 0xC0, 0x7E, 0xFC, 0x07,
  0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xBE, 0x1F, 0xF3, 0xE0,
  0xFE, 0x3E, 0x01, 0x83, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFE,
  0x00, 0x04, 0x00, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x9C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xC2, 0x00, 0x3E, 0x3F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x3F, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xF8, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x01,
  0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x03,
  0x80, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0xF1,
  0xFF, 0xFC, 0x7F, 0xFF, 0x8E, 0x0F, 0xE3, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x1F, 0x0F, 0x80, 0xFF, 0x07, 0x87, 0xC0, 0xFF, 0xE3, 0xE3, 0xC0,
  0xFF, 0xF1, 0xF3, 0xE0, 0xFF, 0xF8, 0x79, 0xF0, 0xF8, 0x7C, 0x3C, 0xF0,
  0x7C, 0x3E, 0x1E, 0x78, 0x3C, 0x1F, 0x0F, 0xBC, 0x3E, 0x0F, 0x07, 0xFE,
  0x1F, 0x07, 0x83, 0xFF, 0x0F, 0x83, 0xC1, 0xFF, 0x87, 0xC1, 0xE0, 0xFF,
  0xC3, 0xE0, 0xF0, 0x7F, 0xE1, 0xE0, 0xF8, 0x3D, 0xF0, 0xF0, 0x7C, 0x1E,
  0xF8, 0x7C, 0x3E, 0x0F, 0x7C, 0x3E, 0x1F, 0x0F, 0xBE, 0x1F, 0x0F, 0x87,
  0xCF, 0x07, 0xCF, 0xE7, 0xC7, 0x83, 0xFF, 0x7F, 0xE3, 0xE0, 0xFF, 0x3F,
  0xE1, 0xF0, 0x7F, 0x8F, 0xE0, 0xF8, 0x0F, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x08, 0x00, 0x3F, 0x80, 0x1C, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7C, 0xF8, 0x00,
  0x1F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0x7C,
  0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03,
  0xF0, 0x3F, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0x80,
  0x3F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x7F,
  0x00, 0x1F, 0x9F, 0xC0, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF0, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7E, 0x1F, 0xF3, 0xF0,
  0x3F, 0xDF, 0x80, 0xFE, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD,
  0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x03, 0xF3, 0xF0, 0x3F, 0x9F, 0x83,
  0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x7E, 0x07, 0xFB, 0xF0, 0x1F, 0xDF, 0x80, 0x7E, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xDF, 0x80, 0xFE, 0xFC, 0x1F, 0xF7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x3F, 0xC1, 0xC1, 0xFC, 0x01, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x02, 0x1F, 0xF0, 0x38, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x40, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x8F, 0xC0, 0xFF, 0x3F, 0x01, 0xFC, 0xFC, 0x03, 0xFB,
  0xF0, 0x0F, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7E, 0xFC, 0x03, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x7F,
  0x3F, 0x03, 0xFC, 0xFC, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFE, 0x07, 0x8F, 0xF0, 0x03,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xF7, 0xE0, 0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0x9F, 0xC0, 0x3F,
  0x3F, 0xE0, 0x7E, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x01, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x87, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0x81, 0xFD, 0xFF,
  0xEF, 0xFF, 0x7F, 0xF3, 0xFF, 0x1F, 0xF0, 0x7E, 0x00, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0xBF, 0x01, 0xFC, 0xFC, 0x07, 0xF3, 0xF0,
  0x3F, 0x8F, 0xC0, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0xFE,
  0x0F, 0xC7, 0xF0, 0x3F, 0x1F, 0xC0, 0xFC, 0xFE, 0x03, 0xF3, 0xF8, 0x0F,
  0xDF, 0xC0, 0x3F, 0x7F, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xF7, 0xE0,
  0x3F, 0x9F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFE, 0x0F, 0xC3, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFE, 0x3F, 0x01,
  0xF8, 0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x3F, 0xBF, 0x00, 0xFE,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFB, 0xE0,
  0x07, 0xFF, 0xFB, 0xE0, 0x07, 0xFF, 0xFB, 0xE0, 0x0F, 0xFF, 0xFB, 0xF0,
  0x0F, 0xBF, 0xF9, 0xF0, 0x0F, 0xBF, 0xF9, 0xF0, 0x0F, 0xBF, 0xF9, 0xF0,
  0x1F, 0x3F, 0xFD, 0xF8, 0x1F, 0x3F, 0xFC, 0xF8, 0x1F, 0x3F, 0xFC, 0xF8,
  0x1F, 0x3F, 0xFC, 0xF8, 0x3E, 0x3F, 0xFC, 0x7C, 0x3E, 0x3F, 0xFC, 0x7C,
  0x3E, 0x3F, 0xFC, 0x7C, 0x7C, 0x3F, 0xFC, 0x7C, 0x7C, 0x3F, 0xFC, 0x3E,
  0x7C, 0x3F, 0xFC, 0x3E, 0x7C, 0x3F, 0xFC, 0x3E, 0xF8, 0x3F, 0xFC, 0x3F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xF8, 0x3F, 0xFC, 0x1F, 0xF0, 0x3F, 0xFC, 0x1F,
  0xF0, 0x3F, 0xFC, 0x1F, 0xF0, 0x3F, 0xFC, 0x0F, 0xF0, 0x3F, 0xFC, 0x0F,
  0xE0, 0x3F, 0xFC, 0x0F, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07,
  0xE0, 0x3F, 0xFC, 0x07, 0xC0, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFB, 0xE0, 0x1F, 0xFB, 0xF0, 0x1F, 0xFB, 0xF0, 0x1F, 0xF9, 0xF8, 0x1F,
  0xF9, 0xF8, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0x7C, 0x1F,
  0xFC, 0x7E, 0x1F, 0xFC, 0x7E, 0x1F, 0xFC, 0x3F, 0x1F, 0xFC, 0x3F, 0x1F,
  0xFC, 0x1F, 0x9F, 0xFC, 0x1F, 0x9F, 0xFC, 0x0F, 0x9F, 0xFC, 0x0F, 0xDF,
  0xFC, 0x0F, 0xDF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0xFE,
  0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF0, 0x01, 0xF9,
  0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF7, 0xE0, 0x01,
  0xFD, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF7,
  0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xDF, 0x80, 0x07,
  0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xE0,
  0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xE1, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0x07, 0xFF,
  0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x83, 0xFF, 0xF1, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F,
  0xFF, 0x07, 0xFF, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFC, 0x07,
  0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF0,
  0x01, 0xF9, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF7,
  0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xDF,
  0x80, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F,
  0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xE1,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xBF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x8F, 0xC1, 0xFE, 0x3F, 0x03, 0xF8, 0xFC, 0x07, 0xE3,
  0xF0, 0x1F, 0xCF, 0xC0, 0x7F, 0x3F, 0x01, 0xFC, 0xFC, 0x07, 0xF3, 0xF0,
  0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xE3, 0xF0, 0xFF,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x0F, 0xC0, 0xFC,
  0x3F, 0x03, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0xCF, 0xC0, 0x3F, 0x3F,
  0x00, 0xFE, 0xFC, 0x03, 0xFB, 0xF0, 0x07, 0xF0, 0x03, 0xFE, 0x03, 0xFF,
  0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0x9F, 0xE7, 0xE7, 0xE0, 0x1B,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xBF, 0xFF,
  0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x10, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0,
  0x1F, 0xDF, 0x80, 0x3F, 0x3F, 0x80, 0xFE, 0x7F, 0x83, 0xFC, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF0,
  0x00, 0x04, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xE7, 0xC0,
  0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0xC3,
  0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x1F,
  0x81, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0,
  0x3F, 0x00, 0xF8, 0x0F, 0xC0, 0x3E, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03,
  0xF0, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x07, 0xE1, 0xF8,
  0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xE3,
  0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xDF, 0x80, 0x01,
  0xF7, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7F, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xE0,
  0x07, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0xC0,
  0x1F, 0x9F, 0x80, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0xFF, 0x80, 0x7E, 0x7E,
  0x01, 0xFF, 0x00, 0xFC, 0x7E, 0x03, 0xDE, 0x03, 0xF0, 0xFC, 0x07, 0xBC,
  0x07, 0xE1, 0xF8, 0x0F, 0x78, 0x0F, 0xC3, 0xF0, 0x3E, 0xF8, 0x1F, 0x87,
  0xE0, 0x7D, 0xF0, 0x3F, 0x07, 0xC0, 0xFB, 0xE0, 0xFC, 0x0F, 0xC1, 0xF7,
  0xC1, 0xF8, 0x1F, 0x83, 0xEF, 0x83, 0xF0, 0x3F, 0x0F, 0x8F, 0x87, 0xE0,
  0x7E, 0x1F, 0x1F, 0x0F, 0xC0, 0x7C, 0x3E, 0x3E, 0x3F, 0x80, 0xFC, 0x7C,
  0x7C, 0x7E, 0x01, 0xF8, 0xF8, 0xF8, 0xFC, 0x03, 0xF3, 0xE0, 0xF9, 0xF8,
  0x07, 0xE7, 0xC1, 0xF3, 0xF0, 0x07, 0xCF, 0x83, 0xE7, 0xE0, 0x0F, 0x9F,
  0x07, 0xDF, 0x80, 0x1F, 0xBE, 0x0F, 0xBF, 0x00, 0x3F, 0x78, 0x0F, 0x7E,
  0x00, 0x7F, 0xF0, 0x1E, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0xFE, 0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xF1, 0xFC,
  0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x7F, 0x03, 0xF0, 0xFC, 0x07, 0xE1,
  0xF8, 0x0F, 0xC7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x1F, 0x7E,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0xFC,
  0x7F, 0x01, 0xF8, 0x7E, 0x07, 0xF0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0x81,
  0xF8, 0x7E, 0x03, 0xF8, 0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xE7, 0xE0, 0x0F,
  0xFF, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFD, 0xF8, 0x03,
  0xFB, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x8F, 0xE0, 0x7E,
  0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0,
  0x7E, 0x3F, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xFB, 0xF0, 0x01,
  0xF7, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xE0, 0x07,
  0xE3, 0xE0, 0x07, 0xC3, 0xF0, 0x0F, 0xC1, 0xF0, 0x0F, 0x81, 0xF8, 0x1F,
  0x80, 0xF8, 0x1F, 0x00, 0xFC, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7E,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xF8,
  0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x30, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0xF0, 0xFF,
  0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xFB, 0xFE, 0x3F, 0xFE, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xCF, 0x9F, 0xF1,
  0xF1, 0xFC, 0x3E, 0x04, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0xFE, 0x0F, 0xCF, 0xF8, 0x7E, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0xFF, 0x0F, 0xE7, 0xF0, 0x3F, 0xBF, 0x80, 0xFD, 0xFC, 0x07, 0xEF, 0xC0,
  0x3F, 0x7E, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xDF, 0xC0, 0x7E, 0xFE, 0x03, 0xF7, 0xF0, 0x3F, 0xBF,
  0xC1, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7E, 0xFF, 0xE3, 0xE7, 0xFE,
  0x1F, 0x0F, 0xE0, 0x00, 0x18, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0xC3, 0xFF,
  0xE3, 0xFF, 0xE3, 0xFF, 0xF1, 0xFC, 0x19, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0x3F, 0xFF, 0x9F,
  0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xE0, 0x01, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x0F, 0xC3, 0xF0, 0xFF, 0x9F, 0x8F, 0xFE, 0xFC, 0xFF,
  0xF7, 0xE7, 0xFF, 0xFF, 0x7F, 0x0F, 0xFB, 0xF0, 0x3F, 0xDF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0x7E, 0x03,
  0xFB, 0xF0, 0x3F, 0xDF, 0xC1, 0xFE, 0x7F, 0xBF, 0xF3, 0xFF, 0xFF, 0x8F,
  0xFE, 0xFC, 0x3F, 0xE7, 0xE0, 0xFE, 0x1F, 0x00, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xDF, 0xC3, 0xF0,
  0xFC, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7C, 0x03, 0xEF, 0xC0, 0x3E, 0xFC,
  0x03, 0xEF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x04, 0x3F, 0xC7,
  0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x02,
  0x00, 0x00, 0x10, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F,
  0xFE, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xF0, 0xF8, 0x7F, 0xCF, 0xC7, 0xFF, 0x7E, 0x7F, 0xFB, 0xF3, 0xFF, 0xFF,
  0xBF, 0x87, 0xFD, 0xFC, 0x1F, 0xEF, 0xC0, 0x7F, 0x7E, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xBF, 0x01, 0xFD, 0xF8, 0x1F, 0xEF,
  0xE0, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0x7E, 0x1F, 0xF3,
  0xF0, 0x7F, 0x1F, 0x80, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0xC0, 0x0F, 0xC7, 0xF7, 0xFE,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x0F,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC7, 0xF0, 0xFC, 0xFF, 0x8F, 0xDF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0x8F, 0xEF, 0xF0, 0x7E, 0xFE,
  0x07, 0xEF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7B, 0xFF, 0xFF, 0xFF, 0xF7, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFF, 0xFF,
  0xFF, 0xBF, 0xEF, 0xF3, 0xF8, 0x78, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0x7E, 0x03, 0xF3, 0xF0, 0x3F, 0x1F, 0x81,
  0xF8, 0xFC, 0x1F, 0x87, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0xFC, 0x0F,
  0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xF3, 0xF0, 0x7F,
  0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0x7E,
  0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x01, 0xFB, 0xF0,
  0x0F, 0xDF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0x03, 0xF8, 0xF9, 0xFF, 0x8F, 0xFC, 0xF9, 0xFF, 0xCF, 0xFE, 0xFB, 0xFF,
  0xDF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF8, 0x7F, 0xFE, 0x0F,
  0xF0, 0x3F, 0xFE, 0x07, 0xF0, 0x3F, 0xFE, 0x07, 0xF0, 0x3F, 0xFC, 0x07,
  0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07,
  0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07,
  0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07,
  0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07,
  0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07,
  0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07,
  0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xF8, 0x7F, 0x0F, 0x9F, 0xF8, 0xF9,
  0xFF, 0xCF, 0xBF, 0xFC, 0xFF, 0xFF, 0xEF, 0xF0, 0xFE, 0xFE, 0x07, 0xEF,
  0xE0, 0x7E, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0x83, 0xF1, 0xF8,
  0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xF7,
  0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xC7, 0xE0, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0x10, 0x00, 0xF8, 0x7F, 0x07, 0xC7, 0xFC, 0x3E, 0x7F, 0xF1, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x7F, 0x83, 0xF3, 0xF8, 0x1F, 0xDF, 0xC0, 0x7E, 0xFE,
  0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xEF, 0xE0, 0x3F, 0x7F, 0x01, 0xFB,
  0xF8, 0x1F, 0xDF, 0xE0, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0x7F,
  0xF1, 0xF9, 0xFF, 0x0F, 0xC7, 0xF0, 0x7E, 0x04, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0xF8, 0x7F, 0xCF, 0xC7, 0xFF,
  0x7E, 0x7F, 0xFB, 0xF3, 0xFF, 0xFF, 0xBF, 0x87, 0xFD, 0xF8, 0x1F, 0xEF,
  0xC0, 0x7F, 0x7E, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x3F,
  0xBF, 0x01, 0xFD, 0xF8, 0x1F, 0xEF, 0xE0, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xC7, 0xFF, 0x7E, 0x1F, 0xF3, 0xF0, 0x7F, 0x1F, 0x80, 0xC0, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x7F, 0xE3, 0xFF,
  0x9F, 0xFE, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0xFE, 0x03,
  0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x0F,
  0xF8, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFC, 0xFC, 0x0C, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x7E, 0xC0, 0x7E, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x07, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7E, 0x01, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F,
  0xC0, 0x20, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x83, 0xFB, 0xF0, 0xFF, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xEF, 0x9F, 0xF8, 0xF0, 0xFE, 0x1E, 0x06,
  0x00, 0x00, 0xFC, 0x00, 0xFD, 0xF8, 0x07, 0xF7, 0xE0, 0x1F, 0x9F, 0x80,
  0x7E, 0x7E, 0x01, 0xF8, 0xF8, 0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC,
  0x3F, 0x03, 0xF0, 0x7C, 0x0F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F,
  0x87, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xF3, 0xF0, 0x0F, 0xCF,
  0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF7, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0xFC, 0x03,
  0xF8, 0x0F, 0xDF, 0x00, 0xFE, 0x03, 0xF7, 0xE0, 0x7F, 0x80, 0xFD, 0xF8,
  0x1F, 0xE0, 0x3E, 0x7E, 0x07, 0xF8, 0x1F, 0x9F, 0x81, 0xFF, 0x07, 0xE3,
  0xF0, 0x7F, 0xC1, 0xF8, 0xFC, 0x1E, 0xF0, 0x7E, 0x3F, 0x0F, 0xBC, 0x1F,
  0x0F, 0xC3, 0xEF, 0x0F, 0xC1, 0xF0, 0xF3, 0xC3, 0xF0, 0x7E, 0x3C, 0xF8,
  0xFC, 0x1F, 0x8F, 0x1E, 0x3E, 0x07, 0xE7, 0xC7, 0x8F, 0x81, 0xF9, 0xF1,
  0xE7, 0xE0, 0x3E, 0x78, 0x79, 0xF8, 0x0F, 0x9E, 0x1E, 0x7E, 0x03, 0xF7,
  0x87, 0xDF, 0x00, 0xFD, 0xE0, 0xF7, 0xC0, 0x1F, 0x78, 0x3D, 0xF0, 0x07,
  0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x07,
  0xF0, 0x00, 0x7E, 0x03, 0xFB, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x0F,
  0xC1, 0xF8, 0x7E, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF0, 0x07,
  0xDF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xE7, 0xE0,
  0x7E, 0x3F, 0x03, 0xF1, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC0,
  0xFC, 0xFC, 0x07, 0xEF, 0xE0, 0x1F, 0x80, 0xFC, 0x00, 0xFD, 0xF8, 0x07,
  0xF7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xC3,
  0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0x81, 0xF8,
  0x7E, 0x07, 0xE1, 0xF8, 0x0F, 0x87, 0xE0, 0x3F, 0x1F, 0x00, 0xFC, 0xFC,
  0x03, 0xF3, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0x7E, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x00,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFE,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x07,
  0xFC, 0x0F, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0xC0,
  0x7F, 0x80, 0x3F, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xC0, 0x3F, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x7F,
  0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0x00, 0x04,
  0xFF, 0x80, 0x37, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFC, 0x03, 0xFF, 0xA0, 0x03, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 39, 13, 3, -38 },
  { 36, 17, 14, 22, 3, -38 },
  { 66, 24, 38, 26, 1, -38 },
  { 180, 20, 43, 24, 2, -40 },
  { 288, 35, 38, 39, 2, -38 },
  { 455, 27, 39, 28, 1, -38 },
  { 587, 6, 14, 12, 3, -38 },
  { 598, 12, 46, 16, 3, -38 },
  { 667, 13, 46, 16, 1, -38 },
  { 742, 20, 20, 23, 1, -40 },
  { 792, 20, 25, 24, 2, -31 },
  { 855, 8, 13, 13, 2, -6 },
  { 868, 13, 6, 16, 1, -17 },
  { 878, 7, 8, 13, 3, -7 },
  { 885, 19, 38, 21, 1, -38 },
  { 976, 20, 39, 24, 2, -38 },
  { 1074, 15, 38, 24, 3, -38 },
  { 1146, 20, 38, 24, 2, -38 },
  { 1241, 20, 39, 24, 2, -38 },
  { 1339, 22, 38, 24, 1, -38 },
  { 1444, 20, 39, 24, 2, -38 },
  { 1542, 20, 39, 24, 2, -38 },
  { 1640, 21, 38, 24, 1, -38 },
  { 1740, 20, 39, 24, 2, -38 },
  { 1838, 20, 39, 24, 2, -38 },
  { 1936, 7, 30, 13, 3, -29 },
  { 1963, 8, 36, 13, 2, -29 },
  { 1999, 21, 24, 24, 1, -31 },
  { 2062, 21, 15, 24, 1, -26 },
  { 2102, 21, 24, 24, 2, -31 },
  { 2165, 18, 39, 19, 0, -38 },
  { 2253, 33, 42, 37, 2, -38 },
  { 2427, 26, 38, 26, 0, -38 },
  { 2551, 21, 38, 27, 4, -38 },
  { 2651, 22, 39, 25, 2, -38 },
  { 2759, 22, 38, 29, 4, -38 },
  { 2864, 16, 38, 22, 4, -38 },
  { 2940, 16, 38, 22, 4, -38 },
  { 3016, 23, 39, 29, 3, -38 },
  { 3129, 22, 38, 30, 4, -38 },
  { 3234, 14, 38, 16, 1, -38 },
  { 3301, 13, 49, 14, -3, -38 },
  { 3381, 22, 38, 26, 4, -38 },
  { 3486, 16, 38, 21, 4, -38 },
  { 3562, 32, 38, 40, 4, -38 },
  { 3714, 24, 38, 32, 4, -38 },
  { 3828, 26, 39, 31, 2, -38 },
  { 3955, 19, 38, 25, 4, -38 },
  { 4046, 26, 47, 31, 2, -38 },
  { 4199, 22, 38, 26, 4, -38 },
  { 4304, 18, 39, 22, 2, -38 },
  { 4392, 20, 38, 22, 1, -38 },
  { 4487, 23, 39, 29, 3, -38 },
  { 4600, 26, 38, 26, 0, -38 },
  { 4724, 39, 38, 39, 0, -38 },
  { 4910, 23, 38, 24, 0, -38 },
  { 5020, 23, 38, 23, 0, -38 },
  { 5130, 19, 38, 21, 1, -38 },
  { 5221, 12, 46, 17, 3, -38 },
  { 5290, 19, 38, 21, 1, -38 },
  { 5381, 12, 46, 17, 1, -38 },
  { 5450, 24, 22, 26, 1, -38 },
  { 5516, 22, 3, 22, 0, 5 },
  { 5525, 11, 9, 16, 2, -41 },
  { 5538, 19, 30, 24, 2, -29 },
  { 5610, 21, 41, 26, 3, -40 },
  { 5718, 17, 30, 20, 2, -29 },
  { 5782, 21, 41, 26, 2, -40 },
  { 5890, 20, 30, 23, 2, -29 },
  { 5965, 16, 41, 15, 0, -41 },
  { 6047, 21, 42, 26, 2, -29 },
  { 6158, 20, 40, 26, 3, -40 },
  { 6258, 6, 40, 12, 3, -40 },
  { 6288, 10, 53, 12, -1, -40 },
  { 6355, 21, 40, 24, 3, -40 },
  { 6460, 6, 40, 12, 3, -40 },
  { 6490, 32, 29, 38, 3, -29 },
  { 6606, 20, 29, 26, 3, -29 },
  { 6679, 21, 30, 25, 2, -29 },
  { 6758, 21, 42, 26, 3, -29 },
  { 6869, 21, 42, 26, 2, -29 },
  { 6980, 14, 29, 18, 3, -29 },
  { 7031, 16, 30, 19, 2, -29 },
  { 7091, 14, 36, 16, 1, -35 },
  { 7154, 19, 30, 26, 3, -29 },
  { 7226, 22, 29, 22, 0, -29 },
  { 7306, 34, 29, 35, 0, -29 },
  { 7430, 21, 29, 21, 0, -29 },
  { 7507, 22, 42, 22, 0, -29 },
  { 7623, 16, 29, 18, 1, -29 },
  { 7681, 16, 46, 19, 1, -38 },
  { 7773, 5, 52, 23, 9, -40 },
  { 7806, 15, 46, 19, 2, -38 },
  { 7893, 22, 8, 24, 1, -23 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold53pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD53PT7B_H_
