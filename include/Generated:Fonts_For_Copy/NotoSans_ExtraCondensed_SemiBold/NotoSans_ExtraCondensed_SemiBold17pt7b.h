#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD17PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x0F, 0xDE, 0xF7, 0xB0, 0x12, 0x16, 0x16, 0x7F, 0x7F,
  0x34, 0x24, 0xFF, 0x2C, 0x2C, 0x2C, 0x68, 0x20, 0xCF, 0xF9, 0xE3, 0x87,
  0x0E, 0x2C, 0xBA, 0xFE, 0x20, 0x80, 0xE3, 0x16, 0x62, 0x48, 0x4B, 0x09,
  0x41, 0x6B, 0xBB, 0x58, 0x5B, 0x0B, 0x63, 0x6C, 0x45, 0x98, 0xE0, 0x3C,
  0x36, 0x19, 0x0D, 0x83, 0xC1, 0xC1, 0xE6, 0xDE, 0xCF, 0x73, 0x1F, 0xCF,
  0xF0, 0xFF, 0x36, 0x4C, 0xCC, 0xCC, 0xCC, 0xC4, 0x66, 0x30, 0xC6, 0x23,
  0x33, 0x11, 0x13, 0x33, 0x26, 0xC0, 0x18, 0x21, 0xFD, 0xE3, 0x8D, 0x80,
  0x18, 0x30, 0x67, 0xFF, 0xE3, 0x06, 0x0C, 0xFE, 0xF8, 0xF0, 0x06, 0x18,
  0x30, 0xC1, 0x82, 0x0C, 0x18, 0x20, 0xC1, 0x86, 0x00, 0x7B, 0x6C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0x9E, 0x3B, 0xFF, 0xB1, 0x8C, 0x63, 0x18,
  0xC6, 0x30, 0xFB, 0x60, 0xC3, 0x18, 0x63, 0x8C, 0x63, 0x0F, 0xFF, 0xFB,
  0x70, 0xC3, 0x19, 0xC7, 0x83, 0x0C, 0x3F, 0xBE, 0x0C, 0x38, 0x71, 0xE2,
  0xCD, 0x93, 0x26, 0xFE, 0x18, 0x30, 0x60, 0xFB, 0xEC, 0x30, 0xF3, 0xE1,
  0xC3, 0x0C, 0x3F, 0xBC, 0x39, 0x9C, 0x30, 0xFA, 0xFC, 0xF3, 0xCF, 0x3F,
  0xDE, 0xFF, 0xFC, 0x18, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x60, 0xC3, 0x80,
  0x7B, 0x3C, 0xF3, 0xF9, 0xCF, 0xB3, 0x8E, 0x3D, 0xDE, 0x7B, 0x6C, 0xE3,
  0x8F, 0x3F, 0xDB, 0x0C, 0x6F, 0xBC, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xF8,
  0x02, 0x1C, 0xF7, 0x87, 0x03, 0x83, 0x81, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0xC1, 0xC0, 0xE0, 0x70, 0xE7, 0x38, 0x40, 0xF9, 0x70, 0xC3, 0x18, 0xC3,
  0x08, 0x00, 0x07, 0x1C, 0x1F, 0x18, 0x64, 0x0B, 0x3B, 0x9A, 0x64, 0x9B,
  0x26, 0x49, 0x96, 0xF7, 0x6C, 0x01, 0x84, 0x3F, 0x00, 0x1C, 0x1C, 0x3C,
  0x34, 0x36, 0x26, 0x66, 0x7E, 0x7F, 0x63, 0xC3, 0xC3, 0xFD, 0xFB, 0x1E,
  0x3C, 0xDF, 0x37, 0x63, 0xC7, 0x8F, 0xF7, 0xC0, 0x3E, 0xEB, 0x86, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0xC1, 0xF1, 0xE0, 0xF9, 0xFB, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0xF7, 0xC0, 0xFF, 0xF1, 0x8C, 0x7F, 0xF8, 0xC6,
  0x3F, 0xF0, 0xFF, 0xF1, 0x8C, 0x7F, 0xF8, 0xC6, 0x31, 0x80, 0x3E, 0xEF,
  0x86, 0x0C, 0x19, 0xF3, 0xE3, 0xC7, 0xCD, 0xF9, 0xF0, 0xC7, 0x8F, 0x1E,
  0x3C, 0x7F, 0xFF, 0xE3, 0xC7, 0x8F, 0x1E, 0x30, 0xF9, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x9D, 0xF0, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xF0,
  0xC7, 0x9B, 0x36, 0xCD, 0x9E, 0x3E, 0x6C, 0xCD, 0x9B, 0x1E, 0x30, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x3F, 0xF0, 0xE0, 0xFC, 0x3F, 0xC7, 0xF8,
  0xBD, 0x17, 0xA6, 0xF6, 0xDE, 0xD3, 0xCE, 0x79, 0xCF, 0x39, 0xE6, 0x30,
  0xE3, 0xE3, 0xF3, 0xF3, 0xDB, 0xDB, 0xDB, 0xCF, 0xCF, 0xC7, 0xC7, 0xC3,
  0x7C, 0x6E, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0x7E, 0x3C,
  0xF9, 0xFB, 0x36, 0x3C, 0xD9, 0xBF, 0x78, 0xC1, 0x83, 0x06, 0x00, 0x7C,
  0x6E, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0x7E, 0x3C, 0x0C,
  0x06, 0x07, 0xF9, 0xFB, 0x3E, 0x3C, 0xDB, 0xBE, 0x6C, 0xCD, 0x9B, 0x3E,
  0x30, 0x7F, 0xEC, 0x30, 0xC1, 0xC3, 0x86, 0x0E, 0x6F, 0xBC, 0xFF, 0xFC,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x80, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8D, 0xFB, 0xE0, 0xC3, 0xC3, 0x63, 0x66,
  0x66, 0x66, 0x26, 0x34, 0x3C, 0x3C, 0x1C, 0x18, 0xC6, 0x1E, 0x31, 0xB1,
  0xCC, 0xCE, 0x66, 0xF3, 0x36, 0x91, 0xB5, 0x8D, 0x3C, 0x29, 0xE1, 0xCF,
  0x0E, 0x38, 0x71, 0x80, 0xE6, 0x66, 0x6C, 0x3C, 0x38, 0x18, 0x38, 0x3C,
  0x2C, 0x64, 0x66, 0xC7, 0xC7, 0x66, 0x66, 0x6C, 0x3C, 0x38, 0x38, 0x18,
  0x18, 0x18, 0x18, 0x18, 0xFF, 0xF0, 0xC6, 0x18, 0x43, 0x0C, 0x61, 0x8F,
  0xFF, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xC0, 0xC1, 0x81,
  0x03, 0x06, 0x04, 0x0C, 0x18, 0x18, 0x30, 0x30, 0xF3, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x3F, 0xF0, 0x18, 0x1C, 0x3C, 0x34, 0x66, 0x62, 0xC3, 0xFF,
  0xFC, 0xCC, 0x80, 0xFA, 0x60, 0xCF, 0xFF, 0x38, 0xF7, 0xEC, 0xC1, 0x83,
  0x06, 0x0F, 0xDD, 0xB1, 0x63, 0xC7, 0x8F, 0x37, 0x6F, 0x80, 0x7E, 0x71,
  0x8C, 0x63, 0x1D, 0x78, 0x0C, 0x30, 0xC3, 0x7F, 0x3C, 0xF3, 0xCF, 0x3C,
  0xFF, 0x74, 0x7B, 0x3C, 0xFF, 0xFF, 0x0C, 0x3B, 0x7C, 0x3B, 0xD8, 0xCF,
  0xB1, 0x8C, 0x63, 0x18, 0xC6, 0x00, 0x77, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF,
  0x7C, 0x30, 0xFF, 0xF8, 0xC3, 0x0C, 0x30, 0xFF, 0xBC, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCC, 0xF8, 0xFF, 0xFF, 0xC0, 0x6D, 0x06, 0xDB, 0x6D, 0xB6, 0xDF,
  0xC0, 0xC1, 0x83, 0x06, 0x1C, 0xDB, 0x36, 0x78, 0xF9, 0xB3, 0x36, 0x6C,
  0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFB, 0xBC, 0xCF, 0x33, 0xCC, 0xF3,
  0x3C, 0xCF, 0x33, 0xCC, 0xC0, 0xFF, 0xBC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCC,
  0x7B, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0x78, 0xFD, 0xDB, 0x16, 0x3C, 0x78,
  0xF3, 0x76, 0xF9, 0x83, 0x06, 0x0C, 0x00, 0x77, 0x3C, 0xF3, 0xCF, 0x3C,
  0xFF, 0x7C, 0x30, 0xC3, 0x0C, 0xFF, 0xCC, 0xCC, 0xCC, 0xC0, 0xFE, 0xA1,
  0xC7, 0x1C, 0x7E, 0xF0, 0x23, 0x3E, 0xC6, 0x31, 0x8C, 0x63, 0xCE, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0x74, 0xC6, 0x8D, 0xB3, 0x66, 0xC5, 0x8A,
  0x1C, 0x38, 0xCE, 0x79, 0xCD, 0xA9, 0x35, 0x66, 0xAC, 0xF7, 0x8E, 0xE1,
  0xCC, 0x31, 0x80, 0xEE, 0xD9, 0xA1, 0xC3, 0x87, 0x1B, 0x36, 0xC6, 0xC6,
  0x8D, 0xB3, 0x66, 0xC5, 0x0E, 0x1C, 0x18, 0x60, 0xC7, 0x8E, 0x00, 0x78,
  0xC6, 0x63, 0x31, 0x8F, 0xF8, 0x19, 0x8C, 0x63, 0x19, 0xDC, 0x31, 0x8C,
  0x63, 0x1C, 0x20, 0xFF, 0xFF, 0x80, 0xC7, 0x18, 0xC6, 0x31, 0xC7, 0x63,
  0x18, 0xC6, 0x72, 0x00, 0x7B, 0x3C,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 12, 4, 1, -12 },
  { 4, 5, 4, 7, 1, -12 },
  { 7, 8, 12, 8, 0, -12 },
  { 19, 6, 14, 8, 1, -13 },
  { 30, 11, 12, 12, 1, -12 },
  { 47, 9, 12, 9, 0, -12 },
  { 61, 2, 4, 4, 1, -12 },
  { 62, 4, 15, 5, 1, -12 },
  { 70, 4, 15, 5, 0, -12 },
  { 78, 7, 6, 7, 0, -13 },
  { 84, 7, 8, 8, 0, -10 },
  { 91, 2, 4, 4, 1, -2 },
  { 92, 5, 1, 5, 0, -5 },
  { 93, 2, 2, 4, 1, -2 },
  { 94, 7, 12, 7, 0, -12 },
  { 105, 6, 12, 8, 1, -12 },
  { 114, 5, 12, 8, 1, -12 },
  { 122, 6, 12, 8, 1, -12 },
  { 131, 6, 12, 8, 1, -12 },
  { 140, 7, 12, 8, 0, -12 },
  { 151, 6, 12, 8, 1, -12 },
  { 160, 6, 12, 8, 1, -12 },
  { 169, 7, 12, 8, 0, -12 },
  { 180, 6, 12, 8, 1, -12 },
  { 189, 6, 12, 8, 1, -12 },
  { 198, 2, 9, 4, 1, -9 },
  { 201, 2, 11, 4, 1, -9 },
  { 204, 7, 8, 8, 0, -10 },
  { 211, 7, 5, 8, 0, -8 },
  { 216, 7, 8, 8, 0, -10 },
  { 223, 6, 12, 6, 0, -12 },
  { 232, 10, 13, 12, 1, -12 },
  { 249, 8, 12, 8, 0, -12 },
  { 261, 7, 12, 9, 1, -12 },
  { 272, 7, 12, 8, 1, -12 },
  { 283, 7, 12, 9, 1, -12 },
  { 294, 5, 12, 7, 1, -12 },
  { 302, 5, 12, 7, 1, -12 },
  { 310, 7, 12, 9, 1, -12 },
  { 321, 7, 12, 10, 1, -12 },
  { 332, 5, 12, 5, 0, -12 },
  { 340, 4, 15, 4, -1, -12 },
  { 348, 7, 12, 8, 1, -12 },
  { 359, 5, 12, 7, 1, -12 },
  { 367, 11, 12, 13, 1, -12 },
  { 384, 8, 12, 10, 1, -12 },
  { 396, 8, 12, 10, 1, -12 },
  { 408, 7, 12, 8, 1, -12 },
  { 419, 8, 15, 10, 1, -12 },
  { 434, 7, 12, 8, 1, -12 },
  { 445, 6, 12, 7, 1, -12 },
  { 454, 7, 12, 7, 0, -12 },
  { 465, 7, 12, 9, 1, -12 },
  { 476, 8, 12, 8, 0, -12 },
  { 488, 13, 12, 13, 0, -12 },
  { 508, 8, 12, 8, 0, -12 },
  { 520, 8, 12, 8, 0, -12 },
  { 532, 6, 12, 7, 0, -12 },
  { 541, 4, 15, 5, 1, -12 },
  { 549, 7, 12, 7, 0, -12 },
  { 560, 4, 15, 5, 0, -12 },
  { 568, 8, 7, 8, 0, -12 },
  { 575, 7, 2, 7, 0, 1 },
  { 577, 3, 3, 5, 1, -13 },
  { 579, 6, 9, 8, 1, -9 },
  { 586, 7, 13, 8, 1, -13 },
  { 598, 5, 9, 6, 1, -9 },
  { 604, 6, 13, 8, 1, -13 },
  { 614, 6, 9, 8, 1, -9 },
  { 621, 5, 13, 5, 0, -13 },
  { 630, 6, 13, 8, 1, -9 },
  { 640, 6, 13, 8, 1, -13 },
  { 650, 2, 13, 4, 1, -13 },
  { 654, 3, 17, 4, 0, -13 },
  { 661, 7, 13, 8, 1, -13 },
  { 673, 2, 13, 4, 1, -13 },
  { 677, 10, 9, 12, 1, -9 },
  { 689, 6, 9, 8, 1, -9 },
  { 696, 6, 9, 8, 1, -9 },
  { 703, 7, 13, 8, 1, -9 },
  { 715, 6, 13, 8, 1, -9 },
  { 725, 4, 9, 6, 1, -9 },
  { 730, 5, 9, 6, 1, -9 },
  { 736, 5, 11, 5, 0, -11 },
  { 743, 6, 9, 8, 1, -9 },
  { 750, 7, 9, 7, 0, -9 },
  { 758, 11, 9, 11, 0, -9 },
  { 771, 7, 9, 7, 0, -9 },
  { 779, 7, 13, 7, 0, -9 },
  { 791, 5, 9, 6, 0, -9 },
  { 797, 5, 15, 6, 0, -12 },
  { 807, 1, 17, 7, 3, -13 },
  { 810, 5, 15, 6, 1, -12 },
  { 820, 7, 2, 8, 0, -7 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold17pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD17PT7B_H_
