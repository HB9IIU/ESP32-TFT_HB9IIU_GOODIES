#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLD33PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLD33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBold.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBold33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0x70, 0x06, 0xFF,
  0xFF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xF8, 0xFE, 0x3F, 0x87, 0xE1,
  0xC0, 0x06, 0x38, 0x1C, 0x70, 0x38, 0xC0, 0x71, 0x80, 0xE7, 0x01, 0xCE,
  0x03, 0x9C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x71, 0x80, 0xE7, 0x01,
  0xCE, 0x03, 0x9C, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFC, 0x71, 0x80, 0xE3,
  0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0C, 0x70, 0x18, 0xE0, 0x02, 0x00,
  0x10, 0x00, 0xC0, 0x3F, 0xE3, 0xFF, 0x3F, 0xF9, 0xC8, 0x9E, 0x40, 0xF2,
  0x03, 0x90, 0x1E, 0x80, 0x7C, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x5E,
  0x02, 0x70, 0x13, 0xC0, 0x9D, 0x84, 0xEF, 0xFF, 0x7F, 0xF1, 0xFF, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x1C, 0x03, 0x80, 0xF8, 0x0C, 0x07,
  0xF0, 0x70, 0x1D, 0xC1, 0xC0, 0xE3, 0x8E, 0x03, 0x8E, 0x38, 0x0E, 0x38,
  0xE0, 0x38, 0xE7, 0x00, 0xE3, 0x9C, 0x03, 0x8E, 0x60, 0x0E, 0x3B, 0x9F,
  0x1D, 0xCE, 0xFE, 0x7F, 0x73, 0xB8, 0xF9, 0xCC, 0x71, 0xC7, 0x71, 0xC0,
  0x39, 0xC7, 0x00, 0xE7, 0x1C, 0x03, 0x9C, 0x70, 0x1C, 0x71, 0xC0, 0x71,
  0xC7, 0x03, 0x83, 0x9C, 0x0E, 0x0E, 0xE0, 0x38, 0x1F, 0x81, 0xC0, 0x7C,
  0x07, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x3D, 0xE0, 0x38, 0xE0, 0x38, 0xE0,
  0x38, 0xE0, 0x39, 0xE0, 0x3D, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0x1F, 0x00,
  0x3F, 0x0F, 0x7F, 0x8E, 0xF3, 0xDE, 0xF3, 0xDE, 0xF1, 0xFE, 0xF0, 0xFC,
  0xF0, 0xFC, 0xF0, 0x78, 0xF8, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0x8F,
  0xFF, 0xFF, 0xFE, 0xEE, 0xE0, 0x0E, 0x3C, 0x71, 0xE3, 0x8F, 0x1C, 0x38,
  0xF1, 0xE3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x8F, 0x1E,
  0x1C, 0x3C, 0x78, 0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x38,
  0x3C, 0x1C, 0x1C, 0x1E, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0E,
  0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x38, 0x78, 0x70, 0xE0,
  0x0F, 0x00, 0xF0, 0x07, 0x04, 0x63, 0xFF, 0xFF, 0xFF, 0x7F, 0xE1, 0xF8,
  0x1F, 0xC3, 0x9C, 0x79, 0xE1, 0x08, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x7B, 0xDE, 0xF7, 0x3B,
  0xDC, 0xFF, 0xFF, 0xFF, 0xFF, 0x6F, 0xFF, 0xF0, 0x00, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0x0F,
  0x00, 0xFE, 0x0F, 0xF8, 0xFF, 0xC7, 0x8F, 0x3C, 0x79, 0xC3, 0xDE, 0x0E,
  0xF0, 0x77, 0x83, 0xBC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0E, 0xF0, 0x73, 0x87, 0x9C, 0x3C, 0xF1, 0xE7, 0x9E, 0x1F, 0xF0, 0xFF,
  0x03, 0xF0, 0x03, 0x83, 0xC3, 0xE3, 0xF3, 0xFB, 0xFF, 0xDE, 0xCF, 0x47,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x03, 0xFC, 0xFF, 0xE7, 0xBE, 0x60,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x70,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x07, 0xFC, 0xFF, 0xE7, 0xBF, 0x40,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x1F, 0xC1, 0xF0, 0x1F,
  0xC0, 0xFE, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xC1,
  0xFF, 0xFE, 0xFF, 0xE7, 0xF8, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0,
  0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x1D, 0xE0, 0xEF, 0x0E, 0x78, 0x73,
  0xC7, 0x1E, 0x38, 0xF3, 0x87, 0x9C, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0xFF, 0xDF, 0xFB, 0xFF,
  0x7F, 0xEF, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1F, 0xE3, 0xFE, 0x7F,
  0xE6, 0xFE, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF8,
  0x3F, 0xFF, 0xBF, 0xE7, 0xF8, 0x03, 0xE0, 0x7F, 0x07, 0xF8, 0x7E, 0x43,
  0xC0, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0xBE, 0x3F, 0xF9, 0xFF,
  0xEF, 0x8F, 0x78, 0x7B, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xDC, 0x1C,
  0xF1, 0xE7, 0x8F, 0x1F, 0xF0, 0xFF, 0x81, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x0F,
  0x81, 0xFE, 0x1F, 0xF8, 0xF1, 0xE7, 0x0F, 0x38, 0x39, 0xC1, 0xCE, 0x1E,
  0x78, 0xF1, 0xEF, 0x0F, 0xF0, 0x3F, 0x01, 0xFC, 0x1F, 0xF1, 0xE7, 0xDE,
  0x1E, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0x3F, 0xF8, 0xFF,
  0x83, 0xF8, 0x0F, 0x01, 0xFE, 0x1F, 0xF8, 0xFF, 0xCF, 0x0F, 0x78, 0x7B,
  0xC3, 0xDE, 0x0E, 0xF0, 0x77, 0x83, 0xFC, 0x3F, 0xE1, 0xF7, 0xFF, 0x3F,
  0xF8, 0xFD, 0xC1, 0x8E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3E,
  0x3F, 0xE1, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x06,
  0xFF, 0xFF, 0x7B, 0xDE, 0xF3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEF,
  0x7B, 0xDC, 0xE7, 0x70, 0x00, 0x18, 0x03, 0xC0, 0x7E, 0x0F, 0xE1, 0xFC,
  0x3F, 0x83, 0xF0, 0x1F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0x80, 0x1C, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x07, 0x80, 0x3F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x7F,
  0x0F, 0xE1, 0xFC, 0x0F, 0x80, 0x70, 0x02, 0x00, 0x00, 0x1F, 0x0F, 0xF3,
  0xFF, 0x3F, 0xF4, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x1E,
  0x07, 0xC0, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x06,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0xE0, 0x1E, 0x07, 0x81, 0xC0, 0x1E, 0x1E, 0x00, 0x70, 0xE0, 0xC1,
  0xCE, 0x1F, 0xCE, 0x71, 0xFE, 0x73, 0x8E, 0x71, 0x9C, 0xE3, 0x8E, 0xC7,
  0x1C, 0x7E, 0x38, 0xE3, 0xF1, 0xC7, 0x1F, 0x8E, 0x38, 0xDC, 0x71, 0xC6,
  0xE3, 0x9E, 0x73, 0x1C, 0xF3, 0x9C, 0x7D, 0xF8, 0xE1, 0xE7, 0x87, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x60, 0x0F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0F, 0x70, 0x0E, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x38, 0x1E, 0x3C, 0x1C, 0x3C, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x0F, 0x78,
  0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x3F, 0xFD, 0xFF, 0xEF,
  0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xBF, 0xFD, 0xFF,
  0x8F, 0xFF, 0x78, 0xFF, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x0F, 0xFF, 0xFB, 0xFF, 0x9F, 0xF8, 0x07, 0xE0, 0xFF, 0xCF,
  0xFC, 0x7F, 0xE7, 0xC1, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC3, 0x1F, 0xF8, 0x7F, 0xC1, 0xFE, 0xFC,
  0x03, 0xFF, 0x0F, 0xFE, 0x3F, 0xFC, 0xF0, 0xFB, 0xC1, 0xEF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xBC, 0x3E, 0xF3, 0xF3,
  0xFF, 0xCF, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0xCF, 0xFF,
  0x7C, 0x05, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x81, 0xDE, 0x07, 0x7C, 0x1C, 0xFF, 0xF1, 0xFF, 0xC3, 0xFE, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x7E, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFE, 0xFC, 0x70,
  0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xBC, 0x3C, 0xF0, 0xF3, 0xC7, 0x8F, 0x1E,
  0x3C, 0xF0, 0xF7, 0xC3, 0xDE, 0x0F, 0x78, 0x3F, 0xE0, 0xFF, 0x83, 0xFF,
  0x0F, 0xBC, 0x3C, 0xF0, 0xF1, 0xE3, 0xC7, 0x8F, 0x0F, 0x3C, 0x3C, 0xF0,
  0x7B, 0xC1, 0xEF, 0x07, 0xFC, 0x0F, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xEF, 0xF7, 0x07, 0x7F,
  0xB8, 0x3B, 0xFD, 0xC3, 0xDF, 0xEF, 0x1C, 0xFF, 0x38, 0xE7, 0xF9, 0xC7,
  0x3F, 0xCE, 0x71, 0xFE, 0x7B, 0x8F, 0xF1, 0xDC, 0x7F, 0x8F, 0xE3, 0xFC,
  0x7E, 0x1F, 0xE1, 0xF0, 0xFF, 0x0F, 0x87, 0xF8, 0x78, 0x3F, 0xC3, 0xC1,
  0xFE, 0x0E, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE,
  0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xF7, 0x0F, 0xF7, 0x8F, 0xF3,
  0x8F, 0xF3, 0xCF, 0xF3, 0xCF, 0xF1, 0xCF, 0xF1, 0xEF, 0xF0, 0xEF, 0xF0,
  0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0,
  0x1F, 0xF0, 0x1F, 0x07, 0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7E, 0xFC, 0x78,
  0x3C, 0xF8, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0x78, 0x3C, 0x7C, 0x7C, 0x3F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xE0, 0xFC, 0x07, 0xFE, 0x3F, 0xF9, 0xFF, 0xEF, 0x0F, 0x78,
  0x7B, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xBC, 0x3D, 0xE3, 0xEF, 0xFE,
  0x7F, 0xF3, 0xFE, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0xC0, 0x1F, 0xF0, 0x3F, 0xF8,
  0x7E, 0xFC, 0x78, 0x3C, 0xF8, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0x78, 0x3C, 0x7C, 0x7C,
  0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x3F,
  0xFC, 0xF0, 0xF3, 0xC3, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC3, 0xCF,
  0x0F, 0x3F, 0xFC, 0xFF, 0xE3, 0xFE, 0x0F, 0xFC, 0x3C, 0xF0, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC1, 0xEF, 0x07, 0xBC, 0x0F,
  0x0F, 0x83, 0xFF, 0x7F, 0xE7, 0xFE, 0x78, 0x2F, 0x00, 0xF0, 0x0F, 0x00,
  0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xE0, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x1E, 0xF3, 0xEF, 0xFE, 0xFF, 0xC7, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFE, 0x0F, 0x78, 0x79, 0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0xF0, 0x0F, 0xF0,
  0x0F, 0x70, 0x0E, 0x70, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x38,
  0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x1C, 0x38, 0x1C, 0x78, 0x1E,
  0x78, 0x1E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0xF0, 0x3C, 0x07,
  0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0x70, 0x3E, 0x0F,
  0x78, 0x7E, 0x0E, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1E,
  0x38, 0x77, 0x1E, 0x38, 0xF7, 0x1C, 0x3C, 0xE7, 0x1C, 0x3C, 0xE7, 0x3C,
  0x3C, 0xE7, 0x3C, 0x1C, 0xE3, 0xBC, 0x1D, 0xE3, 0xBC, 0x1D, 0xC3, 0xB8,
  0x1F, 0xC3, 0xB8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xC1, 0xF8,
  0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x78, 0x3C, 0xF0,
  0x79, 0xE1, 0xE1, 0xE3, 0xC3, 0xC7, 0x83, 0x9E, 0x07, 0xBC, 0x0F, 0x70,
  0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xF8, 0x07, 0xF0, 0x1E, 0xE0, 0x3D, 0xE0, 0xF1, 0xC1, 0xE3, 0xC3, 0xC7,
  0x8F, 0x07, 0x9E, 0x0F, 0x78, 0x1F, 0xF0, 0x1F, 0xE0, 0x79, 0xE0, 0xF3,
  0xC1, 0xE7, 0x87, 0x87, 0x8F, 0x0F, 0x1C, 0x0E, 0x78, 0x1E, 0xF0, 0x3D,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x07, 0x80,
  0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x01,
  0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xFF,
  0xFF, 0xE0, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00,
  0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x07, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xB8, 0x0E, 0x78, 0x3C, 0x70,
  0x70, 0xF1, 0xE0, 0xE3, 0x81, 0xCF, 0x01, 0xDC, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0xF8, 0xF0, 0xF0, 0xE0, 0x1F, 0xC7, 0xFE, 0x3F, 0xE2,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF1, 0xFF, 0x3F, 0xF7, 0xFF, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0xFF, 0x7F, 0x73, 0xE7, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0xF8, 0xFF,
  0xE7, 0xFF, 0xBE, 0x3D, 0xE1, 0xEF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0x7C, 0x7B, 0xFF, 0xDD,
  0xFC, 0xE7, 0xC0, 0x0F, 0xC7, 0xFC, 0xFF, 0x3E, 0x27, 0x80, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xF0, 0x1E, 0x09,
  0xFF, 0x3F, 0xE3, 0xF8, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE3, 0xEF, 0x3F, 0xFB, 0xFF, 0xDE, 0x3E, 0xF0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xF7, 0x87, 0xBC, 0x7D, 0xFF, 0xE7, 0xF7, 0x1F, 0x38, 0x0F, 0x83, 0xFE,
  0x3F, 0xE7, 0x8F, 0x70, 0x77, 0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x13, 0xFF, 0x3F, 0xF0, 0xFE,
  0x0F, 0xC7, 0xF1, 0xFC, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xFE, 0xFF, 0xBF,
  0xE3, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x1F, 0x39, 0xFD, 0xDF,
  0xFE, 0xF1, 0xF7, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xBC, 0x3D, 0xE3, 0xEF, 0xFF, 0x3F, 0xF8,
  0xFB, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xA0, 0x3D, 0xC7, 0xCF, 0xFE, 0x7F,
  0xE0, 0xFC, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x7C, 0xFF, 0xEF, 0xFF, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0x6F, 0xFF, 0x60, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x3C, 0x78, 0xF0, 0xC0, 0x00,
  0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xF7, 0xBF, 0x7E, 0xF0, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x0F,
  0xF0, 0xF7, 0x8F, 0x3C, 0x71, 0xE7, 0x8F, 0x78, 0x7B, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x87, 0xDC, 0x3C, 0xF1, 0xE3, 0x8F, 0x1E, 0x78, 0xF3, 0xC3,
  0xDE, 0x1E, 0xF0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0xC7, 0xCE, 0xFE, 0xFE, 0xFF, 0xFF,
  0xEF, 0x9F, 0x9F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F,
  0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0,
  0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF,
  0x0F, 0x0F, 0xE7, 0xCE, 0xFE, 0xFF, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x0F, 0xC1, 0xFF, 0x0F, 0xFC, 0xF1, 0xE7,
  0x87, 0xB8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xE0,
  0xF7, 0x07, 0xBC, 0x3D, 0xE3, 0xC7, 0xFE, 0x3F, 0xE0, 0x7E, 0x00, 0xE7,
  0xC7, 0x7F, 0x3F, 0xFD, 0xF1, 0xEF, 0x0F, 0x78, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x7B, 0xE3, 0xDF,
  0xFE, 0xFF, 0xE7, 0xBE, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1F, 0x39, 0xFD, 0xDF, 0xFE, 0xF1,
  0xF7, 0x87, 0xB8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xBC, 0x3D, 0xE3, 0xEF, 0xFF, 0x3F, 0xF8, 0xFB, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0xE7, 0xF7, 0xBB, 0xDF, 0xEF, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x00, 0x3F, 0x9F,
  0xFF, 0xFB, 0xC2, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x7F, 0x07, 0xE0, 0xF8,
  0x0F, 0x03, 0xC0, 0xFC, 0x3F, 0xFE, 0xFF, 0xBF, 0xC0, 0x1C, 0x0E, 0x07,
  0x03, 0x83, 0xFF, 0xFF, 0xFE, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xF1, 0xF8, 0x7C, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0xFF, 0x7F, 0x73,
  0xE7, 0xF0, 0x3F, 0xC1, 0xE7, 0x07, 0x9E, 0x1E, 0x78, 0x70, 0xE1, 0xC3,
  0x8F, 0x0F, 0x3C, 0x3C, 0xE0, 0x73, 0x81, 0xDE, 0x07, 0x78, 0x1F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0xF0, 0x78, 0x3B,
  0x87, 0xC3, 0xDC, 0x3E, 0x1E, 0xF1, 0xF0, 0xF7, 0x8F, 0xC7, 0x3C, 0x6E,
  0x38, 0xE7, 0x73, 0xC7, 0x3B, 0x9E, 0x3D, 0xCC, 0xE1, 0xEE, 0x77, 0x0F,
  0x63, 0xB8, 0x3B, 0x1F, 0xC1, 0xD8, 0xFE, 0x0F, 0xC7, 0xE0, 0x7E, 0x1F,
  0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x78, 0x3C, 0x00, 0xF8, 0x7B, 0xC7,
  0x8E, 0x3C, 0x79, 0xC3, 0xDE, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0x80,
  0x7C, 0x03, 0xF0, 0x3F, 0x81, 0xDE, 0x1E, 0xF0, 0xF3, 0xCF, 0x1E, 0x78,
  0x77, 0x83, 0xC0, 0xF0, 0x3F, 0xC1, 0xE7, 0x87, 0x9E, 0x1E, 0x78, 0x70,
  0xE1, 0xC3, 0x8F, 0x0F, 0x3C, 0x3C, 0xE0, 0x73, 0x81, 0xDE, 0x07, 0xF8,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x05, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xE0,
  0x00, 0xFF, 0xBF, 0xEF, 0xF8, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x78, 0x1E,
  0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x87, 0xC3, 0xE3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xC7, 0xE3, 0xC1, 0xF0, 0x7C, 0x0E, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xE1, 0xF0, 0x78, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xC0, 0x3E, 0x0F, 0xC1, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x78, 0x1E, 0x03, 0xF0, 0x7C, 0x3F, 0x1F, 0x87,
  0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x0F, 0xC3,
  0xF0, 0xF8, 0x00, 0x7C, 0x0F, 0xF8, 0xFF, 0xFF, 0x0F, 0xF8, 0x0E, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBold33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 24, 8, 2, -24 },
  { 13, 10, 9, 14, 2, -24 },
  { 25, 15, 24, 16, 1, -24 },
  { 70, 13, 27, 15, 1, -25 },
  { 114, 22, 24, 24, 1, -24 },
  { 180, 16, 24, 17, 1, -24 },
  { 228, 4, 9, 7, 2, -24 },
  { 233, 7, 29, 10, 2, -24 },
  { 259, 8, 29, 10, 1, -24 },
  { 288, 12, 12, 14, 1, -25 },
  { 306, 13, 16, 15, 1, -20 },
  { 332, 5, 8, 8, 1, -4 },
  { 337, 8, 4, 10, 1, -11 },
  { 341, 4, 5, 8, 2, -5 },
  { 344, 13, 24, 13, 0, -24 },
  { 383, 13, 24, 15, 1, -24 },
  { 422, 9, 24, 15, 2, -24 },
  { 449, 12, 24, 15, 1, -24 },
  { 485, 12, 24, 15, 1, -24 },
  { 521, 13, 24, 15, 1, -24 },
  { 560, 11, 24, 15, 2, -24 },
  { 593, 13, 24, 15, 1, -24 },
  { 632, 13, 24, 15, 1, -24 },
  { 671, 13, 24, 15, 1, -24 },
  { 710, 13, 24, 15, 1, -24 },
  { 749, 4, 18, 8, 2, -18 },
  { 758, 5, 22, 8, 1, -18 },
  { 772, 13, 15, 15, 1, -19 },
  { 797, 13, 9, 15, 1, -16 },
  { 812, 13, 15, 15, 1, -19 },
  { 837, 11, 24, 12, 0, -24 },
  { 870, 21, 27, 23, 1, -24 },
  { 941, 16, 24, 16, 0, -24 },
  { 989, 13, 24, 17, 2, -24 },
  { 1028, 13, 24, 15, 2, -24 },
  { 1067, 14, 24, 18, 2, -24 },
  { 1109, 10, 24, 14, 2, -24 },
  { 1139, 10, 24, 14, 2, -24 },
  { 1169, 14, 24, 18, 2, -24 },
  { 1211, 14, 24, 19, 2, -24 },
  { 1253, 8, 24, 10, 1, -24 },
  { 1277, 8, 31, 8, -2, -24 },
  { 1308, 14, 24, 16, 2, -24 },
  { 1350, 10, 24, 13, 2, -24 },
  { 1380, 21, 24, 25, 2, -24 },
  { 1443, 16, 24, 20, 2, -24 },
  { 1491, 16, 24, 19, 2, -24 },
  { 1539, 13, 24, 16, 2, -24 },
  { 1578, 16, 30, 19, 2, -24 },
  { 1638, 14, 24, 16, 2, -24 },
  { 1680, 12, 24, 14, 1, -24 },
  { 1716, 13, 24, 14, 0, -24 },
  { 1755, 14, 24, 18, 2, -24 },
  { 1797, 16, 24, 16, 0, -24 },
  { 1845, 24, 24, 24, 0, -24 },
  { 1917, 15, 24, 15, 0, -24 },
  { 1962, 15, 24, 15, 0, -24 },
  { 2007, 11, 24, 13, 1, -24 },
  { 2040, 7, 29, 10, 2, -24 },
  { 2066, 13, 24, 13, 0, -24 },
  { 2105, 7, 29, 10, 1, -24 },
  { 2131, 15, 14, 16, 1, -24 },
  { 2158, 14, 2, 14, 0, 3 },
  { 2162, 7, 5, 10, 1, -25 },
  { 2167, 12, 18, 15, 1, -18 },
  { 2194, 13, 25, 16, 2, -25 },
  { 2235, 11, 18, 13, 1, -18 },
  { 2260, 13, 25, 16, 1, -25 },
  { 2301, 12, 18, 15, 1, -18 },
  { 2328, 10, 25, 9, 0, -25 },
  { 2360, 13, 26, 16, 1, -18 },
  { 2403, 12, 25, 16, 2, -25 },
  { 2441, 4, 25, 8, 2, -25 },
  { 2454, 7, 33, 8, -1, -25 },
  { 2483, 13, 25, 15, 2, -25 },
  { 2524, 4, 25, 8, 2, -25 },
  { 2537, 20, 18, 24, 2, -18 },
  { 2582, 12, 18, 16, 2, -18 },
  { 2609, 13, 18, 16, 1, -18 },
  { 2639, 13, 26, 16, 2, -18 },
  { 2682, 13, 26, 16, 1, -18 },
  { 2725, 9, 18, 11, 2, -18 },
  { 2746, 10, 18, 12, 1, -18 },
  { 2769, 9, 22, 10, 0, -22 },
  { 2794, 12, 18, 16, 2, -18 },
  { 2821, 14, 18, 14, 0, -18 },
  { 2853, 21, 18, 21, 0, -18 },
  { 2901, 13, 18, 13, 0, -18 },
  { 2931, 14, 26, 14, 0, -18 },
  { 2977, 10, 18, 11, 1, -18 },
  { 3000, 9, 29, 12, 1, -24 },
  { 3033, 4, 33, 14, 5, -25 },
  { 3050, 10, 29, 12, 1, -24 },
  { 3087, 13, 5, 15, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBold33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBold33pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBold33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLD33PT7B_H_
