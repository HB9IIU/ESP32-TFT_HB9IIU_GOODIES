#ifndef _NOTOSANS_CONDENSED_ITALIC20PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC4, 0x23, 0x18, 0x84, 0x23, 0x00, 0x0C, 0x60, 0x6D, 0x2C,
  0xB6, 0x90, 0x04, 0xC3, 0x20, 0x88, 0x24, 0x3F, 0xD6, 0x41, 0x30, 0x48,
  0xFF, 0xBF, 0xE2, 0x41, 0x90, 0x4C, 0x12, 0x00, 0x02, 0x03, 0x07, 0xE6,
  0x92, 0x41, 0x20, 0xE0, 0x38, 0x0E, 0x05, 0x02, 0x82, 0x4D, 0xE7, 0xE0,
  0x40, 0x40, 0x38, 0x66, 0x8C, 0x48, 0x8C, 0x90, 0xC9, 0x08, 0xA6, 0x96,
  0xAF, 0x53, 0x0D, 0x30, 0x92, 0x13, 0x23, 0x32, 0x23, 0x46, 0x1C, 0x0F,
  0x06, 0x41, 0x10, 0x4C, 0x12, 0x07, 0x01, 0x80, 0xF3, 0x6C, 0xB1, 0xEC,
  0x73, 0x0C, 0xCF, 0x1E, 0x60, 0x6B, 0x68, 0x06, 0x10, 0x60, 0x83, 0x04,
  0x18, 0x30, 0x40, 0x81, 0x06, 0x04, 0x08, 0x10, 0x20, 0x60, 0x18, 0x20,
  0x83, 0x0C, 0x30, 0xC3, 0x08, 0x21, 0x84, 0x30, 0xC6, 0x10, 0xC0, 0x19,
  0x23, 0xC9, 0xF3, 0x99, 0x13, 0x00, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF,
  0x18, 0x18, 0x18, 0x18, 0x36, 0x64, 0x80, 0xF8, 0xF8, 0x01, 0x80, 0x80,
  0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x0C, 0x04, 0x06,
  0x00, 0x1E, 0x32, 0x63, 0x63, 0x43, 0xC3, 0xC2, 0xC2, 0x86, 0x86, 0x84,
  0x8C, 0xD8, 0x70, 0x1C, 0xEF, 0x96, 0x18, 0x41, 0x0C, 0x30, 0xC2, 0x18,
  0x61, 0x80, 0x1F, 0x18, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x18, 0x08, 0x0C,
  0x0C, 0x0C, 0x0C, 0x0C, 0x07, 0xF0, 0x3F, 0x08, 0xC0, 0x60, 0x30, 0x30,
  0x30, 0x70, 0x1C, 0x02, 0x01, 0x00, 0x80, 0xC8, 0xC7, 0xC0, 0x03, 0x81,
  0x81, 0x41, 0xE0, 0xB0, 0x90, 0xC8, 0xCC, 0x46, 0x7F, 0xBF, 0xC0, 0x80,
  0xC0, 0x60, 0x1F, 0x88, 0x04, 0x06, 0x03, 0x01, 0xE0, 0xF8, 0x06, 0x03,
  0x01, 0x80, 0x80, 0xC8, 0xE7, 0xC0, 0x0F, 0x18, 0x20, 0x60, 0x40, 0xDC,
  0xEE, 0xC6, 0xC6, 0x86, 0x86, 0x84, 0xCC, 0x78, 0x7F, 0x03, 0x02, 0x06,
  0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0xC0, 0x1F, 0x08,
  0xCC, 0x66, 0x33, 0x10, 0xF0, 0x70, 0x6C, 0x62, 0x61, 0xB0, 0xD8, 0x4E,
  0x63, 0xE0, 0x1F, 0x18, 0x8C, 0x64, 0x36, 0x13, 0x09, 0x8C, 0x7E, 0x1B,
  0x01, 0x01, 0x80, 0x89, 0xC7, 0xC0, 0x33, 0x20, 0x00, 0x00, 0x0C, 0xC0,
  0x18, 0xC6, 0x00, 0x00, 0x00, 0x01, 0x98, 0x8C, 0x40, 0x01, 0x03, 0x0E,
  0x38, 0xE0, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0xC0, 0x70, 0x1C, 0x07, 0x07, 0x1C, 0x70, 0xC0, 0x7D, 0x30, 0x41,
  0x0C, 0x63, 0x18, 0x41, 0x00, 0x00, 0xC3, 0x00, 0x0F, 0xC1, 0x82, 0x30,
  0x32, 0x01, 0x47, 0x94, 0x99, 0x99, 0x19, 0x13, 0x91, 0x29, 0x32, 0x95,
  0x48, 0x98, 0x80, 0x0C, 0x00, 0x77, 0x01, 0xC0, 0x03, 0x03, 0x81, 0x40,
  0xA0, 0xD0, 0x48, 0x66, 0x23, 0x3F, 0x98, 0xD8, 0x6C, 0x3C, 0x1E, 0x0C,
  0x1F, 0x86, 0x61, 0x0C, 0xC3, 0x30, 0x8C, 0x63, 0xE0, 0x8C, 0x61, 0x18,
  0x66, 0x11, 0x0C, 0x46, 0x3F, 0x00, 0x02, 0x07, 0xC6, 0x26, 0x06, 0x03,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x03, 0x21, 0xF0, 0x1F,
  0x86, 0x61, 0x0C, 0xC3, 0x30, 0xCC, 0x32, 0x0C, 0x83, 0x60, 0x98, 0x66,
  0x19, 0x0C, 0x5E, 0x3E, 0x00, 0x1F, 0x8C, 0x04, 0x06, 0x03, 0x01, 0x88,
  0xF8, 0x40, 0x60, 0x30, 0x18, 0x08, 0x04, 0x07, 0xE0, 0x1F, 0x8C, 0x04,
  0x06, 0x03, 0x01, 0x80, 0xF8, 0x7C, 0x60, 0x30, 0x18, 0x08, 0x04, 0x06,
  0x00, 0x02, 0x03, 0xF1, 0x84, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x1E, 0xC7,
  0xB0, 0x6C, 0x1B, 0x04, 0xC3, 0x18, 0xC3, 0xF0, 0x18, 0x63, 0x0C, 0x41,
  0x98, 0x23, 0x04, 0x61, 0x8F, 0xF1, 0x06, 0x60, 0x8C, 0x31, 0x86, 0x20,
  0xC4, 0x11, 0x86, 0x00, 0x1F, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18,
  0x18, 0x10, 0x30, 0x30, 0x30, 0xF8, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06,
  0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0xF0, 0xE0,
  0x18, 0xE3, 0x30, 0x46, 0x19, 0x83, 0x60, 0x78, 0x0B, 0x01, 0xE0, 0x64,
  0x0C, 0xC1, 0x98, 0x23, 0x04, 0x21, 0x86, 0x00, 0x18, 0x61, 0x0C, 0x30,
  0xC2, 0x08, 0x61, 0x86, 0x10, 0x43, 0xF0, 0x1C, 0x0C, 0x70, 0x71, 0xC1,
  0xCF, 0x0F, 0x3C, 0x28, 0xF1, 0xA2, 0x45, 0x89, 0x36, 0x64, 0x99, 0x96,
  0x46, 0x51, 0x11, 0xCC, 0x46, 0x33, 0x18, 0xC0, 0x18, 0x31, 0xC2, 0x1C,
  0x23, 0xC6, 0x34, 0x63, 0x46, 0x26, 0x42, 0x64, 0x62, 0xC6, 0x2C, 0x63,
  0x84, 0x38, 0x41, 0x8C, 0x18, 0x1F, 0x8E, 0x63, 0x0D, 0x83, 0x60, 0xF0,
  0x3C, 0x0F, 0x02, 0xC1, 0xB0, 0x6C, 0x13, 0x0C, 0x66, 0x1F, 0x00, 0x1F,
  0x0C, 0xC4, 0x26, 0x13, 0x19, 0x8C, 0x8C, 0x7C, 0x60, 0x30, 0x18, 0x08,
  0x04, 0x06, 0x00, 0x1F, 0x8E, 0x63, 0x0D, 0x83, 0x60, 0xF0, 0x3C, 0x0F,
  0x02, 0xC1, 0xB0, 0x6C, 0x13, 0x0C, 0x66, 0x1F, 0x00, 0xC0, 0x30, 0x06,
  0x00, 0x1F, 0x0C, 0xC4, 0x26, 0x13, 0x19, 0x8C, 0x8C, 0x7C, 0x64, 0x33,
  0x19, 0x88, 0xC4, 0x26, 0x18, 0x1F, 0x98, 0x8C, 0x04, 0x03, 0x01, 0x80,
  0x70, 0x18, 0x06, 0x03, 0x01, 0x80, 0xC8, 0xC7, 0xC0, 0xFE, 0x60, 0xC1,
  0x83, 0x04, 0x18, 0x30, 0x60, 0x81, 0x06, 0x0C, 0x18, 0x00, 0x30, 0xC8,
  0x32, 0x09, 0x82, 0x61, 0x98, 0x64, 0x1B, 0x04, 0xC1, 0x30, 0xCC, 0x33,
  0x08, 0xC6, 0x1F, 0x00, 0x81, 0xC1, 0xB0, 0x98, 0xCC, 0x46, 0x63, 0x31,
  0xB0, 0xD8, 0x68, 0x3C, 0x1C, 0x0E, 0x06, 0x00, 0x83, 0x0E, 0x1C, 0x68,
  0x71, 0xA1, 0xC4, 0x8F, 0x32, 0x2C, 0xC9, 0xB6, 0x24, 0xD8, 0xB3, 0x42,
  0xCF, 0x0A, 0x38, 0x38, 0xA0, 0xC3, 0x83, 0x0C, 0x00, 0x18, 0x61, 0x18,
  0x26, 0x06, 0x80, 0xF0, 0x1C, 0x01, 0x80, 0x70, 0x1E, 0x02, 0xC0, 0xC8,
  0x31, 0x06, 0x31, 0x86, 0x00, 0xC3, 0xC6, 0xCC, 0xCC, 0xD8, 0x50, 0x70,
  0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0x1F, 0xC0, 0x20, 0x18, 0x0C,
  0x03, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x04, 0x03, 0x01, 0x80, 0x60, 0x3F,
  0x80, 0x1E, 0x20, 0x41, 0x83, 0x06, 0x08, 0x10, 0x60, 0xC1, 0x02, 0x04,
  0x18, 0x30, 0x40, 0xF0, 0xDB, 0x24, 0x93, 0x6D, 0x92, 0x40, 0x1E, 0x0C,
  0x18, 0x20, 0x41, 0x83, 0x06, 0x08, 0x10, 0x60, 0xC1, 0x02, 0x04, 0x18,
  0xF0, 0x0C, 0x07, 0x07, 0x82, 0x43, 0x31, 0x19, 0x85, 0x83, 0xFE, 0xC9,
  0x80, 0x1D, 0x37, 0x63, 0x43, 0xC2, 0xC6, 0x86, 0x86, 0x8C, 0xDC, 0xF4,
  0x18, 0x0C, 0x04, 0x02, 0x03, 0x71, 0xF8, 0xC6, 0x63, 0x21, 0xB0, 0x98,
  0x4C, 0x66, 0x37, 0x33, 0x70, 0x1E, 0x69, 0x86, 0x0C, 0x18, 0x20, 0x40,
  0x81, 0x91, 0xE0, 0x01, 0x80, 0xC0, 0x60, 0x21, 0xD1, 0xB9, 0x8D, 0x84,
  0xC2, 0x63, 0x21, 0x90, 0xC8, 0xC6, 0xE3, 0xD0, 0x1C, 0x6D, 0x9E, 0x3C,
  0xDF, 0x20, 0x40, 0x81, 0x89, 0xE0, 0x03, 0xC1, 0x80, 0x60, 0x10, 0x0F,
  0x07, 0xC0, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03,
  0x00, 0xC0, 0x30, 0x08, 0x0E, 0x03, 0x00, 0x0E, 0x8D, 0xCC, 0x6C, 0x36,
  0x13, 0x19, 0x0C, 0x86, 0x46, 0x37, 0x1F, 0x80, 0xC0, 0x60, 0x63, 0xF0,
  0xE0, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x71, 0xF8, 0xC6, 0x62, 0x21, 0x31,
  0x98, 0xCC, 0x64, 0x26, 0x13, 0x18, 0x18, 0xC0, 0x03, 0x18, 0xC4, 0x23,
  0x18, 0xC4, 0x63, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x06, 0x06, 0x04,
  0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0xF0, 0xE0,
  0x18, 0x0C, 0x04, 0x02, 0x03, 0x19, 0x98, 0xD8, 0x58, 0x28, 0x3C, 0x1B,
  0x0D, 0x84, 0xC6, 0x23, 0x18, 0x18, 0xC4, 0x23, 0x18, 0xC4, 0x23, 0x18,
  0xC4, 0x63, 0x00, 0x37, 0x31, 0xFB, 0xCC, 0x66, 0x62, 0x32, 0x31, 0xB1,
  0x8D, 0x8C, 0x4C, 0x42, 0x42, 0x36, 0x31, 0xB1, 0x8C, 0x37, 0x1F, 0x8C,
  0x66, 0x22, 0x13, 0x19, 0x8C, 0xC6, 0x42, 0x63, 0x31, 0x80, 0x1C, 0x6D,
  0x8E, 0x1C, 0x38, 0x61, 0xC3, 0x85, 0x99, 0xE0, 0x1B, 0x87, 0x61, 0x8C,
  0x63, 0x10, 0xCC, 0x33, 0x08, 0xC6, 0x31, 0x8C, 0xC6, 0xE1, 0x80, 0x40,
  0x10, 0x0C, 0x03, 0x00, 0x1D, 0x37, 0x63, 0xC3, 0xC2, 0xC6, 0x86, 0x86,
  0x8C, 0xDC, 0xFC, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x36, 0x7C, 0xC1, 0x82,
  0x0C, 0x18, 0x30, 0x41, 0x83, 0x00, 0x1E, 0x6D, 0x83, 0x07, 0x07, 0x07,
  0x06, 0x0D, 0x33, 0xE0, 0x31, 0x1F, 0xF6, 0x21, 0x18, 0xC6, 0x21, 0x0E,
  0x00, 0x63, 0x63, 0x63, 0x42, 0xC2, 0xC6, 0xC6, 0x84, 0x8C, 0xD4, 0xFC,
  0xC3, 0xC6, 0xC4, 0xCC, 0xCC, 0xD8, 0xD8, 0xD0, 0xF0, 0x60, 0x60, 0xC6,
  0x3C, 0x62, 0xCA, 0x6C, 0xA4, 0xDA, 0xCD, 0x2C, 0xD2, 0x8E, 0x78, 0xE7,
  0x0E, 0x70, 0xC7, 0x00, 0x11, 0x88, 0xC6, 0xC3, 0x40, 0xC0, 0x60, 0x70,
  0x28, 0x36, 0x33, 0x31, 0x80, 0x18, 0x63, 0x18, 0x63, 0x0C, 0xC1, 0x98,
  0x12, 0x02, 0xC0, 0x50, 0x0E, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20,
  0x3C, 0x07, 0x00, 0x1F, 0x1F, 0x06, 0x04, 0x0C, 0x18, 0x18, 0x30, 0x20,
  0x60, 0xFC, 0x07, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x30, 0xC0, 0x30,
  0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x30, 0xFF, 0xFF, 0xF0, 0x1C, 0x18,
  0x10, 0x20, 0xC1, 0x83, 0x06, 0x06, 0x10, 0x60, 0x81, 0x06, 0x0C, 0x30,
  0xE0, 0xF9, 0x8F,
};

const GFXglyph NotoSans_Condensed_Italic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 14, 5, 0, -14 },
  { 10, 6, 5, 7, 2, -14 },
  { 14, 10, 14, 10, 0, -14 },
  { 32, 9, 16, 9, 0, -15 },
  { 50, 12, 14, 13, 1, -14 },
  { 71, 10, 14, 10, 0, -14 },
  { 89, 3, 5, 4, 2, -14 },
  { 91, 7, 17, 5, 0, -14 },
  { 106, 6, 17, 5, -1, -14 },
  { 119, 7, 7, 8, 2, -15 },
  { 126, 8, 10, 9, 1, -12 },
  { 136, 4, 5, 4, -1, -2 },
  { 139, 5, 1, 6, 0, -6 },
  { 140, 3, 2, 4, 0, -2 },
  { 141, 9, 14, 7, -1, -14 },
  { 157, 8, 14, 9, 1, -14 },
  { 171, 6, 14, 9, 2, -14 },
  { 182, 9, 14, 9, 0, -14 },
  { 198, 9, 14, 9, 0, -14 },
  { 214, 9, 14, 9, 0, -14 },
  { 230, 9, 14, 9, 0, -14 },
  { 246, 8, 14, 9, 1, -14 },
  { 260, 8, 14, 9, 1, -14 },
  { 274, 9, 14, 9, 0, -14 },
  { 290, 9, 14, 9, 0, -14 },
  { 306, 4, 11, 4, 0, -11 },
  { 312, 5, 14, 4, -1, -11 },
  { 321, 8, 9, 9, 1, -12 },
  { 330, 8, 6, 9, 1, -10 },
  { 336, 8, 9, 9, 1, -12 },
  { 345, 6, 14, 7, 1, -14 },
  { 356, 12, 16, 13, 1, -14 },
  { 380, 9, 14, 9, -1, -14 },
  { 396, 10, 14, 10, 0, -14 },
  { 414, 9, 15, 9, 1, -15 },
  { 431, 10, 14, 11, 0, -14 },
  { 449, 9, 14, 8, 0, -14 },
  { 465, 9, 14, 8, 0, -14 },
  { 481, 10, 15, 11, 1, -15 },
  { 500, 11, 14, 11, 0, -14 },
  { 520, 8, 14, 6, -1, -14 },
  { 534, 8, 18, 4, -3, -14 },
  { 552, 11, 14, 9, 0, -14 },
  { 572, 6, 14, 8, 0, -14 },
  { 583, 14, 14, 14, 0, -14 },
  { 608, 12, 14, 11, 0, -14 },
  { 629, 10, 14, 11, 1, -14 },
  { 647, 9, 14, 9, 0, -14 },
  { 663, 10, 17, 11, 1, -14 },
  { 685, 9, 14, 9, 0, -14 },
  { 701, 9, 14, 8, 0, -14 },
  { 717, 7, 14, 8, 2, -14 },
  { 730, 10, 14, 11, 1, -14 },
  { 748, 9, 14, 9, 2, -14 },
  { 764, 14, 14, 14, 2, -14 },
  { 789, 11, 14, 8, -1, -14 },
  { 809, 8, 14, 8, 2, -14 },
  { 823, 10, 14, 8, -1, -14 },
  { 841, 7, 17, 6, 0, -14 },
  { 856, 3, 14, 7, 2, -14 },
  { 862, 7, 17, 6, -1, -14 },
  { 877, 9, 8, 9, 0, -14 },
  { 886, 7, 1, 7, -2, 2 },
  { 887, 3, 3, 5, 3, -15 },
  { 889, 8, 11, 9, 1, -11 },
  { 900, 9, 15, 9, 0, -15 },
  { 917, 7, 11, 7, 1, -11 },
  { 927, 9, 15, 9, 1, -15 },
  { 944, 7, 11, 8, 1, -11 },
  { 954, 10, 20, 5, -2, -15 },
  { 979, 9, 16, 9, 0, -11 },
  { 997, 9, 15, 9, 0, -15 },
  { 1014, 5, 15, 4, 0, -15 },
  { 1024, 8, 20, 4, -3, -15 },
  { 1044, 9, 15, 8, 0, -15 },
  { 1061, 5, 15, 4, 0, -15 },
  { 1071, 13, 11, 14, 0, -11 },
  { 1089, 9, 11, 9, 0, -11 },
  { 1102, 7, 11, 9, 1, -11 },
  { 1112, 10, 16, 9, -1, -11 },
  { 1132, 8, 16, 9, 1, -11 },
  { 1148, 7, 11, 6, 0, -11 },
  { 1158, 7, 11, 7, 0, -11 },
  { 1168, 5, 13, 5, 1, -13 },
  { 1177, 8, 11, 9, 1, -11 },
  { 1188, 8, 11, 8, 1, -11 },
  { 1199, 12, 11, 12, 1, -11 },
  { 1216, 9, 11, 8, -1, -11 },
  { 1229, 11, 16, 8, -2, -11 },
  { 1251, 8, 11, 7, -1, -11 },
  { 1262, 8, 17, 7, 0, -14 },
  { 1279, 1, 20, 8, 4, -15 },
  { 1282, 7, 17, 7, -1, -14 },
  { 1297, 8, 2, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_Italic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic20pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_CONDENSED_ITALIC20PT7B_H_
