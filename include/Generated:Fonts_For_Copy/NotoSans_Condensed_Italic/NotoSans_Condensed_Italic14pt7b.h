#ifndef _NOTOSANS_CONDENSED_ITALIC14PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x22, 0x44, 0x40, 0x4C, 0x55, 0x59, 0x12, 0x28, 0x53, 0xF2,
  0x85, 0x3F, 0x24, 0x51, 0xA0, 0x08, 0x23, 0xD4, 0x50, 0xC1, 0x8A, 0x2B,
  0xE2, 0x08, 0x62, 0x94, 0xA4, 0xA8, 0xAF, 0xD5, 0x29, 0x29, 0x4A, 0xCE,
  0x18, 0x48, 0xB1, 0x43, 0x0A, 0x75, 0x46, 0x88, 0xE8, 0x56, 0x19, 0x88,
  0x84, 0x23, 0x10, 0x84, 0x10, 0x80, 0x11, 0x11, 0x11, 0x11, 0x22, 0x4C,
  0x14, 0xBE, 0x65, 0x08, 0x21, 0x09, 0xF2, 0x10, 0x2D, 0x40, 0xF0, 0x70,
  0x06, 0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x41, 0x80, 0x1C, 0x96, 0x51,
  0x45, 0x14, 0xB2, 0x59, 0xC0, 0x3E, 0xB4, 0x92, 0xD0, 0x3C, 0x90, 0x41,
  0x08, 0x43, 0x18, 0xC3, 0xE0, 0x3C, 0x90, 0x43, 0x38, 0x60, 0x82, 0x1B,
  0xC0, 0x0C, 0x31, 0xCA, 0x29, 0x28, 0xBF, 0x10, 0x40, 0x3C, 0x82, 0x10,
  0x78, 0x20, 0x82, 0x1B, 0xC0, 0x1C, 0xC2, 0x10, 0x79, 0x34, 0xF2, 0x49,
  0xC0, 0xFC, 0x21, 0x84, 0x30, 0x86, 0x10, 0xC2, 0x00, 0x3C, 0x92, 0x4B,
  0x39, 0xEC, 0xA2, 0x89, 0xC0, 0x38, 0x94, 0x51, 0x4D, 0xD0, 0x82, 0x13,
  0x80, 0x2C, 0x00, 0x16, 0x13, 0x00, 0x00, 0x24, 0x48, 0x09, 0xB1, 0x83,
  0x04, 0xF8, 0x01, 0xF0, 0x83, 0x06, 0x36, 0x40, 0x78, 0x42, 0x33, 0x11,
  0x00, 0x46, 0x00, 0x0F, 0x08, 0x48, 0x29, 0xD5, 0x2A, 0xA6, 0x53, 0x3A,
  0x82, 0x20, 0x0F, 0x00, 0x0C, 0x30, 0xC5, 0x14, 0x93, 0xD9, 0x47, 0x10,
  0x3C, 0x4C, 0x89, 0x27, 0x89, 0x91, 0x22, 0xCD, 0xF0, 0x3D, 0x84, 0x20,
  0x82, 0x08, 0x20, 0x81, 0xC0, 0x3C, 0x4C, 0x89, 0x14, 0x28, 0x51, 0xA2,
  0xC9, 0xE0, 0x3C, 0x82, 0x08, 0x79, 0x04, 0x10, 0xC3, 0xC0, 0x3C, 0x82,
  0x08, 0x61, 0xE4, 0x10, 0xC2, 0x00, 0x3E, 0xC1, 0x04, 0x08, 0x13, 0xA1,
  0x46, 0x88, 0xF0, 0x21, 0x23, 0x22, 0x22, 0x7E, 0x46, 0x44, 0x44, 0x44,
  0x84, 0x3C, 0x41, 0x04, 0x10, 0xC2, 0x08, 0x23, 0xC0, 0x08, 0x42, 0x11,
  0x88, 0x42, 0x11, 0x09, 0xCC, 0x00, 0x22, 0x48, 0xB1, 0xC5, 0x0E, 0x16,
  0x24, 0xC9, 0x18, 0x22, 0x22, 0x44, 0x44, 0xCF, 0x30, 0xCC, 0x33, 0x1C,
  0xC6, 0x52, 0x94, 0xA5, 0x49, 0x56, 0xD9, 0x26, 0x40, 0x31, 0x31, 0x31,
  0x33, 0x4A, 0x4A, 0x4A, 0x4A, 0xCC, 0x84, 0x3C, 0xC9, 0x1C, 0x38, 0x70,
  0xA1, 0x46, 0x89, 0xE0, 0x3C, 0x48, 0x99, 0x24, 0x4F, 0x10, 0x20, 0xC1,
  0x00, 0x3C, 0xC9, 0x1C, 0x38, 0x70, 0xA1, 0x46, 0x89, 0xE0, 0x40, 0xC0,
  0x3C, 0x48, 0x99, 0x24, 0xCF, 0x16, 0x24, 0xC9, 0x10, 0x3D, 0x84, 0x18,
  0x30, 0x60, 0x82, 0x9B, 0xC0, 0xFC, 0x82, 0x08, 0x61, 0x04, 0x10, 0x43,
  0x00, 0x42, 0x89, 0x16, 0x28, 0x51, 0xA2, 0x44, 0x99, 0xE0, 0x86, 0x18,
  0xA2, 0xD3, 0x4E, 0x18, 0x61, 0x00, 0x8C, 0x63, 0x38, 0xCA, 0x52, 0x95,
  0x29, 0x4A, 0x62, 0x98, 0xC6, 0x31, 0x00, 0x13, 0x12, 0x14, 0x14, 0x18,
  0x18, 0x38, 0x28, 0x4C, 0xC4, 0x8F, 0x25, 0x14, 0x61, 0x84, 0x10, 0x43,
  0x00, 0x3C, 0x30, 0x86, 0x10, 0x86, 0x10, 0x83, 0xE0, 0x39, 0x08, 0x44,
  0x21, 0x08, 0xC4, 0x21, 0xC0, 0xC9, 0x24, 0x92, 0x24, 0x38, 0x42, 0x11,
  0x08, 0x42, 0x21, 0x09, 0xC0, 0x10, 0x62, 0x92, 0x46, 0x10, 0xF8, 0x94,
  0x14, 0xB4, 0x51, 0x4F, 0x2C, 0x9E, 0x20, 0x82, 0x0A, 0x75, 0x94, 0x51,
  0x4F, 0x2B, 0x00, 0x19, 0x50, 0x84, 0x61, 0x0E, 0x02, 0x04, 0x08, 0xA2,
  0xC8, 0x91, 0x26, 0xC9, 0x91, 0xE0, 0x18, 0xB4, 0x96, 0x63, 0x04, 0x1E,
  0x06, 0x18, 0x20, 0x61, 0x83, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x1C,
  0x00, 0x14, 0xB4, 0x51, 0x4F, 0x2C, 0x9E, 0x08, 0x4F, 0x00, 0x30, 0x82,
  0x0A, 0x75, 0x94, 0x53, 0x4B, 0x28, 0x80, 0x20, 0xB4, 0x92, 0xD0, 0x08,
  0x02, 0x31, 0x08, 0x42, 0x31, 0x08, 0x4E, 0x00, 0x30, 0x82, 0x09, 0x69,
  0x67, 0x1C, 0x53, 0x49, 0x80, 0x32, 0x22, 0x64, 0x44, 0x4C, 0x80, 0x29,
  0x2F, 0x59, 0x29, 0x94, 0x8A, 0x4F, 0x25, 0x12, 0x29, 0x56, 0x51, 0x4D,
  0x2C, 0xA2, 0x18, 0xB4, 0x51, 0x47, 0x24, 0x9C, 0x14, 0x74, 0xC9, 0x12,
  0x24, 0xD9, 0x2C, 0x40, 0x83, 0x00, 0x14, 0xB4, 0x51, 0x4F, 0x2C, 0x9E,
  0x08, 0x61, 0x00, 0x2A, 0xD8, 0x84, 0x23, 0x10, 0x32, 0x50, 0xC3, 0x08,
  0x5C, 0x27, 0x24, 0x44, 0x4C, 0x60, 0x25, 0x94, 0x51, 0x49, 0x2D, 0x9A,
  0x8C, 0xA5, 0x6A, 0x53, 0x18, 0x99, 0x9B, 0xAA, 0xAA, 0xAC, 0xCC, 0xC8,
  0x88, 0x22, 0x48, 0x60, 0xC1, 0x05, 0x1A, 0x64, 0x22, 0x4C, 0x91, 0x62,
  0x85, 0x0C, 0x18, 0x20, 0x43, 0x00, 0x78, 0xC4, 0x42, 0x22, 0x1E, 0x1C,
  0x41, 0x08, 0x21, 0x8C, 0x08, 0x41, 0x04, 0x18, 0xFF, 0xFC, 0x10, 0x42,
  0x21, 0x0C, 0x66, 0x21, 0x09, 0x80, 0xCD, 0xC0,
};

const GFXglyph NotoSans_Condensed_Italic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 10, 3, 0, -10 },
  { 6, 4, 4, 5, 1, -10 },
  { 8, 7, 10, 7, 0, -10 },
  { 17, 6, 12, 6, 0, -11 },
  { 26, 8, 10, 9, 1, -10 },
  { 36, 7, 10, 7, 0, -10 },
  { 45, 2, 4, 3, 1, -10 },
  { 46, 5, 12, 4, 0, -10 },
  { 54, 4, 12, 4, -1, -10 },
  { 60, 5, 6, 6, 1, -11 },
  { 64, 5, 6, 7, 1, -8 },
  { 68, 3, 4, 3, -1, -2 },
  { 70, 4, 1, 4, 0, -4 },
  { 71, 2, 2, 3, 0, -2 },
  { 72, 7, 10, 5, -1, -10 },
  { 81, 6, 10, 6, 0, -10 },
  { 89, 3, 10, 6, 2, -10 },
  { 93, 6, 10, 6, 0, -10 },
  { 101, 6, 10, 6, 0, -10 },
  { 109, 6, 10, 6, 0, -10 },
  { 117, 6, 10, 6, 0, -10 },
  { 125, 6, 10, 6, 0, -10 },
  { 133, 6, 10, 6, 1, -10 },
  { 141, 6, 10, 6, 0, -10 },
  { 149, 6, 10, 6, 0, -10 },
  { 157, 3, 8, 3, 0, -8 },
  { 160, 4, 10, 3, -1, -8 },
  { 165, 5, 6, 7, 1, -8 },
  { 169, 5, 4, 7, 1, -7 },
  { 172, 5, 6, 7, 1, -8 },
  { 176, 5, 10, 5, 0, -10 },
  { 183, 9, 11, 9, 0, -10 },
  { 196, 6, 10, 6, -1, -10 },
  { 204, 7, 10, 7, 0, -10 },
  { 213, 6, 10, 6, 1, -10 },
  { 221, 7, 10, 7, 0, -10 },
  { 230, 6, 10, 6, 0, -10 },
  { 238, 6, 10, 5, 0, -10 },
  { 246, 7, 10, 8, 1, -10 },
  { 255, 8, 10, 8, 0, -10 },
  { 265, 6, 10, 4, -1, -10 },
  { 273, 5, 13, 3, -2, -10 },
  { 282, 7, 10, 6, 0, -10 },
  { 291, 4, 10, 5, 0, -10 },
  { 296, 10, 10, 10, 0, -10 },
  { 309, 8, 10, 8, 0, -10 },
  { 319, 7, 10, 8, 1, -10 },
  { 328, 7, 10, 6, 0, -10 },
  { 337, 7, 12, 8, 1, -10 },
  { 348, 7, 10, 7, 0, -10 },
  { 357, 6, 10, 6, 0, -10 },
  { 365, 6, 10, 5, 1, -10 },
  { 373, 7, 10, 7, 1, -10 },
  { 382, 6, 10, 6, 1, -10 },
  { 390, 10, 10, 10, 1, -10 },
  { 403, 8, 10, 6, -1, -10 },
  { 413, 6, 10, 6, 1, -10 },
  { 421, 6, 10, 6, 0, -10 },
  { 429, 5, 12, 4, 0, -10 },
  { 437, 3, 10, 5, 1, -10 },
  { 441, 5, 12, 4, -1, -10 },
  { 449, 6, 6, 6, 0, -10 },
  { 454, 5, 1, 5, -1, 1 },
  { 455, 2, 3, 4, 2, -11 },
  { 456, 6, 8, 7, 0, -8 },
  { 462, 6, 11, 7, 0, -11 },
  { 471, 5, 8, 5, 0, -8 },
  { 476, 7, 11, 7, 0, -11 },
  { 486, 6, 8, 6, 0, -8 },
  { 492, 7, 14, 4, -2, -11 },
  { 505, 6, 11, 7, 0, -8 },
  { 514, 6, 11, 6, 0, -11 },
  { 523, 3, 10, 3, 0, -10 },
  { 527, 5, 13, 3, -2, -10 },
  { 536, 6, 11, 6, 0, -11 },
  { 545, 4, 11, 3, 0, -11 },
  { 551, 9, 8, 10, 0, -8 },
  { 560, 6, 8, 6, 0, -8 },
  { 566, 6, 8, 6, 0, -8 },
  { 572, 7, 11, 7, -1, -8 },
  { 582, 6, 11, 7, 0, -8 },
  { 591, 5, 8, 4, 0, -8 },
  { 596, 5, 8, 5, 0, -8 },
  { 601, 4, 9, 4, 0, -9 },
  { 606, 6, 8, 6, 0, -8 },
  { 612, 5, 8, 5, 1, -8 },
  { 617, 8, 8, 8, 1, -8 },
  { 625, 7, 8, 5, -1, -8 },
  { 632, 7, 11, 5, -1, -8 },
  { 642, 5, 8, 5, 0, -8 },
  { 647, 6, 12, 5, 0, -10 },
  { 656, 1, 14, 6, 3, -11 },
  { 658, 5, 12, 5, -1, -10 },
  { 666, 5, 2, 7, 1, -6 },
};

const GFXfont NotoSans_Condensed_Italic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic14pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_CONDENSED_ITALIC14PT7B_H_
