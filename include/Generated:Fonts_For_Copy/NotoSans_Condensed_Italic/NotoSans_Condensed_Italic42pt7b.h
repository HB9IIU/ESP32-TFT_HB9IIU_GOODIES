#ifndef _NOTOSANS_CONDENSED_ITALIC42PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F,
  0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0x03, 0xC0,
  0xF0, 0x38, 0x00, 0x3C, 0xF3, 0x8F, 0x38, 0xF7, 0x8E, 0x70, 0xE7, 0x0E,
  0x70, 0xE7, 0x1C, 0x61, 0xCE, 0x1C, 0xE1, 0x80, 0x00, 0x38, 0x70, 0x01,
  0xC3, 0x80, 0x0C, 0x1C, 0x00, 0xE0, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70,
  0x03, 0x83, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFE, 0x03, 0x87, 0x00, 0x18, 0x30, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00,
  0x60, 0xC0, 0x07, 0x06, 0x00, 0x38, 0x70, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x07, 0x0E, 0x00, 0x30, 0x60, 0x03, 0x87, 0x00, 0x1C,
  0x38, 0x00, 0xC1, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x07, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x0F, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3C, 0xC4, 0x0F, 0x38,
  0x01, 0xC6, 0x00, 0x38, 0xC0, 0x07, 0x18, 0x00, 0xE3, 0x00, 0x1E, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x6F, 0x00, 0x0C, 0xF0, 0x01, 0x9E, 0x00, 0x71, 0xC0, 0x0C, 0x78,
  0x01, 0x8E, 0x10, 0x31, 0xC1, 0xC6, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x00,
  0x3F, 0x80, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0xC0, 0x1E, 0x0F, 0xE0, 0x1C, 0x1C, 0xE0, 0x38, 0x1C, 0x60, 0x38,
  0x38, 0x70, 0x70, 0x38, 0x70, 0x60, 0x70, 0x60, 0xE0, 0x70, 0x61, 0xC0,
  0x70, 0xE1, 0xC0, 0x70, 0xE3, 0x80, 0x60, 0xE3, 0x00, 0x60, 0xE7, 0x00,
  0xE1, 0xCE, 0x3E, 0xE1, 0xCE, 0x7F, 0xE3, 0x9C, 0xE7, 0x73, 0x9D, 0xC3,
  0x7F, 0x39, 0xC3, 0x3E, 0x71, 0x83, 0x00, 0x73, 0x83, 0x00, 0xE3, 0x87,
  0x00, 0xE3, 0x87, 0x01, 0xC3, 0x07, 0x01, 0x87, 0x07, 0x03, 0x87, 0x06,
  0x07, 0x07, 0x0E, 0x07, 0x07, 0x0E, 0x0E, 0x07, 0x1C, 0x0C, 0x07, 0xBC,
  0x1C, 0x03, 0xF8, 0x38, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x01,
  0xE7, 0x80, 0x1C, 0x38, 0x03, 0xC3, 0x80, 0x38, 0x38, 0x03, 0x83, 0x80,
  0x38, 0x78, 0x03, 0x87, 0x00, 0x38, 0xF0, 0x03, 0x9E, 0x00, 0x3F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x1E, 0xF0,
  0x71, 0xC7, 0x8F, 0x38, 0x78, 0xE7, 0x83, 0x8E, 0x70, 0x3D, 0xC7, 0x01,
  0xFC, 0xF0, 0x1F, 0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF8,
  0x3F, 0x87, 0xFF, 0xF8, 0x3F, 0xF3, 0xC1, 0xFC, 0x3C, 0x3C, 0xE3, 0x9E,
  0x79, 0xC7, 0x1C, 0x71, 0x8E, 0x00, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x02, 0x0E, 0x06, 0x18, 0x1F, 0x30, 0x3F, 0xFF, 0x87, 0xFF, 0x07,
  0xFE, 0x1F, 0x80, 0x77, 0x01, 0xE7, 0x07, 0x8E, 0x06, 0x1E, 0x04, 0x1C,
  0x00, 0x20, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0F, 0x0E, 0x1E,
  0x1E, 0x1C, 0x3C, 0x38, 0x70, 0x70, 0x60, 0xE0, 0xFF, 0xFF, 0xEF, 0xF8,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0xF0, 0xF0, 0x70, 0x78, 0x78, 0x1C, 0x38, 0x0E, 0x3C, 0x07, 0x1C,
  0x03, 0x8E, 0x01, 0xCF, 0x00, 0xE7, 0x00, 0xF3, 0x80, 0x7B, 0xC0, 0x3D,
  0xE0, 0x1E, 0xF0, 0x0E, 0x70, 0x07, 0x38, 0x07, 0x9C, 0x03, 0xDE, 0x01,
  0xCF, 0x00, 0xE7, 0x80, 0xF3, 0xC0, 0x71, 0xE0, 0x78, 0xF0, 0x38, 0x38,
  0x3C, 0x1E, 0x3C, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xE0,
  0x7C, 0x1F, 0x07, 0xE3, 0xFC, 0xFF, 0xBC, 0xF3, 0x1C, 0x43, 0x80, 0x70,
  0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38,
  0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C,
  0x07, 0x80, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x01,
  0xC0, 0xF0, 0x10, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x1C,
  0x0F, 0x02, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xFF, 0x00,
  0x3E, 0x00, 0x1F, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x0F, 0x08, 0x07, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x06, 0xE0, 0x03, 0xB8, 0x01, 0xDE, 0x00, 0xE7, 0x80, 0x39, 0xC0, 0x1C,
  0x70, 0x0E, 0x1C, 0x03, 0x8F, 0x01, 0xC3, 0x80, 0xE0, 0xE0, 0x38, 0x38,
  0x1C, 0x1E, 0x0E, 0x07, 0x83, 0x81, 0xC1, 0xC0, 0x70, 0xFF, 0xFF, 0xBF,
  0xFF, 0xEF, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFF, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0xC3, 0x01, 0xF0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x7F,
  0xC0, 0x7F, 0xE0, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x3E, 0x07, 0x3F, 0x83,
  0xBF, 0xE3, 0xF8, 0xF1, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x38, 0x07,
  0x9C, 0x03, 0xCE, 0x01, 0xE7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x78, 0xE0,
  0x38, 0x70, 0x3C, 0x3C, 0x3C, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFC, 0x00,
  0x1F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0xF0, 0x0F, 0xFF, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x0E, 0x03, 0xC1, 0xC0,
  0x78, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x78, 0x1E, 0x1E, 0x03, 0xC7,
  0x80, 0x3D, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x0F, 0x3C,
  0x03, 0xC3, 0xC0, 0xF0, 0x38, 0x3C, 0x07, 0x87, 0x00, 0x70, 0xE0, 0x0E,
  0x3C, 0x01, 0xC7, 0x80, 0x38, 0xF0, 0x0F, 0x0E, 0x01, 0xC1, 0xE0, 0x78,
  0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x01, 0xFF,
  0x01, 0xFF, 0xC1, 0xE0, 0xE0, 0xE0, 0x78, 0xF0, 0x3C, 0x70, 0x0E, 0x78,
  0x07, 0x3C, 0x03, 0x9C, 0x03, 0xCE, 0x01, 0xE7, 0x00, 0xF3, 0x80, 0x79,
  0xC0, 0x78, 0xF0, 0x7C, 0x7C, 0x7E, 0x1F, 0xFF, 0x0F, 0xF7, 0x81, 0xE3,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xF0, 0x00,
  0x03, 0x07, 0xC3, 0xE1, 0xE0, 0xF0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0F, 0x0F, 0x87,
  0xC1, 0xC0, 0x00, 0xC0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x38,
  0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01,
  0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x60, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x78, 0x00, 0x30, 0x00, 0x10, 0x00, 0x00, 0x07, 0xF0,
  0x7F, 0xE1, 0xFF, 0xC6, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x07, 0x80, 0x3E, 0x00, 0xF8,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xE1,
  0xF0, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0x60, 0x70,
  0x00, 0x1C, 0x1C, 0x00, 0x07, 0x0E, 0x07, 0xE1, 0xC7, 0x03, 0xFC, 0x31,
  0xC1, 0xEF, 0x0C, 0xE0, 0xE1, 0x83, 0x38, 0x70, 0xE0, 0xCC, 0x18, 0x38,
  0x77, 0x0E, 0x0E, 0x1D, 0xC3, 0x83, 0x07, 0x70, 0xC1, 0xC1, 0x98, 0x70,
  0x70, 0xE6, 0x1C, 0x1C, 0x39, 0x87, 0x0E, 0x0C, 0xE1, 0xC3, 0x87, 0x38,
  0x71, 0xE1, 0x8E, 0x1C, 0x7C, 0xE3, 0x87, 0xF7, 0xF0, 0xE0, 0xF8, 0xF8,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x18, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0x70, 0x00,
  0xEF, 0x00, 0x39, 0xE0, 0x07, 0x3C, 0x01, 0xE7, 0x80, 0x38, 0xF0, 0x0F,
  0x0E, 0x01, 0xC1, 0xC0, 0x78, 0x38, 0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x1E, 0x01, 0xC3, 0xC0,
  0x38, 0xF0, 0x07, 0x1E, 0x00, 0xE7, 0x80, 0x1C, 0xF0, 0x03, 0xBC, 0x00,
  0x77, 0x80, 0x0F, 0xE0, 0x01, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0xE0, 0x3C, 0x1F, 0x03, 0x80, 0xF0, 0x38, 0x0F, 0x07, 0x80, 0x70,
  0x78, 0x07, 0x07, 0x80, 0xF0, 0x70, 0x0F, 0x07, 0x01, 0xE0, 0xF0, 0x1E,
  0x0F, 0x07, 0xC0, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x1E, 0x07,
  0x81, 0xE0, 0x3C, 0x1C, 0x03, 0xC1, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0,
  0x3C, 0x3C, 0x03, 0xC3, 0x80, 0x3C, 0x38, 0x07, 0x87, 0x80, 0xF8, 0x78,
  0x1F, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3E, 0x04, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x08, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0x87, 0xE0, 0x38,
  0x0F, 0x01, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78,
  0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80,
  0x3C, 0x38, 0x01, 0xE1, 0xC0, 0x0F, 0x1E, 0x00, 0x70, 0xF0, 0x07, 0x87,
  0x00, 0x3C, 0x38, 0x01, 0xE3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x0F,
  0x07, 0x00, 0xF8, 0x38, 0x0F, 0x83, 0xC0, 0xF8, 0x1E, 0x1F, 0x80, 0xFF,
  0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x81, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x81, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFE, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0xC0, 0x7F, 0xFE, 0x07, 0xC0, 0x60, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x7F, 0x9E, 0x03,
  0xFC, 0xF0, 0x1F, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x71, 0xE0, 0x03, 0x8F,
  0x00, 0x1C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x70, 0xF0, 0x03,
  0x83, 0xC0, 0x3C, 0x1F, 0x01, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x78, 0x03, 0xC1, 0xE0,
  0x0F, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x83, 0xC0, 0x1E,
  0x0F, 0x00, 0x78, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x07, 0x80, 0x1C, 0x1E,
  0x00, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3C, 0x01,
  0xE0, 0xF0, 0x07, 0x83, 0x80, 0x1E, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC1,
  0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x83, 0xC0,
  0x0E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xE0, 0x07, 0x03, 0x80, 0x1C,
  0x00, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x8F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x3C,
  0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x03, 0x81, 0xE0, 0x0E,
  0x0F, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x1C, 0x78,
  0x00, 0x73, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x78, 0x00, 0x3B, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xC3,
  0x80, 0x07, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC1, 0xC0,
  0x0E, 0x07, 0x80, 0x38, 0x1E, 0x01, 0xE0, 0x38, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x70, 0x0F, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x00,
  0x7C, 0x07, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7F,
  0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3B, 0x81,
  0xDC, 0x01, 0xFE, 0x07, 0x70, 0x07, 0x78, 0x1D, 0xC0, 0x3D, 0xC0, 0x77,
  0x00, 0xE7, 0x03, 0xDC, 0x03, 0xBC, 0x0F, 0x70, 0x1C, 0xF0, 0x39, 0xE0,
  0x73, 0x80, 0xE3, 0x83, 0x8E, 0x03, 0x8E, 0x0E, 0x38, 0x1E, 0x38, 0x71,
  0xE0, 0x70, 0xE1, 0xC7, 0x81, 0xC3, 0x8E, 0x1C, 0x07, 0x0E, 0x38, 0x70,
  0x3C, 0x39, 0xC1, 0xC0, 0xF0, 0xE7, 0x0F, 0x03, 0x83, 0xB8, 0x3C, 0x0E,
  0x0E, 0xE0, 0xE0, 0x38, 0x3F, 0x03, 0x81, 0xE0, 0xFC, 0x1E, 0x07, 0x83,
  0xF0, 0x78, 0x1C, 0x0F, 0x81, 0xE0, 0x70, 0x3E, 0x07, 0x03, 0xC0, 0x70,
  0x3C, 0x00, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0x80, 0xF8, 0x01, 0xC0,
  0x7E, 0x00, 0xE0, 0x3F, 0x00, 0xF0, 0x1F, 0x80, 0x78, 0x1F, 0xC0, 0x38,
  0x0E, 0xF0, 0x1C, 0x07, 0x38, 0x0E, 0x03, 0x9C, 0x0F, 0x01, 0xCE, 0x07,
  0x81, 0xE7, 0x03, 0x80, 0xF3, 0xC1, 0xC0, 0x70, 0xE0, 0xE0, 0x38, 0x70,
  0xF0, 0x1C, 0x38, 0x70, 0x1E, 0x1E, 0x38, 0x0E, 0x07, 0x1C, 0x07, 0x03,
  0x9E, 0x03, 0x81, 0xCF, 0x03, 0xC0, 0xF7, 0x01, 0xE0, 0x3B, 0x80, 0xE0,
  0x1D, 0xC0, 0x70, 0x0E, 0xE0, 0x38, 0x07, 0xF0, 0x3C, 0x03, 0xF0, 0x1E,
  0x00, 0xF8, 0x0E, 0x00, 0x7C, 0x07, 0x00, 0x3E, 0x07, 0x80, 0x1E, 0x00,
  0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0x83, 0xE0, 0x78,
  0x0F, 0x07, 0x80, 0x38, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x3C, 0x00, 0x79,
  0xE0, 0x03, 0xCE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00,
  0x3D, 0xC0, 0x01, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC,
  0x00, 0x39, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xE3, 0xC0, 0x0F,
  0x1E, 0x00, 0x70, 0xF0, 0x07, 0x83, 0xC0, 0x78, 0x1F, 0x07, 0xC0, 0x7F,
  0xFC, 0x03, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0xC0, 0x3C, 0x3E, 0x03, 0x81, 0xE0, 0x38, 0x0E, 0x07, 0x80,
  0xF0, 0x78, 0x0F, 0x07, 0x80, 0xE0, 0x70, 0x0E, 0x07, 0x01, 0xE0, 0xF0,
  0x1E, 0x0F, 0x01, 0xC0, 0xE0, 0x3C, 0x0E, 0x0F, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x01, 0xFF, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0x83, 0xE0, 0x78, 0x0F, 0x07,
  0x80, 0x38, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03,
  0xCE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xC0,
  0x01, 0xDE, 0x00, 0x0E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x39,
  0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xE3, 0xC0, 0x0F, 0x1E, 0x00,
  0x78, 0xF0, 0x07, 0x83, 0xC0, 0x78, 0x1F, 0x07, 0xC0, 0x7F, 0xFC, 0x03,
  0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x3C, 0x3E, 0x03, 0x81,
  0xE0, 0x38, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x70,
  0x0E, 0x07, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x03, 0xC0, 0xE0, 0x7C, 0x0E,
  0x3F, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xE3, 0x80, 0x1C, 0x38, 0x01,
  0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC1, 0xC0, 0x3C, 0x1C, 0x03, 0x81, 0xE0,
  0x38, 0x1E, 0x07, 0x80, 0xE0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x70, 0x0F,
  0x0F, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFF, 0x03, 0xE0,
  0xE0, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x10, 0x07, 0x83, 0x01, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xD0, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x07, 0x00, 0x38, 0x78, 0x03,
  0xC3, 0xC0, 0x1E, 0x1C, 0x00, 0xF0, 0xE0, 0x07, 0x0F, 0x00, 0x38, 0x78,
  0x03, 0xC3, 0xC0, 0x1E, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x0F, 0x00, 0x38,
  0x78, 0x03, 0xC3, 0x80, 0x1E, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x0F, 0x00,
  0x78, 0x78, 0x03, 0xC3, 0x80, 0x1E, 0x1C, 0x00, 0xE1, 0xE0, 0x07, 0x0F,
  0x00, 0x78, 0x78, 0x03, 0xC3, 0x80, 0x1C, 0x1C, 0x01, 0xE0, 0xF0, 0x0F,
  0x07, 0x80, 0xF0, 0x3E, 0x0F, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7B, 0x80, 0x1E, 0xE0,
  0x07, 0x38, 0x03, 0xCE, 0x00, 0xE3, 0x80, 0x78, 0xE0, 0x1E, 0x38, 0x0F,
  0x0E, 0x03, 0xC3, 0x80, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0F, 0x0F, 0x03,
  0xC3, 0x80, 0xF1, 0xE0, 0x3C, 0x70, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3,
  0x80, 0x3D, 0xE0, 0x07, 0x70, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x3F, 0x00, 0x78, 0x03, 0xF8, 0x03, 0xC0, 0x1D, 0xC0, 0x1E, 0x01,
  0xEE, 0x01, 0xF0, 0x0F, 0x70, 0x0F, 0x80, 0x73, 0x80, 0xFC, 0x07, 0x9C,
  0x07, 0xE0, 0x38, 0xE0, 0x7F, 0x03, 0xC7, 0x03, 0xB8, 0x1C, 0x38, 0x1D,
  0xC0, 0xE1, 0xC1, 0xCE, 0x0F, 0x0E, 0x0E, 0x70, 0x70, 0x70, 0xE3, 0x87,
  0x83, 0x87, 0x1C, 0x38, 0x1C, 0x38, 0xE1, 0xC0, 0xE3, 0x87, 0x1E, 0x07,
  0x1C, 0x38, 0xE0, 0x39, 0xC1, 0xCF, 0x01, 0xCE, 0x0E, 0x70, 0x0E, 0x70,
  0x73, 0x80, 0x77, 0x03, 0xBC, 0x03, 0xB8, 0x1D, 0xC0, 0x1F, 0x80, 0xFE,
  0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3E, 0x01, 0xF0, 0x01,
  0xF0, 0x0F, 0x80, 0x0F, 0x00, 0x7C, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x1E, 0x03, 0x80, 0x78, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0x80, 0x0E,
  0x0F, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x78, 0x00, 0x79, 0xE0, 0x00, 0xF3,
  0x80, 0x00, 0xEF, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x39, 0xE0, 0x00,
  0xF1, 0xC0, 0x03, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x1E, 0x0F, 0x00, 0x78,
  0x1E, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x1E, 0x00,
  0xF0, 0x00, 0xE0, 0x07, 0xF0, 0x07, 0xBC, 0x07, 0x9E, 0x03, 0xCF, 0x03,
  0xC7, 0x81, 0xC1, 0xC1, 0xE0, 0xE0, 0xE0, 0x70, 0xF0, 0x38, 0x70, 0x1E,
  0x78, 0x0F, 0x38, 0x03, 0xB8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03,
  0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x02, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0xFF, 0x01, 0xFE, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xF0,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x78, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x3C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x7F, 0x80,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1D, 0xC0, 0x0E, 0x70, 0x0E, 0x38, 0x0F, 0x1C, 0x07,
  0x07, 0x07, 0x03, 0x83, 0x81, 0xC3, 0x80, 0x71, 0xC0, 0x39, 0xC0, 0x1E,
  0xE0, 0x07, 0xE0, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0xF1, 0xC7, 0x8E,
  0x1C, 0x70, 0xC0, 0x00, 0xF1, 0xC0, 0xFE, 0x70, 0x7F, 0xDC, 0x3E, 0x3F,
  0x1F, 0x07, 0x87, 0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x38, 0x07, 0x9E,
  0x01, 0xC7, 0x80, 0x71, 0xC0, 0x1C, 0x70, 0x0F, 0x1C, 0x03, 0xCF, 0x00,
  0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x8F, 0x03, 0xE1, 0xC1, 0xF0,
  0x7F, 0xDC, 0x1F, 0xE7, 0x03, 0xF1, 0xC0, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xC7, 0x80, 0x73, 0xF8, 0x1D, 0xFE, 0x0F, 0xE3,
  0xC3, 0xE0, 0xF0, 0xF8, 0x1C, 0x3C, 0x07, 0x0F, 0x01, 0xC7, 0x80, 0x71,
  0xE0, 0x1C, 0x70, 0x0F, 0x1C, 0x03, 0xC7, 0x00, 0xF3, 0xC0, 0x38, 0xF0,
  0x0E, 0x38, 0x07, 0x8E, 0x01, 0xC7, 0x80, 0xF1, 0xF0, 0x38, 0x7C, 0x1E,
  0x1F, 0xFF, 0x07, 0x7F, 0x83, 0x8F, 0xC0, 0x00, 0xFC, 0x07, 0xFC, 0x1F,
  0xF0, 0x7C, 0x21, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x87, 0xFE, 0x07, 0xFC,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x0F, 0x1C, 0x03, 0xF9, 0xC0, 0x7F, 0xDC, 0x0F, 0x8F, 0xC1,
  0xE0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0x78, 0x3C, 0x07, 0x83, 0x80, 0x78,
  0x78, 0x07, 0x07, 0x80, 0x70, 0x70, 0x07, 0x07, 0x00, 0xF0, 0xF0, 0x0F,
  0x0F, 0x00, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x3E, 0x0F, 0x03,
  0xC0, 0x70, 0x7C, 0x07, 0xFD, 0xC0, 0x7F, 0x9C, 0x03, 0xF1, 0xC0, 0x00,
  0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0x0E, 0x1E, 0x0F, 0x1C, 0x0F, 0x3C,
  0x0E, 0x38, 0x0E, 0x78, 0x1E, 0x78, 0x7C, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F,
  0x80, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x08, 0x7E, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0xE0, 0x3F, 0x9C, 0x0F, 0xFB, 0x83, 0xE3, 0xF0, 0xF0, 0x3C,
  0x1E, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1C, 0x03, 0xC7, 0x80, 0x70,
  0xF0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xC3,
  0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x03, 0xE1, 0xE0, 0x78, 0x1C, 0x1F, 0x03,
  0xFE, 0xE0, 0x7F, 0x9C, 0x07, 0xE7, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x08, 0x07, 0x81, 0x81, 0xE0, 0x3F,
  0xFC, 0x07, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xC7, 0xC0, 0x73, 0xF8, 0x1D, 0xFE, 0x0F, 0xE3,
  0xC3, 0xE0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0E, 0x03, 0xC7, 0x80, 0xE1,
  0xE0, 0x38, 0x70, 0x0E, 0x1C, 0x07, 0x87, 0x01, 0xE3, 0xC0, 0x70, 0xF0,
  0x1C, 0x38, 0x0F, 0x0E, 0x03, 0xC7, 0x80, 0xE1, 0xE0, 0x38, 0x70, 0x0E,
  0x1C, 0x07, 0x87, 0x01, 0xE3, 0xC0, 0x70, 0x01, 0xC0, 0xF0, 0x3C, 0x0F,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03,
  0x80, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0,
  0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x3F, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x3C, 0x1C, 0x0F, 0x03, 0x83, 0xC0, 0xF0, 0xF0, 0x1E, 0x3C,
  0x03, 0x87, 0x00, 0x71, 0xE0, 0x0E, 0x78, 0x03, 0xDE, 0x00, 0x77, 0x80,
  0x0E, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xBC, 0x01, 0xE3, 0x80,
  0x38, 0x70, 0x07, 0x0F, 0x00, 0xE1, 0xE0, 0x3C, 0x1C, 0x07, 0x03, 0x80,
  0xE0, 0x78, 0x1C, 0x0F, 0x07, 0x80, 0xE0, 0x01, 0xE0, 0x38, 0x07, 0x01,
  0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80,
  0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0,
  0x38, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0x80, 0x07, 0x1E, 0x07, 0x80, 0x77, 0xF9, 0xFE, 0x07, 0x7F,
  0xBF, 0xE0, 0xEC, 0x7B, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0xF0, 0x3C, 0x0F,
  0x0F, 0x03, 0xC0, 0xE0, 0xE0, 0x38, 0x0E, 0x1E, 0x03, 0x80, 0xE1, 0xE0,
  0x78, 0x1E, 0x1C, 0x07, 0x81, 0xE1, 0xC0, 0x70, 0x1C, 0x1C, 0x07, 0x01,
  0xC3, 0xC0, 0x70, 0x1C, 0x3C, 0x0F, 0x03, 0xC3, 0x80, 0xF0, 0x3C, 0x38,
  0x0E, 0x03, 0x87, 0x80, 0xE0, 0x38, 0x78, 0x1E, 0x03, 0x87, 0x01, 0xE0,
  0x78, 0x70, 0x1C, 0x07, 0x07, 0x01, 0xC0, 0x70, 0xF0, 0x1C, 0x07, 0x00,
  0x07, 0x1F, 0x01, 0xDF, 0xE0, 0x77, 0xF8, 0x3F, 0x8F, 0x0F, 0x83, 0xC3,
  0xE0, 0xF0, 0xF0, 0x3C, 0x38, 0x0F, 0x1E, 0x03, 0x87, 0x80, 0xE1, 0xC0,
  0x78, 0x70, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xC3, 0xC0, 0x70, 0xE0, 0x3C,
  0x38, 0x0F, 0x1E, 0x03, 0x87, 0x80, 0xE1, 0xC0, 0x38, 0x70, 0x1E, 0x1C,
  0x07, 0x8F, 0x01, 0xC0, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x81, 0xE1,
  0xE1, 0xE0, 0x70, 0xE0, 0x3C, 0xF0, 0x1E, 0x70, 0x0F, 0x38, 0x07, 0xBC,
  0x03, 0xDC, 0x01, 0xEE, 0x00, 0xE7, 0x00, 0x77, 0x80, 0x7B, 0xC0, 0x3D,
  0xE0, 0x1C, 0xF0, 0x1E, 0x78, 0x0F, 0x1C, 0x0F, 0x0F, 0x0F, 0x07, 0xFF,
  0x81, 0xFF, 0x80, 0x7F, 0x00, 0x01, 0xC7, 0xC0, 0x1C, 0xFE, 0x01, 0xDF,
  0xE0, 0x3F, 0x8F, 0x03, 0xE0, 0x70, 0x3E, 0x07, 0x03, 0xC0, 0x70, 0x3C,
  0x07, 0x07, 0x80, 0x70, 0x78, 0x07, 0x07, 0x00, 0x70, 0x70, 0x0F, 0x07,
  0x00, 0xF0, 0xF0, 0x0E, 0x0F, 0x00, 0xE0, 0xE0, 0x1E, 0x0E, 0x01, 0xC0,
  0xE0, 0x3C, 0x1F, 0x03, 0x81, 0xF0, 0x78, 0x1F, 0xFF, 0x01, 0xDF, 0xE0,
  0x3C, 0xFC, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF1, 0xC0, 0xFE, 0x70, 0x7F, 0xDC, 0x3E,
  0x3F, 0x1E, 0x07, 0x87, 0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x38, 0x07,
  0x9E, 0x01, 0xC7, 0x80, 0x71, 0xC0, 0x1C, 0x70, 0x0F, 0x1C, 0x03, 0xCF,
  0x00, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x8F, 0x03, 0xC1, 0xC1,
  0xF0, 0x7F, 0xDC, 0x1F, 0xE7, 0x03, 0xF3, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x07, 0x1E, 0x0E, 0xFC, 0x1D,
  0xF0, 0x77, 0xA0, 0xFC, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0xF0, 0x61, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0xC4, 0x07, 0x8F, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x03,
  0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x1F, 0xDF, 0xFB, 0xFF, 0x0E, 0x03,
  0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01,
  0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x0F, 0xE1, 0xFC,
  0x1F, 0x80, 0x0E, 0x01, 0xC3, 0x80, 0xF0, 0xE0, 0x3C, 0x78, 0x0E, 0x1E,
  0x03, 0x87, 0x01, 0xE1, 0xC0, 0x78, 0xF0, 0x1C, 0x3C, 0x07, 0x0E, 0x01,
  0xC3, 0x80, 0xF0, 0xE0, 0x3C, 0x78, 0x0E, 0x1E, 0x03, 0x87, 0x01, 0xE1,
  0xC0, 0x78, 0x70, 0x1E, 0x3C, 0x0F, 0x0F, 0x07, 0xC3, 0xC3, 0xF0, 0x7F,
  0xDC, 0x1F, 0xE6, 0x03, 0xF3, 0x80, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E,
  0xF0, 0x1C, 0x70, 0x3C, 0x70, 0x3C, 0x70, 0x38, 0x70, 0x78, 0x70, 0x70,
  0x70, 0xF0, 0x70, 0xE0, 0x71, 0xE0, 0x71, 0xC0, 0x73, 0xC0, 0x73, 0x80,
  0x73, 0x80, 0x77, 0x00, 0x77, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xE0, 0x3C, 0x0F, 0xE0, 0x7C, 0x0F, 0xE0, 0x7C,
  0x0E, 0xE0, 0x7C, 0x1E, 0xE0, 0xFC, 0x1C, 0xE0, 0xFC, 0x3C, 0xE1, 0xDC,
  0x38, 0xE1, 0xDC, 0x38, 0xE3, 0x9C, 0x78, 0xE3, 0x9C, 0x70, 0xE3, 0x9C,
  0xF0, 0xE7, 0x1C, 0xE0, 0xE7, 0x1C, 0xE0, 0xEE, 0x19, 0xE0, 0xEE, 0x19,
  0xC0, 0xEE, 0x19, 0xC0, 0xFC, 0x1B, 0x80, 0xDC, 0x1B, 0x80, 0xD8, 0x1F,
  0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1E,
  0x00, 0x07, 0x80, 0xF0, 0x78, 0x1E, 0x03, 0x81, 0xC0, 0x38, 0x3C, 0x03,
  0xC7, 0x80, 0x1C, 0x70, 0x01, 0xCF, 0x00, 0x1D, 0xE0, 0x01, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x03, 0xB8, 0x00, 0x7B, 0x80, 0x07, 0x38, 0x00, 0xF3, 0xC0, 0x1E, 0x1C,
  0x01, 0xC1, 0xC0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x0E, 0x00, 0x03,
  0xC0, 0x3C, 0x07, 0x00, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x01, 0xC0,
  0x70, 0x07, 0x03, 0xC0, 0x1C, 0x0E, 0x00, 0x70, 0x78, 0x01, 0xC1, 0xC0,
  0x07, 0x0F, 0x00, 0x1C, 0x38, 0x00, 0x71, 0xE0, 0x01, 0xC7, 0x00, 0x07,
  0x1C, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xDC, 0x00, 0x03, 0x70,
  0x00, 0x0D, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE,
  0x08, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xFF, 0xF0,
  0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0,
  0x03, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x78, 0x07, 0xF0,
  0x1F, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x0C, 0x00, 0x00, 0x08, 0x00, 0xBF, 0x80,
  0x7F, 0xF8, 0xFE, 0xFF, 0xFC, 0x0F, 0xF4, 0x01, 0xE0,
};

const GFXglyph NotoSans_Condensed_Italic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 30, 10, 1, -30 },
  { 39, 12, 11, 15, 4, -30 },
  { 56, 21, 30, 21, 0, -30 },
  { 135, 19, 34, 18, 0, -32 },
  { 216, 24, 30, 28, 2, -30 },
  { 306, 20, 30, 21, 0, -30 },
  { 381, 6, 11, 8, 4, -30 },
  { 390, 13, 37, 11, 1, -30 },
  { 451, 13, 37, 11, -3, -30 },
  { 512, 15, 16, 18, 4, -32 },
  { 542, 17, 20, 20, 2, -25 },
  { 585, 8, 11, 9, -2, -5 },
  { 596, 10, 3, 12, 1, -13 },
  { 600, 4, 5, 9, 1, -5 },
  { 603, 20, 30, 14, -2, -30 },
  { 678, 17, 30, 18, 1, -30 },
  { 742, 11, 30, 18, 5, -30 },
  { 784, 19, 30, 18, -1, -30 },
  { 856, 18, 30, 18, 0, -30 },
  { 924, 18, 30, 18, 0, -30 },
  { 992, 19, 30, 18, 0, -30 },
  { 1064, 17, 30, 18, 2, -30 },
  { 1128, 18, 30, 18, 2, -30 },
  { 1196, 19, 30, 18, 0, -30 },
  { 1268, 17, 30, 18, 1, -30 },
  { 1332, 9, 23, 9, 0, -23 },
  { 1358, 11, 29, 9, -2, -23 },
  { 1398, 17, 20, 20, 2, -25 },
  { 1441, 17, 12, 20, 2, -21 },
  { 1467, 17, 20, 20, 2, -25 },
  { 1510, 14, 30, 14, 1, -30 },
  { 1563, 26, 34, 28, 1, -30 },
  { 1674, 19, 30, 19, -3, -30 },
  { 1746, 20, 30, 20, 0, -30 },
  { 1821, 20, 30, 19, 2, -30 },
  { 1896, 21, 30, 22, 0, -30 },
  { 1975, 19, 30, 17, 0, -30 },
  { 2047, 19, 30, 16, 0, -30 },
  { 2119, 21, 30, 23, 2, -30 },
  { 2198, 22, 30, 23, 1, -30 },
  { 2281, 17, 30, 12, -2, -30 },
  { 2345, 16, 38, 9, -6, -30 },
  { 2421, 22, 30, 19, 0, -30 },
  { 2504, 13, 30, 16, 0, -30 },
  { 2553, 30, 30, 30, 0, -30 },
  { 2666, 25, 30, 24, 0, -30 },
  { 2760, 21, 30, 24, 2, -30 },
  { 2839, 20, 30, 19, 0, -30 },
  { 2914, 21, 37, 24, 2, -30 },
  { 3012, 20, 30, 19, 0, -30 },
  { 3087, 19, 30, 17, 0, -30 },
  { 3159, 17, 30, 16, 3, -30 },
  { 3223, 21, 30, 22, 2, -30 },
  { 3302, 18, 30, 19, 4, -30 },
  { 3370, 29, 30, 30, 4, -30 },
  { 3479, 23, 30, 18, -2, -30 },
  { 3566, 17, 30, 17, 4, -30 },
  { 3630, 20, 30, 17, -1, -30 },
  { 3705, 16, 37, 12, -1, -30 },
  { 3779, 7, 30, 14, 4, -30 },
  { 3806, 16, 37, 12, -3, -30 },
  { 3880, 17, 17, 19, 1, -30 },
  { 3917, 15, 2, 14, -4, 4 },
  { 3921, 6, 7, 11, 6, -32 },
  { 3927, 18, 23, 20, 1, -23 },
  { 3979, 18, 32, 20, 0, -32 },
  { 4051, 15, 23, 15, 1, -23 },
  { 4095, 20, 32, 20, 1, -32 },
  { 4175, 16, 23, 18, 1, -23 },
  { 4221, 21, 42, 11, -5, -32 },
  { 4332, 19, 33, 20, 0, -23 },
  { 4411, 18, 32, 19, 0, -32 },
  { 4483, 10, 31, 9, 0, -31 },
  { 4522, 15, 41, 9, -5, -31 },
  { 4599, 19, 32, 17, 0, -32 },
  { 4675, 11, 32, 9, 0, -32 },
  { 4719, 28, 23, 29, 0, -23 },
  { 4800, 18, 23, 19, 0, -23 },
  { 4852, 17, 23, 19, 1, -23 },
  { 4901, 20, 33, 20, -2, -23 },
  { 4984, 18, 33, 20, 1, -23 },
  { 5059, 15, 23, 13, 0, -23 },
  { 5103, 15, 23, 15, 0, -23 },
  { 5147, 11, 28, 11, 1, -28 },
  { 5186, 18, 23, 19, 1, -23 },
  { 5238, 16, 23, 16, 2, -23 },
  { 5284, 24, 23, 25, 3, -23 },
  { 5353, 20, 23, 16, -2, -23 },
  { 5411, 22, 33, 16, -4, -23 },
  { 5502, 16, 23, 14, -1, -23 },
  { 5548, 16, 37, 14, 1, -30 },
  { 5622, 3, 42, 18, 8, -32 },
  { 5638, 15, 37, 14, -2, -30 },
  { 5708, 17, 6, 20, 2, -18 },
};

const GFXfont NotoSans_Condensed_Italic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic42pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_CONDENSED_ITALIC42PT7B_H_
