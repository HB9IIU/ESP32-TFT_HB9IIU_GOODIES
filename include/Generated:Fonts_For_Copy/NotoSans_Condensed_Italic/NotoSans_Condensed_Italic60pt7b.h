#ifndef _NOTOSANS_CONDENSED_ITALIC60PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0x80, 0x08, 0x00, 0x3F, 0x0F, 0x9F, 0x07, 0xCF, 0x83,
  0xE7, 0xC3, 0xE3, 0xE1, 0xF1, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3C, 0x7C,
  0x1E, 0x3C, 0x1F, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x03, 0xC7, 0x81, 0xE3,
  0xC0, 0xE1, 0xE0, 0x70, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0E, 0x03, 0xC0,
  0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0x3C, 0x07, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x01,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x0F, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x1E, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x70,
  0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x38, 0x0F,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0x38, 0x70, 0x0F, 0x8E,
  0x04, 0x07, 0xC3, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0x30, 0x00, 0x1E,
  0x1C, 0x00, 0x07, 0x87, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x7C, 0x70, 0x00,
  0x1F, 0x98, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x19, 0xF8, 0x00, 0x0E, 0x3E, 0x00,
  0x03, 0x87, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x1C, 0x1E,
  0x00, 0x07, 0x07, 0x80, 0x01, 0xC3, 0xE0, 0x80, 0x70, 0xF8, 0x30, 0x1C,
  0x7C, 0x0F, 0x8E, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x7F, 0xC0, 0x03, 0xC0, 0x1F,
  0xFC, 0x00, 0x78, 0x03, 0xCF, 0x80, 0x1E, 0x00, 0xF0, 0xF0, 0x03, 0xC0,
  0x3C, 0x1E, 0x00, 0xF0, 0x07, 0x81, 0xC0, 0x3C, 0x00, 0xF0, 0x38, 0x07,
  0x80, 0x3C, 0x0F, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x3C, 0x00, 0xF0, 0x3C,
  0x0F, 0x00, 0x3C, 0x07, 0x83, 0xC0, 0x07, 0x80, 0xF0, 0x78, 0x00, 0xF0,
  0x1E, 0x1E, 0x00, 0x1E, 0x07, 0x83, 0xC0, 0x03, 0xC0, 0xF0, 0xF0, 0x00,
  0x70, 0x1E, 0x3E, 0x00, 0x0E, 0x03, 0xC7, 0x87, 0xE3, 0xC0, 0xF1, 0xE1,
  0xFE, 0x78, 0x1E, 0x3C, 0x7F, 0xE7, 0x07, 0x8F, 0x1F, 0x3C, 0xF0, 0xF1,
  0xE7, 0xC7, 0xDE, 0x7C, 0x78, 0xF0, 0x7B, 0xFF, 0x9E, 0x3C, 0x0F, 0x3F,
  0xE3, 0xC7, 0x81, 0xE3, 0xF0, 0xF0, 0xF0, 0x3C, 0x00, 0x1E, 0x3C, 0x07,
  0x80, 0x07, 0x87, 0x81, 0xE0, 0x01, 0xF0, 0xF0, 0x3C, 0x00, 0x3C, 0x3C,
  0x07, 0x80, 0x0F, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0xF0, 0x1E, 0x00, 0x78,
  0x1E, 0x07, 0x80, 0x1F, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x78, 0x1E, 0x00,
  0xF0, 0x0F, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0xF0, 0x07, 0x80, 0x3C, 0x1E,
  0x00, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x00, 0xF9, 0xF0, 0x0F, 0x00, 0x1F,
  0xFC, 0x01, 0xE0, 0x01, 0xFF, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0x7E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x3E, 0x07,
  0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80,
  0x07, 0xC0, 0x78, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFD, 0xF0, 0x1F, 0x0F, 0xCF, 0xC0, 0xF0, 0xFC, 0x3E,
  0x0F, 0x87, 0xC1, 0xF8, 0x7C, 0x7C, 0x07, 0xC7, 0xC3, 0xE0, 0x3E, 0x3E,
  0x3E, 0x00, 0xFB, 0xE1, 0xF0, 0x07, 0xDF, 0x0F, 0x00, 0x3F, 0xF0, 0xF8,
  0x00, 0xFF, 0x07, 0xC0, 0x07, 0xF8, 0x3E, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x3E, 0x01, 0xFF, 0x81, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFF, 0xFB, 0xF0, 0x3F, 0xFF, 0x8F, 0x80, 0xFF, 0xF8, 0x7E, 0x03,
  0xFF, 0x03, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0x3F, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0x00, 0x32, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x20, 0x3C, 0x01, 0xC1, 0xE0, 0x0F, 0x8F, 0x00, 0xFF, 0x78, 0x1F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xBF, 0x81, 0xFC,
  0x00, 0x1F, 0xF0, 0x01, 0xF7, 0x80, 0x1F, 0x1E, 0x01, 0xF0, 0xF0, 0x1F,
  0x87, 0xC0, 0x38, 0x1E, 0x00, 0x80, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xF8,
  0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x00, 0x7F, 0xFD,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x3C, 0xFB, 0xFF, 0xEF, 0xDF, 0xBE, 0x10,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFC, 0x7E, 0x01, 0xF0,
  0x3E, 0x03, 0xF0, 0x1F, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00,
  0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x7C, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03,
  0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xFC, 0x0F,
  0x80, 0x7C, 0x1F, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x1F, 0xFE, 0x3F, 0xBC, 0x7F,
  0x7C, 0xFC, 0x7C, 0x78, 0x7C, 0x70, 0x78, 0x20, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xC0, 0xFC, 0x00, 0xE0, 0x0F, 0xC0, 0x18, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x01, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0xF8, 0x1F, 0x80, 0x38, 0x03, 0xF0, 0x08, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x20,
  0x00, 0xFC, 0x0E, 0x00, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xBE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0xBE, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x1F, 0x1E, 0x00, 0x03, 0xC7,
  0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x83, 0xC0, 0x01,
  0xE0, 0xF8, 0x00, 0x78, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xC0, 0x7C,
  0x00, 0xF0, 0x0F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0x80, 0x7C, 0x01, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x80,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x80, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x20, 0x00, 0xFC, 0x0E, 0x00, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x03, 0xF8, 0x08, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0xF0, 0x0F, 0xBF, 0xFC, 0x07, 0xFF,
  0xFF, 0x03, 0xDE, 0x3F, 0x83, 0xFC, 0x07, 0xE1, 0xFC, 0x03, 0xF0, 0xFC,
  0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F,
  0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1,
  0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x3F,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xF8, 0x1F,
  0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x03, 0xE0,
  0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x78, 0x1F, 0x00, 0x3E, 0x03,
  0xC0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0xF8,
  0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0x9F, 0x80, 0x1F, 0xC3, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x0F, 0x81,
  0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07,
  0xC3, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x0F, 0x00,
  0x07, 0xC3, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x0F,
  0xE0, 0x3F, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0x83, 0xF0, 0x1F,
  0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x0F, 0x87,
  0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F,
  0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x07,
  0xF0, 0xFC, 0x07, 0xF8, 0x3F, 0x0F, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xBE, 0x01, 0xFF, 0x9F, 0x00, 0x7F, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x02, 0x01, 0xFC, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0x7C, 0x01, 0x00, 0x00, 0x08, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x7F,
  0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0x07, 0xF0, 0xC0, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x78, 0x03, 0xFE, 0x07, 0x87, 0x80,
  0x7F, 0xF8, 0x3C, 0x3C, 0x07, 0xFF, 0xC1, 0xE3, 0xC0, 0x7C, 0x3C, 0x0F,
  0x1E, 0x03, 0xC1, 0xE0, 0x78, 0xF0, 0x3C, 0x0F, 0x03, 0xCF, 0x03, 0xC0,
  0x78, 0x1E, 0x78, 0x1E, 0x07, 0x80, 0xF3, 0x81, 0xE0, 0x3C, 0x07, 0x3C,
  0x0F, 0x01, 0xE0, 0x79, 0xE0, 0x70, 0x0F, 0x03, 0xCF, 0x07, 0x80, 0xF0,
  0x1E, 0x70, 0x3C, 0x07, 0x80, 0xF7, 0x81, 0xE0, 0x3C, 0x0F, 0x3C, 0x0E,
  0x03, 0xE0, 0x79, 0xE0, 0xF0, 0x1E, 0x03, 0x8F, 0x07, 0x80, 0xF0, 0x3C,
  0x78, 0x3C, 0x0F, 0x81, 0xE3, 0xC1, 0xE0, 0x7C, 0x1E, 0x1E, 0x0F, 0x87,
  0xE0, 0xF0, 0xF0, 0x3C, 0x77, 0x9F, 0x07, 0x81, 0xFF, 0xBF, 0xF0, 0x3C,
  0x07, 0xF8, 0xFF, 0x01, 0xE0, 0x1F, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x06, 0x00, 0x00, 0xFF, 0x87,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x3E, 0x78, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x3E, 0x3C,
  0x00, 0x07, 0x87, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x0F,
  0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x81, 0xF0,
  0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xE0, 0x07, 0xC0, 0xF8, 0x00,
  0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x3E,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xF8, 0x7F, 0xE0,
  0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x3F, 0x01, 0xF0,
  0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1F,
  0x03, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xE0, 0x3E,
  0x00, 0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x07, 0xC3, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x01,
  0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF8, 0x3E, 0x00,
  0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xE0,
  0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0xC0, 0x7C, 0x0F, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xF8, 0x1C, 0x00, 0xFE,
  0x00, 0x40, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x0E, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7C, 0x07,
  0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x7E, 0x01, 0xF0, 0x01, 0xF8,
  0x0F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E,
  0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xFC, 0x3E,
  0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x87, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7E,
  0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF0, 0x3E,
  0x00, 0x1F, 0x81, 0xF0, 0x01, 0xF8, 0x0F, 0x00, 0x1F, 0xC0, 0xF8, 0x01,
  0xFC, 0x07, 0xC0, 0x1F, 0xC0, 0x3E, 0x03, 0xFC, 0x01, 0xF1, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x1F, 0x00, 0x3F, 0x80, 0x0E, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xFC, 0x3F, 0x00, 0x3F, 0xF8,
  0x7E, 0x00, 0x7F, 0xF0, 0xF8, 0x00, 0xFF, 0xE1, 0xF0, 0x03, 0xFF, 0xC3,
  0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0x78, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0xC0,
  0x07, 0xC0, 0x1F, 0xE0, 0x1F, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x3C, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x07,
  0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x43, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x7E, 0x01, 0xF0, 0x01, 0xF8, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x1F,
  0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0,
  0x1F, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xF8, 0xFC,
  0x00, 0x01, 0xF3, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F, 0x9F, 0x80,
  0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFB, 0xF0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x07, 0xC0,
  0x1F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x01, 0xEF, 0x00,
  0x01, 0xEF, 0x80, 0x7B, 0xC0, 0x00, 0xFB, 0xC0, 0x1E, 0xF0, 0x00, 0x3D,
  0xF0, 0x0F, 0xBC, 0x00, 0x1F, 0x7C, 0x03, 0xEF, 0x00, 0x07, 0xDF, 0x00,
  0xFB, 0xE0, 0x03, 0xE7, 0x80, 0x3C, 0xF8, 0x00, 0xFB, 0xE0, 0x0F, 0x3E,
  0x00, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x0F,
  0x8F, 0x80, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1E, 0x1E, 0x00, 0xF1, 0xF0,
  0x0F, 0x87, 0x80, 0x7C, 0x7C, 0x03, 0xE1, 0xE0, 0x1E, 0x1F, 0x00, 0xF8,
  0x78, 0x0F, 0x87, 0xC0, 0x3E, 0x1E, 0x03, 0xC3, 0xE0, 0x0F, 0x07, 0x81,
  0xF0, 0xF8, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x01, 0xF0, 0x78, 0x3E, 0x0F,
  0x80, 0x7C, 0x1E, 0x0F, 0x03, 0xE0, 0x1F, 0x07, 0x87, 0xC1, 0xF0, 0x07,
  0x81, 0xF1, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0xF8, 0x1F, 0x00, 0xF8, 0x1F,
  0x3C, 0x07, 0xC0, 0x3E, 0x07, 0xDF, 0x03, 0xE0, 0x0F, 0x01, 0xF7, 0x80,
  0xF8, 0x03, 0xC0, 0x3F, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xFE, 0x01, 0xF0, 0x07, 0x80,
  0x3F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x3F, 0x80, 0x01, 0xF0, 0x0F, 0xE0,
  0x00, 0x7C, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0x07, 0x80, 0x3F,
  0xC0, 0x03, 0xE0, 0x1F, 0xF0, 0x00, 0xF8, 0x07, 0xFC, 0x00, 0x3E, 0x01,
  0xEF, 0x00, 0x0F, 0x80, 0x7B, 0xE0, 0x03, 0xC0, 0x1E, 0xF8, 0x01, 0xF0,
  0x0F, 0xBE, 0x00, 0x7C, 0x03, 0xE7, 0x80, 0x1F, 0x00, 0xF9, 0xF0, 0x07,
  0xC0, 0x3C, 0x7C, 0x03, 0xE0, 0x0F, 0x1F, 0x00, 0xF8, 0x07, 0xC3, 0xC0,
  0x3E, 0x01, 0xF0, 0xF0, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xC0, 0x1E, 0x0F,
  0x81, 0xF0, 0x0F, 0x81, 0xE0, 0x7C, 0x03, 0xE0, 0x78, 0x1F, 0x00, 0xF8,
  0x1F, 0x07, 0xC0, 0x3E, 0x07, 0xC1, 0xE0, 0x0F, 0x01, 0xF0, 0xF8, 0x07,
  0xC0, 0x3C, 0x3E, 0x01, 0xF0, 0x0F, 0x0F, 0x80, 0x7C, 0x03, 0xE3, 0xE0,
  0x1F, 0x00, 0xF8, 0xF0, 0x07, 0x80, 0x1E, 0x7C, 0x03, 0xE0, 0x07, 0x9F,
  0x00, 0xF8, 0x01, 0xF7, 0xC0, 0x3E, 0x00, 0x7D, 0xE0, 0x0F, 0x00, 0x1F,
  0x78, 0x03, 0xC0, 0x03, 0xDE, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x7C, 0x00,
  0x3F, 0xE0, 0x1F, 0x00, 0x0F, 0xF0, 0x07, 0x80, 0x01, 0xFC, 0x03, 0xE0,
  0x00, 0x7F, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x3E, 0x00, 0x07, 0xF0, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x07,
  0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F,
  0xCF, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7C,
  0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7E, 0x0F,
  0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x7E, 0x01, 0xF8,
  0x03, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xF0, 0x3F, 0x80, 0x7C, 0x01,
  0xF0, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07,
  0xC0, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07,
  0xC0, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8,
  0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x1F, 0xC0, 0xF8, 0x07, 0xF0,
  0x1F, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF0,
  0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xCF,
  0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7C, 0x3E,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7E, 0x0F, 0xC0,
  0x01, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x01, 0xF8, 0x0F, 0x80,
  0x3F, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x81,
  0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x01,
  0xF0, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0x1F,
  0x00, 0x7E, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x0F, 0xE0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xE0,
  0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x3E, 0x00,
  0x3E, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xFC, 0x07,
  0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x07,
  0xE0, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0x07, 0xC0, 0x0F, 0xC0, 0x0C, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x06, 0x00, 0x3F,
  0x80, 0x78, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8,
  0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F,
  0x80, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x07,
  0xC0, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x3F, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3F, 0x1E, 0x00, 0x07, 0xC3, 0xC0,
  0x01, 0xF8, 0x78, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF0,
  0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x1F,
  0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F,
  0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7D,
  0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xEF, 0x00, 0x03, 0xE0, 0x00, 0xF9,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x80, 0x07, 0xC7, 0x80,
  0x07, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x1E, 0x00, 0x1F,
  0xC0, 0x07, 0xC3, 0xC0, 0x07, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0xFF, 0x00,
  0x3E, 0x0F, 0x00, 0x3F, 0xE0, 0x07, 0xC1, 0xE0, 0x07, 0xBC, 0x01, 0xF0,
  0x3C, 0x00, 0xF7, 0x80, 0x3E, 0x07, 0x80, 0x3C, 0xF0, 0x07, 0xC0, 0xF0,
  0x07, 0x9E, 0x01, 0xF0, 0x1E, 0x01, 0xF3, 0xC0, 0x3E, 0x07, 0xC0, 0x3C,
  0x78, 0x0F, 0x80, 0xF8, 0x07, 0x8F, 0x01, 0xF0, 0x1F, 0x01, 0xE1, 0xE0,
  0x3E, 0x03, 0xE0, 0x3C, 0x3C, 0x0F, 0x80, 0x7C, 0x0F, 0x87, 0x81, 0xF0,
  0x0F, 0x81, 0xE0, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x1E, 0x0F, 0x80, 0x3E,
  0x0F, 0x03, 0xC1, 0xE0, 0x07, 0xC1, 0xE0, 0x78, 0x7C, 0x00, 0xF8, 0x7C,
  0x0F, 0x0F, 0x80, 0x1F, 0x0F, 0x01, 0xE3, 0xE0, 0x03, 0xE3, 0xE0, 0x3C,
  0x7C, 0x00, 0x7C, 0x78, 0x07, 0x8F, 0x00, 0x0F, 0x8F, 0x01, 0xF3, 0xE0,
  0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x00, 0x3E, 0x78, 0x07, 0xDF, 0x00, 0x07,
  0xDF, 0x00, 0xFB, 0xE0, 0x00, 0xFB, 0xC0, 0x1F, 0x78, 0x00, 0x1F, 0x78,
  0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x0F,
  0x78, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x07, 0xE1, 0xE0,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8,
  0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0,
  0x3E, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x00,
  0x1E, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x00, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0,
  0x7C, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x0F,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x3C, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0xFB, 0xC0, 0x00, 0x79, 0xF0, 0x00, 0x7C, 0x78,
  0x00, 0x3C, 0x3C, 0x00, 0x3E, 0x1F, 0x00, 0x1E, 0x07, 0x80, 0x1F, 0x03,
  0xC0, 0x0F, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0x3C, 0x07, 0x80,
  0x1F, 0x07, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0xE3, 0xE0, 0x00, 0xF1, 0xE0,
  0x00, 0x79, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x7C, 0x7C, 0x3E, 0x3E,
  0x1E, 0x0F, 0x0F, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xF1, 0xF0, 0x0F,
  0xFE, 0x78, 0x07, 0xFF, 0x9E, 0x03, 0xFD, 0xFF, 0x81, 0xF8, 0x1F, 0xE0,
  0xFC, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xC0, 0x0F,
  0xC3, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x80,
  0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x7C, 0x1F,
  0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8,
  0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x01,
  0xF8, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x7F, 0x03, 0xF0, 0x1F, 0xC0, 0xFC,
  0x1F, 0xF0, 0x1F, 0xFF, 0x7C, 0x07, 0xFF, 0x9E, 0x00, 0xFF, 0xC7, 0x80,
  0x1F, 0xE1, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x1F, 0xE0, 0x07, 0xCF, 0xFC, 0x01,
  0xE7, 0xFF, 0x80, 0x7B, 0xEF, 0xE0, 0x3F, 0xE0, 0xFC, 0x0F, 0xE0, 0x1F,
  0x03, 0xF8, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x80,
  0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x3E,
  0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8,
  0x3C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xE1, 0xF0, 0x01,
  0xF0, 0x7C, 0x00, 0x7C, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x83, 0xF0,
  0x07, 0xE0, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0xE0, 0x7E, 0x07,
  0xFF, 0xFF, 0x01, 0xE7, 0xFF, 0x80, 0x78, 0xFF, 0xC0, 0x3C, 0x1F, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xC0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xDF, 0x03, 0xF0, 0x10, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x30, 0x3F, 0xFF, 0x80, 0xFF,
  0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00,
  0x7F, 0xC7, 0x80, 0x0F, 0xFE, 0xF8, 0x01, 0xFF, 0xEF, 0x80, 0x3F, 0xFF,
  0xF8, 0x07, 0xE0, 0x7F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x01,
  0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xE0, 0x3E, 0x00,
  0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0,
  0x7C, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0x7C, 0x0F, 0x80,
  0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0xF8,
  0x0F, 0x80, 0x1F, 0x80, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0xF8,
  0x03, 0xF0, 0x0F, 0x80, 0x7F, 0x00, 0xF8, 0x0F, 0xF0, 0x0F, 0xC1, 0xFF,
  0x00, 0x7F, 0xFD, 0xE0, 0x07, 0xFF, 0x9E, 0x00, 0x3F, 0xF1, 0xE0, 0x01,
  0xFE, 0x1E, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xF9, 0xF8, 0x1F, 0x81, 0xF0,
  0xFC, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF3, 0xE0,
  0x0F, 0x8F, 0x80, 0x3E, 0x7E, 0x01, 0xF1, 0xF0, 0x1F, 0xC7, 0xC3, 0xFE,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x01, 0x81, 0xFF, 0x7E, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x10,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x10, 0x01, 0xFF, 0x1E, 0x00, 0x3F, 0xF9,
  0xE0, 0x07, 0xFF, 0x9E, 0x00, 0xFF, 0x7F, 0xE0, 0x1F, 0x81, 0xFE, 0x03,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7C, 0x00,
  0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x81,
  0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF0, 0x1F, 0x00,
  0x1F, 0x03, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0,
  0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x7E, 0x03, 0xE0,
  0x07, 0xE0, 0x3E, 0x00, 0xFE, 0x03, 0xE0, 0x0F, 0xC0, 0x3E, 0x01, 0xFC,
  0x03, 0xE0, 0x3F, 0xC0, 0x3F, 0x07, 0xFC, 0x01, 0xFF, 0xF7, 0xC0, 0x1F,
  0xFE, 0x78, 0x00, 0xFF, 0xCF, 0x80, 0x07, 0xF8, 0xF8, 0x00, 0x1C, 0x0F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x08, 0x00, 0xFC, 0x00, 0xE0, 0x1F, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x1F, 0xE0,
  0x07, 0xDF, 0xFC, 0x01, 0xEF, 0xFF, 0x80, 0x7B, 0xFF, 0xE0, 0x3F, 0xC0,
  0xF8, 0x0F, 0xE0, 0x3E, 0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x7E,
  0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0,
  0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07,
  0xC0, 0xF8, 0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x07, 0xC0,
  0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x0F,
  0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C,
  0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00,
  0xF8, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0x78,
  0x0F, 0x80, 0x3E, 0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x03, 0xE0, 0xF8, 0x00,
  0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xCF, 0xC0,
  0x01, 0xF3, 0xE0, 0x00, 0x79, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xBE, 0x00, 0x1F,
  0xCF, 0x80, 0x07, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00,
  0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x0F,
  0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF0,
  0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC3, 0xFC, 0x0F, 0xF0, 0x07, 0x9F,
  0xFC, 0x7F, 0xF0, 0x0F, 0x7F, 0xF9, 0xFF, 0xF0, 0x1E, 0xFF, 0xFB, 0xFF,
  0xE0, 0x7F, 0x83, 0xFF, 0x07, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0x81, 0xF8,
  0x07, 0xF0, 0x1F, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x1F, 0x00,
  0x7C, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x7C,
  0x01, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC0,
  0x1F, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x1F,
  0x00, 0x7C, 0x00, 0xF0, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0,
  0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0x80, 0x1F, 0x07,
  0xC0, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C,
  0x01, 0xF0, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x07, 0xC1,
  0xF0, 0x07, 0xC0, 0x0F, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1F,
  0x00, 0x7C, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x01, 0xF0,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x78, 0x7F, 0x80,
  0x1E, 0x7F, 0xF0, 0x07, 0xBF, 0xFE, 0x03, 0xEF, 0xFF, 0x80, 0xFF, 0x83,
  0xE0, 0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0x1F, 0x03, 0xF0, 0x0F, 0x81, 0xF8,
  0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81,
  0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F,
  0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x00,
  0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x3E,
  0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0,
  0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03,
  0xE0, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFC, 0x0F, 0x83, 0xF0,
  0x1F, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0xF8, 0x00,
  0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F,
  0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xF7,
  0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x3E, 0x7C,
  0x00, 0x7C, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x87, 0xE0,
  0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07,
  0x87, 0xF8, 0x00, 0x78, 0xFF, 0xC0, 0x07, 0x9F, 0xFE, 0x00, 0x7B, 0xCF,
  0xE0, 0x0F, 0xF8, 0x3F, 0x00, 0xFF, 0x01, 0xF0, 0x0F, 0xE0, 0x1F, 0x00,
  0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x01, 0xF8, 0x01, 0xF0, 0x1F, 0x80,
  0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0,
  0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xC0,
  0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7C,
  0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0x80, 0xFC,
  0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0xE0, 0x7E,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0x7F, 0xF8, 0x01, 0xF3, 0xFF, 0x00, 0x1E,
  0x1F, 0xE0, 0x03, 0xE0, 0x20, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x40, 0x1F, 0xF1, 0xE0, 0x0F,
  0xFE, 0x78, 0x07, 0xFF, 0x9E, 0x03, 0xFF, 0xFF, 0x81, 0xF8, 0x1F, 0xE0,
  0xFC, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xC0, 0x0F,
  0xC3, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x80,
  0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x7C, 0x3F,
  0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8,
  0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x03,
  0xF8, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x7F, 0x03, 0xE0, 0x3F, 0xC0, 0xFC,
  0x1F, 0xF0, 0x1F, 0xFF, 0x78, 0x07, 0xFF, 0x9E, 0x00, 0xFF, 0xCF, 0x80,
  0x1F, 0xE3, 0xE0, 0x01, 0xC0, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x0F, 0x0F, 0xC0, 0x79, 0xFE, 0x03, 0xDF, 0xE0,
  0x1E, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x7F, 0x1F, 0x07, 0xE0, 0x18, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE1, 0x00, 0x3F, 0x0C, 0x03, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x1F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x7F, 0xC0, 0x3F, 0xC0, 0x04, 0x00, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07,
  0xC1, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00,
  0xF8, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x3E, 0x0F, 0x80,
  0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xC1, 0xF0,
  0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83,
  0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xF0,
  0x7C, 0x03, 0xF8, 0x3E, 0x03, 0xF8, 0x1F, 0x83, 0xBC, 0x0F, 0xFF, 0xDE,
  0x03, 0xFF, 0xCF, 0x01, 0xFF, 0xCF, 0x80, 0x7F, 0x87, 0x80, 0x02, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xE3, 0xC0,
  0x07, 0xC7, 0x80, 0x1F, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0xF8, 0x3C, 0x01,
  0xF0, 0x78, 0x03, 0xC0, 0xF0, 0x0F, 0x81, 0xE0, 0x1F, 0x03, 0xC0, 0x7C,
  0x07, 0x80, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x00,
  0x7C, 0x3E, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xC0, 0x07,
  0xCF, 0x80, 0x0F, 0x9E, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x03,
  0xF0, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0xFB, 0xC0, 0x1F, 0xC0, 0x3E, 0x78,
  0x03, 0xF8, 0x07, 0xCF, 0x00, 0xFF, 0x00, 0xF9, 0xE0, 0x1F, 0xE0, 0x3E,
  0x3C, 0x03, 0xBC, 0x07, 0xC7, 0x80, 0xF7, 0x81, 0xF0, 0xF0, 0x1E, 0xF0,
  0x3E, 0x1E, 0x07, 0x9E, 0x07, 0x83, 0xC0, 0xF3, 0xC1, 0xF0, 0x78, 0x3E,
  0x78, 0x3E, 0x0F, 0x07, 0x8F, 0x0F, 0x81, 0xE0, 0xF1, 0xE1, 0xF0, 0x3C,
  0x3C, 0x3C, 0x3C, 0x07, 0x87, 0x87, 0x8F, 0x80, 0xF1, 0xF0, 0xF1, 0xF0,
  0x1E, 0x3C, 0x1E, 0x7C, 0x03, 0xC7, 0x83, 0xCF, 0x80, 0x79, 0xE0, 0x79,
  0xE0, 0x0F, 0x3C, 0x1E, 0x7C, 0x01, 0xEF, 0x83, 0xCF, 0x00, 0x3D, 0xE0,
  0x79, 0xE0, 0x07, 0xBC, 0x0F, 0x7C, 0x00, 0xFF, 0x01, 0xEF, 0x00, 0x1F,
  0xE0, 0x3D, 0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0x80, 0xFC, 0x00, 0x7C, 0x0F, 0x80,
  0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3E,
  0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x1F,
  0x00, 0x0F, 0x81, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x3F, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E,
  0x3E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1E,
  0x7C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFE,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x01,
  0x3F, 0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFE, 0x80, 0x07, 0xFC, 0x80, 0x00, 0x60,
};

const GFXglyph NotoSans_Condensed_Italic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 14, 44, 15, 1, -43 },
  { 78, 17, 16, 21, 6, -43 },
  { 112, 30, 43, 29, 1, -43 },
  { 274, 26, 49, 26, 1, -46 },
  { 434, 35, 44, 40, 3, -43 },
  { 627, 29, 44, 30, 0, -43 },
  { 787, 8, 16, 12, 6, -43 },
  { 803, 19, 52, 16, 1, -43 },
  { 927, 18, 52, 16, -4, -43 },
  { 1044, 21, 23, 25, 6, -46 },
  { 1105, 24, 28, 28, 3, -35 },
  { 1189, 11, 15, 13, -3, -7 },
  { 1210, 14, 4, 17, 1, -18 },
  { 1217, 7, 8, 13, 1, -7 },
  { 1224, 28, 43, 20, -3, -43 },
  { 1375, 24, 44, 26, 2, -43 },
  { 1507, 16, 43, 26, 7, -43 },
  { 1593, 27, 43, 26, -1, -43 },
  { 1739, 26, 44, 26, 0, -43 },
  { 1882, 27, 43, 26, -1, -43 },
  { 2028, 26, 44, 26, 0, -43 },
  { 2171, 25, 44, 26, 2, -43 },
  { 2309, 25, 43, 26, 3, -43 },
  { 2444, 26, 44, 26, 1, -43 },
  { 2587, 25, 44, 26, 1, -43 },
  { 2725, 12, 34, 13, 0, -33 },
  { 2776, 16, 41, 13, -3, -33 },
  { 2858, 24, 27, 28, 3, -35 },
  { 2939, 24, 16, 28, 3, -29 },
  { 2987, 24, 27, 28, 3, -35 },
  { 3068, 20, 44, 20, 2, -43 },
  { 3178, 37, 48, 40, 2, -43 },
  { 3400, 27, 43, 27, -4, -43 },
  { 3546, 28, 43, 29, 1, -43 },
  { 3697, 28, 45, 27, 3, -44 },
  { 3855, 29, 43, 32, 1, -43 },
  { 4011, 26, 43, 25, 1, -43 },
  { 4151, 26, 43, 23, 1, -43 },
  { 4291, 31, 45, 33, 3, -44 },
  { 4466, 33, 43, 33, 1, -43 },
  { 4644, 24, 43, 17, -3, -43 },
  { 4773, 24, 54, 13, -9, -43 },
  { 4935, 31, 43, 27, 1, -43 },
  { 5102, 18, 43, 23, 1, -43 },
  { 5199, 42, 43, 42, 1, -43 },
  { 5425, 34, 43, 34, 1, -43 },
  { 5608, 30, 44, 34, 3, -43 },
  { 5773, 27, 43, 27, 1, -43 },
  { 5919, 30, 53, 34, 3, -43 },
  { 6118, 27, 43, 28, 1, -43 },
  { 6264, 28, 44, 25, -1, -43 },
  { 6418, 23, 43, 23, 5, -43 },
  { 6542, 30, 44, 32, 3, -43 },
  { 6707, 27, 43, 27, 5, -43 },
  { 6853, 43, 43, 43, 5, -43 },
  { 7085, 33, 43, 25, -3, -43 },
  { 7263, 24, 43, 24, 5, -43 },
  { 7392, 29, 43, 24, -2, -43 },
  { 7548, 22, 53, 17, -1, -43 },
  { 7694, 10, 43, 21, 6, -43 },
  { 7748, 23, 53, 17, -4, -43 },
  { 7901, 25, 24, 27, 1, -43 },
  { 7976, 20, 4, 20, -5, 5 },
  { 7986, 8, 10, 15, 9, -46 },
  { 7996, 26, 34, 28, 2, -33 },
  { 8107, 26, 47, 28, 0, -46 },
  { 8260, 21, 34, 21, 2, -33 },
  { 8350, 28, 47, 28, 2, -46 },
  { 8515, 22, 34, 25, 2, -33 },
  { 8609, 30, 60, 15, -7, -46 },
  { 8834, 28, 47, 28, 0, -33 },
  { 8999, 26, 46, 28, 0, -46 },
  { 9149, 15, 44, 13, 0, -44 },
  { 9232, 23, 58, 13, -8, -44 },
  { 9399, 26, 46, 24, 0, -46 },
  { 9549, 15, 46, 13, 0, -46 },
  { 9636, 39, 33, 42, 0, -33 },
  { 9797, 26, 33, 28, 0, -33 },
  { 9905, 23, 34, 27, 2, -33 },
  { 10003, 28, 47, 28, -2, -33 },
  { 10168, 26, 47, 28, 2, -33 },
  { 10321, 21, 33, 19, 0, -33 },
  { 10408, 21, 34, 21, 0, -33 },
  { 10498, 16, 40, 16, 2, -39 },
  { 10578, 25, 33, 28, 2, -32 },
  { 10682, 23, 32, 23, 3, -32 },
  { 10774, 35, 32, 36, 4, -32 },
  { 10914, 28, 32, 23, -3, -32 },
  { 11026, 32, 46, 23, -6, -32 },
  { 11210, 23, 32, 20, -2, -32 },
  { 11302, 23, 52, 20, 1, -43 },
  { 11452, 4, 60, 25, 11, -46 },
  { 11482, 22, 52, 20, -3, -43 },
  { 11625, 24, 8, 28, 3, -25 },
};

const GFXfont NotoSans_Condensed_Italic60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic60pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_CONDENSED_ITALIC60PT7B_H_
