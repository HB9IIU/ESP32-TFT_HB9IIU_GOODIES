#ifndef _NOTOSANS_CONDENSED_ITALIC33PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C,
  0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x00, 0x00, 0x00, 0x70, 0x70, 0xF0,
  0x70, 0x39, 0xDC, 0x77, 0x19, 0xCE, 0x73, 0x98, 0xC6, 0x31, 0x8C, 0xC3,
  0x00, 0x00, 0xC3, 0x00, 0x63, 0x80, 0x31, 0x80, 0x30, 0xC0, 0x18, 0x60,
  0x0C, 0x60, 0x0E, 0x30, 0x3F, 0xFF, 0x1F, 0xFF, 0x93, 0x8C, 0x01, 0x86,
  0x00, 0xC7, 0x00, 0x63, 0x00, 0x61, 0x80, 0x30, 0xC1, 0xFF, 0xFC, 0xFF,
  0xFC, 0x0C, 0x30, 0x06, 0x30, 0x07, 0x18, 0x03, 0x0C, 0x01, 0x8C, 0x00,
  0xC6, 0x00, 0xC3, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x1F, 0xE0,
  0x7F, 0xE1, 0xD9, 0x87, 0x30, 0x0E, 0x60, 0x1C, 0x80, 0x39, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xB8, 0x03, 0x30,
  0x04, 0x60, 0x08, 0xC0, 0x33, 0x8C, 0x6F, 0x1F, 0xFC, 0x1F, 0xE0, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x0E, 0x01, 0x83, 0xE0, 0x70,
  0xCC, 0x0C, 0x39, 0xC3, 0x86, 0x18, 0x60, 0xC7, 0x18, 0x38, 0xC3, 0x06,
  0x18, 0xC0, 0xC3, 0x38, 0x18, 0x66, 0x03, 0x19, 0x9F, 0x63, 0x37, 0xEE,
  0xEC, 0xCF, 0xFB, 0xB8, 0xDE, 0x66, 0x18, 0x1C, 0xC7, 0x03, 0x38, 0xC0,
  0xC6, 0x18, 0x38, 0xC3, 0x06, 0x18, 0xE1, 0xC3, 0x18, 0x30, 0x63, 0x0C,
  0x0F, 0xC3, 0x80, 0xF0, 0x00, 0xF0, 0x03, 0xF8, 0x03, 0xB8, 0x07, 0x1C,
  0x06, 0x1C, 0x06, 0x18, 0x06, 0x38, 0x06, 0x38, 0x06, 0x70, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1D, 0xC7, 0x39, 0xC6, 0x70, 0xCE,
  0x60, 0xEC, 0xE0, 0xFC, 0xE0, 0x78, 0xE0, 0x78, 0xE0, 0xF8, 0xF1, 0xF8,
  0x7F, 0x9C, 0x3F, 0x1C, 0x39, 0x9C, 0xE7, 0x31, 0x8C, 0xE0, 0x00, 0xC0,
  0x60, 0x30, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x07, 0x01,
  0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x80, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x70, 0x00, 0x03,
  0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C,
  0x06, 0x03, 0x80, 0xE0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0x80, 0xE0, 0x00,
  0x03, 0x00, 0x30, 0x07, 0x06, 0x60, 0xFE, 0x33, 0xFF, 0x0F, 0xF1, 0xF0,
  0x3B, 0x07, 0x38, 0x21, 0xC0, 0x18, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x1C, 0xE3, 0x9C, 0x71, 0x8E,
  0x30, 0xFF, 0xFC, 0x77, 0xF7, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x3F, 0x83, 0xFE, 0x1C, 0x71,
  0xC1, 0x8E, 0x0C, 0xE0, 0x67, 0x03, 0x30, 0x3B, 0x81, 0xDC, 0x0E, 0xE0,
  0x76, 0x03, 0xF0, 0x1B, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0x38, 0x39,
  0xC1, 0x8E, 0x1C, 0x39, 0xC1, 0xFC, 0x07, 0xC0, 0x03, 0x83, 0x83, 0xC7,
  0xE7, 0xF7, 0x39, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xE0,
  0x70, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x00,
  0xF8, 0x07, 0xF8, 0x1F, 0xF8, 0x30, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x01, 0xE0, 0x1F, 0xE0,
  0xFF, 0xC3, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE3, 0x07, 0x8F, 0xFC,
  0x3F, 0xC0, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x1F, 0x00, 0xFC, 0x03,
  0x60, 0x19, 0x80, 0xEE, 0x03, 0x38, 0x18, 0xC0, 0xE3, 0x03, 0x1C, 0x18,
  0x70, 0xE1, 0xC3, 0x06, 0x18, 0x18, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x80,
  0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0xFE, 0x0F, 0xF8,
  0x1F, 0xF0, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x18,
  0x3C, 0x3F, 0xF0, 0x7F, 0x80, 0x00, 0x7C, 0x07, 0xF0, 0x3E, 0xC1, 0xC0,
  0x0E, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xCF, 0x07, 0x7E,
  0x1F, 0xFC, 0x78, 0x71, 0xC1, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81,
  0xCE, 0x07, 0x38, 0x38, 0xE0, 0xE1, 0xC7, 0x07, 0xF8, 0x0F, 0xC0, 0x3F,
  0xFC, 0xFF, 0xE7, 0xFF, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x07, 0xF0, 0x1E, 0xF0, 0x70,
  0x70, 0xC0, 0xE1, 0x81, 0xC3, 0x03, 0x06, 0x0E, 0x0E, 0x1C, 0x1C, 0x70,
  0x1F, 0xC0, 0x1E, 0x00, 0xFE, 0x03, 0x9C, 0x0E, 0x1C, 0x38, 0x38, 0x60,
  0x39, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0x8E, 0x07, 0x0E, 0x1E, 0x1F, 0xF8,
  0x1F, 0xC0, 0x01, 0xE0, 0x1F, 0xE0, 0xFF, 0x83, 0x87, 0x1C, 0x1C, 0x70,
  0x71, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x0F, 0x3C,
  0x78, 0x7F, 0x60, 0xFB, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x01, 0xC2, 0x0E, 0x0F, 0xF0, 0x3F, 0x80, 0x0C, 0x3C, 0x78, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x78, 0xF1, 0xC0,
  0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x06, 0x06, 0x07,
  0x00, 0x00, 0x18, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xC0,
  0x1C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1C,
  0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x80, 0x07, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x0F, 0x00, 0x60, 0x02, 0x00, 0x00, 0x0F, 0x87, 0xF8, 0xFF, 0x90, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xC0,
  0x30, 0x0E, 0x01, 0x80, 0x30, 0x00, 0x00, 0x00, 0x00, 0x06, 0x01, 0xE0,
  0x3C, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xF8, 0x01, 0xE1, 0xC0, 0x38,
  0x06, 0x06, 0x00, 0x70, 0xC0, 0x03, 0x1C, 0x00, 0x31, 0x83, 0xF3, 0x30,
  0xFE, 0x33, 0x1C, 0x63, 0x61, 0x86, 0x36, 0x38, 0xE3, 0x63, 0x0C, 0x36,
  0x30, 0xC3, 0xC7, 0x0C, 0x6C, 0x61, 0xC6, 0xC6, 0x18, 0x6C, 0x73, 0x8C,
  0xC7, 0xEF, 0x8C, 0x3C, 0xF0, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x18, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x06, 0xC0, 0x1D, 0x80, 0x33,
  0x00, 0xE6, 0x01, 0xCC, 0x03, 0x18, 0x0E, 0x30, 0x18, 0x60, 0x70, 0xC0,
  0xE1, 0x83, 0xFF, 0x87, 0xFF, 0x1F, 0xFE, 0x38, 0x1C, 0xE0, 0x39, 0xC0,
  0x73, 0x00, 0xEE, 0x01, 0xDC, 0x03, 0xF0, 0x07, 0x07, 0xE0, 0x07, 0xFC,
  0x07, 0xFE, 0x06, 0x0F, 0x06, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x07,
  0x0C, 0x0E, 0x1C, 0x1E, 0x1C, 0x7C, 0x1F, 0xF0, 0x1F, 0xF8, 0x18, 0x38,
  0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x30, 0x1C, 0x70, 0x3C,
  0x70, 0x38, 0x71, 0xF0, 0x7F, 0xE0, 0xFF, 0x80, 0x00, 0xF8, 0x07, 0xFC,
  0x1F, 0xF0, 0x70, 0x21, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0F,
  0x08, 0x1F, 0xF0, 0x0F, 0xE0, 0x07, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x80,
  0xC1, 0xE0, 0x60, 0x70, 0x70, 0x38, 0x38, 0x0E, 0x1C, 0x07, 0x0C, 0x03,
  0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x61, 0xC0, 0x70, 0xC0, 0x38, 0xE0,
  0x1C, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x0F, 0x0C, 0x07, 0x0E, 0x07, 0x07,
  0x07, 0x83, 0x9F, 0x81, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x04, 0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x30,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x70, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0x02, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0xFE, 0xE0, 0xFC, 0xE0, 0x1C, 0xC0, 0x1C, 0xC0, 0x1C,
  0xC0, 0x1C, 0xE0, 0x18, 0xE0, 0x38, 0xF0, 0x38, 0x78, 0x38, 0x3F, 0xF0,
  0x1F, 0xF0, 0x07, 0x00, 0xC1, 0xC0, 0x70, 0x70, 0x1C, 0x18, 0x07, 0x06,
  0x01, 0xC3, 0x80, 0x60, 0xE0, 0x38, 0x38, 0x0E, 0x0C, 0x03, 0x87, 0x00,
  0xE1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x06, 0x01, 0xC3, 0x80, 0x60,
  0xE0, 0x38, 0x38, 0x0E, 0x0E, 0x03, 0x83, 0x00, 0xE1, 0xC0, 0x30, 0x70,
  0x1C, 0x1C, 0x07, 0x06, 0x01, 0xC3, 0x80, 0x70, 0x07, 0xF0, 0xFF, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0x80, 0xFF, 0x0F, 0xF0, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0x81, 0x3C, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0x01, 0xC1,
  0xC0, 0xE0, 0x70, 0x70, 0x18, 0x38, 0x06, 0x1E, 0x03, 0x87, 0x00, 0xE3,
  0x80, 0x39, 0xC0, 0x0C, 0xE0, 0x07, 0x78, 0x01, 0xDC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xCC, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E,
  0x38, 0x03, 0x06, 0x01, 0xC1, 0xC0, 0x70, 0x70, 0x1C, 0x1C, 0x06, 0x03,
  0x83, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0,
  0x38, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0xFF, 0xFF, 0x07, 0x80, 0x0F,
  0x07, 0x80, 0x1F, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x3E,
  0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x6E, 0x0D, 0xC0, 0xEC, 0x0D, 0xC0, 0xDC,
  0x1D, 0xC1, 0xDC, 0x1D, 0xC1, 0x9C, 0x1D, 0xC3, 0x98, 0x18, 0xC3, 0x18,
  0x18, 0xC7, 0x38, 0x38, 0xC6, 0x38, 0x38, 0xCE, 0x38, 0x38, 0xCE, 0x30,
  0x30, 0xCC, 0x70, 0x30, 0xDC, 0x70, 0x70, 0xD8, 0x70, 0x70, 0xF8, 0x70,
  0x70, 0xF0, 0x60, 0x60, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0x07, 0x80, 0x60,
  0xF0, 0x0C, 0x1E, 0x03, 0x83, 0xC0, 0x70, 0x78, 0x0E, 0x1F, 0x81, 0x83,
  0xF0, 0x30, 0x66, 0x0E, 0x0C, 0xC1, 0xC3, 0x9C, 0x38, 0x73, 0x86, 0x0E,
  0x71, 0xC1, 0x86, 0x38, 0x30, 0xE7, 0x0E, 0x1C, 0xC1, 0xC3, 0x98, 0x38,
  0x37, 0x06, 0x06, 0xE0, 0xC0, 0xFC, 0x38, 0x1F, 0x07, 0x01, 0xE0, 0xE0,
  0x3C, 0x18, 0x07, 0x87, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xFC, 0x0F, 0xFE,
  0x0E, 0x0E, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x70, 0x07, 0x70, 0x07,
  0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0xE0, 0x0E,
  0xC0, 0x0E, 0xC0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x70,
  0xF0, 0xF0, 0x7F, 0xE0, 0x3F, 0x80, 0x07, 0xC0, 0x0F, 0xF0, 0x1F, 0xF0,
  0x30, 0xF0, 0x60, 0xE1, 0xC1, 0xC3, 0x81, 0x87, 0x07, 0x0C, 0x0E, 0x38,
  0x1C, 0x70, 0x70, 0xE1, 0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xE0, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x00, 0x01, 0xF0, 0x03, 0xFC, 0x0F, 0xFE, 0x0E, 0x0E, 0x1C,
  0x07, 0x38, 0x07, 0x38, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0xE0, 0x0E, 0xC0, 0x0E, 0xC0,
  0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x70, 0xF0, 0xF0, 0x7F,
  0xE0, 0x3F, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x30, 0xF0, 0x60,
  0xE1, 0xC0, 0xC3, 0x81, 0x87, 0x07, 0x0C, 0x0E, 0x38, 0x1C, 0x70, 0x70,
  0xE3, 0xE1, 0xFF, 0x03, 0xFC, 0x0E, 0x30, 0x1C, 0x70, 0x38, 0xE0, 0x71,
  0xC0, 0xC1, 0x83, 0x83, 0x87, 0x07, 0x0E, 0x0E, 0x18, 0x0E, 0x70, 0x1C,
  0x01, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x70, 0x21, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x88, 0x0E, 0x1C, 0x7C, 0x3F, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFC, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00,
  0x1C, 0x03, 0x1C, 0x07, 0x18, 0x07, 0x18, 0x07, 0x38, 0x06, 0x38, 0x0E,
  0x38, 0x0E, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x70, 0x1C, 0x70, 0x1C,
  0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x18, 0xE0, 0x38, 0xE0, 0x38, 0xC0, 0x38,
  0xC0, 0x30, 0xC0, 0x70, 0xE0, 0xE0, 0xF1, 0xE0, 0x7F, 0xC0, 0x3F, 0x80,
  0xE0, 0x0F, 0xC0, 0x3B, 0x80, 0x77, 0x01, 0xCE, 0x03, 0x9C, 0x0E, 0x38,
  0x1C, 0x70, 0x30, 0xE0, 0xE1, 0xC1, 0x83, 0x87, 0x07, 0x0E, 0x0E, 0x38,
  0x1C, 0x70, 0x39, 0xC0, 0x73, 0x80, 0xE6, 0x00, 0xDC, 0x01, 0xB0, 0x03,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x38, 0x0F,
  0xC0, 0x70, 0x1F, 0x81, 0xE0, 0x37, 0x03, 0xC0, 0xEE, 0x07, 0x81, 0xDC,
  0x1F, 0x07, 0x38, 0x36, 0x0E, 0x70, 0xEC, 0x18, 0xE1, 0x98, 0x71, 0xC3,
  0x30, 0xE3, 0x8E, 0x63, 0x87, 0x18, 0xC7, 0x0E, 0x71, 0x8C, 0x1C, 0xC7,
  0x38, 0x39, 0x8E, 0x60, 0x77, 0x1D, 0xC0, 0xEC, 0x3B, 0x81, 0xF8, 0x76,
  0x03, 0x60, 0xFC, 0x06, 0xC1, 0xF0, 0x0F, 0x03, 0xE0, 0x1E, 0x07, 0xC0,
  0x3C, 0x0F, 0x00, 0x70, 0x1E, 0x00, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x38,
  0x38, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0x63, 0x80, 0x1C, 0xC0, 0x07, 0x70,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3F, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x03, 0x8C, 0x00, 0xC3,
  0x00, 0x70, 0xE0, 0x38, 0x38, 0x0E, 0x0E, 0x07, 0x03, 0x83, 0x80, 0x70,
  0xE0, 0x3F, 0x01, 0xF8, 0x1D, 0xC0, 0xCE, 0x0E, 0x30, 0xE1, 0x87, 0x0E,
  0x70, 0x73, 0x83, 0xB8, 0x1D, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x10, 0xFF,
  0xE0, 0xFF, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0xC0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xFC,
  0x0F, 0xE0, 0x00, 0xE1, 0x86, 0x18, 0x61, 0xC7, 0x1C, 0x70, 0xC3, 0x0C,
  0x30, 0xE3, 0x8E, 0x18, 0x61, 0x86, 0x1C, 0x71, 0xC7, 0x03, 0xF0, 0x3F,
  0x04, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0E, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0x80, 0x1C, 0x00, 0xF0, 0x0F, 0x80,
  0x6C, 0x07, 0x70, 0x33, 0x83, 0x8C, 0x18, 0x71, 0x81, 0x9C, 0x0C, 0xC0,
  0x7E, 0x01, 0xE0, 0x0C, 0xFF, 0xFF, 0xFC, 0xE3, 0x1C, 0x63, 0x80, 0x07,
  0xCC, 0x3F, 0x31, 0xE7, 0xC7, 0x0F, 0x38, 0x38, 0xC0, 0xE7, 0x03, 0x9C,
  0x0E, 0x60, 0x33, 0x80, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x83, 0x8E,
  0x1E, 0x38, 0xF8, 0x7E, 0xE0, 0xF3, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x9C, 0x0D, 0xF8, 0x3E,
  0x71, 0xE1, 0xC7, 0x83, 0x1C, 0x0C, 0x70, 0x33, 0x81, 0xCE, 0x07, 0x38,
  0x1C, 0xC0, 0x73, 0x01, 0x9C, 0x0E, 0x70, 0x39, 0xC1, 0xC7, 0x8E, 0x1B,
  0xF8, 0xEF, 0xC0, 0x03, 0xF0, 0xFE, 0x1E, 0x63, 0xC0, 0x38, 0x07, 0x00,
  0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0F, 0x08, 0x7F, 0x83, 0xF0, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x07, 0x9C, 0x0F, 0xFC,
  0x1E, 0x7C, 0x1C, 0x38, 0x38, 0x38, 0x70, 0x38, 0x70, 0x38, 0x70, 0x38,
  0x60, 0x30, 0xE0, 0x30, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0xF0, 0xE0, 0xE0,
  0xE1, 0xE0, 0xE3, 0xE0, 0x7E, 0xE0, 0x3C, 0xE0, 0x03, 0xC0, 0xFE, 0x1E,
  0x73, 0x87, 0x38, 0x77, 0x07, 0x70, 0xE6, 0x1E, 0xFF, 0xCF, 0xF0, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x04, 0x7F, 0xC3, 0xF8, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xFC, 0x03, 0xFC, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0xBC,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0x03, 0xE6, 0x0F, 0xEC, 0x3C, 0xF8, 0x70,
  0xE1, 0xC1, 0xC3, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x30, 0x18, 0xE0, 0x71,
  0xC0, 0xE3, 0x81, 0xC7, 0x07, 0x8E, 0x0E, 0x1C, 0x3C, 0x38, 0xF8, 0x3F,
  0xF0, 0x7C, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x20, 0x70,
  0x73, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xBE, 0x0D, 0xF8, 0x3E, 0xF1,
  0xE1, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0x73, 0x81, 0x8E, 0x06, 0x38, 0x38,
  0xE0, 0xE3, 0x03, 0x9C, 0x0C, 0x70, 0x71, 0xC1, 0xC6, 0x07, 0x18, 0x1C,
  0xE0, 0x60, 0x07, 0x07, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x0C, 0x0C, 0x1C,
  0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x60,
  0x60, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x0B, 0x80, 0xF8,
  0x0F, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x0F, 0x0C, 0x1C, 0x18, 0x70, 0x71, 0xC0, 0xE7,
  0x01, 0xDC, 0x03, 0x30, 0x0E, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x73, 0x00,
  0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x18, 0x18, 0x38, 0x30, 0x70, 0xE0,
  0xE0, 0x07, 0x07, 0x07, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C,
  0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x60,
  0x60, 0xE0, 0x0C, 0xF0, 0xF0, 0x37, 0xE7, 0xE0, 0xFB, 0xFB, 0xC7, 0x87,
  0x87, 0x1C, 0x1C, 0x1C, 0x70, 0x70, 0x61, 0x81, 0x81, 0x8E, 0x06, 0x0E,
  0x38, 0x38, 0x38, 0xE0, 0xE0, 0xE3, 0x83, 0x83, 0x0C, 0x0C, 0x0C, 0x70,
  0x70, 0x71, 0xC1, 0xC1, 0xC7, 0x07, 0x07, 0x18, 0x18, 0x18, 0x60, 0x60,
  0xE3, 0x83, 0x83, 0x80, 0x0C, 0xF8, 0x37, 0xF0, 0xFB, 0xC7, 0x87, 0x1E,
  0x1C, 0x70, 0x71, 0xC1, 0xCE, 0x06, 0x38, 0x18, 0xE0, 0xE3, 0x83, 0x8C,
  0x0E, 0x70, 0x31, 0xC1, 0xC7, 0x07, 0x18, 0x1C, 0x60, 0x73, 0x81, 0x80,
  0x03, 0xC0, 0x7F, 0x87, 0xBC, 0x70, 0x73, 0x83, 0xB8, 0x1D, 0xC0, 0xEC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0D, 0xC0, 0xEE, 0x07, 0x70, 0x73, 0x83,
  0x8E, 0x38, 0x7F, 0x81, 0xF8, 0x00, 0x06, 0x3C, 0x0D, 0xF8, 0x1F, 0x38,
  0x78, 0x70, 0xF0, 0x61, 0xC0, 0xC3, 0x81, 0x86, 0x03, 0x1C, 0x0E, 0x38,
  0x1C, 0x70, 0x38, 0xC0, 0x63, 0x81, 0xC7, 0x03, 0x8E, 0x0E, 0x1E, 0x38,
  0x37, 0xF0, 0xE7, 0xC1, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x07, 0xCC, 0x3F, 0xB1, 0xE7,
  0xC7, 0x0E, 0x38, 0x38, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x60, 0x33, 0x80,
  0xCE, 0x07, 0x38, 0x1C, 0xE0, 0xF3, 0x83, 0x8E, 0x1E, 0x38, 0xF8, 0x7E,
  0xE1, 0xF3, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0x0C, 0xF0, 0xDE, 0x0F, 0xE1, 0xF0, 0x1E,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x07, 0xC1, 0xFF, 0x1C,
  0x63, 0x80, 0x38, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0x88, 0x38, 0xFF, 0x0F, 0xE0, 0x06,
  0x06, 0x03, 0x03, 0x83, 0xFB, 0xFC, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x06,
  0x07, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xC3, 0xE0,
  0x1C, 0x1C, 0x60, 0x73, 0x81, 0x8E, 0x06, 0x38, 0x38, 0xC0, 0xE3, 0x03,
  0x9C, 0x0C, 0x70, 0x71, 0xC1, 0xC6, 0x07, 0x18, 0x1C, 0xE0, 0xE3, 0x83,
  0x8E, 0x1E, 0x38, 0xF8, 0xFE, 0xC1, 0xF3, 0x00, 0xC0, 0x7E, 0x06, 0xE0,
  0xEE, 0x0E, 0xE1, 0xCE, 0x1C, 0xE3, 0x8E, 0x38, 0xE3, 0x0E, 0x70, 0xE6,
  0x0E, 0xE0, 0xEC, 0x0F, 0xC0, 0xF8, 0x07, 0x80, 0x70, 0x07, 0x00, 0xE0,
  0xE0, 0xFC, 0x1C, 0x1F, 0x87, 0x83, 0x70, 0xF0, 0xEE, 0x3E, 0x19, 0xC6,
  0xC7, 0x38, 0xD8, 0xE7, 0x33, 0x18, 0xE6, 0x67, 0x1D, 0xCC, 0xC3, 0x31,
  0xB8, 0x6E, 0x37, 0x0D, 0x86, 0xC1, 0xB0, 0xF8, 0x3E, 0x1E, 0x07, 0x83,
  0xC0, 0xF0, 0x70, 0x1C, 0x0E, 0x00, 0x0C, 0x0E, 0x1C, 0x38, 0x38, 0xE0,
  0x71, 0xC0, 0x67, 0x00, 0xEC, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x7E, 0x01, 0xDC, 0x03, 0x38, 0x0E, 0x30, 0x38, 0x70,
  0x70, 0xE1, 0xC1, 0xC0, 0x07, 0x03, 0x83, 0x81, 0xC1, 0xC1, 0xC0, 0xE0,
  0xE0, 0x70, 0xE0, 0x38, 0x70, 0x1C, 0x30, 0x0E, 0x38, 0x07, 0x18, 0x01,
  0x9C, 0x00, 0xCC, 0x00, 0x6E, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x01, 0x78, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0xF8, 0x7F, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x0E, 0x08, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x10, 0x1F, 0x03, 0xF0, 0x38,
  0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1C, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0x38, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0xC0,
  0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x02,
  0x00, 0x3C, 0x03, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x1E, 0x00, 0x70, 0x1F, 0x03,
  0xC0, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x1C, 0x0F, 0x80, 0xF0, 0x00, 0x38, 0x0F, 0xF0, 0xFF, 0xFF,
  0x07, 0xE8, 0x00, 0x00,
};

const GFXglyph NotoSans_Condensed_Italic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 24, 8, 0, -24 },
  { 25, 10, 9, 12, 3, -24 },
  { 37, 17, 24, 16, 0, -24 },
  { 88, 15, 27, 14, 0, -25 },
  { 139, 19, 24, 22, 2, -24 },
  { 196, 16, 24, 17, 0, -24 },
  { 244, 5, 9, 7, 3, -24 },
  { 250, 10, 29, 9, 1, -24 },
  { 287, 10, 29, 9, -2, -24 },
  { 324, 12, 12, 14, 3, -25 },
  { 342, 13, 15, 16, 2, -19 },
  { 367, 6, 8, 7, -1, -4 },
  { 373, 7, 2, 9, 1, -10 },
  { 375, 4, 4, 7, 0, -4 },
  { 377, 16, 24, 11, -2, -24 },
  { 425, 13, 24, 14, 1, -24 },
  { 464, 9, 24, 14, 4, -24 },
  { 491, 15, 24, 14, -1, -24 },
  { 536, 14, 24, 14, 0, -24 },
  { 578, 14, 24, 14, 0, -24 },
  { 620, 15, 24, 14, 0, -24 },
  { 665, 14, 24, 14, 1, -24 },
  { 707, 14, 24, 14, 2, -24 },
  { 749, 15, 24, 14, 0, -24 },
  { 794, 14, 24, 14, 0, -24 },
  { 836, 7, 18, 7, 0, -18 },
  { 852, 9, 22, 7, -2, -18 },
  { 877, 13, 15, 16, 2, -19 },
  { 902, 13, 9, 16, 2, -16 },
  { 917, 13, 15, 16, 2, -19 },
  { 942, 11, 24, 11, 1, -24 },
  { 975, 20, 27, 22, 1, -24 },
  { 1043, 15, 24, 15, -2, -24 },
  { 1088, 16, 24, 16, 0, -24 },
  { 1136, 15, 24, 15, 2, -24 },
  { 1181, 17, 24, 17, 0, -24 },
  { 1232, 15, 24, 14, 0, -24 },
  { 1277, 15, 24, 13, 0, -24 },
  { 1322, 16, 24, 18, 2, -24 },
  { 1370, 18, 24, 18, 0, -24 },
  { 1424, 12, 24, 9, -1, -24 },
  { 1460, 13, 30, 7, -5, -24 },
  { 1509, 18, 24, 15, 0, -24 },
  { 1563, 10, 24, 13, 0, -24 },
  { 1593, 24, 24, 23, 0, -24 },
  { 1665, 19, 24, 19, 0, -24 },
  { 1722, 16, 24, 19, 2, -24 },
  { 1770, 15, 24, 15, 0, -24 },
  { 1815, 16, 30, 19, 2, -24 },
  { 1875, 15, 24, 15, 0, -24 },
  { 1920, 15, 24, 14, 0, -24 },
  { 1965, 13, 24, 13, 3, -24 },
  { 2004, 16, 24, 18, 2, -24 },
  { 2052, 15, 24, 15, 3, -24 },
  { 2097, 23, 24, 24, 3, -24 },
  { 2166, 18, 24, 14, -2, -24 },
  { 2220, 13, 24, 13, 3, -24 },
  { 2259, 16, 24, 13, -1, -24 },
  { 2307, 13, 29, 9, -1, -24 },
  { 2355, 6, 24, 11, 3, -24 },
  { 2373, 12, 29, 9, -2, -24 },
  { 2417, 13, 14, 15, 1, -24 },
  { 2440, 11, 2, 11, -3, 3 },
  { 2443, 5, 5, 9, 5, -25 },
  { 2447, 14, 18, 15, 1, -18 },
  { 2479, 14, 25, 15, 0, -25 },
  { 2523, 12, 18, 12, 1, -18 },
  { 2550, 16, 25, 15, 1, -25 },
  { 2600, 12, 18, 14, 1, -18 },
  { 2627, 16, 33, 8, -4, -25 },
  { 2693, 15, 26, 16, 0, -18 },
  { 2742, 14, 25, 15, 0, -25 },
  { 2786, 8, 24, 7, 0, -24 },
  { 2810, 12, 32, 7, -4, -24 },
  { 2858, 15, 25, 13, 0, -25 },
  { 2905, 8, 25, 7, 0, -25 },
  { 2930, 22, 18, 23, 0, -18 },
  { 2980, 14, 18, 15, 0, -18 },
  { 3012, 13, 18, 15, 1, -18 },
  { 3042, 15, 26, 15, -1, -18 },
  { 3091, 14, 26, 15, 1, -18 },
  { 3137, 12, 18, 10, 0, -18 },
  { 3164, 12, 18, 12, 0, -18 },
  { 3191, 9, 22, 9, 1, -22 },
  { 3216, 14, 18, 15, 1, -18 },
  { 3248, 12, 18, 12, 2, -18 },
  { 3275, 19, 18, 20, 2, -18 },
  { 3318, 15, 18, 13, -1, -18 },
  { 3352, 17, 26, 12, -3, -18 },
  { 3408, 13, 18, 11, -1, -18 },
  { 3438, 12, 29, 11, 1, -24 },
  { 3482, 2, 33, 14, 6, -25 },
  { 3491, 12, 29, 11, -2, -24 },
  { 3535, 13, 5, 16, 2, -14 },
};

const GFXfont NotoSans_Condensed_Italic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic33pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_CONDENSED_ITALIC33PT7B_H_
