#ifndef _NOTOSANS_CONDENSED_ITALIC43PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F,
  0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x00, 0x3C, 0x79, 0xE3, 0x8E, 0x1C, 0x71, 0xE7, 0x8F,
  0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x70, 0xC3, 0x0E, 0x38, 0x70, 0x00, 0x18,
  0x38, 0x00, 0xE0, 0xC0, 0x03, 0x87, 0x00, 0x0C, 0x1C, 0x00, 0x70, 0x60,
  0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x18, 0x38, 0x00, 0xE0, 0xC0, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x01, 0xC3, 0x80, 0x06, 0x0E,
  0x00, 0x38, 0x30, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x1C, 0x18, 0x00,
  0x70, 0xE0, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0xE1,
  0xC0, 0x03, 0x07, 0x00, 0x1C, 0x18, 0x00, 0x70, 0xE0, 0x01, 0x83, 0x80,
  0x0E, 0x0C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x07, 0x07, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x07, 0xF8,
  0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3C, 0xC6, 0x07, 0x18, 0x01, 0xE3, 0x00,
  0x38, 0xE0, 0x07, 0x18, 0x00, 0xE3, 0x00, 0x1E, 0x60, 0x01, 0xEC, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00,
  0x0C, 0xF0, 0x01, 0x9E, 0x00, 0x31, 0xC0, 0x06, 0x38, 0x01, 0x87, 0x00,
  0x31, 0xE1, 0x06, 0x38, 0x38, 0xDF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x07,
  0xF0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x03, 0xC0, 0x0E, 0x07, 0xF0, 0x06, 0x03, 0xBC, 0x07, 0x03,
  0x8E, 0x07, 0x03, 0x87, 0x03, 0x81, 0xC3, 0x83, 0x80, 0xE1, 0xC1, 0xC0,
  0xE0, 0xE1, 0xC0, 0x70, 0x71, 0xC0, 0x38, 0x30, 0xE0, 0x1C, 0x38, 0xE0,
  0x0C, 0x1C, 0x70, 0x06, 0x0E, 0x71, 0xE7, 0x0E, 0x31, 0xF9, 0x87, 0x39,
  0xFE, 0xC7, 0x39, 0xC7, 0x7F, 0x9C, 0xE3, 0xBF, 0x9C, 0xE1, 0xCF, 0x8E,
  0x70, 0xE0, 0x0E, 0x30, 0x70, 0x0E, 0x38, 0x38, 0x07, 0x1C, 0x1C, 0x07,
  0x0E, 0x0C, 0x03, 0x87, 0x0E, 0x03, 0x83, 0x07, 0x03, 0x81, 0x83, 0x81,
  0xC0, 0xC3, 0x81, 0xC0, 0x71, 0xC0, 0xE0, 0x39, 0xC0, 0xE0, 0x1F, 0xC0,
  0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03,
  0xC7, 0x80, 0x1C, 0x3C, 0x01, 0xE1, 0xE0, 0x0E, 0x0F, 0x00, 0x70, 0x70,
  0x03, 0x83, 0x80, 0x1C, 0x38, 0x00, 0xF3, 0xC0, 0x07, 0xBC, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x78,
  0xF3, 0xC3, 0x8F, 0x1E, 0x1C, 0x70, 0x71, 0xE7, 0x83, 0xCE, 0x38, 0x0E,
  0xF3, 0xC0, 0x7F, 0x1E, 0x03, 0xF8, 0xF0, 0x0F, 0x87, 0x80, 0x78, 0x3C,
  0x07, 0xE0, 0xF0, 0x7F, 0x07, 0xFF, 0xBC, 0x1F, 0xF9, 0xE0, 0x7F, 0x07,
  0x80, 0x7B, 0xDC, 0xE7, 0x7B, 0x9C, 0xE7, 0x30, 0x00, 0x38, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x06, 0x1C, 0x0F, 0x30, 0x3F,
  0xE3, 0x9F, 0xFF, 0x03, 0xFE, 0x0F, 0x80, 0x3B, 0x00, 0xE7, 0x03, 0xCE,
  0x0F, 0x0E, 0x04, 0x1E, 0x00, 0x30, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0F, 0x0F, 0x1E, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0x60, 0xE0,
  0xFF, 0xFF, 0xEF, 0xF8, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0x1E, 0x07, 0x83,
  0x83, 0xC0, 0xE0, 0xF0, 0x3C, 0x38, 0x0F, 0x1E, 0x03, 0xC7, 0x00, 0xF3,
  0xC0, 0x3C, 0xF0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE7, 0x80, 0x79, 0xE0,
  0x1E, 0x78, 0x07, 0x9C, 0x01, 0xE7, 0x00, 0x71, 0xC0, 0x3C, 0xF0, 0x0F,
  0x3C, 0x03, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1C, 0x3C, 0x0F, 0x07,
  0x07, 0x81, 0xE3, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x00,
  0xE0, 0x3C, 0x1F, 0x87, 0xF1, 0xFE, 0x7B, 0xBE, 0x77, 0x9E, 0x63, 0xC0,
  0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0x80, 0x70, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x03,
  0xFF, 0xE0, 0x3C, 0x3E, 0x01, 0x81, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0xC1, 0xE0, 0x20, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x60, 0x3E, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x73, 0x80,
  0x1C, 0xF0, 0x03, 0x9E, 0x00, 0xE3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x01,
  0xC3, 0xC0, 0x70, 0x78, 0x1E, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x78, 0x3C,
  0x0F, 0x07, 0x01, 0xC1, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xFF, 0x00, 0x1F,
  0xF8, 0x07, 0xFF, 0x80, 0x61, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x60, 0x3E, 0x0F, 0xFF,
  0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xF8, 0x0F, 0x80, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x79, 0xF8, 0x1D,
  0xFF, 0x07, 0xFF, 0xC3, 0xF0, 0x78, 0xF8, 0x1E, 0x3C, 0x03, 0x8F, 0x00,
  0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x07, 0x8E, 0x01, 0xE3, 0x80, 0x70,
  0xE0, 0x1C, 0x38, 0x0F, 0x0F, 0x07, 0x83, 0xC3, 0xE0, 0x7F, 0xF0, 0x1F,
  0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFC, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xE1, 0xF0,
  0x78, 0x1E, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x07, 0x07, 0x01, 0xE0,
  0xE0, 0x38, 0x1E, 0x0F, 0x03, 0xC3, 0xC0, 0x3C, 0xF0, 0x03, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x03, 0xE3, 0xC0, 0xF8, 0x3C, 0x1E,
  0x07, 0x87, 0x80, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC7, 0x80, 0x38, 0xF0,
  0x07, 0x1E, 0x01, 0xE1, 0xC0, 0x3C, 0x3C, 0x0F, 0x07, 0xFF, 0xC0, 0x7F,
  0xF0, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xF1,
  0xF0, 0xF0, 0x78, 0xF0, 0x1C, 0x78, 0x0E, 0x38, 0x07, 0x3C, 0x03, 0x9E,
  0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x79, 0xC0, 0x3C, 0xF0, 0x3E,
  0x78, 0x3F, 0x3F, 0x7F, 0x0F, 0xFB, 0x83, 0xFB, 0xC0, 0x71, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0x87,
  0xC3, 0xE1, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x0F, 0x0F, 0x87, 0xC1, 0xC0,
  0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x0E, 0x01,
  0xC0, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC0, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x78, 0x00, 0x30, 0x00, 0x10, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xF0,
  0x7F, 0xF0, 0xE1, 0xF1, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0x38,
  0x07, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0xE1, 0xC0, 0xFF, 0x1C, 0x70, 0x7F, 0xC3, 0x8E, 0x0E, 0x38, 0x73,
  0x83, 0x87, 0x0E, 0x70, 0xE0, 0xE1, 0xCC, 0x1C, 0x38, 0x3B, 0x87, 0x07,
  0x06, 0x70, 0xE0, 0xE1, 0xCE, 0x18, 0x1C, 0x39, 0xC7, 0x07, 0x07, 0x30,
  0xE0, 0xE0, 0xC6, 0x1C, 0x1C, 0x39, 0xC3, 0x87, 0x86, 0x38, 0x70, 0xF1,
  0xC7, 0x0F, 0x76, 0x70, 0xE0, 0xFC, 0xFC, 0x0C, 0x0F, 0x0F, 0x01, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x0C, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xE0,
  0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07, 0x8E,
  0x00, 0x70, 0xE0, 0x0F, 0x0E, 0x00, 0xE0, 0xE0, 0x1E, 0x0E, 0x01, 0xE0,
  0xE0, 0x3C, 0x0E, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x70,
  0x0E, 0x0F, 0x00, 0xE0, 0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x3C,
  0x00, 0xF3, 0xC0, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0xF0, 0x00, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x78, 0x7E, 0x07, 0x81,
  0xE0, 0x70, 0x0F, 0x07, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0,
  0x0E, 0x0E, 0x01, 0xE0, 0xE0, 0x3C, 0x1E, 0x07, 0xC1, 0xFF, 0xF8, 0x1F,
  0xFE, 0x01, 0xFF, 0xE0, 0x1C, 0x3F, 0x03, 0xC0, 0x78, 0x3C, 0x07, 0x83,
  0xC0, 0x38, 0x38, 0x03, 0x83, 0x80, 0x38, 0x78, 0x03, 0x87, 0x80, 0x78,
  0x70, 0x07, 0x87, 0x00, 0xF8, 0xF0, 0x1F, 0x0F, 0x03, 0xE0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0x06, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x40, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0x3F, 0xC0, 0x78,
  0x1F, 0x03, 0xC0, 0x78, 0x1C, 0x03, 0xC1, 0xE0, 0x0F, 0x0F, 0x00, 0x78,
  0x78, 0x03, 0xC3, 0x80, 0x1E, 0x1C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00,
  0x3C, 0x78, 0x01, 0xC3, 0x80, 0x1E, 0x1C, 0x00, 0xF1, 0xE0, 0x07, 0x8F,
  0x00, 0x3C, 0x78, 0x03, 0xC3, 0x80, 0x1E, 0x1C, 0x00, 0xF1, 0xE0, 0x0F,
  0x0F, 0x00, 0xF8, 0x70, 0x07, 0x83, 0x80, 0x78, 0x3C, 0x0F, 0x81, 0xE1,
  0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xF0, 0x1F, 0xFE,
  0x07, 0xFF, 0x80, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFC, 0x0E, 0x07, 0xC0, 0x08,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x03, 0xFC, 0xF0, 0x1F, 0xE3, 0xC0, 0x7F, 0x8F,
  0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x0F, 0x00,
  0x1C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x38,
  0x1F, 0x00, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xC0, 0x1E, 0x07, 0x00, 0x3C, 0x0E, 0x00, 0x78, 0x3C, 0x00, 0xE0,
  0x78, 0x01, 0xC0, 0xE0, 0x07, 0x81, 0xC0, 0x0F, 0x03, 0x80, 0x1E, 0x0F,
  0x00, 0x38, 0x1E, 0x00, 0x70, 0x38, 0x01, 0xE0, 0x70, 0x03, 0xC1, 0xE0,
  0x07, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x78, 0x01, 0xC0, 0xF0, 0x03, 0x81, 0xE0, 0x0F, 0x03, 0x80, 0x1E,
  0x07, 0x00, 0x3C, 0x1E, 0x00, 0x70, 0x3C, 0x00, 0xE0, 0x70, 0x03, 0xC0,
  0xE0, 0x07, 0x81, 0xC0, 0x0E, 0x07, 0x80, 0x1C, 0x0F, 0x00, 0x78, 0x1C,
  0x00, 0xF0, 0x38, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x7F,
  0x80, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x03,
  0xC0, 0x3C, 0x0E, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x7C, 0x07, 0x81,
  0xE0, 0x1C, 0x0F, 0x00, 0x70, 0x78, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00,
  0x3C, 0x78, 0x00, 0xE3, 0xC0, 0x03, 0x9E, 0x00, 0x1E, 0xF8, 0x00, 0x7B,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFB, 0xC0,
  0x03, 0xC7, 0x00, 0x0F, 0x1E, 0x00, 0x38, 0x78, 0x00, 0xE0, 0xE0, 0x07,
  0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x70, 0x3C, 0x01, 0xC0, 0x70, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x38, 0x0E, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0xFF,
  0x7F, 0xFB, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xF0,
  0x3E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F,
  0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x0F, 0xF0,
  0x07, 0x70, 0x3B, 0xC0, 0x3D, 0xC0, 0xEF, 0x00, 0xEF, 0x03, 0x9C, 0x07,
  0xBC, 0x1E, 0x70, 0x1C, 0xE0, 0x79, 0xC0, 0xF3, 0x81, 0xC7, 0x03, 0x9E,
  0x07, 0x1C, 0x1E, 0x78, 0x1C, 0x70, 0x71, 0xE0, 0xF1, 0xC3, 0xC7, 0x03,
  0xC7, 0x0E, 0x1C, 0x0E, 0x1C, 0x78, 0xF0, 0x38, 0x71, 0xC3, 0xC0, 0xE1,
  0xCF, 0x0F, 0x07, 0x87, 0x38, 0x38, 0x1C, 0x1C, 0xE0, 0xE0, 0x70, 0x77,
  0x07, 0x81, 0xC1, 0xFC, 0x1E, 0x0F, 0x03, 0xE0, 0x78, 0x3C, 0x0F, 0x81,
  0xC0, 0xE0, 0x3C, 0x07, 0x03, 0x80, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xF0,
  0x00, 0x03, 0xC0, 0x07, 0x03, 0xC0, 0x07, 0x03, 0xE0, 0x0F, 0x07, 0xE0,
  0x0F, 0x07, 0xE0, 0x0E, 0x07, 0xE0, 0x0E, 0x07, 0xF0, 0x0E, 0x0F, 0xF0,
  0x1E, 0x0F, 0x70, 0x1E, 0x0E, 0x70, 0x1C, 0x0E, 0x70, 0x1C, 0x0E, 0x78,
  0x3C, 0x1E, 0x38, 0x3C, 0x1E, 0x38, 0x3C, 0x1C, 0x38, 0x38, 0x1C, 0x3C,
  0x38, 0x1C, 0x3C, 0x78, 0x3C, 0x1C, 0x78, 0x3C, 0x1C, 0x70, 0x38, 0x1C,
  0x70, 0x38, 0x1E, 0x70, 0x38, 0x0E, 0xF0, 0x78, 0x0E, 0xF0, 0x78, 0x0E,
  0xE0, 0x70, 0x0F, 0xE0, 0x70, 0x07, 0xE0, 0xF0, 0x07, 0xE0, 0xF0, 0x07,
  0xE0, 0xE0, 0x07, 0xC0, 0xE0, 0x07, 0xC0, 0xE0, 0x03, 0xC0, 0x00, 0x3F,
  0x80, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xC3, 0xE0, 0x78, 0x0F, 0x87,
  0xC0, 0x3C, 0x3C, 0x01, 0xE3, 0xC0, 0x07, 0x1E, 0x00, 0x39, 0xE0, 0x01,
  0xCF, 0x00, 0x0E, 0x70, 0x00, 0x77, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0,
  0x01, 0xEE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xBC, 0x00, 0x3D,
  0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00,
  0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3C, 0x1E, 0x03, 0xE0, 0xF8, 0x3E, 0x03,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x03, 0xCF, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC1, 0xC0,
  0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x38, 0x07, 0x87, 0x00,
  0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x81, 0xE0, 0xE1, 0xF8, 0x1F, 0xFE,
  0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xC3, 0xE0, 0x78, 0x0F, 0x87,
  0xC0, 0x3C, 0x3C, 0x01, 0xE3, 0xC0, 0x07, 0x1E, 0x00, 0x39, 0xE0, 0x01,
  0xCF, 0x00, 0x0E, 0x70, 0x00, 0x77, 0x80, 0x03, 0xBC, 0x00, 0x3D, 0xE0,
  0x01, 0xEE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xBC, 0x00, 0x3D,
  0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00,
  0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3C, 0x1E, 0x03, 0xE0, 0xF8, 0x3E, 0x03,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x03, 0xCF, 0xE0,
  0x78, 0x3E, 0x0F, 0x03, 0xC1, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1,
  0xE0, 0x3C, 0x38, 0x07, 0x87, 0x00, 0xE1, 0xE0, 0x3C, 0x3C, 0x0F, 0x87,
  0x83, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFE, 0x00, 0xF1, 0xE0, 0x1E,
  0x3C, 0x03, 0x83, 0x80, 0x70, 0x70, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x70,
  0x3C, 0x0E, 0x03, 0x83, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xC0,
  0x1C, 0x38, 0x03, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x83,
  0xF0, 0xE0, 0x78, 0x04, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC2, 0x00, 0xF8, 0x60, 0x3E, 0x0F, 0xFF,
  0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x3C, 0x1C,
  0x00, 0xF0, 0xF0, 0x03, 0x83, 0xC0, 0x0E, 0x0E, 0x00, 0x78, 0x38, 0x01,
  0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1C, 0x1E, 0x00, 0x70, 0x70, 0x03, 0xC1,
  0xC0, 0x0F, 0x0F, 0x00, 0x38, 0x3C, 0x00, 0xE0, 0xF0, 0x07, 0x83, 0x80,
  0x1E, 0x0E, 0x00, 0x78, 0x78, 0x01, 0xC1, 0xE0, 0x07, 0x07, 0x00, 0x3C,
  0x1C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0E, 0x0F, 0x00, 0x78, 0x3C,
  0x01, 0xE0, 0xF0, 0x07, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x1E, 0x0F,
  0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0xE0, 0x01,
  0xFC, 0x00, 0x3B, 0x80, 0x0F, 0x70, 0x01, 0xCE, 0x00, 0x79, 0xE0, 0x0F,
  0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x70,
  0x78, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0xF0, 0x3C, 0x1C, 0x07, 0x87, 0x80,
  0xF0, 0xF0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xE0, 0x07, 0x3C, 0x00,
  0xE7, 0x00, 0x1D, 0xE0, 0x03, 0xB8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x07, 0x80, 0x3F, 0x80, 0x1E, 0x00, 0xFE, 0x00, 0xF8, 0x03, 0xB8,
  0x03, 0xE0, 0x1E, 0xE0, 0x0F, 0x80, 0x73, 0x80, 0x7E, 0x03, 0xCE, 0x01,
  0xF8, 0x0F, 0x38, 0x0E, 0xE0, 0x38, 0xE0, 0x3B, 0x81, 0xE3, 0x80, 0xEE,
  0x07, 0x0E, 0x07, 0x38, 0x3C, 0x38, 0x1C, 0xE0, 0xF0, 0xE0, 0xE3, 0x83,
  0x83, 0x83, 0x8E, 0x1E, 0x0E, 0x0E, 0x38, 0x70, 0x38, 0x70, 0xE3, 0xC0,
  0xE1, 0xC3, 0x8F, 0x03, 0x8E, 0x0E, 0x38, 0x0E, 0x38, 0x39, 0xE0, 0x39,
  0xE0, 0xE7, 0x00, 0xE7, 0x03, 0xBC, 0x03, 0x9C, 0x0E, 0xE0, 0x0E, 0xE0,
  0x3B, 0x80, 0x3B, 0x80, 0xDE, 0x00, 0xEE, 0x03, 0x70, 0x03, 0xF0, 0x1D,
  0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0xE0,
  0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xC0, 0x1E,
  0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x0F, 0x03, 0xC0, 0x0E, 0x07, 0x80,
  0x1C, 0x1E, 0x00, 0x38, 0x38, 0x00, 0x78, 0xF0, 0x00, 0xF3, 0xC0, 0x00,
  0xE7, 0x00, 0x01, 0xDE, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x0E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x71, 0xC0,
  0x01, 0xE3, 0x80, 0x07, 0x87, 0x80, 0x0E, 0x0F, 0x00, 0x3C, 0x1E, 0x00,
  0xF0, 0x1C, 0x01, 0xE0, 0x38, 0x07, 0x80, 0x78, 0x1E, 0x00, 0xF0, 0x3C,
  0x01, 0xE0, 0x00, 0xE0, 0x07, 0xF8, 0x03, 0xBC, 0x03, 0xDE, 0x03, 0xCF,
  0x01, 0xE3, 0x81, 0xE1, 0xC0, 0xF0, 0xE0, 0xF0, 0x70, 0x70, 0x3C, 0x78,
  0x1E, 0x38, 0x0F, 0x3C, 0x03, 0x9C, 0x01, 0xDE, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xF0, 0x70, 0x70, 0x70, 0x70,
  0x70, 0x70, 0x78, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1E, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0F, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x39, 0xC0, 0x1E, 0x70,
  0x07, 0x1E, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x70, 0x1C, 0x1C, 0x07, 0x0E,
  0x01, 0xC3, 0x80, 0x39, 0xC0, 0x0E, 0xF0, 0x03, 0xB8, 0x00, 0x70, 0x7F,
  0xFF, 0xFF, 0xFC, 0xF1, 0xE7, 0x8E, 0x1C, 0x70, 0xC0, 0x01, 0xF8, 0xE0,
  0x7F, 0xB8, 0x1F, 0xF7, 0x07, 0x83, 0xE1, 0xE0, 0x7C, 0x3C, 0x07, 0x8F,
  0x00, 0xE1, 0xE0, 0x1C, 0x38, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x38,
  0x03, 0x87, 0x00, 0x70, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x70, 0xF0,
  0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0xF8, 0x3C, 0x3F, 0x07, 0xFF, 0xC0, 0x7F,
  0xB8, 0x0F, 0xC7, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x7E, 0x03, 0xBF, 0xE0, 0x7F, 0xFC, 0x1F,
  0x83, 0x83, 0xE0, 0x78, 0x7C, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x78,
  0x07, 0x8F, 0x00, 0xF1, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0xF1, 0xE0,
  0x1E, 0x3C, 0x03, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x3E, 0x07, 0x87, 0xC0,
  0xF0, 0xF8, 0x3C, 0x1D, 0xFF, 0x03, 0xBF, 0xC0, 0xE3, 0xF0, 0x00, 0x01,
  0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0x87, 0xFF, 0x07, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x7E, 0x78,
  0x07, 0xFB, 0x80, 0x7F, 0xFC, 0x07, 0x83, 0xE0, 0x78, 0x1F, 0x03, 0xC0,
  0x78, 0x3C, 0x03, 0x81, 0xE0, 0x1C, 0x0E, 0x01, 0xE0, 0xF0, 0x0F, 0x07,
  0x80, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F,
  0x07, 0x80, 0x70, 0x3C, 0x07, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x3C,
  0x3F, 0x01, 0xFF, 0x70, 0x07, 0xFB, 0x80, 0x3F, 0x1C, 0x00, 0x01, 0xFC,
  0x03, 0xFE, 0x07, 0xDF, 0x0F, 0x0F, 0x1E, 0x07, 0x1C, 0x07, 0x3C, 0x0F,
  0x38, 0x0E, 0x78, 0x1E, 0x78, 0x7C, 0x7F, 0xF8, 0x7F, 0xE0, 0x7F, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x08, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x20, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFC, 0x70, 0x1F, 0xEE, 0x03, 0xFF, 0xE0, 0x78, 0x3E, 0x0F,
  0x03, 0xE0, 0xF0, 0x3E, 0x1E, 0x01, 0xC1, 0xE0, 0x3C, 0x1C, 0x03, 0xC3,
  0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0x80, 0x38, 0x38, 0x03, 0x83, 0x80, 0x78,
  0x78, 0x07, 0x87, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x81, 0xF0, 0x78, 0x1F,
  0x03, 0xC3, 0xF0, 0x3F, 0xFE, 0x03, 0xFE, 0xE0, 0x1F, 0x8E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x08, 0x0F, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x7B,
  0xF8, 0x1D, 0xFF, 0x07, 0xFF, 0xC3, 0xF0, 0xF0, 0xF8, 0x1C, 0x3C, 0x07,
  0x0F, 0x01, 0xC3, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0E, 0x1C, 0x03, 0x87,
  0x00, 0xE1, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x0E, 0x01, 0xC3, 0x80,
  0x71, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x78,
  0xF0, 0x1E, 0x00, 0x00, 0x80, 0x70, 0x3C, 0x0F, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E,
  0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03,
  0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0x00, 0x02, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x07, 0x83, 0x81, 0xE0,
  0x70, 0x78, 0x1E, 0x1E, 0x03, 0xC7, 0x80, 0x78, 0xE0, 0x0E, 0x3C, 0x01,
  0xCF, 0x00, 0x7B, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x01, 0xF3, 0x80, 0x3C, 0x70, 0x07, 0x0F, 0x00, 0xE1, 0xE0, 0x1C,
  0x1C, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0xF0,
  0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78,
  0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C,
  0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x00,
  0x07, 0x3F, 0x07, 0xE0, 0x77, 0xF9, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFC,
  0x3F, 0x0F, 0x0F, 0x83, 0xE0, 0x70, 0xF0, 0x3E, 0x07, 0x0F, 0x03, 0xC0,
  0xF0, 0xE0, 0x3C, 0x0F, 0x1E, 0x03, 0x80, 0xF1, 0xE0, 0x38, 0x0E, 0x1C,
  0x07, 0x80, 0xE1, 0xC0, 0x78, 0x1E, 0x1C, 0x07, 0x01, 0xE3, 0xC0, 0x70,
  0x1E, 0x3C, 0x07, 0x01, 0xC3, 0x80, 0xF0, 0x1C, 0x38, 0x0F, 0x03, 0xC3,
  0x80, 0xE0, 0x3C, 0x78, 0x0E, 0x03, 0x87, 0x80, 0xE0, 0x38, 0x70, 0x1E,
  0x03, 0x87, 0x01, 0xE0, 0x78, 0xF0, 0x1C, 0x07, 0x80, 0x00, 0x04, 0x01,
  0xCF, 0xE0, 0x77, 0xFC, 0x1F, 0xFF, 0x0F, 0xC3, 0xC3, 0xE0, 0x70, 0xF0,
  0x1C, 0x3C, 0x07, 0x0E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0E,
  0x1C, 0x03, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1C, 0x38, 0x07, 0x0E,
  0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0E, 0x1C, 0x03, 0x87, 0x01,
  0xE3, 0xC0, 0x78, 0x01, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xE0, 0xF1,
  0xE0, 0x78, 0xE0, 0x3C, 0xF0, 0x0E, 0x70, 0x07, 0x38, 0x03, 0xBC, 0x03,
  0xDE, 0x01, 0xEE, 0x00, 0xF7, 0x00, 0x7F, 0x80, 0x3B, 0xC0, 0x3D, 0xE0,
  0x1E, 0xF0, 0x0E, 0x78, 0x0F, 0x1C, 0x0F, 0x0F, 0x0F, 0x87, 0xFF, 0x81,
  0xFF, 0x80, 0x7F, 0x00, 0x01, 0xC7, 0xE0, 0x0E, 0xFF, 0x80, 0x77, 0x7C,
  0x07, 0xE0, 0xE0, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x78,
  0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1C, 0x0E, 0x00, 0xE0,
  0x70, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0x81, 0xE0, 0x3C, 0x0F, 0x01,
  0xE0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x01, 0xDF, 0xF0, 0x0E,
  0xFF, 0x00, 0xF3, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0xE0, 0x7F, 0xB8,
  0x1F, 0xFF, 0x07, 0x83, 0xE1, 0xE0, 0x7C, 0x3C, 0x0F, 0x8F, 0x00, 0xE1,
  0xE0, 0x3C, 0x38, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x38, 0x03, 0x87,
  0x00, 0x70, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0xF0, 0xF0, 0x1E, 0x1E,
  0x07, 0xC3, 0xC0, 0xF8, 0x3C, 0x3F, 0x07, 0xFF, 0xC0, 0xFF, 0xB8, 0x0F,
  0xC7, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x07, 0x3E, 0x0E, 0xFC, 0x1F, 0xF8, 0x7F, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFC,
  0x1F, 0xFC, 0x7E, 0xF8, 0xF0, 0x21, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC4, 0x07, 0x8F,
  0xFE, 0x1F, 0xFC, 0x3F, 0xE0, 0x00, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70,
  0x07, 0x01, 0xFF, 0x7F, 0xE7, 0xFE, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80,
  0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x07, 0xF0, 0x7F, 0x03, 0xF0,
  0x0F, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0x87,
  0x00, 0xE1, 0xC0, 0x38, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xC3, 0x80,
  0x70, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xE1, 0xC0, 0x78,
  0x70, 0x1E, 0x3C, 0x0F, 0x8F, 0x03, 0xC1, 0xC1, 0xF0, 0x7F, 0xDC, 0x1F,
  0xE7, 0x03, 0xF1, 0xC0, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x1E, 0x70, 0x1E,
  0x70, 0x1C, 0x70, 0x3C, 0x70, 0x38, 0x70, 0x78, 0x70, 0x70, 0x70, 0xF0,
  0x70, 0xE0, 0x71, 0xE0, 0x71, 0xC0, 0x71, 0xC0, 0x73, 0x80, 0x73, 0x80,
  0x77, 0x80, 0x77, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xE0, 0x3C, 0x07, 0xF0, 0x3E, 0x07, 0xB8, 0x1F, 0x03, 0xDC,
  0x0F, 0x81, 0xCE, 0x0F, 0xC1, 0xE7, 0x07, 0xE0, 0xE3, 0x87, 0x70, 0xF1,
  0xC3, 0xB8, 0x70, 0xE1, 0xDC, 0x38, 0x71, 0xCE, 0x3C, 0x38, 0xE7, 0x1C,
  0x1C, 0xE3, 0x9E, 0x0E, 0x71, 0xCE, 0x07, 0x30, 0xE7, 0x03, 0xB8, 0x77,
  0x81, 0xDC, 0x3B, 0x80, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3E, 0x07,
  0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0x80, 0xF8, 0x03, 0xC0,
  0x78, 0x00, 0x07, 0x80, 0xF0, 0x38, 0x1E, 0x03, 0x81, 0xC0, 0x3C, 0x3C,
  0x01, 0xC7, 0x80, 0x1C, 0x70, 0x01, 0xCF, 0x00, 0x1F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xB8, 0x00, 0x7B, 0x80, 0x07, 0x3C, 0x00, 0xF1, 0xC0, 0x1E,
  0x1C, 0x01, 0xC1, 0xE0, 0x3C, 0x1E, 0x07, 0x80, 0xE0, 0xF0, 0x0F, 0x00,
  0x01, 0xC0, 0x1C, 0x07, 0x00, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x01,
  0xC0, 0x70, 0x07, 0x03, 0xC0, 0x1C, 0x0E, 0x00, 0x70, 0x78, 0x01, 0xC1,
  0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0x70, 0xE0, 0x01, 0xE7, 0x80,
  0x07, 0x9C, 0x00, 0x1E, 0xF0, 0x00, 0x3B, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x0F,
  0xFF, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xFF,
  0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xC0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x7D, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0xFE, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0xBF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x7F, 0xF8, 0x07, 0xF4, 0x00, 0x60,
};

const GFXglyph NotoSans_Condensed_Italic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 31, 10, 1, -31 },
  { 40, 13, 11, 15, 4, -31 },
  { 58, 22, 31, 21, 0, -31 },
  { 144, 19, 36, 19, 0, -33 },
  { 230, 25, 31, 29, 2, -31 },
  { 327, 21, 31, 22, 0, -31 },
  { 409, 5, 11, 8, 5, -31 },
  { 416, 13, 38, 11, 1, -31 },
  { 478, 13, 38, 11, -3, -31 },
  { 540, 15, 16, 18, 4, -33 },
  { 570, 17, 20, 20, 2, -25 },
  { 613, 8, 11, 9, -2, -5 },
  { 624, 10, 3, 12, 1, -13 },
  { 628, 4, 5, 9, 1, -5 },
  { 631, 20, 31, 15, -2, -31 },
  { 709, 18, 31, 19, 1, -31 },
  { 779, 11, 31, 19, 5, -31 },
  { 822, 20, 31, 19, -1, -31 },
  { 900, 19, 31, 19, 0, -31 },
  { 974, 19, 31, 19, 0, -31 },
  { 1048, 19, 31, 19, 0, -31 },
  { 1122, 18, 31, 19, 2, -31 },
  { 1192, 18, 31, 19, 2, -31 },
  { 1262, 19, 31, 19, 0, -31 },
  { 1336, 17, 31, 19, 1, -31 },
  { 1402, 9, 23, 9, 0, -23 },
  { 1428, 11, 29, 9, -2, -23 },
  { 1468, 17, 20, 20, 2, -25 },
  { 1511, 17, 12, 20, 2, -21 },
  { 1537, 17, 20, 20, 2, -25 },
  { 1580, 15, 31, 14, 1, -31 },
  { 1639, 27, 35, 29, 1, -31 },
  { 1758, 20, 31, 19, -3, -31 },
  { 1836, 20, 31, 21, 1, -31 },
  { 1914, 20, 31, 19, 2, -31 },
  { 1992, 21, 31, 23, 1, -31 },
  { 2074, 18, 31, 18, 1, -31 },
  { 2144, 19, 31, 17, 1, -31 },
  { 2218, 22, 31, 24, 2, -31 },
  { 2304, 23, 31, 23, 1, -31 },
  { 2394, 17, 31, 12, -2, -31 },
  { 2460, 17, 39, 10, -6, -31 },
  { 2543, 22, 31, 19, 1, -31 },
  { 2629, 13, 31, 16, 1, -31 },
  { 2680, 30, 31, 30, 1, -31 },
  { 2797, 24, 31, 25, 1, -31 },
  { 2890, 21, 31, 24, 2, -31 },
  { 2972, 19, 31, 19, 1, -31 },
  { 3046, 21, 38, 24, 2, -31 },
  { 3146, 19, 31, 20, 1, -31 },
  { 3220, 19, 31, 18, 0, -31 },
  { 3294, 16, 31, 17, 4, -31 },
  { 3356, 22, 31, 23, 2, -31 },
  { 3442, 19, 31, 19, 4, -31 },
  { 3516, 30, 31, 31, 4, -31 },
  { 3633, 23, 31, 18, -2, -31 },
  { 3723, 17, 31, 17, 4, -31 },
  { 3789, 20, 31, 17, -1, -31 },
  { 3867, 16, 38, 12, -1, -31 },
  { 3943, 8, 31, 15, 4, -31 },
  { 3974, 16, 38, 12, -3, -31 },
  { 4050, 18, 18, 19, 1, -31 },
  { 4091, 15, 2, 14, -4, 4 },
  { 4095, 6, 7, 11, 6, -33 },
  { 4101, 19, 23, 20, 1, -23 },
  { 4156, 19, 33, 20, 0, -33 },
  { 4235, 15, 23, 15, 1, -23 },
  { 4279, 21, 33, 20, 1, -33 },
  { 4366, 16, 23, 18, 1, -23 },
  { 4412, 21, 43, 11, -5, -33 },
  { 4525, 20, 33, 20, 0, -23 },
  { 4608, 18, 33, 20, 0, -33 },
  { 4683, 10, 32, 9, 0, -32 },
  { 4723, 16, 42, 9, -6, -32 },
  { 4807, 19, 33, 17, 0, -33 },
  { 4886, 11, 33, 9, 0, -33 },
  { 4932, 28, 23, 30, 0, -23 },
  { 5013, 18, 24, 20, 0, -24 },
  { 5067, 17, 23, 20, 1, -23 },
  { 5116, 21, 33, 20, -2, -23 },
  { 5203, 19, 33, 20, 1, -23 },
  { 5282, 15, 23, 13, 0, -23 },
  { 5326, 15, 23, 15, 0, -23 },
  { 5370, 12, 28, 11, 1, -28 },
  { 5412, 18, 23, 20, 1, -23 },
  { 5464, 16, 23, 16, 2, -23 },
  { 5510, 25, 23, 26, 3, -23 },
  { 5582, 20, 23, 17, -2, -23 },
  { 5640, 22, 33, 16, -4, -23 },
  { 5731, 16, 23, 14, -1, -23 },
  { 5777, 16, 38, 14, 1, -31 },
  { 5853, 3, 43, 18, 8, -33 },
  { 5870, 16, 38, 14, -2, -31 },
  { 5946, 17, 6, 20, 2, -18 },
};

const GFXfont NotoSans_Condensed_Italic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic43pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_CONDENSED_ITALIC43PT7B_H_
