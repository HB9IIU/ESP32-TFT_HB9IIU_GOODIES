#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_Condensed_Italic
// Headers: 67

#include "NotoSans_Condensed_Italic6pt7b.h"
#include "NotoSans_Condensed_Italic7pt7b.h"
#include "NotoSans_Condensed_Italic8pt7b.h"
#include "NotoSans_Condensed_Italic9pt7b.h"
#include "NotoSans_Condensed_Italic10pt7b.h"
#include "NotoSans_Condensed_Italic11pt7b.h"
#include "NotoSans_Condensed_Italic12pt7b.h"
#include "NotoSans_Condensed_Italic13pt7b.h"
#include "NotoSans_Condensed_Italic14pt7b.h"
#include "NotoSans_Condensed_Italic15pt7b.h"
#include "NotoSans_Condensed_Italic16pt7b.h"
#include "NotoSans_Condensed_Italic17pt7b.h"
#include "NotoSans_Condensed_Italic18pt7b.h"
#include "NotoSans_Condensed_Italic19pt7b.h"
#include "NotoSans_Condensed_Italic20pt7b.h"
#include "NotoSans_Condensed_Italic21pt7b.h"
#include "NotoSans_Condensed_Italic22pt7b.h"
#include "NotoSans_Condensed_Italic23pt7b.h"
#include "NotoSans_Condensed_Italic24pt7b.h"
#include "NotoSans_Condensed_Italic25pt7b.h"
#include "NotoSans_Condensed_Italic26pt7b.h"
#include "NotoSans_Condensed_Italic27pt7b.h"
#include "NotoSans_Condensed_Italic28pt7b.h"
#include "NotoSans_Condensed_Italic29pt7b.h"
#include "NotoSans_Condensed_Italic30pt7b.h"
#include "NotoSans_Condensed_Italic31pt7b.h"
#include "NotoSans_Condensed_Italic32pt7b.h"
#include "NotoSans_Condensed_Italic33pt7b.h"
#include "NotoSans_Condensed_Italic34pt7b.h"
#include "NotoSans_Condensed_Italic35pt7b.h"
#include "NotoSans_Condensed_Italic36pt7b.h"
#include "NotoSans_Condensed_Italic37pt7b.h"
#include "NotoSans_Condensed_Italic38pt7b.h"
#include "NotoSans_Condensed_Italic39pt7b.h"
#include "NotoSans_Condensed_Italic40pt7b.h"
#include "NotoSans_Condensed_Italic41pt7b.h"
#include "NotoSans_Condensed_Italic42pt7b.h"
#include "NotoSans_Condensed_Italic43pt7b.h"
#include "NotoSans_Condensed_Italic44pt7b.h"
#include "NotoSans_Condensed_Italic45pt7b.h"
#include "NotoSans_Condensed_Italic46pt7b.h"
#include "NotoSans_Condensed_Italic47pt7b.h"
#include "NotoSans_Condensed_Italic48pt7b.h"
#include "NotoSans_Condensed_Italic49pt7b.h"
#include "NotoSans_Condensed_Italic50pt7b.h"
#include "NotoSans_Condensed_Italic51pt7b.h"
#include "NotoSans_Condensed_Italic52pt7b.h"
#include "NotoSans_Condensed_Italic53pt7b.h"
#include "NotoSans_Condensed_Italic54pt7b.h"
#include "NotoSans_Condensed_Italic55pt7b.h"
#include "NotoSans_Condensed_Italic56pt7b.h"
#include "NotoSans_Condensed_Italic57pt7b.h"
#include "NotoSans_Condensed_Italic58pt7b.h"
#include "NotoSans_Condensed_Italic59pt7b.h"
#include "NotoSans_Condensed_Italic60pt7b.h"
#include "NotoSans_Condensed_Italic61pt7b.h"
#include "NotoSans_Condensed_Italic62pt7b.h"
#include "NotoSans_Condensed_Italic63pt7b.h"
#include "NotoSans_Condensed_Italic64pt7b.h"
#include "NotoSans_Condensed_Italic65pt7b.h"
#include "NotoSans_Condensed_Italic66pt7b.h"
#include "NotoSans_Condensed_Italic67pt7b.h"
#include "NotoSans_Condensed_Italic68pt7b.h"
#include "NotoSans_Condensed_Italic69pt7b.h"
#include "NotoSans_Condensed_Italic70pt7b.h"
#include "NotoSans_Condensed_Italic71pt7b.h"
#include "NotoSans_Condensed_Italic72pt7b.h"
