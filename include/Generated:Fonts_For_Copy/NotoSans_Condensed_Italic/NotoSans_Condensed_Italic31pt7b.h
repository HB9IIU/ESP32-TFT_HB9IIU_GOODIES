#ifndef _NOTOSANS_CONDENSED_ITALIC31PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x18,
  0x18, 0x18, 0x38, 0x30, 0x30, 0x00, 0x00, 0x20, 0x70, 0xF0, 0xE0, 0x73,
  0xB9, 0xD8, 0xCC, 0x66, 0x33, 0x33, 0x19, 0x8C, 0x00, 0xC6, 0x01, 0x8C,
  0x01, 0x8C, 0x01, 0x8C, 0x03, 0x0C, 0x03, 0x18, 0x1F, 0xFF, 0x3F, 0xFF,
  0x06, 0x30, 0x06, 0x30, 0x0C, 0x30, 0x0C, 0x60, 0x0C, 0x60, 0x7F, 0xFC,
  0xFF, 0xFC, 0x18, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x31, 0x80, 0x31, 0x80,
  0x61, 0x80, 0x63, 0x00, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0xFC, 0x07,
  0xFC, 0x3A, 0x61, 0xC8, 0x06, 0x20, 0x19, 0x80, 0x66, 0x01, 0xD0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x98, 0x02, 0x70, 0x19, 0xC0,
  0x66, 0x21, 0x38, 0xFF, 0xC3, 0xFE, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x1E, 0x03, 0x0F, 0xC1, 0x87, 0x30, 0xE1, 0x8C, 0x30, 0x63,
  0x18, 0x30, 0xC6, 0x0C, 0x33, 0x03, 0x18, 0xC0, 0xC6, 0x62, 0x31, 0xBB,
  0xEC, 0xCD, 0xDB, 0xF6, 0x66, 0x79, 0xB1, 0xC0, 0xCC, 0x60, 0x73, 0x18,
  0x18, 0xC6, 0x0C, 0x61, 0x83, 0x18, 0xE1, 0x86, 0x30, 0xE1, 0x8C, 0x30,
  0x3E, 0x18, 0x0F, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x18, 0xE0, 0x31, 0xC0,
  0xE3, 0x81, 0xC6, 0x03, 0x9C, 0x07, 0x70, 0x07, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xFC, 0x03, 0xB8, 0xEE, 0x39, 0x98, 0x77, 0x70, 0x6C, 0xE0, 0xF9,
  0xC0, 0xE3, 0x83, 0xC7, 0x0F, 0x87, 0xFB, 0x87, 0xE7, 0x80, 0x77, 0x76,
  0x66, 0xCC, 0x03, 0x81, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30,
  0x38, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x1C, 0x00, 0x07, 0x01, 0x80,
  0xE0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x38,
  0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x70,
  0x70, 0x30, 0x30, 0x00, 0x05, 0x00, 0xC0, 0x18, 0x23, 0x0F, 0x60, 0xFF,
  0xC3, 0xF8, 0xF0, 0x33, 0x0E, 0x60, 0x8E, 0x00, 0x80, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x19, 0xCE, 0xE7, 0x33, 0x18, 0xFF,
  0xFF, 0xF0, 0x27, 0xF6, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0x0E, 0x71,
  0xC3, 0x38, 0x33, 0x83, 0x30, 0x37, 0x03, 0x70, 0x36, 0x03, 0x60, 0x7E,
  0x07, 0xE0, 0x7E, 0x06, 0xE0, 0xEE, 0x0E, 0xC0, 0xCE, 0x1C, 0xE1, 0x8E,
  0x38, 0x7F, 0x03, 0xE0, 0x07, 0x1E, 0x3E, 0x76, 0xEE, 0xCE, 0x0C, 0x0C,
  0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x30, 0x70, 0x70,
  0x60, 0x60, 0x03, 0xF8, 0x1F, 0xF0, 0x61, 0xC1, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x07, 0xF0, 0x7F, 0xC3, 0x0E, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x7F, 0x03, 0xC0, 0x1F,
  0x80, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x39,
  0x03, 0x8F, 0xF8, 0x7F, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3E,
  0x01, 0xF8, 0x06, 0xC0, 0x33, 0x01, 0xDC, 0x06, 0x70, 0x31, 0x81, 0x86,
  0x06, 0x18, 0x30, 0xE1, 0x83, 0x8E, 0x0C, 0x3F, 0xFE, 0xFF, 0xF0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x07, 0xFC, 0x1F, 0xE0,
  0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x1B, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x0E, 0x20, 0x70, 0xFF, 0x83, 0xFC, 0x00, 0x01,
  0xF8, 0x1F, 0xC1, 0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x73, 0x83, 0xFF, 0x1F, 0x38, 0xE0, 0xCE, 0x06, 0x70, 0x33, 0x81, 0x9C,
  0x0C, 0xE0, 0xE7, 0x07, 0x38, 0x70, 0xE3, 0x87, 0xF8, 0x1F, 0x80, 0x3F,
  0xFC, 0xFF, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00,
  0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xE1, 0xC3, 0x07, 0x1C, 0x1C, 0x70,
  0x71, 0xC1, 0x83, 0x0E, 0x0E, 0x70, 0x1F, 0x80, 0x78, 0x07, 0xF0, 0x38,
  0xE1, 0xC1, 0x86, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x06, 0x1C,
  0x38, 0x7F, 0xC0, 0xFE, 0x00, 0x03, 0xF0, 0x3F, 0x83, 0x8E, 0x38, 0x31,
  0x81, 0x9C, 0x0C, 0xE0, 0x67, 0x03, 0x38, 0x39, 0xC1, 0xCE, 0x1E, 0x7B,
  0xF1, 0xFB, 0x07, 0x98, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70,
  0x07, 0x0F, 0xF0, 0x7F, 0x00, 0x0C, 0x71, 0xC7, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x87, 0x3C, 0xE0, 0x03, 0x03, 0xC1, 0xC0, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x30,
  0x38, 0x18, 0x0C, 0x0C, 0x0E, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0x80, 0x04, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3C, 0x00, 0xF0, 0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x80, 0xE0,
  0x08, 0x00, 0x1F, 0x8F, 0xF2, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06,
  0x03, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x1C,
  0x07, 0x03, 0x00, 0x60, 0xC0, 0x06, 0x30, 0x00, 0xCE, 0x1F, 0x99, 0x87,
  0xE3, 0x71, 0x8C, 0x6C, 0x61, 0x8D, 0x8C, 0x71, 0xB3, 0x0C, 0x3C, 0x61,
  0x8D, 0x8C, 0x31, 0xB1, 0x8E, 0x36, 0x31, 0x8C, 0xC7, 0x7B, 0x98, 0xFB,
  0xE3, 0x04, 0x10, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x0C,
  0x00, 0xFF, 0x80, 0x07, 0x80, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x3E, 0x00, 0xD8, 0x03, 0x60, 0x19, 0xC0, 0x67, 0x03, 0x9C, 0x0C, 0x70,
  0x71, 0xC1, 0x87, 0x0E, 0x1C, 0x3F, 0xF1, 0xFF, 0xC7, 0x07, 0x18, 0x1C,
  0xE0, 0x73, 0x01, 0xDC, 0x07, 0x70, 0x1F, 0x80, 0x70, 0x07, 0xF8, 0x0F,
  0xF8, 0x38, 0x78, 0x70, 0x70, 0xE0, 0xE1, 0x81, 0xC3, 0x03, 0x8E, 0x0E,
  0x1C, 0x1C, 0x3F, 0xF0, 0x7F, 0x80, 0xFF, 0x83, 0x83, 0x87, 0x07, 0x0E,
  0x06, 0x18, 0x0C, 0x30, 0x38, 0xE0, 0x71, 0xC1, 0xC3, 0x07, 0x87, 0xFE,
  0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x1C, 0x10, 0x70, 0x01, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0xC2, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x07,
  0xFC, 0x0E, 0x1E, 0x0E, 0x0E, 0x0E, 0x06, 0x0C, 0x07, 0x0C, 0x07, 0x1C,
  0x07, 0x1C, 0x07, 0x1C, 0x07, 0x18, 0x06, 0x18, 0x0E, 0x38, 0x0E, 0x38,
  0x0E, 0x38, 0x1C, 0x30, 0x1C, 0x30, 0x38, 0x70, 0x38, 0x70, 0x70, 0x61,
  0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x7F, 0xC1, 0xFE,
  0x07, 0xF8, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0xE0, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x00, 0x01,
  0xFF, 0x03, 0xFF, 0x07, 0x83, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x7E, 0x60, 0x7E, 0x60,
  0xFC, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0x60, 0x18, 0x70, 0x18, 0x70,
  0x38, 0x78, 0x38, 0x3F, 0xF8, 0x1F, 0xF0, 0x07, 0x01, 0x83, 0x01, 0xC1,
  0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x30, 0x60, 0x18, 0x30, 0x1C, 0x38, 0x0E,
  0x1C, 0x06, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0x80, 0xE1, 0xC0,
  0x60, 0xE0, 0x30, 0x60, 0x38, 0x30, 0x1C, 0x38, 0x0E, 0x1C, 0x06, 0x0C,
  0x03, 0x06, 0x03, 0x87, 0x01, 0xC0, 0x0F, 0xF0, 0x7C, 0x03, 0x80, 0x38,
  0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80,
  0xFE, 0x0F, 0xE0, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x02, 0xF0, 0x1F, 0x01, 0xF0,
  0x00, 0x07, 0x07, 0x83, 0x07, 0x03, 0x83, 0x81, 0xC3, 0x80, 0xE3, 0x80,
  0x63, 0x80, 0x33, 0x80, 0x39, 0xC0, 0x1D, 0xC0, 0x0F, 0xC0, 0x06, 0xE0,
  0x03, 0xF0, 0x03, 0xDC, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x61, 0x80, 0x30,
  0xE0, 0x38, 0x70, 0x1C, 0x38, 0x0C, 0x0E, 0x06, 0x07, 0x07, 0x03, 0x80,
  0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01,
  0x80, 0x7F, 0xFF, 0xE0, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0xF8, 0x07,
  0xC3, 0xE0, 0x1F, 0x0D, 0x80, 0xF8, 0x36, 0x03, 0x60, 0xD8, 0x1F, 0x87,
  0x60, 0x6E, 0x1D, 0x83, 0xB8, 0x66, 0x0C, 0xC1, 0x98, 0x73, 0x06, 0x61,
  0x9C, 0x39, 0x8E, 0x70, 0xE6, 0x31, 0x83, 0x1D, 0xC6, 0x0C, 0x76, 0x38,
  0x31, 0xD8, 0xE1, 0xC7, 0xC3, 0x87, 0x0F, 0x0C, 0x18, 0x38, 0x30, 0x60,
  0xE1, 0xC3, 0x83, 0x07, 0x00, 0x07, 0x00, 0xC1, 0xC0, 0x70, 0xF8, 0x1C,
  0x3E, 0x07, 0x0D, 0x81, 0x83, 0x60, 0x60, 0xDC, 0x38, 0x77, 0x0E, 0x1C,
  0xC3, 0x06, 0x30, 0xC1, 0x8C, 0x30, 0x63, 0x9C, 0x38, 0xE7, 0x0E, 0x19,
  0x83, 0x06, 0x60, 0xC1, 0xF8, 0x30, 0x7E, 0x1C, 0x0F, 0x87, 0x03, 0xC1,
  0x80, 0xF0, 0x60, 0x3C, 0x38, 0x07, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x0F,
  0x0E, 0x0E, 0x06, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x30, 0x07, 0x70,
  0x07, 0x70, 0x07, 0x70, 0x07, 0x60, 0x06, 0x60, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0x60, 0x38, 0x70, 0x78, 0x78, 0xF0, 0x3F,
  0xE0, 0x1F, 0x80, 0x07, 0xF0, 0x1F, 0xE0, 0xE3, 0xC3, 0x87, 0x0E, 0x0C,
  0x30, 0x30, 0xC0, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0xE1, 0x87, 0x87, 0xFC,
  0x3F, 0xC0, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0x0E,
  0x0E, 0x06, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x30, 0x07, 0x70, 0x07,
  0x70, 0x07, 0x70, 0x07, 0x60, 0x06, 0x60, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x1C, 0xE0, 0x1C, 0x60, 0x38, 0x70, 0x78, 0x78, 0xF0, 0x3F, 0xE0,
  0x1F, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0,
  0x07, 0xF0, 0x1F, 0xE0, 0xE3, 0xC3, 0x87, 0x0E, 0x0C, 0x30, 0x30, 0xC0,
  0xC7, 0x07, 0x1C, 0x1C, 0x70, 0xE1, 0x9F, 0x87, 0xF8, 0x3F, 0xC0, 0xE7,
  0x03, 0x8C, 0x0C, 0x30, 0x30, 0xE1, 0xC3, 0x87, 0x06, 0x18, 0x18, 0x60,
  0x73, 0x81, 0xC0, 0x07, 0xFC, 0x3F, 0xE1, 0xE0, 0x87, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x30, 0xF0, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x0C, 0x07, 0x0C, 0x07, 0x1C, 0x07, 0x1C, 0x06, 0x18,
  0x06, 0x18, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0C, 0x30, 0x0C, 0x30,
  0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x18, 0x60, 0x38, 0x60, 0x38, 0xE0,
  0x38, 0xE0, 0x30, 0x60, 0x70, 0x70, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0xC0,
  0x3F, 0x00, 0xEC, 0x03, 0x30, 0x1C, 0xC0, 0x63, 0x03, 0x8C, 0x0C, 0x38,
  0x70, 0xE1, 0xC3, 0x8E, 0x0E, 0x38, 0x38, 0xC0, 0xE7, 0x03, 0x98, 0x0E,
  0xE0, 0x3B, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x01,
  0xC0, 0x00, 0xC0, 0x70, 0x1F, 0x01, 0xC0, 0xEC, 0x0F, 0x03, 0xB0, 0x3C,
  0x1C, 0xC0, 0xF0, 0x73, 0x06, 0xC1, 0x8C, 0x1B, 0x0E, 0x30, 0xEC, 0x38,
  0xC3, 0x31, 0xC3, 0x0C, 0xC7, 0x0C, 0x63, 0x18, 0x31, 0x8C, 0xE0, 0xCE,
  0x33, 0x03, 0x30, 0xDC, 0x0D, 0xC3, 0x70, 0x36, 0x0D, 0x80, 0xD8, 0x3E,
  0x03, 0xE0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xE0, 0x38, 0x03,
  0x80, 0xE0, 0x00, 0x07, 0x03, 0x81, 0x83, 0x80, 0xE1, 0xC0, 0x71, 0xC0,
  0x38, 0xC0, 0x0C, 0xE0, 0x06, 0x60, 0x03, 0x60, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1B, 0x00, 0x1D, 0x80, 0x1C,
  0xE0, 0x0C, 0x70, 0x0E, 0x38, 0x0E, 0x0C, 0x07, 0x06, 0x07, 0x03, 0x87,
  0x01, 0xC0, 0xC0, 0x7E, 0x06, 0xE0, 0xEE, 0x1C, 0xE1, 0xC6, 0x38, 0x63,
  0x06, 0x70, 0x66, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x38, 0x03, 0x00, 0x30,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x07,
  0xFE, 0x1F, 0xFC, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x03, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C,
  0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30,
  0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x07, 0xE0, 0xFC, 0x00, 0xE7, 0x18,
  0xC6, 0x31, 0x8E, 0x73, 0x8C, 0x63, 0x18, 0xC7, 0x38, 0xC6, 0x31, 0x8C,
  0x07, 0xF0, 0x7E, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C,
  0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0C, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0x00, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0xCC, 0x0E, 0x60, 0x63, 0x87, 0x0C, 0x30, 0x63, 0x83, 0x98, 0x0D, 0x80,
  0x70, 0xFF, 0xFF, 0xFC, 0xCE, 0x66, 0x30, 0x07, 0x98, 0x7E, 0xC7, 0x3E,
  0x70, 0xF3, 0x07, 0x38, 0x39, 0xC1, 0xCC, 0x0E, 0xE0, 0x77, 0x03, 0x38,
  0x39, 0xC1, 0xCE, 0x0E, 0x70, 0xE3, 0x8F, 0x0F, 0xD8, 0x7C, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03,
  0x3C, 0x0D, 0xF8, 0x7C, 0xE1, 0xE1, 0x87, 0x06, 0x1C, 0x1C, 0xE0, 0x63,
  0x81, 0x8E, 0x06, 0x30, 0x38, 0xC0, 0xE7, 0x03, 0x1C, 0x1C, 0x70, 0x61,
  0xE3, 0x87, 0xFC, 0x33, 0xE0, 0x07, 0xC1, 0xFC, 0x71, 0x1C, 0x03, 0x00,
  0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x43, 0xF8, 0x3F, 0x00, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x03, 0xCC, 0x0F, 0xD8, 0x39, 0xF0,
  0xE1, 0xE1, 0x83, 0x87, 0x07, 0x0E, 0x0E, 0x18, 0x1C, 0x70, 0x38, 0xE0,
  0x61, 0xC1, 0xC3, 0x83, 0x87, 0x07, 0x0E, 0x1C, 0x1C, 0x78, 0x1F, 0xB0,
  0x3E, 0x60, 0x07, 0xC1, 0xFC, 0x73, 0x9C, 0x33, 0x06, 0xE1, 0xD8, 0x3F,
  0x7E, 0xFF, 0x1E, 0x03, 0x80, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x23, 0xFC,
  0x3F, 0x00, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x7A, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF8, 0x03, 0xF8, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x03, 0xCC, 0x1F, 0xB0, 0xE7, 0xC7, 0x0F, 0x18,
  0x38, 0xE0, 0xE3, 0x83, 0x8C, 0x0E, 0x70, 0x39, 0xC0, 0xC7, 0x07, 0x1C,
  0x1C, 0x70, 0x71, 0xC3, 0x87, 0x1E, 0x0F, 0xD8, 0x3E, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0xC2, 0x0E, 0x0F, 0xF8, 0x3F, 0x80, 0x07, 0x00,
  0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x9E, 0x0D,
  0xF8, 0xF9, 0xC7, 0x86, 0x38, 0x31, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x06,
  0x30, 0x31, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x06, 0x30, 0x31, 0x83, 0x9C,
  0x1C, 0x06, 0x07, 0x0E, 0x04, 0x00, 0x00, 0x0C, 0x0C, 0x1C, 0x1C, 0x18,
  0x18, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x60, 0x60, 0xE0,
  0x00, 0x60, 0x07, 0x00, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x0C,
  0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30,
  0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0xF8, 0x0F, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x07, 0x0C,
  0x38, 0x71, 0xC1, 0xCE, 0x06, 0x30, 0x19, 0x80, 0xEE, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x80, 0xEE, 0x07, 0x18, 0x1C, 0x60, 0x61, 0xC1, 0x87, 0x06,
  0x0C, 0x38, 0x38, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C,
  0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x60,
  0x60, 0x60, 0xE0, 0x0C, 0xF1, 0xE0, 0xDF, 0x3F, 0x1F, 0x7E, 0x71, 0xE3,
  0xC3, 0x1C, 0x38, 0x31, 0x83, 0x83, 0x38, 0x38, 0x73, 0x83, 0x07, 0x38,
  0x30, 0x63, 0x07, 0x06, 0x30, 0x70, 0x67, 0x06, 0x0E, 0x70, 0x60, 0xE7,
  0x06, 0x0C, 0x60, 0xE0, 0xC6, 0x0E, 0x1C, 0xE0, 0xC1, 0xC0, 0x0C, 0xF0,
  0xEF, 0xC7, 0xDE, 0x3C, 0x31, 0xC1, 0x8E, 0x1C, 0xE0, 0xE7, 0x07, 0x38,
  0x31, 0x81, 0x8C, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x31, 0x81, 0x9C, 0x1C,
  0xE0, 0xE0, 0x07, 0x80, 0xFE, 0x1C, 0xE3, 0x87, 0x30, 0x77, 0x03, 0x60,
  0x76, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x6E, 0x0E, 0xE0, 0xEE, 0x1C, 0xE3,
  0xC7, 0xF8, 0x3E, 0x00, 0x06, 0x78, 0x0D, 0xF8, 0x3E, 0x70, 0x78, 0x60,
  0xE0, 0xC1, 0xC1, 0xC7, 0x03, 0x0E, 0x06, 0x1C, 0x0C, 0x30, 0x38, 0x60,
  0x71, 0xC0, 0xC3, 0x83, 0x87, 0x07, 0x0F, 0x1C, 0x1F, 0xF0, 0x77, 0xC0,
  0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60,
  0x00, 0x07, 0x98, 0x7E, 0xC7, 0x3E, 0x70, 0xF3, 0x07, 0x38, 0x39, 0xC1,
  0xCC, 0x0E, 0xE0, 0x77, 0x03, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0xE3,
  0x8F, 0x0F, 0xD8, 0x7D, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x0C, 0xE1, 0xBC, 0x6F, 0x0F, 0x01, 0xC0, 0x38,
  0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18,
  0x03, 0x00, 0xE0, 0x00, 0x07, 0x83, 0xFC, 0xF1, 0x1C, 0x03, 0x00, 0x70,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x20,
  0xE7, 0xF8, 0xFE, 0x00, 0x0C, 0x0C, 0x1C, 0x3F, 0x7F, 0x38, 0x38, 0x30,
  0x30, 0x70, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xF8, 0x78,
  0x18, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x63, 0x03, 0x18, 0x39, 0xC1, 0xCE,
  0x0C, 0x60, 0x63, 0x03, 0x18, 0x39, 0xC1, 0xCE, 0x1C, 0x70, 0xE3, 0x8F,
  0x1F, 0xD8, 0x7D, 0xC0, 0xC0, 0x78, 0x1F, 0x03, 0x60, 0xEC, 0x19, 0x87,
  0x30, 0xC6, 0x38, 0xC6, 0x19, 0xC3, 0x30, 0x66, 0x0F, 0xC1, 0xB0, 0x3E,
  0x07, 0x80, 0xF0, 0x00, 0xC1, 0xC1, 0xF0, 0x70, 0x6C, 0x1C, 0x3B, 0x0F,
  0x0E, 0xC3, 0xC3, 0x31, 0xB1, 0xCC, 0x6C, 0x63, 0x1B, 0x38, 0xCC, 0xCE,
  0x33, 0x33, 0x0D, 0x8D, 0xC3, 0x63, 0x60, 0xD8, 0xD8, 0x3C, 0x3C, 0x0F,
  0x0F, 0x03, 0x83, 0xC0, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x30, 0xE0, 0xC3,
  0x83, 0x9C, 0x06, 0x60, 0x1B, 0x80, 0x7C, 0x01, 0xE0, 0x07, 0x00, 0x1E,
  0x00, 0xF8, 0x07, 0x60, 0x19, 0x80, 0xE7, 0x07, 0x0C, 0x18, 0x30, 0xE0,
  0xE0, 0x06, 0x03, 0x06, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x06, 0x0C, 0x07,
  0x1C, 0x07, 0x18, 0x07, 0x38, 0x07, 0x30, 0x07, 0x30, 0x07, 0x70, 0x03,
  0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x0F,
  0xF8, 0xFF, 0x80, 0x01, 0xE0, 0x7C, 0x0E, 0x03, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x0F, 0x81, 0xC0, 0x1C, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x78, 0x07, 0x80, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0x80, 0x7C, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0,
  0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xF0, 0x07, 0x03, 0xE0,
  0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x3C, 0x0F, 0x80, 0xE0, 0x00, 0x3C, 0x0B, 0xF8, 0xF9, 0xFF, 0x03,
  0xE0,
};

const GFXglyph NotoSans_Condensed_Italic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 22, 8, 0, -22 },
  { 23, 9, 8, 11, 3, -22 },
  { 32, 16, 22, 15, 0, -22 },
  { 76, 14, 26, 14, 0, -24 },
  { 122, 18, 22, 21, 2, -22 },
  { 172, 15, 22, 16, 0, -22 },
  { 214, 4, 8, 6, 3, -22 },
  { 218, 9, 27, 8, 1, -22 },
  { 249, 9, 27, 8, -2, -22 },
  { 280, 11, 12, 13, 3, -24 },
  { 297, 12, 14, 15, 2, -18 },
  { 318, 5, 8, 7, -1, -4 },
  { 323, 7, 3, 9, 1, -10 },
  { 326, 4, 4, 7, 0, -4 },
  { 328, 14, 22, 11, -1, -22 },
  { 367, 12, 22, 14, 1, -22 },
  { 400, 8, 22, 14, 4, -22 },
  { 422, 14, 22, 14, -1, -22 },
  { 461, 13, 22, 14, 0, -22 },
  { 497, 14, 22, 14, 0, -22 },
  { 536, 14, 22, 14, 0, -22 },
  { 575, 13, 22, 14, 1, -22 },
  { 611, 14, 22, 14, 1, -22 },
  { 650, 14, 22, 14, 0, -22 },
  { 689, 13, 22, 14, 0, -22 },
  { 725, 6, 17, 7, 0, -17 },
  { 738, 9, 21, 7, -2, -17 },
  { 762, 13, 14, 15, 1, -18 },
  { 785, 12, 8, 15, 2, -15 },
  { 797, 12, 14, 15, 2, -18 },
  { 818, 10, 22, 10, 1, -22 },
  { 846, 19, 25, 21, 1, -22 },
  { 906, 14, 22, 14, -2, -22 },
  { 945, 15, 22, 15, 0, -22 },
  { 987, 15, 22, 14, 1, -22 },
  { 1029, 16, 22, 16, 0, -22 },
  { 1073, 14, 22, 13, 0, -22 },
  { 1112, 14, 22, 12, 0, -22 },
  { 1151, 16, 22, 17, 1, -22 },
  { 1195, 17, 22, 17, 0, -22 },
  { 1242, 12, 22, 9, -1, -22 },
  { 1275, 13, 28, 7, -5, -22 },
  { 1321, 17, 22, 14, 0, -22 },
  { 1368, 10, 22, 12, 0, -22 },
  { 1396, 22, 22, 22, 0, -22 },
  { 1457, 18, 22, 18, 0, -22 },
  { 1507, 16, 22, 17, 1, -22 },
  { 1551, 14, 22, 14, 0, -22 },
  { 1590, 16, 27, 17, 1, -22 },
  { 1644, 14, 22, 14, 0, -22 },
  { 1683, 14, 22, 13, 0, -22 },
  { 1722, 12, 22, 12, 3, -22 },
  { 1755, 16, 22, 17, 1, -22 },
  { 1799, 14, 22, 14, 3, -22 },
  { 1838, 22, 22, 22, 3, -22 },
  { 1899, 17, 22, 13, -2, -22 },
  { 1946, 12, 22, 12, 3, -22 },
  { 1979, 15, 22, 12, -1, -22 },
  { 2021, 12, 27, 9, -1, -22 },
  { 2062, 5, 22, 11, 3, -22 },
  { 2076, 12, 27, 9, -2, -22 },
  { 2117, 13, 12, 14, 1, -22 },
  { 2137, 11, 2, 10, -3, 3 },
  { 2140, 4, 5, 8, 5, -24 },
  { 2143, 13, 17, 14, 1, -17 },
  { 2171, 14, 24, 14, 0, -24 },
  { 2213, 11, 17, 11, 1, -17 },
  { 2237, 15, 24, 15, 1, -24 },
  { 2282, 11, 17, 13, 1, -17 },
  { 2306, 16, 31, 8, -4, -24 },
  { 2368, 14, 24, 15, 0, -17 },
  { 2410, 13, 24, 14, 0, -24 },
  { 2449, 8, 23, 7, 0, -23 },
  { 2472, 12, 30, 7, -4, -23 },
  { 2517, 14, 24, 12, 0, -24 },
  { 2559, 8, 24, 7, 0, -24 },
  { 2583, 20, 17, 21, 0, -17 },
  { 2626, 13, 17, 14, 0, -17 },
  { 2654, 12, 17, 14, 1, -17 },
  { 2680, 15, 24, 14, -1, -17 },
  { 2725, 13, 24, 15, 1, -17 },
  { 2764, 11, 17, 10, 0, -17 },
  { 2788, 11, 17, 11, 0, -17 },
  { 2812, 8, 20, 8, 1, -20 },
  { 2832, 13, 17, 14, 1, -17 },
  { 2860, 11, 17, 12, 2, -17 },
  { 2884, 18, 17, 19, 2, -17 },
  { 2923, 14, 17, 12, -1, -17 },
  { 2953, 16, 24, 12, -3, -17 },
  { 3001, 12, 17, 10, -1, -17 },
  { 3027, 11, 27, 10, 1, -22 },
  { 3065, 2, 31, 13, 6, -24 },
  { 3073, 12, 27, 10, -2, -22 },
  { 3114, 13, 4, 15, 1, -13 },
};

const GFXfont NotoSans_Condensed_Italic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic31pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_CONDENSED_ITALIC31PT7B_H_
