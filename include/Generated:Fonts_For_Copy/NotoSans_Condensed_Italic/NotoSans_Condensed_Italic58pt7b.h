#ifndef _NOTOSANS_CONDENSED_ITALIC58PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8,
  0x01, 0x80, 0x00, 0x3E, 0x1F, 0x9F, 0x0F, 0x8F, 0x87, 0xC7, 0x83, 0xC7,
  0xC1, 0xE3, 0xE1, 0xF1, 0xE0, 0xF8, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E,
  0x1C, 0x0F, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x83, 0xC3, 0x81, 0xC0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x78, 0x1E,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x0F, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC0, 0x0E, 0x07, 0x80, 0x00, 0xF0, 0x3C,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78,
  0x1E, 0x00, 0x03, 0xC0, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0x81, 0xE0, 0x00,
  0x3C, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0,
  0x3C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x78, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xF9, 0xC7, 0x01,
  0xF0, 0xE0, 0x80, 0xF8, 0x60, 0x00, 0x78, 0x70, 0x00, 0x3C, 0x38, 0x00,
  0x1E, 0x1C, 0x00, 0x0F, 0x0C, 0x00, 0x07, 0x8E, 0x00, 0x03, 0xE7, 0x00,
  0x01, 0xF3, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0E, 0xFC, 0x00, 0x07, 0x3E, 0x00, 0x03, 0x8F, 0x80, 0x01,
  0x87, 0xC0, 0x01, 0xC3, 0xE0, 0x00, 0xE1, 0xF0, 0x00, 0x70, 0xF8, 0x00,
  0x38, 0x78, 0x00, 0x18, 0x7C, 0x18, 0x1C, 0x7E, 0x0F, 0x0E, 0x7E, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x02, 0x01,
  0xFE, 0x00, 0x0E, 0x01, 0xFF, 0x80, 0x0F, 0x00, 0xFF, 0xC0, 0x0F, 0x00,
  0xF0, 0xE0, 0x07, 0x80, 0xF0, 0x78, 0x07, 0x80, 0x78, 0x3C, 0x03, 0x80,
  0x78, 0x1E, 0x03, 0xC0, 0x3C, 0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x81, 0xE0,
  0x0E, 0x03, 0x81, 0xE0, 0x0F, 0x01, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0xF0,
  0x03, 0xC0, 0xF0, 0xF0, 0x01, 0xC0, 0x78, 0x78, 0x00, 0xE0, 0x3C, 0x78,
  0x00, 0xF0, 0x3C, 0x3C, 0x00, 0x78, 0x1E, 0x3C, 0x3F, 0x3C, 0x0F, 0x3C,
  0x3F, 0xDE, 0x0F, 0x1E, 0x3F, 0xFF, 0x07, 0x9E, 0x3C, 0x7B, 0xC7, 0x8F,
  0x3C, 0x3D, 0xFF, 0xCF, 0x1E, 0x0E, 0xFF, 0xC7, 0x9E, 0x07, 0x3F, 0xC7,
  0x8F, 0x03, 0x8F, 0x87, 0x87, 0x01, 0xC0, 0x03, 0xC7, 0x81, 0xE0, 0x03,
  0xC3, 0xC0, 0xF0, 0x01, 0xE1, 0xE0, 0x78, 0x01, 0xE0, 0xE0, 0x3C, 0x01,
  0xE0, 0xF0, 0x1E, 0x00, 0xF0, 0x78, 0x0E, 0x00, 0xF0, 0x3C, 0x0F, 0x00,
  0x78, 0x1E, 0x07, 0x80, 0x78, 0x0F, 0x03, 0x80, 0x7C, 0x07, 0x83, 0xC0,
  0x3C, 0x03, 0xC1, 0xE0, 0x3C, 0x01, 0xE1, 0xE0, 0x1E, 0x00, 0xF9, 0xF0,
  0x1E, 0x00, 0x3F, 0xF0, 0x0F, 0x00, 0x1F, 0xF0, 0x0F, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x1F,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x03, 0xE0, 0x00,
  0xF8, 0x3C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0x9F,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0x01, 0xF0, 0x7C, 0xF8, 0x1F, 0x0F, 0x8F, 0x81, 0xE1, 0xF0, 0x7C, 0x3E,
  0x3E, 0x07, 0xC3, 0xE3, 0xE0, 0x7E, 0x7C, 0x7C, 0x03, 0xE7, 0xC7, 0xC0,
  0x3E, 0xF8, 0x78, 0x01, 0xFF, 0x0F, 0x80, 0x1F, 0xF0, 0xF8, 0x00, 0xFE,
  0x0F, 0x80, 0x0F, 0xE0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0xC0, 0x7C,
  0x03, 0xFE, 0x07, 0xE0, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xF1,
  0xF0, 0x1F, 0xFE, 0x1F, 0x80, 0xFF, 0x80, 0xF8, 0x01, 0x80, 0x00, 0x00,
  0x3F, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0x70,
  0xF0, 0xF0, 0xE0, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x06, 0x07, 0x00, 0x78, 0x70, 0x0F, 0xE7,
  0x00, 0xFF, 0xF7, 0xF3, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x03,
  0xF0, 0x00, 0x7B, 0x80, 0x0F, 0x3C, 0x01, 0xF3, 0xC0, 0x3E, 0x1E, 0x07,
  0xC1, 0xE0, 0x38, 0x1F, 0x01, 0x80, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F,
  0x03, 0xE0, 0xF8, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C,
  0x00, 0x7F, 0xFD, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x39, 0xFF,
  0xFF, 0xFF, 0xFF, 0x88, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x1F, 0xCF, 0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x0F, 0x83, 0xF0,
  0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01,
  0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0x80, 0x0F, 0x9F, 0x00, 0x1F,
  0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xE7,
  0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0xF8,
  0x00, 0x79, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80,
  0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xF8, 0x03,
  0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x7C, 0x0F, 0x81, 0xF8,
  0x0F, 0x87, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xE0, 0x7F, 0xC3, 0xFF, 0x8F, 0xDF, 0x3F, 0x3C, 0xFC, 0xF9, 0xF1,
  0xF1, 0x83, 0xE2, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0xFE, 0x3F, 0x80, 0x1C, 0x03, 0xF0, 0x06, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0x83, 0xF0, 0x07, 0x00, 0xFC, 0x02,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x08, 0x00, 0x3F, 0x07,
  0x00, 0x7F, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0x78, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x7C, 0x00, 0x07,
  0x9F, 0x00, 0x03, 0xC7, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF8, 0x78, 0x00,
  0x3C, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x83, 0xC0, 0x03, 0xC0, 0xF0,
  0x01, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3C, 0x07, 0xC0, 0x1E, 0x01,
  0xE0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x80, 0xF0,
  0x03, 0xE0, 0x7C, 0x00, 0xF0, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x02, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x02, 0x00, 0x0F, 0xC0, 0xE0, 0x0F, 0xE0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0x82, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x3E, 0x7F, 0xE0, 0x3E,
  0xFF, 0xE0, 0x3D, 0xFF, 0xF0, 0x7F, 0xC3, 0xF8, 0x7F, 0x01, 0xF8, 0x7E,
  0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8,
  0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0x80, 0xF8,
  0x0F, 0x80, 0x3E, 0x07, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07,
  0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xE0, 0x7C, 0x01, 0xF0, 0x1E, 0x00,
  0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xFD,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x8F, 0xC0, 0x1F, 0x83, 0xF0, 0x1F,
  0x80, 0xF8, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x87,
  0xC0, 0x07, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF8,
  0x78, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F,
  0x07, 0xE0, 0x1F, 0x01, 0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x50, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xF8, 0x7E, 0x03,
  0xF0, 0x3E, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x1F, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x3E, 0x1E,
  0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0xFE, 0x1F,
  0x81, 0xFE, 0x0F, 0xEF, 0xFC, 0x0F, 0xFF, 0xBC, 0x07, 0xFF, 0x7C, 0x03,
  0xFC, 0x7C, 0x00, 0x70, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x1E, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3E, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x3E, 0x07, 0xE0, 0x7E,
  0x0F, 0xE0, 0xFC, 0x07, 0xC0, 0x20, 0x00, 0x00, 0x08, 0x00, 0x7C, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF,
  0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xF0, 0xFE, 0x18, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xC0,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x7F,
  0xC0, 0xF0, 0xF0, 0x0F, 0xFE, 0x0F, 0x0F, 0x01, 0xFF, 0xE0, 0xF1, 0xE0,
  0x3C, 0x1C, 0x0F, 0x1E, 0x07, 0x83, 0xC0, 0xF3, 0xC0, 0xF0, 0x3C, 0x0F,
  0x3C, 0x0F, 0x03, 0xC0, 0xE3, 0x81, 0xE0, 0x38, 0x0E, 0x78, 0x1E, 0x07,
  0x81, 0xE7, 0x83, 0xC0, 0x78, 0x1E, 0x78, 0x3C, 0x07, 0x81, 0xE7, 0x03,
  0x80, 0x70, 0x1C, 0x70, 0x78, 0x0F, 0x01, 0xCF, 0x07, 0x80, 0xF0, 0x3C,
  0xF0, 0x78, 0x0F, 0x03, 0x8F, 0x07, 0x81, 0xE0, 0x78, 0xF0, 0x78, 0x1E,
  0x07, 0x8F, 0x07, 0x83, 0xE0, 0xF0, 0xF0, 0x78, 0x3E, 0x0F, 0x0F, 0x07,
  0x87, 0xF1, 0xE0, 0xF0, 0x7F, 0xE7, 0xFC, 0x0F, 0x03, 0xFC, 0x7F, 0x80,
  0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0x00, 0x20, 0x08, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x06, 0x00, 0x00, 0xFF, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01,
  0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE0, 0xF8,
  0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C,
  0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07,
  0xC0, 0x07, 0xC1, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x0F, 0xC0, 0x01,
  0xE1, 0xF0, 0x00, 0x3C, 0x7E, 0x00, 0x07, 0x8F, 0x80, 0x00, 0xFB, 0xF0,
  0x00, 0x1F, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F,
  0x01, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0,
  0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xE0,
  0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0x07, 0xF8, 0x03,
  0xC0, 0x1F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x03,
  0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C,
  0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3E,
  0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0xFE, 0x07, 0x80,
  0x7F, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFC, 0xF8, 0x03, 0xF8, 0x03,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x01, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xF0, 0x1F, 0xC0,
  0x1F, 0x00, 0x7E, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x3F, 0x01, 0xE0,
  0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F,
  0x03, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C,
  0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x0F,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0x83,
  0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xF0, 0x7C, 0x00,
  0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x01, 0xFC, 0x07, 0xC0, 0x7F, 0x80,
  0x78, 0x3F, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xFC, 0x3F, 0x00, 0x7F, 0x00, 0x38, 0x07, 0xE0,
  0x00, 0x40, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x0F, 0xFC, 0x7C, 0x00, 0xFF, 0xE3, 0xE0, 0x07, 0xFF, 0x1F,
  0x00, 0x3F, 0xF8, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3C, 0x3E, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xE0,
  0x03, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8,
  0x07, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x7C, 0x07,
  0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0,
  0x1F, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x01, 0xF0, 0x1F,
  0x00, 0x03, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x21,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x3E,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xE0, 0x3E, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF3,
  0xF0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0xFB, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFE, 0xF8, 0x00, 0x07, 0xF3, 0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x00,
  0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x1F,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x78, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xE0,
  0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0xBC, 0x01, 0xFF, 0x00,
  0x07, 0xFE, 0x01, 0xF7, 0x80, 0x03, 0xDF, 0x00, 0xFB, 0xC0, 0x03, 0xEF,
  0x80, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x01, 0xF7, 0xC0, 0x1E,
  0x78, 0x00, 0xF3, 0xE0, 0x1F, 0x3C, 0x00, 0xF9, 0xF0, 0x0F, 0x9E, 0x00,
  0x78, 0xF0, 0x07, 0x8F, 0x00, 0x7C, 0xF8, 0x03, 0xC7, 0x80, 0x3C, 0x7C,
  0x03, 0xE3, 0xC0, 0x1E, 0x3E, 0x01, 0xF1, 0xE0, 0x1F, 0x1F, 0x00, 0xF8,
  0xF0, 0x0F, 0x0F, 0x00, 0x78, 0x7C, 0x0F, 0x8F, 0x80, 0x3C, 0x3E, 0x07,
  0x87, 0xC0, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x83, 0xC1, 0xF0,
  0x0F, 0x83, 0xC3, 0xE0, 0xF0, 0x07, 0x81, 0xE1, 0xE0, 0xF8, 0x03, 0xC0,
  0xF1, 0xF0, 0x7C, 0x03, 0xE0, 0x78, 0xF0, 0x3E, 0x01, 0xF0, 0x3C, 0xF8,
  0x1F, 0x00, 0xF0, 0x1E, 0x78, 0x0F, 0x00, 0x78, 0x0F, 0x7C, 0x0F, 0x80,
  0x7C, 0x07, 0xBC, 0x07, 0xC0, 0x3E, 0x03, 0xFE, 0x03, 0xE0, 0x1F, 0x01,
  0xFE, 0x01, 0xF0, 0x0F, 0x00, 0xFF, 0x01, 0xF0, 0x07, 0x80, 0x7F, 0x00,
  0xF8, 0x07, 0xC0, 0x3F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x3E, 0x01,
  0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x07, 0xC0, 0x3F, 0x80, 0x03, 0xE0,
  0x1F, 0xC0, 0x01, 0xE0, 0x1F, 0xE0, 0x01, 0xF0, 0x0F, 0xF0, 0x00, 0xF8,
  0x07, 0xFC, 0x00, 0x7C, 0x03, 0xFE, 0x00, 0x3C, 0x01, 0xEF, 0x00, 0x1E,
  0x01, 0xF7, 0x80, 0x1F, 0x00, 0xFB, 0xC0, 0x0F, 0x80, 0x79, 0xF0, 0x07,
  0xC0, 0x3C, 0xF8, 0x03, 0xC0, 0x1E, 0x3C, 0x01, 0xE0, 0x1F, 0x1E, 0x01,
  0xF0, 0x0F, 0x8F, 0x80, 0xF8, 0x07, 0x87, 0xC0, 0x7C, 0x03, 0xC1, 0xE0,
  0x3C, 0x03, 0xE0, 0xF0, 0x3E, 0x01, 0xF0, 0x78, 0x1F, 0x00, 0xF8, 0x3E,
  0x0F, 0x80, 0x78, 0x1F, 0x07, 0xC0, 0x3C, 0x07, 0x83, 0xC0, 0x3E, 0x03,
  0xC3, 0xE0, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x80, 0xF8, 0xF8, 0x07, 0x80,
  0x3C, 0x78, 0x03, 0xC0, 0x1E, 0x3C, 0x03, 0xE0, 0x0F, 0xBE, 0x01, 0xF0,
  0x07, 0xDF, 0x00, 0xF8, 0x01, 0xEF, 0x80, 0x78, 0x00, 0xF7, 0x80, 0x7C,
  0x00, 0x7B, 0xC0, 0x3E, 0x00, 0x3F, 0xE0, 0x1F, 0x00, 0x1F, 0xF0, 0x0F,
  0x00, 0x07, 0xF8, 0x07, 0x80, 0x03, 0xF8, 0x07, 0xC0, 0x01, 0xFC, 0x03,
  0xE0, 0x00, 0xFE, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x7E, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x3E,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F,
  0xDF, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3E,
  0x00, 0x01, 0xF9, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F,
  0x07, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x01, 0xF0, 0x3F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFC,
  0x07, 0xC0, 0x1F, 0x01, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x7C,
  0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x81, 0xE0, 0x07, 0xC0,
  0xF8, 0x03, 0xF0, 0x3E, 0x03, 0xF8, 0x0F, 0x8F, 0xFC, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0,
  0x7E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xF1, 0xF0,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x3E, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x1F, 0x3E, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C,
  0x7C, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x81, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x01, 0xF0, 0x3F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x07,
  0xC0, 0x1F, 0x01, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C,
  0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF0, 0x03, 0xF0, 0x7C, 0x00,
  0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x0F, 0xC0, 0xF8,
  0x07, 0xE0, 0x3E, 0x0F, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xC1, 0xF0,
  0x01, 0xF0, 0x7C, 0x00, 0x78, 0x1F, 0x00, 0x3E, 0x03, 0xC0, 0x0F, 0x80,
  0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x78, 0x01, 0xF8,
  0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFD, 0xFC, 0x01, 0xF8, 0x03, 0x00, 0x7E,
  0x00, 0x20, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x04, 0x00, 0x3F, 0x00, 0xF0, 0x1F, 0xE0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xE0,
  0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0xF8, 0x1E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x03, 0xE0,
  0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x3C, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0,
  0x7C, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0,
  0x3E, 0x00, 0x3E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xEF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00,
  0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x07, 0x80, 0x0F, 0x81, 0xE0, 0x07, 0xC0, 0x78, 0x01, 0xF0,
  0x1E, 0x00, 0x7C, 0x07, 0x80, 0x3E, 0x01, 0xE0, 0x0F, 0x80, 0x78, 0x07,
  0xC0, 0x1E, 0x01, 0xF0, 0x07, 0x80, 0xF8, 0x01, 0xE0, 0x3E, 0x00, 0x78,
  0x1F, 0x00, 0x1E, 0x07, 0xC0, 0x07, 0x81, 0xE0, 0x01, 0xF0, 0xF8, 0x00,
  0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF3, 0xE0,
  0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x80, 0x07, 0xDF,
  0x00, 0x0F, 0xC0, 0x03, 0xEF, 0x80, 0x0F, 0xE0, 0x03, 0xE7, 0xC0, 0x07,
  0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xFC, 0x00,
  0xF8, 0xF8, 0x01, 0xFE, 0x00, 0x78, 0x7C, 0x01, 0xEF, 0x00, 0x7C, 0x3E,
  0x00, 0xF7, 0x80, 0x3E, 0x1F, 0x00, 0x7B, 0xC0, 0x3E, 0x0F, 0x80, 0x79,
  0xE0, 0x1F, 0x07, 0xC0, 0x3C, 0xF0, 0x0F, 0x03, 0xE0, 0x3C, 0x78, 0x0F,
  0x81, 0xF0, 0x1E, 0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x1E, 0x07, 0xC0, 0x7C,
  0x0F, 0x0F, 0x03, 0xE0, 0x3E, 0x07, 0x87, 0x83, 0xE0, 0x1F, 0x07, 0x83,
  0xC1, 0xF0, 0x0F, 0x83, 0xC1, 0xE0, 0xF0, 0x07, 0xC3, 0xE0, 0xF0, 0xF8,
  0x03, 0xE1, 0xE0, 0x78, 0x7C, 0x01, 0xF0, 0xF0, 0x3C, 0x7C, 0x00, 0xF8,
  0xF0, 0x1E, 0x3E, 0x00, 0x7C, 0x78, 0x0F, 0x1E, 0x00, 0x3E, 0x7C, 0x07,
  0x9F, 0x00, 0x1F, 0x3C, 0x03, 0xCF, 0x80, 0x0F, 0x9E, 0x01, 0xE7, 0x80,
  0x07, 0xDE, 0x00, 0xF7, 0xC0, 0x03, 0xEF, 0x00, 0x7B, 0xC0, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7B, 0xC0, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x1E, 0x01, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x0F, 0x0F, 0x80, 0x00,
  0x0F, 0x1F, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF3, 0xC0, 0x07, 0xC7, 0xC0,
  0x0F, 0x8F, 0x80, 0x3E, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x07,
  0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x3E, 0x01, 0xE0, 0x7C, 0x03, 0xE1, 0xF0,
  0x07, 0xC3, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x1E, 0x7C, 0x00,
  0x3D, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0xF8,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x83,
  0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0xF1, 0xE0, 0x00,
  0xF1, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xC0, 0xF8, 0x07,
  0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0x7C, 0x0F, 0x00, 0x3C, 0x1E,
  0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x1F, 0x78,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFC, 0x3E, 0x0F, 0x87, 0xC1, 0xE0, 0xF8, 0x3C, 0x0F,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xC3, 0xC0, 0x7F, 0xF3, 0xC0,
  0x7F, 0xF9, 0xE0, 0x3F, 0xBE, 0xF0, 0x3F, 0x07, 0xF8, 0x3F, 0x01, 0xFC,
  0x1F, 0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x0F,
  0x87, 0xC0, 0x07, 0x83, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01,
  0xF0, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0x78, 0x7C, 0x00, 0x7C, 0x3E, 0x00,
  0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0x83, 0xE0,
  0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x3E,
  0x03, 0xF8, 0x1F, 0x83, 0xBC, 0x07, 0xF7, 0xDE, 0x03, 0xFF, 0xCF, 0x00,
  0xFF, 0xCF, 0x00, 0x3F, 0x87, 0x80, 0x06, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x07, 0x00, 0x0F, 0x8F, 0xE0, 0x07, 0x9F, 0xF8, 0x07, 0xDF, 0xFE,
  0x03, 0xFF, 0x7F, 0x01, 0xEE, 0x0F, 0xC0, 0xFE, 0x03, 0xE0, 0x7E, 0x01,
  0xF0, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80,
  0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0,
  0x01, 0xF0, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x87,
  0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xE0,
  0xFF, 0x07, 0xE0, 0x7B, 0xEF, 0xF0, 0x3C, 0xFF, 0xF0, 0x1E, 0x7F, 0xF0,
  0x1E, 0x1F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0x00, 0x07, 0xFF,
  0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFD, 0xE0, 0x7E, 0x02, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x20, 0x7F, 0xBE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0xE0, 0xF8, 0x00, 0xFF, 0x1E, 0x00, 0x7F, 0xF3, 0xC0, 0x1F, 0xFF, 0x78,
  0x03, 0xFB, 0xFF, 0x00, 0xFC, 0x1F, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC0,
  0x3F, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81,
  0xF0, 0x01, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01,
  0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0x81, 0xF0, 0x01, 0xF0, 0x3E,
  0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3E,
  0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x01, 0xF8, 0x0F, 0x80, 0x3F, 0x01, 0xF0,
  0x0F, 0xC0, 0x3E, 0x03, 0xF8, 0x07, 0xE0, 0xEF, 0x00, 0x7F, 0x7D, 0xE0,
  0x0F, 0xFF, 0x7C, 0x00, 0xFF, 0xCF, 0x00, 0x0F, 0xE1, 0xE0, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0xE0, 0x3F, 0x1F, 0x83, 0xE0, 0x7C, 0x3E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F,
  0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3C, 0x78, 0x03, 0xE7, 0xC0, 0x3E,
  0x3E, 0x07, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF,
  0x80, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x03, 0x07, 0xF9, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01,
  0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x47, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xFC, 0x3C, 0x00, 0xFF, 0xCF, 0x00, 0x7F,
  0xFD, 0xE0, 0x0F, 0xEF, 0xBC, 0x03, 0xF0, 0x7F, 0x80, 0xFC, 0x07, 0xE0,
  0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0x3E, 0x07, 0xC0, 0x0F, 0x80, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07,
  0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1E, 0x00, 0x1E, 0x07, 0xC0, 0x07,
  0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0x7C,
  0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x07, 0xE0, 0x3E, 0x01, 0xFC,
  0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x0F, 0xE0, 0x1F, 0x83, 0xBC, 0x01, 0xFD,
  0xFF, 0x80, 0x3F, 0xFD, 0xF0, 0x03, 0xFF, 0x3C, 0x00, 0x3F, 0x87, 0x80,
  0x00, 0x81, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x80, 0x0F, 0x80, 0x1E, 0x07, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x07, 0x00, 0x0F, 0x9F, 0xE0, 0x07, 0x9F, 0xF8, 0x07,
  0xDF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFE, 0x0F, 0xC0, 0xFE, 0x03, 0xE0,
  0x7E, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x78, 0x1F, 0x00, 0x3C,
  0x0F, 0x80, 0x3E, 0x07, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07,
  0x81, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xE0, 0x78, 0x01, 0xF0, 0x7C, 0x00,
  0xF8, 0x3E, 0x00, 0x78, 0x1F, 0x00, 0x7C, 0x0F, 0x00, 0x3E, 0x0F, 0x80,
  0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0x81, 0xF0, 0x07, 0xC0, 0xF0,
  0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF0, 0x3E, 0x00, 0x78, 0x1E,
  0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x38, 0x01, 0xF0, 0x07, 0xC0,
  0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x78, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x08, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x40, 0x7C,
  0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x07, 0x80, 0xF8, 0x03, 0xE0, 0x7E, 0x00,
  0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x07, 0xC0, 0x07, 0xC3, 0xE0,
  0x01, 0xF1, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0x9F,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFD, 0xF0, 0x00, 0x7E, 0x3E, 0x00,
  0x1F, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x1F,
  0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xC0, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3E, 0x03,
  0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x03, 0x80, 0x07, 0x8F, 0xF0, 0x3F, 0xC0,
  0x1E, 0x7F, 0xE1, 0xFF, 0x80, 0x7B, 0xFF, 0x9F, 0xFE, 0x03, 0xDF, 0x7F,
  0x7D, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xF0, 0x3F, 0x01, 0xFC, 0x07, 0xC0,
  0xFC, 0x07, 0xF0, 0x1F, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x7C,
  0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0x1E, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0,
  0x0F, 0x83, 0xE0, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x3C,
  0x00, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x83, 0xE0,
  0x07, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0xF8, 0x03, 0xE0, 0x0F, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x1F, 0x00,
  0x3C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0x1F,
  0x07, 0x80, 0x1F, 0x00, 0x78, 0x3E, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0xF1, 0xFE, 0x00, 0x79, 0xFF, 0x80, 0x7D, 0xFF, 0xE0, 0x3D,
  0xFF, 0xF0, 0x1F, 0xE0, 0xFC, 0x0F, 0xE0, 0x3E, 0x07, 0xE0, 0x1F, 0x07,
  0xE0, 0x0F, 0x83, 0xF0, 0x07, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0,
  0x7C, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7C,
  0x0F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07,
  0x81, 0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00,
  0xF8, 0x3E, 0x00, 0x78, 0x1F, 0x00, 0x7C, 0x0F, 0x00, 0x3E, 0x0F, 0x80,
  0x1F, 0x07, 0xC0, 0x0F, 0x03, 0xE0, 0x0F, 0x81, 0xE0, 0x07, 0xC1, 0xF0,
  0x03, 0xE0, 0x00, 0x06, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF,
  0xFE, 0x07, 0xFB, 0xF8, 0x1F, 0x03, 0xF0, 0xF8, 0x07, 0xC7, 0xE0, 0x1F,
  0x1F, 0x00, 0x3C, 0x78, 0x00, 0xF3, 0xE0, 0x03, 0xCF, 0x80, 0x0F, 0x7C,
  0x00, 0x3D, 0xF0, 0x00, 0xF7, 0xC0, 0x07, 0xDE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3E, 0xF8, 0x00, 0xFB,
  0xE0, 0x03, 0xEF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xE0,
  0x0F, 0x8F, 0x80, 0x7C, 0x1F, 0x03, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC,
  0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x0F, 0x0F, 0xE0, 0x01, 0xE7, 0xFE, 0x00, 0x3D, 0xFF, 0xE0, 0x0F,
  0xFC, 0xFC, 0x01, 0xEE, 0x0F, 0xC0, 0x3F, 0x80, 0xF8, 0x07, 0xE0, 0x1F,
  0x01, 0xFC, 0x03, 0xE0, 0x3F, 0x00, 0x3C, 0x07, 0xC0, 0x0F, 0x80, 0xF8,
  0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8,
  0x1F, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x78, 0x1F, 0x00,
  0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x01,
  0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x01, 0xF8, 0x07,
  0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xF0, 0x7E, 0x01, 0xFF, 0xBF, 0xC0, 0x3E,
  0xFF, 0xF0, 0x07, 0x9F, 0xFC, 0x00, 0xF1, 0xFE, 0x00, 0x3E, 0x06, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3F, 0xC3, 0xC0, 0x7F, 0xF3, 0xC0, 0x7F, 0xFD, 0xE0, 0x3F, 0xBE,
  0xF0, 0x3F, 0x07, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x1F, 0x00,
  0x7E, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0x83, 0xC0,
  0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0x78, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0,
  0xF8, 0x07, 0xF0, 0x7C, 0x03, 0xF0, 0x3E, 0x03, 0xF8, 0x1F, 0x83, 0xBC,
  0x07, 0xF7, 0xFE, 0x03, 0xFF, 0xDF, 0x00, 0xFF, 0xCF, 0x00, 0x3F, 0x8F,
  0x80, 0x02, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x0F, 0x1F, 0x80, 0x79, 0xFC, 0x03, 0x9F, 0xE0, 0x3D, 0xFF, 0x01, 0xEF,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x07, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7E, 0x1E, 0x07, 0xC0,
  0x10, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x20, 0x07, 0xC1, 0x80, 0x7E, 0x0F, 0xDF,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x0F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF0, 0x7C, 0x00, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x01,
  0x80, 0x00, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F,
  0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x78, 0x3E, 0x00, 0x78, 0x3C, 0x00, 0xF8, 0x3C,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0x78,
  0x01, 0xF0, 0x78, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xE0, 0xF8,
  0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x0F, 0xE0, 0xF8, 0x1F, 0xE0, 0xFF,
  0xFB, 0xC0, 0x7F, 0xF3, 0xC0, 0x7F, 0xE3, 0xC0, 0x3F, 0xC3, 0xC0, 0x06,
  0x00, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0x3E, 0x00,
  0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0x87, 0x80, 0x3E, 0x1E, 0x01, 0xF0,
  0x78, 0x07, 0xC1, 0xE0, 0x3E, 0x07, 0x80, 0xF8, 0x1E, 0x03, 0xC0, 0x78,
  0x1F, 0x01, 0xE0, 0x78, 0x07, 0x83, 0xE0, 0x1E, 0x0F, 0x00, 0x78, 0x7C,
  0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x80, 0x1E, 0x3C, 0x00, 0x79, 0xF0, 0x01,
  0xE7, 0xC0, 0x07, 0x9E, 0x00, 0x1E, 0xF8, 0x00, 0x7B, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x0F, 0xF8, 0x03, 0xF0, 0x07,
  0xFC, 0x01, 0xF8, 0x07, 0xDE, 0x01, 0xFC, 0x03, 0xEF, 0x00, 0xFE, 0x01,
  0xE7, 0x80, 0xFF, 0x01, 0xF3, 0xC0, 0x7F, 0x80, 0xF1, 0xE0, 0x3B, 0xC0,
  0xF8, 0xF0, 0x3D, 0xE0, 0x7C, 0x78, 0x1E, 0xF0, 0x3C, 0x3C, 0x1E, 0x78,
  0x3E, 0x1E, 0x0F, 0x3C, 0x1E, 0x0F, 0x0F, 0x1E, 0x1F, 0x07, 0x87, 0x8F,
  0x0F, 0x83, 0xC3, 0xC7, 0x87, 0x81, 0xE3, 0xC3, 0xC7, 0xC0, 0xF1, 0xE1,
  0xE3, 0xC0, 0x79, 0xE0, 0xF3, 0xE0, 0x3C, 0xF0, 0x79, 0xE0, 0x1E, 0x78,
  0x3C, 0xF0, 0x0F, 0x78, 0x1E, 0xF8, 0x07, 0xBC, 0x0F, 0x78, 0x03, 0xFC,
  0x07, 0xBC, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x0F,
  0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0x7C,
  0x07, 0xC0, 0x07, 0x81, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x0F, 0x80,
  0x03, 0xE3, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC1, 0xE0,
  0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x80, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x7C, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x80, 0x1E, 0x00, 0x7C,
  0x00, 0x78, 0x01, 0xF0, 0x01, 0xE0, 0x0F, 0x80, 0x07, 0x80, 0x3E, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0,
  0x78, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0xF1, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x3E, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x8F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x02, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xA0, 0x01, 0xFC, 0x00,
};

const GFXglyph NotoSans_Condensed_Italic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 14, 42, 14, 1, -41 },
  { 75, 17, 15, 21, 6, -41 },
  { 107, 29, 41, 28, 1, -41 },
  { 256, 25, 47, 25, 1, -44 },
  { 403, 33, 43, 39, 3, -42 },
  { 581, 28, 43, 29, 0, -42 },
  { 732, 8, 15, 11, 6, -41 },
  { 747, 18, 51, 15, 1, -42 },
  { 862, 18, 51, 15, -4, -42 },
  { 977, 20, 21, 24, 6, -44 },
  { 1030, 23, 27, 27, 3, -34 },
  { 1108, 11, 15, 13, -3, -7 },
  { 1129, 14, 5, 16, 1, -18 },
  { 1138, 6, 8, 13, 1, -7 },
  { 1144, 27, 42, 20, -3, -42 },
  { 1286, 23, 43, 25, 2, -42 },
  { 1410, 15, 41, 25, 7, -41 },
  { 1487, 26, 42, 25, -1, -42 },
  { 1624, 25, 43, 25, 0, -42 },
  { 1759, 26, 42, 25, -1, -42 },
  { 1896, 26, 42, 25, 0, -41 },
  { 2033, 24, 43, 25, 2, -42 },
  { 2162, 24, 41, 25, 3, -41 },
  { 2285, 25, 43, 25, 1, -42 },
  { 2420, 24, 43, 25, 1, -42 },
  { 2549, 12, 33, 13, 0, -32 },
  { 2599, 15, 40, 13, -3, -32 },
  { 2674, 23, 27, 27, 3, -34 },
  { 2752, 23, 16, 27, 3, -28 },
  { 2798, 23, 27, 27, 3, -34 },
  { 2876, 19, 43, 19, 2, -42 },
  { 2979, 36, 47, 39, 2, -42 },
  { 3191, 27, 42, 26, -4, -42 },
  { 3333, 27, 41, 28, 1, -41 },
  { 3472, 27, 43, 26, 3, -42 },
  { 3618, 28, 41, 31, 1, -41 },
  { 3762, 25, 41, 24, 1, -41 },
  { 3891, 25, 41, 22, 1, -41 },
  { 4020, 29, 43, 32, 3, -42 },
  { 4176, 31, 41, 31, 1, -41 },
  { 4335, 22, 41, 16, -2, -41 },
  { 4448, 23, 52, 13, -9, -41 },
  { 4598, 30, 41, 26, 1, -41 },
  { 4752, 17, 41, 22, 1, -41 },
  { 4840, 41, 41, 41, 1, -41 },
  { 5051, 33, 41, 33, 1, -41 },
  { 5221, 29, 43, 33, 3, -42 },
  { 5377, 26, 41, 26, 1, -41 },
  { 5511, 29, 52, 33, 3, -42 },
  { 5700, 26, 41, 27, 1, -41 },
  { 5834, 27, 43, 24, -1, -42 },
  { 5980, 22, 41, 23, 5, -41 },
  { 6093, 29, 42, 31, 3, -41 },
  { 6246, 26, 41, 26, 5, -41 },
  { 6380, 41, 41, 41, 5, -41 },
  { 6591, 32, 41, 24, -3, -41 },
  { 6755, 23, 41, 23, 5, -41 },
  { 6873, 28, 41, 23, -2, -41 },
  { 7017, 22, 51, 16, -1, -42 },
  { 7158, 10, 42, 20, 6, -42 },
  { 7211, 22, 51, 16, -4, -42 },
  { 7352, 24, 23, 26, 1, -41 },
  { 7421, 20, 4, 19, -5, 5 },
  { 7431, 9, 9, 15, 8, -44 },
  { 7442, 25, 33, 27, 2, -32 },
  { 7546, 25, 45, 27, 0, -44 },
  { 7687, 20, 33, 21, 2, -32 },
  { 7770, 27, 45, 27, 2, -44 },
  { 7922, 21, 33, 24, 2, -32 },
  { 8009, 29, 58, 15, -7, -44 },
  { 8220, 27, 46, 27, 0, -32 },
  { 8376, 25, 44, 27, 0, -44 },
  { 8514, 14, 43, 12, 0, -43 },
  { 8590, 21, 57, 12, -7, -43 },
  { 8740, 26, 44, 23, 0, -44 },
  { 8883, 15, 44, 12, 0, -44 },
  { 8966, 38, 32, 40, 0, -32 },
  { 9118, 25, 32, 27, 0, -32 },
  { 9218, 22, 33, 26, 2, -32 },
  { 9309, 27, 46, 27, -2, -32 },
  { 9465, 25, 46, 27, 2, -32 },
  { 9609, 21, 32, 18, 0, -32 },
  { 9693, 21, 33, 20, 0, -32 },
  { 9780, 15, 39, 15, 2, -38 },
  { 9854, 24, 32, 27, 2, -31 },
  { 9950, 22, 31, 22, 3, -31 },
  { 10036, 33, 31, 35, 4, -31 },
  { 10164, 27, 31, 22, -3, -31 },
  { 10269, 30, 45, 22, -5, -31 },
  { 10438, 22, 31, 19, -2, -31 },
  { 10524, 22, 50, 19, 1, -41 },
  { 10662, 5, 58, 24, 10, -44 },
  { 10699, 21, 50, 19, -3, -41 },
  { 10831, 23, 7, 27, 3, -24 },
};

const GFXfont NotoSans_Condensed_Italic58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic58pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_CONDENSED_ITALIC58PT7B_H_
