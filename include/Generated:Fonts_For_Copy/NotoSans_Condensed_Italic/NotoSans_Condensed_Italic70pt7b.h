#ifndef _NOTOSANS_CONDENSED_ITALIC70PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x0E,
  0x00, 0x00, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x3F, 0x03, 0xE3, 0xF0, 0x7E,
  0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07,
  0xC7, 0xE0, 0xFC, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0x80,
  0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0xF8, 0x1F, 0x0F, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x0F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x3E, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0x1C, 0x1C, 0x01,
  0xF8, 0x70, 0x10, 0x0F, 0xC1, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF8,
  0x3C, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x0F, 0x83, 0x80, 0x00, 0x3E, 0x0E,
  0x00, 0x00, 0xF8, 0x78, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0x0F, 0xC7, 0x00,
  0x00, 0x3F, 0x9C, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xDF, 0xC0, 0x00, 0x0F, 0x3F, 0x00, 0x00, 0x3C, 0x7E, 0x00, 0x00, 0xE1,
  0xF8, 0x00, 0x03, 0x83, 0xE0, 0x00, 0x0E, 0x0F, 0x80, 0x00, 0x78, 0x3E,
  0x00, 0x01, 0xE0, 0xF8, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x1C, 0x1F, 0x80,
  0x00, 0x70, 0x7C, 0x0C, 0x03, 0xC3, 0xF0, 0x3C, 0x0F, 0x1F, 0x80, 0xFF,
  0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x01, 0xFF,
  0x80, 0x01, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xF0, 0x07, 0xFF, 0xC0, 0x03,
  0xE0, 0x0F, 0xC7, 0xC0, 0x03, 0xC0, 0x0F, 0x83, 0xC0, 0x07, 0xC0, 0x1F,
  0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x03, 0xE0,
  0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x1E, 0x00, 0x3E, 0x03, 0xC0, 0x3E, 0x00,
  0x3C, 0x03, 0xC0, 0x7C, 0x00, 0x7C, 0x03, 0xC0, 0x7C, 0x00, 0x7C, 0x03,
  0xC0, 0xF8, 0x00, 0x78, 0x07, 0xC0, 0xF0, 0x00, 0x78, 0x07, 0xC1, 0xF0,
  0x00, 0x78, 0x07, 0xC1, 0xE0, 0x00, 0xF8, 0x07, 0x83, 0xE0, 0x00, 0xF8,
  0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x0F, 0x87, 0xC0, 0x60, 0xF8, 0x0F, 0x0F,
  0x83, 0xF8, 0xF8, 0x1F, 0x0F, 0x0F, 0xFC, 0xF8, 0x1F, 0x1F, 0x1F, 0xFE,
  0xF8, 0x3E, 0x3E, 0x3F, 0xFE, 0xF8, 0x3E, 0x3E, 0x3E, 0x1F, 0xF8, 0x7C,
  0x7C, 0x7C, 0x1F, 0x7F, 0xFC, 0x78, 0x78, 0x1F, 0x7F, 0xF8, 0xF8, 0xF8,
  0x1F, 0x3F, 0xF1, 0xF0, 0xF8, 0x1F, 0x1F, 0xC1, 0xF1, 0xF0, 0x1F, 0x07,
  0x03, 0xE1, 0xF0, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x1F, 0x00, 0x07, 0xC1,
  0xE0, 0x1F, 0x00, 0x07, 0x83, 0xE0, 0x1E, 0x00, 0x0F, 0x83, 0xE0, 0x1E,
  0x00, 0x1F, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x03, 0xC0, 0x3E, 0x00, 0x3E,
  0x03, 0xC0, 0x3E, 0x00, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0x7C, 0x07, 0xC0,
  0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x78, 0x01,
  0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x03,
  0xC1, 0xF0, 0x07, 0xC0, 0x03, 0xE3, 0xE0, 0x07, 0xC0, 0x03, 0xFF, 0xE0,
  0x0F, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0xF8, 0x07, 0xE0, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x03, 0xE0, 0x3F, 0x00,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0x03, 0xF3, 0xF0, 0x0F, 0xC1,
  0xF8, 0x7E, 0x03, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xF0, 0x7C,
  0x1F, 0x80, 0xFC, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x83, 0xE0, 0x07, 0xE7,
  0xE1, 0xF8, 0x01, 0xF9, 0xF0, 0x7E, 0x00, 0x3F, 0xFC, 0x1F, 0x00, 0x0F,
  0xFE, 0x07, 0xC0, 0x03, 0xFF, 0x83, 0xF0, 0x00, 0x7F, 0xC0, 0xFC, 0x00,
  0x1F, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0xFF, 0x80, 0x7E, 0x00, 0x7F, 0xF0, 0x1F, 0xC0, 0x3F, 0xFC, 0x07,
  0xFC, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xC7, 0xE0, 0x1F, 0xFF, 0xE1, 0xF8,
  0x03, 0xFF, 0xF0, 0x7F, 0x00, 0x7F, 0xF0, 0x0F, 0xE0, 0x03, 0xC0, 0x00,
  0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x40,
  0x1F, 0x00, 0x70, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x7F, 0x1E, 0x00, 0xFF,
  0xDE, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xEF, 0x00, 0x0F,
  0xCF, 0x80, 0x1F, 0xC7, 0x80, 0x3F, 0x87, 0xC0, 0x7F, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x1E, 0x03, 0xE0, 0x0C, 0x03, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F,
  0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0xF8, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF,
  0xF7, 0xFF, 0xF8, 0x3E, 0x7E, 0x7F, 0xFF, 0xFF, 0xFE, 0xFE, 0x7C, 0x38,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFD, 0xFE, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xE0, 0x3F,
  0x01, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x01, 0xF0, 0x3F,
  0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x01,
  0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x1F,
  0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF0, 0x00,
  0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xFC,
  0x7C, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC,
  0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x07, 0xF0, 0x7F,
  0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF,
  0x81, 0xFF, 0xE0, 0x7F, 0x7C, 0x1F, 0xDF, 0x87, 0xF3, 0xF3, 0xFC, 0x7C,
  0x3F, 0x0F, 0x87, 0x83, 0xF0, 0x60, 0x7E, 0x08, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0x00,
  0xFF, 0x00, 0x1E, 0x00, 0x7F, 0x00, 0x08, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xC0, 0x1F, 0xC0,
  0x1C, 0x00, 0x7F, 0x00, 0x20, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x80, 0x00, 0xFF, 0x03, 0x80, 0x07,
  0xF8, 0x0F, 0xE0, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x07, 0xC3, 0xF0,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x7C, 0x07, 0xE0,
  0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xC0,
  0x03, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x80,
  0x3E, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x9E,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x04, 0x00, 0x07, 0xF8, 0x0E, 0x00,
  0x1F, 0xE0, 0x1F, 0xC1, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0x38,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x01, 0x00, 0x03, 0xF0, 0xFF, 0x80, 0x1F, 0x9F, 0xFE, 0x00, 0xF9, 0xFF,
  0xF8, 0x0F, 0xDF, 0xFF, 0xC0, 0x7F, 0xFD, 0xFF, 0x03, 0xFF, 0x03, 0xF8,
  0x1F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x0F, 0xF0, 0x01, 0xF8, 0x7F,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3F,
  0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xFC, 0x1F,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xF0, 0x3F, 0x00,
  0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x01, 0xFC,
  0x01, 0xFE, 0x7F, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xF0,
  0x1F, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFE,
  0x1F, 0xC0, 0x01, 0xFD, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x01,
  0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8,
  0x3F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x01, 0xFC, 0x01, 0xFC, 0x07,
  0xFC, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xF8, 0x1F, 0xC0,
  0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0xFC,
  0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8,
  0x7C, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0xFE, 0x0F, 0xC0, 0x0F, 0xF0, 0x7E, 0x00, 0xFF, 0x83, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFB, 0xF7, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFB, 0xF0, 0x07,
  0xFF, 0x1F, 0x80, 0x1F, 0xF0, 0xF8, 0x00, 0x18, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xE3, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x03, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x7E, 0x01,
  0xF8, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xF3, 0xFE, 0x07, 0x00, 0x7E, 0x06, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0xC0, 0x03, 0xC0, 0xF8, 0x01, 0xFF, 0xC0, 0x78, 0x1E, 0x00,
  0x7F, 0xFC, 0x0F, 0x07, 0xC0, 0x3F, 0xFF, 0x81, 0xE0, 0xF0, 0x0F, 0xE3,
  0xF0, 0x3C, 0x3E, 0x01, 0xF0, 0x3C, 0x07, 0x87, 0x80, 0x7C, 0x0F, 0x80,
  0xF1, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x3C, 0x03, 0xC0, 0x3E, 0x03, 0xC7,
  0x80, 0xF8, 0x07, 0x80, 0x79, 0xF0, 0x1E, 0x01, 0xF0, 0x1F, 0x3C, 0x07,
  0xC0, 0x3E, 0x03, 0xE7, 0x80, 0xF0, 0x07, 0x80, 0x7C, 0xF0, 0x3E, 0x00,
  0xF0, 0x0F, 0x3E, 0x07, 0xC0, 0x3E, 0x01, 0xE7, 0xC0, 0xF8, 0x07, 0xC0,
  0x7C, 0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0x1E, 0x03, 0xC0, 0x3E, 0x01, 0xE3,
  0xC0, 0xF8, 0x07, 0xC0, 0x7C, 0x78, 0x1F, 0x00, 0xF8, 0x0F, 0x1F, 0x03,
  0xE0, 0x3F, 0x01, 0xE3, 0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x7C, 0x0F, 0x81,
  0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0x3F, 0x83, 0xC1, 0xF0, 0x1F, 0x0E, 0xF0,
  0xF8, 0x3E, 0x03, 0xFF, 0x9F, 0xFE, 0x07, 0xC0, 0x7F, 0xF1, 0xFF, 0x80,
  0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xC0, 0x00, 0x03,
  0xFC, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0xFC, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0xF8, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x01,
  0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xF0, 0x0F, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xC0,
  0x01, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x7E,
  0x00, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x1F, 0xF8, 0x00, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x1F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x07,
  0xF8, 0x0F, 0xC0, 0x07, 0xF8, 0x07, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x38,
  0x00, 0xFF, 0x00, 0x08, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x70, 0x00, 0x7F, 0xF7, 0xF8, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0xFF, 0xC0, 0x07, 0xE0, 0x0F, 0xF0,
  0x01, 0xF8, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x07,
  0xF0, 0x0F, 0xC0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01,
  0xF8, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0x80,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x03, 0xF0, 0x1F, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0xE0,
  0x0F, 0x80, 0x07, 0xF8, 0x07, 0xE0, 0x03, 0xFC, 0x01, 0xF8, 0x03, 0xFE,
  0x00, 0x7E, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xC0, 0x07, 0xFC, 0x00, 0x0C, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x87,
  0xE0, 0x01, 0xFF, 0xF0, 0x7E, 0x00, 0x1F, 0xFF, 0x07, 0xE0, 0x01, 0xFF,
  0xF0, 0x7E, 0x00, 0x1F, 0xFF, 0x07, 0xE0, 0x03, 0xFF, 0xF0, 0xFE, 0x00,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFE, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x3F, 0xC0, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x04, 0x0F, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xE0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x7C, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x3F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00,
  0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0x81, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x1F, 0x8F,
  0xE0, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xBF, 0x00, 0x00, 0x0F,
  0xF1, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0xC0,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x1F, 0x7C,
  0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xE0, 0x07, 0xDF,
  0x00, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0x80, 0x00, 0xF9, 0xF0, 0x03, 0xF7,
  0xC0, 0x00, 0xFC, 0xF8, 0x01, 0xF3, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0xF9,
  0xF8, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0x3E, 0x3F, 0x00, 0x7E,
  0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x1F,
  0x0F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0x87, 0xC0, 0x0F, 0x87, 0xE0, 0x0F,
  0xC3, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF0, 0x07, 0xC1, 0xF0, 0x03,
  0xF0, 0xF8, 0x03, 0xE1, 0xF8, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xFC, 0x00,
  0xF8, 0x3E, 0x01, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x01, 0xF0, 0x3E, 0x00,
  0x7E, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x80,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x7E, 0x07, 0xE0,
  0x0F, 0xC0, 0x7C, 0x3E, 0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x3F, 0x03, 0xF0,
  0x03, 0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0x01, 0xF0, 0x0F, 0x9F, 0x80, 0xFC,
  0x01, 0xF8, 0x07, 0xCF, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xEF, 0xC0, 0x3E,
  0x00, 0x7E, 0x01, 0xF7, 0xC0, 0x3F, 0x00, 0x3E, 0x00, 0xFF, 0xE0, 0x1F,
  0x80, 0x1F, 0x00, 0x7F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xF8, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xFC, 0x00,
  0xFC, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x00, 0x3E, 0x00, 0x7F,
  0xC0, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x00,
  0x7E, 0x00, 0x7F, 0xE0, 0x00, 0x7C, 0x00, 0xFF, 0xE0, 0x00, 0x7C, 0x00,
  0xFB, 0xE0, 0x00, 0xFC, 0x00, 0xFB, 0xF0, 0x00, 0xFC, 0x00, 0xF9, 0xF0,
  0x00, 0xFC, 0x00, 0xF9, 0xF0, 0x00, 0xF8, 0x01, 0xF9, 0xF0, 0x00, 0xF8,
  0x01, 0xF9, 0xF8, 0x01, 0xF8, 0x01, 0xF1, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0xF8, 0x01, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x03,
  0xE0, 0x7C, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x07, 0xE0,
  0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x0F,
  0xC0, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x8F, 0x80, 0x1F,
  0x80, 0x0F, 0x9F, 0x80, 0x1F, 0x00, 0x0F, 0x9F, 0x80, 0x1F, 0x00, 0x0F,
  0x9F, 0x00, 0x3F, 0x00, 0x0F, 0xDF, 0x00, 0x3F, 0x00, 0x0F, 0xDF, 0x00,
  0x3F, 0x00, 0x07, 0xDF, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0x00, 0x3E, 0x00,
  0x07, 0xFE, 0x00, 0x7E, 0x00, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x03, 0xFE,
  0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0x7C, 0x00, 0x03, 0xFE, 0x00, 0x7C,
  0x00, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xE3, 0xF8, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xF3, 0xF8,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x07, 0xE7, 0xF0,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7E, 0x07, 0xFC, 0x00, 0x7E, 0x01, 0xFE, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x03,
  0xE0, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xE0, 0x1F, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0x3F, 0x3F, 0x80, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7E, 0x07, 0xFC, 0x00, 0x7E, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFC, 0x03,
  0xF0, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xE0, 0x07, 0xF0, 0x07,
  0xE0, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F,
  0x80, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xC0, 0x3C, 0x00, 0x7F, 0x00, 0x0C, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x80, 0x00, 0x3F, 0x80, 0x60, 0x00, 0x7F, 0x00, 0x78,
  0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0x80,
  0x00, 0x3E, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3F,
  0x83, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF0,
  0x1F, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8,
  0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0xBF, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0xFF, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xF8, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xFF, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xF7, 0xC0, 0x07, 0xE0, 0xFC,
  0x00, 0x7D, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x7C, 0x00, 0xFC, 0x0F,
  0xC0, 0x0F, 0x9F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x80,
  0xFC, 0x00, 0xF9, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7C, 0x7C, 0x01, 0xF0,
  0x0F, 0xC0, 0x1F, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x87, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xE1, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x7C, 0x07,
  0xE0, 0x0F, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x07, 0xC0,
  0xFC, 0x00, 0xFC, 0x0F, 0x81, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xE0, 0x7C,
  0x1F, 0x80, 0x0F, 0xC1, 0xF0, 0x1F, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x07,
  0xC1, 0xF0, 0x00, 0xFC, 0x1F, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0x80,
  0x7C, 0x3E, 0x00, 0x0F, 0xC3, 0xE0, 0x1F, 0x1F, 0x80, 0x03, 0xF1, 0xF0,
  0x07, 0xC7, 0xE0, 0x00, 0xFC, 0x7C, 0x01, 0xE1, 0xF0, 0x00, 0x3F, 0x1F,
  0x00, 0x78, 0xFC, 0x00, 0x0F, 0xCF, 0x80, 0x1E, 0x3E, 0x00, 0x03, 0xF3,
  0xE0, 0x07, 0x9F, 0x80, 0x00, 0xFD, 0xF0, 0x01, 0xE7, 0xE0, 0x00, 0x3F,
  0x7C, 0x00, 0x79, 0xF0, 0x00, 0x0F, 0xDF, 0x00, 0x1E, 0xFC, 0x00, 0x03,
  0xEF, 0x80, 0x07, 0xBE, 0x00, 0x00, 0xFB, 0xE0, 0x01, 0xEF, 0x80, 0x00,
  0x3E, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x7E,
  0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0xFC,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7E, 0xFC, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x0F,
  0xC7, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF0, 0x7E,
  0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x03,
  0xF0, 0x3E, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x0F,
  0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xFB, 0xF0, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0,
  0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0,
  0x3F, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x03,
  0xE0, 0x3E, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7C,
  0x3F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x0F, 0xBF,
  0x00, 0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFE, 0x3F, 0x87, 0xE1, 0xFC, 0x3F, 0x07, 0xC1, 0xF8,
  0x3E, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x00, 0x07, 0xF0, 0x7C, 0x00, 0x7F,
  0xE1, 0xF0, 0x07, 0xFF, 0xC7, 0xC0, 0x3F, 0xFF, 0xBF, 0x01, 0xFF, 0xFE,
  0xF8, 0x07, 0xF0, 0x3F, 0xE0, 0x3F, 0x80, 0x7F, 0x81, 0xFC, 0x01, 0xFE,
  0x07, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF8, 0x3F,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xC0,
  0x0F, 0xF0, 0x1F, 0x80, 0x7F, 0xC0, 0x7E, 0x03, 0xFE, 0x01, 0xFE, 0x3E,
  0xF8, 0x03, 0xFF, 0xF3, 0xE0, 0x0F, 0xFF, 0x8F, 0x80, 0x1F, 0xFC, 0x3E,
  0x00, 0x3F, 0xE0, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0xFF,
  0xC0, 0x07, 0xE7, 0xFF, 0x80, 0x1F, 0x3F, 0xFF, 0x00, 0x7D, 0xFF, 0xFC,
  0x03, 0xFF, 0x83, 0xF8, 0x0F, 0xF8, 0x07, 0xE0, 0x3F, 0xC0, 0x1F, 0x80,
  0xFF, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x7F,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x80,
  0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01,
  0xF8, 0x3E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC,
  0x1F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3F, 0x0F,
  0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0xE1, 0xFE,
  0x03, 0xE7, 0xFF, 0xF0, 0x0F, 0x9F, 0xFF, 0x80, 0x3E, 0x3F, 0xFC, 0x00,
  0xF0, 0x7F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xE0, 0x30, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x40, 0x1F, 0xE1, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0xE0, 0xF8, 0x00, 0x1F, 0xF8, 0xFC, 0x00, 0x3F, 0xFE, 0x7E,
  0x00, 0x3F, 0xFF, 0xBE, 0x00, 0x3F, 0xFF, 0xDF, 0x00, 0x1F, 0xC0, 0xFF,
  0x80, 0x1F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7C, 0x03, 0xF0,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xF8, 0x01, 0xF8, 0x07, 0xFC, 0x00,
  0xFC, 0x07, 0xFC, 0x00, 0x7F, 0x8F, 0xBE, 0x00, 0x3F, 0xFF, 0x9F, 0x00,
  0x0F, 0xFF, 0x8F, 0x80, 0x03, 0xFF, 0x87, 0x80, 0x00, 0xFF, 0x83, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0x7F, 0x80, 0x7E, 0x07,
  0xE0, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC3, 0xF0,
  0x03, 0xF1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x8F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xF0, 0xF8, 0x07, 0xF8, 0x7E, 0x0F, 0xFC,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x10, 0x0F, 0xE0, 0x3C, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x60, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x21, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0x80, 0x01, 0xFF, 0x87, 0xC0, 0x03,
  0xFF, 0xE3, 0xE0, 0x03, 0xFF, 0xFB, 0xF0, 0x03, 0xFF, 0xFD, 0xF0, 0x01,
  0xFC, 0x0F, 0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xE0,
  0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x03,
  0xF8, 0x07, 0xE0, 0x01, 0xFC, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x7F, 0xC0, 0x0F, 0xC0, 0x7F, 0xC0, 0x07, 0xF8, 0xFB, 0xE0, 0x03, 0xFF,
  0xFB, 0xF0, 0x00, 0xFF, 0xF9, 0xF8, 0x00, 0x3F, 0xF8, 0xFC, 0x00, 0x0F,
  0xF8, 0x7C, 0x00, 0x00, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x01, 0x00, 0x01, 0xF8, 0x00, 0xE0, 0x01, 0xFC, 0x00,
  0x7E, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x01,
  0xF8, 0xFF, 0xC0, 0x0F, 0xCF, 0xFF, 0x00, 0x7C, 0xFF, 0xFC, 0x03, 0xEF,
  0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0x81, 0xFF, 0x00, 0xFC, 0x0F, 0xF0, 0x07,
  0xE0, 0x7F, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC1,
  0xFC, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xE0,
  0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x07,
  0xE0, 0x7C, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x07, 0xE0,
  0x01, 0xF8, 0x3F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07,
  0xE0, 0x7C, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0x81,
  0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x07, 0xE0,
  0x01, 0xF8, 0x3F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x07,
  0xE0, 0x00, 0x00, 0x04, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x02, 0x1F,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x7C, 0x03, 0xF8, 0x03, 0xF0,
  0x1F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xF8, 0x1F,
  0x80, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x01, 0xF8, 0xFC, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x3F, 0x00, 0x00,
  0xFD, 0xFC, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x0F, 0xBF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFD, 0xF0, 0x00, 0x1F, 0xE7,
  0xE0, 0x00, 0x7F, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xE0, 0x3F, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07,
  0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x03, 0xF0,
  0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x7F, 0x80, 0x3F,
  0x80, 0x0F, 0x87, 0xFE, 0x07, 0xFF, 0x00, 0x7C, 0xFF, 0xF8, 0x7F, 0xFC,
  0x03, 0xEF, 0xFF, 0xC7, 0xFF, 0xE0, 0x1F, 0x7F, 0xFF, 0x7F, 0xFF, 0x81,
  0xF7, 0x83, 0xFF, 0xC1, 0xFC, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xE0, 0x7F,
  0x80, 0x7F, 0xC0, 0x3F, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xF8, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC1, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC1,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x00, 0x3F,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC1,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x3F, 0xC0, 0x03, 0xE1, 0xFF,
  0xC0, 0x0F, 0x9F, 0xFF, 0x00, 0x3E, 0x7F, 0xFE, 0x00, 0xFB, 0xFF, 0xF8,
  0x07, 0xFF, 0x07, 0xF0, 0x1F, 0xF0, 0x0F, 0xC0, 0x7F, 0x80, 0x3F, 0x01,
  0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0xFE,
  0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x7F, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF0, 0x1F, 0x80, 0x0F,
  0xC0, 0x7C, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0,
  0x3F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF8, 0x1F,
  0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x07, 0xE0,
  0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E,
  0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xC1,
  0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0,
  0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x3F, 0x1F, 0x80,
  0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x3E,
  0x3E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7E, 0x7C, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF8, 0xFC,
  0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x03,
  0xFC, 0x7F, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x03,
  0xF8, 0x00, 0x07, 0xC3, 0xFF, 0x00, 0x01, 0xF1, 0xFF, 0xE0, 0x00, 0x7C,
  0xFF, 0xFC, 0x00, 0x1F, 0x7F, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xE0, 0x03,
  0xFE, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0x80,
  0x0F, 0xE0, 0x03, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x03, 0xE0, 0x07, 0xE0, 0x00,
  0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x07, 0xE0, 0x0F, 0x80, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x03, 0xF0, 0x07,
  0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x1F,
  0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x87, 0xF8, 0x00, 0xFD, 0xFF,
  0xFC, 0x00, 0x3F, 0x7F, 0xFE, 0x00, 0x0F, 0xCF, 0xFF, 0x00, 0x03, 0xE1,
  0xFF, 0x00, 0x00, 0xF8, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x7C, 0x00, 0x7F, 0xE1, 0xF0, 0x07, 0xFF, 0xC7, 0xC0, 0x3F,
  0xFF, 0xBF, 0x01, 0xFF, 0xFE, 0xF8, 0x07, 0xF0, 0x3F, 0xE0, 0x3F, 0x80,
  0x7F, 0x81, 0xFC, 0x01, 0xFE, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0,
  0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7C, 0x1F, 0x80,
  0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFE,
  0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x03,
  0xF0, 0x03, 0xFC, 0x0F, 0xC0, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0xC0, 0x7E,
  0x03, 0xFE, 0x01, 0xFE, 0x3E, 0xF8, 0x07, 0xFF, 0xF7, 0xE0, 0x0F, 0xFF,
  0x9F, 0x80, 0x1F, 0xFC, 0x7E, 0x00, 0x3F, 0xE1, 0xF0, 0x00, 0x1C, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xF0, 0x7F, 0x01, 0xF0, 0xFE, 0x01, 0xF3, 0xFE, 0x01,
  0xF3, 0xFE, 0x01, 0xE7, 0xFE, 0x03, 0xEF, 0xEC, 0x03, 0xEF, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x3F, 0x80, 0x70, 0x1F, 0x80, 0x08, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0x00, 0x0F, 0xE0,
  0xC0, 0x0F, 0xE0, 0x7C, 0x1F, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0xFF, 0xFF,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x87, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xC2, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xE0, 0x3F, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07,
  0xE0, 0x7E, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xF0,
  0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0xF8, 0x0F,
  0x80, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0,
  0x01, 0xF0, 0x1F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x7E,
  0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x01,
  0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0xC0, 0x7C,
  0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0xE0, 0x3F, 0x00,
  0x7F, 0x80, 0xFE, 0x07, 0xFE, 0x01, 0xFC, 0x7F, 0xF8, 0x07, 0xFF, 0xF7,
  0xC0, 0x1F, 0xFF, 0x9F, 0x00, 0x3F, 0xFC, 0x7C, 0x00, 0x7F, 0xC1, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xEF,
  0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F,
  0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00,
  0x3F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x1F,
  0x00, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x07, 0xC0,
  0x1F, 0x03, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F,
  0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x7C,
  0x7E, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF3, 0xE0, 0x00,
  0x7D, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xDF, 0x80, 0x1F, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xF0, 0x03, 0xE7, 0xE0,
  0x0F, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xFC, 0x01, 0xF1, 0xF8, 0x07, 0xFE,
  0x01, 0xF8, 0xFC, 0x03, 0xFF, 0x00, 0xFC, 0x7E, 0x01, 0xEF, 0x80, 0x7C,
  0x3F, 0x01, 0xF7, 0xC0, 0x7E, 0x1F, 0x80, 0xF3, 0xE0, 0x3E, 0x0F, 0xC0,
  0xF9, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0xF8, 0x1F, 0x03, 0xF0, 0x3C, 0x7C,
  0x0F, 0x81, 0xF8, 0x3E, 0x3E, 0x0F, 0xC0, 0xFC, 0x1F, 0x1F, 0x07, 0xC0,
  0x7E, 0x1F, 0x0F, 0x87, 0xE0, 0x3F, 0x0F, 0x87, 0xC3, 0xE0, 0x1F, 0x8F,
  0x83, 0xE1, 0xF0, 0x0F, 0xC7, 0xC1, 0xF1, 0xF8, 0x07, 0xE3, 0xC0, 0xF8,
  0xF8, 0x03, 0xE3, 0xE0, 0x78, 0xFC, 0x01, 0xF1, 0xF0, 0x3C, 0x7C, 0x00,
  0xF9, 0xF0, 0x1E, 0x3E, 0x00, 0x7C, 0xF8, 0x0F, 0x3E, 0x00, 0x3E, 0x78,
  0x07, 0x9F, 0x00, 0x1F, 0x7C, 0x03, 0xDF, 0x80, 0x0F, 0xBE, 0x01, 0xEF,
  0x80, 0x07, 0xDE, 0x00, 0xF7, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3E, 0x01, 0xF8,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x0F, 0xC0, 0x3E, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3F,
  0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0xFC, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00,
  0x07, 0xCF, 0xC0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x02, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x09, 0xFF, 0xE0, 0x00, 0xDF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFB, 0x80,
  0x1F, 0xFF, 0x98, 0x00, 0x1F, 0xF8, 0x80, 0x00, 0x0E, 0x00,
};

const GFXglyph NotoSans_Condensed_Italic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 17, 51, 17, 1, -50 },
  { 110, 20, 18, 25, 7, -50 },
  { 155, 35, 50, 34, 1, -50 },
  { 374, 30, 57, 31, 1, -53 },
  { 588, 40, 52, 47, 4, -51 },
  { 848, 34, 52, 35, 0, -51 },
  { 1069, 9, 18, 14, 7, -50 },
  { 1090, 21, 61, 19, 2, -50 },
  { 1251, 21, 61, 19, -5, -50 },
  { 1412, 24, 26, 29, 7, -53 },
  { 1490, 28, 33, 33, 3, -41 },
  { 1606, 13, 17, 15, -3, -8 },
  { 1634, 17, 6, 19, 1, -22 },
  { 1647, 8, 9, 15, 1, -8 },
  { 1656, 32, 50, 24, -3, -50 },
  { 1856, 28, 52, 31, 2, -51 },
  { 2038, 19, 50, 31, 8, -50 },
  { 2157, 32, 51, 31, -2, -51 },
  { 2361, 30, 52, 31, 0, -51 },
  { 2556, 32, 50, 31, -1, -50 },
  { 2756, 31, 51, 31, 0, -50 },
  { 2954, 29, 52, 31, 3, -51 },
  { 3143, 30, 50, 31, 3, -50 },
  { 3331, 30, 52, 31, 1, -51 },
  { 3526, 29, 52, 31, 1, -51 },
  { 3715, 14, 39, 15, 0, -38 },
  { 3784, 19, 47, 15, -4, -38 },
  { 3896, 28, 32, 33, 3, -41 },
  { 4008, 27, 19, 33, 4, -34 },
  { 4073, 29, 32, 33, 3, -41 },
  { 4189, 24, 52, 23, 2, -51 },
  { 4345, 43, 56, 47, 2, -50 },
  { 4646, 31, 50, 32, -4, -50 },
  { 4840, 33, 50, 34, 1, -50 },
  { 5047, 33, 52, 31, 3, -51 },
  { 5262, 34, 50, 37, 1, -50 },
  { 5475, 31, 50, 29, 1, -50 },
  { 5669, 31, 50, 27, 1, -50 },
  { 5863, 36, 52, 38, 3, -51 },
  { 6097, 38, 50, 38, 1, -50 },
  { 6335, 27, 50, 20, -3, -50 },
  { 6504, 28, 63, 16, -11, -50 },
  { 6725, 36, 50, 32, 1, -50 },
  { 6950, 21, 50, 27, 1, -50 },
  { 7082, 49, 50, 49, 1, -50 },
  { 7389, 40, 50, 40, 1, -50 },
  { 7639, 35, 52, 39, 3, -51 },
  { 7867, 32, 50, 32, 1, -50 },
  { 8067, 35, 63, 39, 3, -51 },
  { 8343, 32, 50, 32, 1, -50 },
  { 8543, 32, 52, 29, -1, -51 },
  { 8751, 27, 50, 27, 6, -50 },
  { 8920, 36, 51, 37, 3, -50 },
  { 9150, 31, 50, 31, 6, -50 },
  { 9344, 50, 50, 50, 6, -50 },
  { 9657, 38, 50, 29, -4, -50 },
  { 9895, 28, 50, 28, 6, -50 },
  { 10070, 34, 50, 28, -2, -50 },
  { 10283, 27, 61, 20, -2, -50 },
  { 10489, 12, 50, 24, 7, -50 },
  { 10564, 27, 61, 20, -5, -50 },
  { 10770, 30, 28, 32, 1, -50 },
  { 10875, 24, 4, 23, -6, 6 },
  { 10887, 10, 12, 18, 10, -54 },
  { 10902, 30, 39, 33, 2, -38 },
  { 11049, 30, 54, 33, 1, -53 },
  { 11252, 25, 39, 25, 2, -38 },
  { 11374, 33, 54, 33, 2, -53 },
  { 11597, 26, 39, 29, 2, -38 },
  { 11724, 34, 71, 18, -8, -54 },
  { 12026, 33, 55, 33, -1, -38 },
  { 12253, 29, 53, 32, 1, -53 },
  { 12446, 16, 52, 15, 1, -52 },
  { 12550, 26, 69, 15, -9, -52 },
  { 12775, 30, 53, 28, 1, -53 },
  { 12974, 17, 53, 15, 1, -53 },
  { 13087, 45, 38, 48, 1, -38 },
  { 13301, 30, 38, 32, 0, -38 },
  { 13444, 28, 39, 32, 2, -38 },
  { 13581, 34, 54, 33, -3, -38 },
  { 13811, 30, 55, 33, 2, -38 },
  { 14018, 24, 38, 22, 1, -38 },
  { 14132, 25, 39, 25, 0, -38 },
  { 14254, 19, 47, 19, 2, -46 },
  { 14366, 30, 39, 32, 2, -38 },
  { 14513, 26, 38, 26, 4, -38 },
  { 14637, 41, 38, 42, 4, -38 },
  { 14832, 32, 38, 27, -3, -38 },
  { 14984, 37, 55, 26, -7, -38 },
  { 15239, 27, 38, 23, -2, -38 },
  { 15368, 27, 61, 23, 1, -50 },
  { 15574, 5, 70, 29, 13, -53 },
  { 15618, 26, 61, 23, -4, -50 },
  { 15817, 29, 9, 33, 3, -29 },
};

const GFXfont NotoSans_Condensed_Italic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic70pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_CONDENSED_ITALIC70PT7B_H_
