#ifndef _NOTOSANS_CONDENSED_ITALIC56PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x1F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0x60, 0x00, 0x3E, 0x1F, 0x3C, 0x1E,
  0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C,
  0x78, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x70, 0xE0, 0xF0,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x3C,
  0x1E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x07, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0x03, 0x80, 0x00, 0x78,
  0x3C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x38, 0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x1C, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0x1C, 0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x70, 0x3C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xF7, 0x1E, 0x07, 0xC7, 0x04, 0x07, 0x87,
  0x00, 0x07, 0x87, 0x00, 0x0F, 0x86, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x0E,
  0x00, 0x0F, 0x8E, 0x00, 0x07, 0x8C, 0x00, 0x07, 0xCC, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x33, 0xE0, 0x00, 0x31,
  0xF0, 0x00, 0x71, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0x60,
  0xF0, 0x00, 0x61, 0xF0, 0x00, 0xE1, 0xE0, 0x80, 0xE3, 0xE0, 0xE0, 0xE7,
  0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x3C, 0x07, 0xFC, 0x00, 0x78, 0x07, 0xFC, 0x00, 0x70, 0x0F,
  0x1E, 0x00, 0xF0, 0x1E, 0x1E, 0x01, 0xE0, 0x1E, 0x1E, 0x01, 0xE0, 0x3C,
  0x1E, 0x03, 0xC0, 0x3C, 0x1E, 0x03, 0x80, 0x38, 0x1E, 0x07, 0x80, 0x78,
  0x1E, 0x0F, 0x00, 0x78, 0x1E, 0x0F, 0x00, 0x78, 0x1E, 0x1E, 0x00, 0x70,
  0x1C, 0x1C, 0x00, 0x70, 0x3C, 0x3C, 0x00, 0xF0, 0x3C, 0x78, 0x00, 0xF0,
  0x3C, 0x78, 0x10, 0xF0, 0x38, 0xF0, 0xFC, 0xF0, 0x78, 0xF3, 0xFE, 0xF0,
  0x71, 0xE3, 0xFF, 0xF0, 0xF1, 0xC7, 0x8F, 0x71, 0xE3, 0xCF, 0x0F, 0x7F,
  0xE7, 0x8F, 0x07, 0x7F, 0xC7, 0x9E, 0x07, 0x3F, 0x8F, 0x1E, 0x07, 0x04,
  0x0E, 0x1C, 0x0F, 0x00, 0x1E, 0x3C, 0x0F, 0x00, 0x3C, 0x3C, 0x0F, 0x00,
  0x3C, 0x3C, 0x0F, 0x00, 0x78, 0x38, 0x0E, 0x00, 0x78, 0x38, 0x0E, 0x00,
  0xF0, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x1C, 0x03,
  0xC0, 0x78, 0x3C, 0x03, 0xC0, 0x78, 0x3C, 0x07, 0x80, 0x78, 0x78, 0x07,
  0x00, 0x3C, 0xF0, 0x0F, 0x00, 0x3F, 0xF0, 0x1E, 0x00, 0x3F, 0xE0, 0x3E,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xE3, 0xE0,
  0x00, 0xF8, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0xF0,
  0x1E, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xC0, 0xF8, 0x00, 0x78, 0x1E, 0x00,
  0x0F, 0x07, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0xF8, 0x7C, 0x78, 0x1F, 0x1F, 0x0F, 0x83, 0xC3, 0xC1, 0xF0, 0xF8, 0xF8,
  0x1F, 0x1E, 0x3E, 0x03, 0xE7, 0xC7, 0xC0, 0x3E, 0xF0, 0xF0, 0x07, 0xFE,
  0x3E, 0x00, 0x7F, 0x87, 0xC0, 0x0F, 0xF0, 0xF8, 0x01, 0xFC, 0x1F, 0x00,
  0x1F, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x01, 0xFE, 0x07, 0xC0, 0x7F, 0xC0,
  0xFE, 0x7F, 0x7C, 0x0F, 0xFF, 0xCF, 0x80, 0xFF, 0xF0, 0xF8, 0x0F, 0xF8,
  0x1F, 0x80, 0x38, 0x00, 0x00, 0x3E, 0x7C, 0xF1, 0xE7, 0xCF, 0x9E, 0x3C,
  0x78, 0xE3, 0xC7, 0x8F, 0x1C, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x81, 0xE0, 0x3C, 0x3C, 0x07, 0xE7,
  0x00, 0xFF, 0xE3, 0xEF, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F,
  0x00, 0x1F, 0xE0, 0x07, 0xDE, 0x01, 0xF1, 0xC0, 0x7C, 0x3C, 0x0F, 0x87,
  0xC0, 0xE0, 0x78, 0x08, 0x0F, 0x80, 0x01, 0x80, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC3, 0xE0, 0xF8,
  0x7C, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xC0, 0xF0,
  0x00, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x11, 0xFF, 0xFF, 0xFF,
  0xEF, 0x88, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0,
  0x3C, 0x3E, 0x00, 0xF0, 0xF8, 0x03, 0xC7, 0xC0, 0x0F, 0x1F, 0x00, 0x3C,
  0x78, 0x00, 0xF3, 0xE0, 0x03, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF0,
  0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x79, 0xE0, 0x03,
  0xE7, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xCF,
  0x80, 0x1F, 0x3C, 0x00, 0x7C, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x8F, 0x00,
  0x3E, 0x3C, 0x00, 0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x1E, 0x0F, 0x80, 0xF8,
  0x3E, 0x07, 0xC0, 0x7C, 0x3F, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xFC,
  0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x87, 0xFF, 0x1F, 0xBE, 0xFE,
  0x7C, 0xF0, 0xF0, 0xC3, 0xE1, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x07, 0x80, 0xFC, 0x01, 0x80, 0x3E, 0x00, 0x80, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFD, 0xFE, 0x01,
  0xE0, 0x3F, 0x00, 0x80, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x80, 0x07, 0xE0, 0xC0, 0x0F, 0xC0, 0xFE,
  0x7F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xBC,
  0x00, 0x03, 0xDE, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xE7,
  0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x78,
  0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x3C, 0x07, 0xC0, 0x1E,
  0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x1F, 0x00, 0x78, 0x0F,
  0x00, 0x7C, 0x0F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x10, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xF1, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x20, 0x01, 0xF8, 0x18, 0x01, 0xFC, 0x0F,
  0xEF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFD, 0xE0, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x3F, 0x80, 0x79, 0xFF, 0x80, 0xF7, 0xFF, 0x83, 0xFF,
  0xFF, 0x07, 0xF8, 0x3F, 0x0F, 0xE0, 0x3E, 0x1F, 0x80, 0x7C, 0x3E, 0x00,
  0x78, 0xFC, 0x00, 0xF1, 0xF0, 0x01, 0xE3, 0xE0, 0x03, 0xC7, 0xC0, 0x07,
  0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF0,
  0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x03, 0xC0, 0x3E, 0x07,
  0xC0, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF2, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x0F, 0xE7, 0xF0, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xC0,
  0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C,
  0x01, 0xF0, 0x3E, 0x00, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0xF8, 0x03,
  0xE0, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xDF, 0x80,
  0x1F, 0x87, 0xC0, 0x1F, 0x81, 0xF0, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01,
  0xE0, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x78, 0x3C, 0x00, 0x7C, 0x1E, 0x00,
  0x3E, 0x0F, 0x80, 0x3E, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x7F, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x7E, 0x0F, 0x81, 0xF0, 0x0F, 0x03, 0xE0, 0x1F, 0x0F,
  0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0,
  0x03, 0xE3, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x8F, 0x00, 0x1F, 0x1E, 0x00,
  0x3E, 0x3C, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0xF8, 0x07, 0xE1, 0xF0, 0x1F,
  0xC3, 0xF0, 0x7F, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xBC, 0x07, 0xFE, 0x78,
  0x07, 0xF1, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xE0, 0x3E, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x3C, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x3C, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x07, 0x80, 0x20, 0x00,
  0x00, 0x3C, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0x80,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x7F, 0xC0, 0x3F,
  0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x18, 0x0F, 0x82, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x0F, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0E, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x1C, 0x3C, 0x01, 0xFE,
  0x07, 0x0F, 0x01, 0xFF, 0xC1, 0xC7, 0x80, 0xFF, 0xF0, 0x71, 0xE0, 0x78,
  0x38, 0x1C, 0x70, 0x3C, 0x1E, 0x07, 0x3C, 0x0F, 0x07, 0x81, 0xCE, 0x07,
  0x81, 0xE0, 0x73, 0x81, 0xC0, 0x70, 0x3D, 0xE0, 0xF0, 0x3C, 0x0F, 0x78,
  0x38, 0x0F, 0x03, 0xDC, 0x0E, 0x03, 0xC0, 0xE7, 0x07, 0x80, 0xE0, 0x3B,
  0xC1, 0xE0, 0x78, 0x1E, 0xF0, 0x78, 0x1E, 0x07, 0x3C, 0x1C, 0x07, 0x81,
  0xCF, 0x07, 0x03, 0xE0, 0xF3, 0x81, 0xC0, 0xF0, 0x38, 0xE0, 0x70, 0x7C,
  0x1E, 0x38, 0x1E, 0x1F, 0x8F, 0x0E, 0x07, 0xDE, 0xF7, 0x83, 0x81, 0xFF,
  0x3F, 0xC0, 0xF0, 0x3F, 0x87, 0xE0, 0x3C, 0x03, 0x80, 0xE0, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x0C, 0x00, 0x03, 0xFC, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0x9E,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x1F,
  0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF8, 0x78, 0x00,
  0x3C, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x03, 0xE0, 0x78,
  0x00, 0xF0, 0x1E, 0x00, 0x7C, 0x07, 0x80, 0x1F, 0x01, 0xE0, 0x0F, 0x80,
  0x78, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x0F, 0x80, 0x1E, 0x03, 0xE0, 0x07, 0x81, 0xF0, 0x01, 0xE0,
  0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xC0, 0x01,
  0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80,
  0x01, 0xF7, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xF0, 0x3F,
  0x80, 0x7C, 0x03, 0xF0, 0x1E, 0x00, 0x7C, 0x07, 0x80, 0x1F, 0x03, 0xE0,
  0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x07,
  0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0xFC,
  0x07, 0x80, 0x7E, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xC0, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x7C,
  0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0x81, 0xE0, 0x03, 0xE0,
  0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xC0, 0x03,
  0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x07, 0x80,
  0x1F, 0x81, 0xE0, 0x1F, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0x00, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0x07, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x78, 0x01, 0xF0, 0x0F,
  0x00, 0x3F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F,
  0x81, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0,
  0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C,
  0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x1E, 0x00,
  0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3,
  0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01,
  0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x7C,
  0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x01, 0xE0, 0x1F, 0xC0, 0x3C, 0x0F, 0xF0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xE0, 0x1E, 0x01,
  0xF8, 0x00, 0x40, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x01, 0xFF, 0x8F, 0x80, 0x1F, 0xF8, 0xF8, 0x03, 0xFF, 0x8F, 0x80,
  0x3F, 0xF8, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1F,
  0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xE0, 0xF8,
  0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03,
  0xE0, 0x7C, 0x00, 0x3C, 0x07, 0xE0, 0x07, 0xC0, 0x7F, 0x00, 0x7C, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3C, 0x03, 0xC0, 0x01,
  0xF0, 0x0F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x78,
  0x07, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0x7C, 0x03, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0x80, 0x7C, 0x00,
  0x1E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0x80, 0x03, 0xE0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xE0, 0x1F,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0xF8, 0x0F, 0x80,
  0x03, 0xC0, 0x3E, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xC0, 0x01,
  0xF0, 0x0F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x78,
  0x07, 0x80, 0x03, 0xE0, 0x1E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0xF0, 0x0F, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1F, 0x00, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x0E, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFC,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0x80, 0x0F,
  0x80, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x00,
  0xF8, 0x0F, 0xC0, 0x07, 0x80, 0x7C, 0x00, 0x3C, 0x07, 0xC0, 0x03, 0xE0,
  0x7C, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x00,
  0xF1, 0xF0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0x7C, 0x00, 0x03, 0xF1, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0xF0, 0x7C, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0,
  0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x03, 0xE0, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x0F, 0xFC, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x0F, 0x78, 0x00, 0x7D,
  0xE0, 0x1E, 0xF0, 0x00, 0xF7, 0xC0, 0x7D, 0xE0, 0x03, 0xEF, 0x80, 0xFB,
  0xC0, 0x07, 0x9F, 0x01, 0xE7, 0xC0, 0x1F, 0x3C, 0x03, 0xCF, 0x80, 0x3C,
  0x78, 0x07, 0x8F, 0x00, 0xF9, 0xF0, 0x1F, 0x1E, 0x01, 0xE3, 0xE0, 0x3E,
  0x3C, 0x03, 0xC7, 0x80, 0x78, 0x78, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1E,
  0x3E, 0x01, 0xE1, 0xE0, 0x78, 0x7C, 0x07, 0xC3, 0xC0, 0xF0, 0xF8, 0x0F,
  0x87, 0x83, 0xC1, 0xE0, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x1E,
  0x0F, 0x80, 0x78, 0x3C, 0x3C, 0x1F, 0x01, 0xF0, 0x78, 0xF0, 0x3E, 0x03,
  0xE0, 0xF1, 0xE0, 0x78, 0x07, 0x81, 0xE7, 0xC0, 0xF0, 0x0F, 0x03, 0xEF,
  0x03, 0xE0, 0x3E, 0x03, 0xFE, 0x07, 0xC0, 0x7C, 0x07, 0xF8, 0x0F, 0x80,
  0xF0, 0x0F, 0xF0, 0x1E, 0x01, 0xE0, 0x1F, 0xC0, 0x7C, 0x03, 0xC0, 0x3F,
  0x80, 0xF8, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x1F, 0x00, 0xFC, 0x03, 0xE0,
  0x3C, 0x01, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1E, 0x01, 0xFC,
  0x00, 0x1E, 0x01, 0xFC, 0x00, 0x1E, 0x01, 0xFE, 0x00, 0x3E, 0x01, 0xFE,
  0x00, 0x3E, 0x01, 0xFE, 0x00, 0x3C, 0x03, 0xFE, 0x00, 0x3C, 0x03, 0xDF,
  0x00, 0x7C, 0x03, 0xCF, 0x00, 0x7C, 0x03, 0xCF, 0x00, 0x7C, 0x07, 0xCF,
  0x00, 0x78, 0x07, 0xCF, 0x80, 0x78, 0x07, 0x8F, 0x80, 0xF8, 0x07, 0x87,
  0x80, 0xF8, 0x07, 0x87, 0x80, 0xF0, 0x0F, 0x87, 0x80, 0xF0, 0x0F, 0x87,
  0xC0, 0xF0, 0x0F, 0x03, 0xC1, 0xF0, 0x0F, 0x03, 0xC1, 0xF0, 0x0F, 0x03,
  0xC1, 0xE0, 0x1F, 0x03, 0xE1, 0xE0, 0x1F, 0x03, 0xE3, 0xE0, 0x1E, 0x01,
  0xE3, 0xE0, 0x1E, 0x01, 0xE3, 0xE0, 0x1E, 0x01, 0xE3, 0xC0, 0x3E, 0x01,
  0xF3, 0xC0, 0x3E, 0x00, 0xF3, 0xC0, 0x3C, 0x00, 0xF7, 0xC0, 0x3C, 0x00,
  0xF7, 0xC0, 0x7C, 0x00, 0xFF, 0x80, 0x7C, 0x00, 0x7F, 0x80, 0x78, 0x00,
  0x7F, 0x80, 0x78, 0x00, 0x7F, 0x80, 0x78, 0x00, 0x7F, 0x00, 0xF8, 0x00,
  0x7F, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0x7C,
  0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF1, 0xF0, 0x00, 0x1E, 0x7C, 0x00,
  0x03, 0xCF, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0x78, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0,
  0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x83, 0xF0, 0x03, 0xF0,
  0x3E, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0x07, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x3E, 0x03, 0xC0,
  0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x78,
  0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x0F,
  0x80, 0x3E, 0x07, 0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x1F, 0x81,
  0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE1,
  0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF1, 0xF0, 0x00,
  0x1E, 0x7C, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x0F, 0x7C,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xF7, 0xC0,
  0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3E,
  0x78, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x3E, 0x3E, 0x00,
  0x07, 0xC7, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x83,
  0xF0, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F,
  0x07, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0x80, 0x3E, 0x03, 0xC0, 0x1F, 0x03,
  0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x78, 0x01, 0xF0,
  0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E,
  0x07, 0x80, 0x3E, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x3F, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3E, 0x1F,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x07, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0xC0,
  0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF0, 0x0F, 0x00, 0xF8,
  0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1E, 0x00, 0x78, 0x0F,
  0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xE1,
  0xE0, 0x01, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0x01, 0xC0, 0x1F,
  0x80, 0x10, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x01, 0x00, 0x0F, 0xC0,
  0x70, 0x0F, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xA0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x1F,
  0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0, 0x78,
  0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3C, 0x0F, 0x80, 0x03,
  0xC0, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F,
  0x00, 0x07, 0x81, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x1F, 0x03,
  0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xE0, 0x7C, 0x00,
  0x1E, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0,
  0xF8, 0x00, 0x3C, 0x0F, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x7C, 0x0F, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xF8,
  0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xBE,
  0x00, 0x07, 0xDF, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xE3,
  0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x07,
  0xC0, 0x1E, 0x03, 0xC0, 0x0F, 0x03, 0xE0, 0x07, 0x81, 0xF0, 0x03, 0xC1,
  0xF0, 0x01, 0xE0, 0xF8, 0x00, 0xF0, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x3C,
  0x3C, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x9F, 0x00, 0x03,
  0xCF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0xF8,
  0x01, 0xFC, 0x00, 0xF8, 0xF8, 0x01, 0xFC, 0x00, 0xF8, 0xF8, 0x01, 0xFC,
  0x00, 0xF0, 0xF8, 0x03, 0xFC, 0x01, 0xF0, 0xF8, 0x03, 0xFC, 0x01, 0xF0,
  0xF8, 0x07, 0xBC, 0x03, 0xE0, 0xF8, 0x07, 0xBC, 0x03, 0xE0, 0xF8, 0x07,
  0xBC, 0x03, 0xC0, 0xF8, 0x0F, 0x3C, 0x07, 0xC0, 0xF8, 0x0F, 0x3C, 0x07,
  0xC0, 0xF8, 0x1E, 0x3C, 0x0F, 0x80, 0xF8, 0x1E, 0x3C, 0x0F, 0x80, 0xF8,
  0x3E, 0x3C, 0x0F, 0x00, 0xF8, 0x3C, 0x3C, 0x1F, 0x00, 0xF8, 0x3C, 0x3C,
  0x1E, 0x00, 0xF8, 0x78, 0x3C, 0x3E, 0x00, 0xF8, 0x78, 0x3C, 0x3E, 0x00,
  0xF8, 0xF0, 0x3C, 0x3C, 0x00, 0xF8, 0xF0, 0x3C, 0x7C, 0x00, 0xF0, 0xF0,
  0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x3C, 0xF8, 0x00, 0xF1, 0xE0, 0x3C, 0xF8,
  0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x3D, 0xF0, 0x00, 0xF3,
  0xC0, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0,
  0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x7C,
  0x1E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0x80,
  0xF8, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0xF8, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x0F, 0xBE, 0x00, 0x7C, 0x78, 0x01, 0xF1, 0xE0, 0x0F, 0x87, 0x80, 0x3E,
  0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x0F,
  0x07, 0xC0, 0x3C, 0x1E, 0x00, 0xF0, 0xF8, 0x03, 0xC7, 0xC0, 0x0F, 0x9F,
  0x00, 0x3E, 0xF8, 0x00, 0x7B, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x87, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x79, 0xE0,
  0x00, 0xF3, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x1E, 0x07, 0x80,
  0x3C, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x07, 0x80, 0x3C, 0x1F,
  0x00, 0x78, 0x3C, 0x00, 0x78, 0xF8, 0x00, 0xF1, 0xE0, 0x01, 0xE7, 0x80,
  0x01, 0xEF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x7C, 0x7C, 0x3C, 0x3E, 0x1E, 0x1E, 0x0F,
  0x07, 0x00, 0x08, 0x00, 0x00, 0x7F, 0x0F, 0x01, 0xFF, 0x9E, 0x03, 0xFF,
  0xDE, 0x07, 0xF3, 0xDE, 0x07, 0xC0, 0xFE, 0x0F, 0x80, 0xFE, 0x1F, 0x80,
  0x7C, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3C, 0x00,
  0x7C, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x78, 0x00,
  0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x07,
  0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x0F, 0xE0, 0xF8, 0x1F, 0xC0, 0x7E, 0x7B,
  0xC0, 0x7F, 0xF3, 0xC0, 0x3F, 0xE3, 0xC0, 0x1F, 0xC3, 0x80, 0x02, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x60, 0x01, 0xE3, 0xF8, 0x03, 0xE7, 0xFE, 0x03, 0xEF,
  0xFE, 0x03, 0xDE, 0x7F, 0x03, 0xF8, 0x1F, 0x03, 0xF0, 0x1F, 0x07, 0xF0,
  0x0F, 0x07, 0xE0, 0x0F, 0x07, 0xC0, 0x0F, 0x07, 0xC0, 0x0F, 0x07, 0x80,
  0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00,
  0x1F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x3E, 0x1E, 0x00,
  0x3E, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0xF8, 0x3E, 0x00, 0xF8, 0x3F, 0x01, 0xF0, 0x7F, 0x03, 0xF0, 0x7B, 0xCF,
  0xE0, 0x7B, 0xFF, 0xC0, 0x79, 0xFF, 0x80, 0xF0, 0xFF, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F,
  0x9C, 0x1F, 0x80, 0x83, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x10, 0x3F, 0x9E, 0x07, 0xFF, 0xC0, 0x7F, 0xF8,
  0x03, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x1C, 0x1F, 0x00,
  0x1F, 0xC7, 0xC0, 0x1F, 0xF9, 0xE0, 0x0F, 0xFF, 0x78, 0x07, 0xF3, 0xDE,
  0x01, 0xF0, 0x3F, 0x80, 0xF8, 0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x1F, 0x00,
  0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF0, 0x01, 0xE0, 0x7C,
  0x00, 0x78, 0x1F, 0x00, 0x1E, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xE0,
  0xF8, 0x00, 0xF0, 0x3E, 0x00, 0x3C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07,
  0xC0, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0xF8, 0x0F, 0x00, 0x3E, 0x03, 0xC0,
  0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x0F, 0x81, 0xFC, 0x01,
  0xF9, 0xEF, 0x00, 0x7F, 0xF3, 0xC0, 0x0F, 0xF8, 0xF0, 0x01, 0xFC, 0x38,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xE0,
  0x3F, 0xFE, 0x07, 0xE3, 0xF0, 0xFC, 0x1F, 0x0F, 0x80, 0xF1, 0xF0, 0x0F,
  0x1E, 0x00, 0xF3, 0xE0, 0x1F, 0x3C, 0x01, 0xF7, 0xC0, 0x3E, 0x7C, 0x07,
  0xC7, 0x83, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xF8,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0x07,
  0xF0, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7C, 0x20, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0xF0, 0xF0, 0x07,
  0xFE, 0x78, 0x03, 0xFF, 0xDE, 0x01, 0xFC, 0xF7, 0x80, 0x7C, 0x0F, 0xE0,
  0x3E, 0x03, 0xF8, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x07,
  0xC0, 0xF8, 0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x1F, 0x00, 0x1E, 0x07, 0xC0,
  0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x0F,
  0x80, 0x0F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3C, 0x00, 0x7C,
  0x0F, 0x00, 0x3E, 0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x07, 0xE0, 0x3E, 0x03,
  0xF8, 0x0F, 0x80, 0xFE, 0x03, 0xE0, 0x7F, 0x00, 0xFE, 0x7B, 0xC0, 0x1F,
  0xFD, 0xF0, 0x03, 0xFE, 0x7C, 0x00, 0x7F, 0x1E, 0x00, 0x02, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x08, 0x00, 0xF8, 0x03, 0x00,
  0x7C, 0x00, 0xFD, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x60, 0x01, 0xE3, 0xFC, 0x03, 0xE7, 0xFE,
  0x03, 0xEF, 0xFE, 0x03, 0xDF, 0x7F, 0x03, 0xF8, 0x1F, 0x03, 0xF0, 0x1F,
  0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1E,
  0x07, 0x80, 0x1E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x3E,
  0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C,
  0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x3E, 0x00, 0x78, 0x3E, 0x00, 0xF8,
  0x3E, 0x00, 0xF8, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x7C, 0x01, 0xF0,
  0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x78, 0x01, 0xE0, 0xF8, 0x03, 0xE0,
  0x00, 0x78, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0xFC, 0x07, 0x80, 0xF8, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x7C, 0x01, 0xE0, 0x7C, 0x00, 0xF0, 0x7C, 0x00, 0xF8, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x3E,
  0x00, 0x0F, 0xBE, 0x00, 0x07, 0xBF, 0x00, 0x03, 0xDF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFE, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x3E,
  0x3E, 0x00, 0x1E, 0x0F, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07,
  0xC1, 0xF0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3C, 0x01, 0xF0, 0x3E, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x40, 0x02, 0x00, 0x0E, 0x1F,
  0xC0, 0xFF, 0x00, 0xF3, 0xFF, 0x0F, 0xFC, 0x07, 0x9F, 0xFC, 0xFF, 0xE0,
  0x3D, 0xE7, 0xEF, 0xBF, 0x01, 0xFC, 0x1F, 0xE0, 0x7C, 0x0F, 0xC0, 0x7E,
  0x03, 0xE0, 0xFC, 0x03, 0xF0, 0x1F, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x3E,
  0x00, 0xF8, 0x07, 0x81, 0xF0, 0x0F, 0x80, 0x3C, 0x0F, 0x00, 0x7C, 0x01,
  0xE0, 0xF8, 0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x3C, 0x00,
  0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x80, 0x3C, 0x0F, 0x00, 0x7C, 0x03, 0xE0,
  0xF8, 0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x3C, 0x01, 0xF0,
  0x07, 0x81, 0xE0, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0xF8,
  0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0x07,
  0x81, 0xE0, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0xF8, 0x03,
  0xC0, 0x1F, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xF0, 0x07, 0x83,
  0xE0, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xE3, 0xFC, 0x03,
  0xCF, 0xFE, 0x03, 0xCF, 0xFE, 0x03, 0xDF, 0xFF, 0x03, 0xF8, 0x1F, 0x03,
  0xF0, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07,
  0xC0, 0x1E, 0x07, 0x80, 0x1E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x3E, 0x0F, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x1F,
  0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x78, 0x3E, 0x00, 0xF8, 0x3E,
  0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x7C,
  0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x78, 0x01, 0xE0, 0xF8,
  0x03, 0xE0, 0x00, 0x04, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0xF3, 0xF0, 0x3F, 0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xC0, 0x1E,
  0x1E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0x7C,
  0x00, 0x7D, 0xF0, 0x01, 0xE7, 0x80, 0x07, 0xBE, 0x00, 0x1E, 0xF8, 0x00,
  0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBC, 0x00, 0x3C, 0xF0, 0x01, 0xF3,
  0xC0, 0x07, 0xCF, 0x00, 0x3E, 0x3C, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xE0,
  0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0xDF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x1E, 0x3F,
  0xC0, 0x0F, 0x1F, 0xF8, 0x03, 0xCF, 0xFE, 0x00, 0xF7, 0x8F, 0xC0, 0x3F,
  0x81, 0xF0, 0x0F, 0xC0, 0x7C, 0x07, 0xF0, 0x0F, 0x01, 0xF8, 0x03, 0xC0,
  0x7C, 0x00, 0xF0, 0x1F, 0x00, 0x3C, 0x07, 0xC0, 0x0F, 0x03, 0xE0, 0x03,
  0xC0, 0xF8, 0x00, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x03, 0xC0,
  0x07, 0xC1, 0xF0, 0x01, 0xE0, 0x7C, 0x00, 0xF8, 0x1E, 0x00, 0x3E, 0x07,
  0x80, 0x0F, 0x81, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0xF8,
  0x0F, 0x80, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xFC, 0x0F, 0xC0, 0x7F, 0xCF,
  0xE0, 0x1E, 0xFF, 0xF0, 0x07, 0x9F, 0xF8, 0x01, 0xE3, 0xFC, 0x00, 0xF8,
  0x30, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0x0F, 0x01,
  0xFF, 0x9E, 0x03, 0xFF, 0xDE, 0x07, 0xF3, 0xDE, 0x07, 0xC0, 0xFE, 0x0F,
  0x80, 0xFE, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x3C, 0x00, 0x78, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0x78, 0x7C,
  0x00, 0xF8, 0x78, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0xF8,
  0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x03, 0xE0, 0xF0,
  0x03, 0xE0, 0xF0, 0x07, 0xE0, 0xF8, 0x0F, 0xE0, 0xF8, 0x0F, 0xE0, 0xF8,
  0x1F, 0xC0, 0xFE, 0x7B, 0xC0, 0x7F, 0xF7, 0xC0, 0x3F, 0xE7, 0xC0, 0x1F,
  0xC7, 0x80, 0x02, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x60, 0x1C, 0x3F, 0x03, 0xCF,
  0xE0, 0x3C, 0xFE, 0x03, 0xDF, 0xE0, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xE1, 0xE0,
  0xF8, 0x04, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x80, 0x3E, 0x0F, 0x8F, 0xE0, 0xFF, 0xFC, 0x0F,
  0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x20, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0xFF, 0x7F, 0xFC,
  0xFF, 0xF9, 0xFF, 0xF0, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF9, 0x03, 0xFE,
  0x03, 0xFC, 0x03, 0xF8, 0x00, 0x80, 0x00, 0x07, 0x80, 0x1E, 0x1F, 0x00,
  0x7C, 0x3E, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0xF0, 0x03, 0xC3, 0xE0, 0x07,
  0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0,
  0xF8, 0x01, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0x80, 0x1E, 0x0F,
  0x00, 0x3C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF0, 0x03, 0xE1, 0xE0,
  0x07, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0xFC, 0x3E, 0x01,
  0xF0, 0x7C, 0x07, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x7F, 0x83, 0xFB, 0xEF,
  0x03, 0xFF, 0xBC, 0x07, 0xFE, 0x78, 0x07, 0xF8, 0xF0, 0x01, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x07, 0xCF,
  0x80, 0x3E, 0x7C, 0x01, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF0, 0x78, 0x0F,
  0x83, 0xC0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x07, 0x83, 0xE0, 0x3C,
  0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x78, 0x03, 0xC7, 0xC0,
  0x1E, 0x3C, 0x00, 0xF3, 0xE0, 0x07, 0x9E, 0x00, 0x3D, 0xF0, 0x01, 0xEF,
  0x00, 0x0F, 0x78, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0xFC, 0x03, 0xF0, 0x07, 0xBE, 0x01, 0xF8, 0x07, 0xDF, 0x00, 0xFC, 0x03,
  0xCF, 0x80, 0xFE, 0x03, 0xE7, 0xC0, 0x7F, 0x01, 0xF3, 0xE0, 0x7F, 0x80,
  0xF1, 0xF0, 0x3F, 0xC0, 0xF8, 0xF8, 0x1D, 0xE0, 0x78, 0x7C, 0x1E, 0xF0,
  0x7C, 0x3E, 0x0F, 0x78, 0x3E, 0x1F, 0x0F, 0x3C, 0x1E, 0x0F, 0x87, 0x9E,
  0x1F, 0x07, 0xC7, 0x8F, 0x0F, 0x03, 0xE3, 0xC7, 0x8F, 0x81, 0xF1, 0xE3,
  0xC7, 0x80, 0xF9, 0xE1, 0xE3, 0xC0, 0x7C, 0xF0, 0xF3, 0xE0, 0x3E, 0xF0,
  0x79, 0xE0, 0x1F, 0x78, 0x3C, 0xF0, 0x0F, 0x38, 0x1E, 0xF0, 0x07, 0xBC,
  0x0F, 0x78, 0x03, 0xDE, 0x07, 0xFC, 0x01, 0xEE, 0x03, 0xFC, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F,
  0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x0F, 0xC0, 0x78, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x07, 0xC0,
  0xF8, 0x01, 0xF0, 0x3C, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x03,
  0xE3, 0xC0, 0x00, 0x79, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xBC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xE7, 0x80, 0x01, 0xF1, 0xE0, 0x00,
  0x78, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0xC0, 0xF0,
  0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x3E, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0x80, 0x3E, 0x00,
  0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x3E, 0x00, 0x3C, 0x01, 0xE0,
  0x01, 0xE0, 0x1F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x03,
  0xC0, 0x7C, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x0F, 0x80,
  0x00, 0x78, 0x78, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x01,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x20, 0x00, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x05, 0xFF, 0xC0, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x7F, 0xE8, 0x00, 0x3E, 0x00,
};

const GFXglyph NotoSans_Condensed_Italic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 13, 41, 14, 1, -40 },
  { 68, 16, 14, 20, 6, -40 },
  { 96, 29, 40, 27, 0, -40 },
  { 241, 24, 46, 25, 1, -43 },
  { 379, 32, 42, 37, 3, -41 },
  { 547, 27, 42, 28, 0, -41 },
  { 689, 7, 14, 11, 6, -40 },
  { 702, 18, 49, 15, 1, -40 },
  { 813, 17, 49, 15, -4, -40 },
  { 918, 19, 21, 23, 6, -43 },
  { 968, 22, 26, 26, 3, -33 },
  { 1040, 10, 13, 12, -2, -6 },
  { 1057, 13, 4, 15, 1, -17 },
  { 1064, 6, 8, 12, 1, -7 },
  { 1070, 26, 40, 19, -3, -40 },
  { 1200, 22, 42, 25, 2, -41 },
  { 1316, 15, 40, 25, 6, -40 },
  { 1391, 25, 41, 25, -1, -41 },
  { 1520, 24, 42, 25, 0, -41 },
  { 1646, 25, 40, 25, -1, -40 },
  { 1771, 25, 41, 25, 0, -40 },
  { 1900, 23, 42, 25, 2, -41 },
  { 2021, 23, 40, 25, 3, -40 },
  { 2136, 25, 42, 25, 0, -41 },
  { 2268, 23, 42, 25, 1, -41 },
  { 2389, 12, 31, 12, 0, -30 },
  { 2436, 15, 37, 12, -3, -30 },
  { 2506, 22, 26, 26, 3, -33 },
  { 2578, 22, 16, 26, 3, -28 },
  { 2622, 22, 26, 26, 3, -33 },
  { 2694, 19, 42, 19, 2, -41 },
  { 2794, 34, 45, 37, 2, -40 },
  { 2986, 26, 40, 25, -4, -40 },
  { 3116, 26, 40, 27, 1, -40 },
  { 3246, 26, 42, 25, 3, -41 },
  { 3383, 27, 40, 29, 1, -40 },
  { 3518, 24, 40, 23, 1, -40 },
  { 3638, 24, 40, 22, 1, -40 },
  { 3758, 28, 42, 31, 3, -41 },
  { 3905, 30, 40, 30, 1, -40 },
  { 4055, 21, 40, 16, -2, -40 },
  { 4160, 22, 51, 12, -8, -40 },
  { 4301, 29, 40, 25, 1, -40 },
  { 4446, 17, 40, 21, 1, -40 },
  { 4531, 39, 40, 39, 1, -40 },
  { 4726, 32, 40, 32, 1, -40 },
  { 4886, 27, 42, 32, 3, -41 },
  { 5028, 25, 40, 25, 1, -40 },
  { 5153, 27, 51, 32, 3, -41 },
  { 5326, 25, 40, 26, 1, -40 },
  { 5451, 26, 42, 23, -1, -41 },
  { 5588, 21, 40, 22, 5, -40 },
  { 5693, 28, 41, 30, 3, -40 },
  { 5837, 25, 40, 25, 5, -40 },
  { 5962, 40, 40, 40, 5, -40 },
  { 6162, 31, 40, 23, -3, -40 },
  { 6317, 22, 40, 23, 5, -40 },
  { 6427, 27, 40, 22, -2, -40 },
  { 6562, 21, 49, 16, -1, -40 },
  { 6691, 9, 40, 19, 6, -40 },
  { 6736, 21, 49, 16, -4, -40 },
  { 6865, 23, 23, 25, 1, -40 },
  { 6932, 19, 3, 19, -5, 5 },
  { 6940, 8, 9, 14, 8, -43 },
  { 6949, 24, 32, 26, 2, -31 },
  { 7045, 24, 44, 26, 0, -43 },
  { 7177, 19, 32, 20, 2, -31 },
  { 7253, 26, 44, 26, 2, -43 },
  { 7396, 20, 32, 23, 2, -31 },
  { 7476, 28, 56, 14, -7, -43 },
  { 7672, 26, 44, 26, 0, -31 },
  { 7815, 24, 43, 26, 0, -43 },
  { 7944, 14, 41, 12, 0, -41 },
  { 8016, 21, 54, 12, -7, -41 },
  { 8158, 25, 43, 22, 0, -43 },
  { 8293, 14, 43, 12, 0, -43 },
  { 8369, 37, 31, 39, 0, -31 },
  { 8513, 24, 31, 26, 0, -31 },
  { 8606, 22, 32, 25, 2, -31 },
  { 8694, 26, 44, 26, -2, -31 },
  { 8837, 24, 44, 26, 2, -31 },
  { 8969, 20, 31, 18, 0, -31 },
  { 9047, 20, 32, 20, 0, -31 },
  { 9127, 15, 38, 15, 2, -37 },
  { 9199, 23, 31, 26, 2, -30 },
  { 9289, 21, 30, 21, 3, -30 },
  { 9368, 33, 30, 33, 3, -30 },
  { 9492, 26, 30, 22, -2, -30 },
  { 9590, 29, 44, 21, -5, -30 },
  { 9750, 22, 30, 19, -2, -30 },
  { 9833, 21, 49, 19, 1, -40 },
  { 9962, 4, 56, 24, 10, -43 },
  { 9990, 21, 49, 19, -3, -40 },
  { 10119, 22, 7, 26, 3, -23 },
};

const GFXfont NotoSans_Condensed_Italic56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic56pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_CONDENSED_ITALIC56PT7B_H_
