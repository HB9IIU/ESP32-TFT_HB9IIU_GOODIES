#ifndef _NOTOSANS_CONDENSED_ITALIC13PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x82, 0xC0, 0x55, 0xA0, 0x14, 0x29, 0xF9, 0x42, 0x9F,
  0x94, 0x28, 0x90, 0x08, 0xE7, 0x54, 0x60, 0x42, 0x8A, 0xF0, 0x84, 0x00,
  0x67, 0x4A, 0xA5, 0xBD, 0xA5, 0x4A, 0xA5, 0xCC, 0x38, 0xA2, 0x8C, 0x71,
  0x59, 0xA6, 0xFC, 0x58, 0x12, 0x64, 0x44, 0x88, 0x84, 0x40, 0x31, 0x11,
  0x11, 0x12, 0x24, 0x80, 0x25, 0x1E, 0xA5, 0x00, 0x21, 0x09, 0xF2, 0x10,
  0x6A, 0x00, 0xE0, 0x70, 0x04, 0x20, 0x84, 0x10, 0x82, 0x10, 0xC0, 0x38,
  0x94, 0x53, 0x4B, 0x28, 0xB4, 0x70, 0x75, 0x24, 0xB4, 0x80, 0x78, 0x10,
  0x82, 0x10, 0xC6, 0x30, 0xF0, 0x78, 0x10, 0x86, 0x30, 0x20, 0x86, 0xF0,
  0x0C, 0x62, 0x8A, 0x4A, 0x4F, 0x84, 0x10, 0x3C, 0x84, 0x1C, 0x18, 0x20,
  0x86, 0xF0, 0x1C, 0x84, 0x1E, 0x49, 0x2C, 0x92, 0x70, 0xF8, 0xC4, 0x42,
  0x21, 0x10, 0x80, 0x3D, 0x14, 0xCE, 0x31, 0x28, 0xA2, 0x70, 0x39, 0x34,
  0xD2, 0x58, 0xA0, 0x84, 0xE0, 0x68, 0x01, 0x30, 0x32, 0x00, 0x02, 0x44,
  0x80, 0x08, 0xD9, 0x06, 0x0C, 0xF8, 0x3E, 0x86, 0x0C, 0x36, 0x40, 0x78,
  0x46, 0x22, 0x20, 0x08, 0xC0, 0x1F, 0x21, 0x4F, 0x55, 0x55, 0xA5, 0xAD,
  0x96, 0x40, 0x3C, 0x0C, 0x31, 0x45, 0x24, 0xF4, 0x51, 0xC4, 0x3C, 0x92,
  0x53, 0x79, 0x34, 0xF2, 0xF0, 0x3D, 0x0C, 0x20, 0x82, 0x08, 0x20, 0xF0,
  0x3C, 0x48, 0x9A, 0x34, 0x48, 0x93, 0x64, 0xF0, 0x3C, 0x82, 0x10, 0x79,
  0x04, 0x30, 0xF0, 0x3C, 0x82, 0x10, 0x79, 0x04, 0x30, 0x80, 0x3D, 0x0C,
  0x20, 0x9E, 0x28, 0xA2, 0xF8, 0x22, 0x44, 0x8A, 0x27, 0xC8, 0x91, 0x62,
  0x88, 0x3C, 0x41, 0x04, 0x20, 0x82, 0x08, 0xF0, 0x08, 0x42, 0x21, 0x08,
  0x46, 0x21, 0x38, 0x26, 0x58, 0xA2, 0x87, 0x0A, 0x14, 0x64, 0x88, 0x22,
  0x24, 0x44, 0x4C, 0xF0, 0x31, 0x98, 0xCC, 0xAA, 0x55, 0x52, 0xA9, 0x65,
  0x32, 0x9B, 0x00, 0x33, 0x32, 0x32, 0x52, 0x52, 0x4C, 0x4C, 0xCC, 0x8C,
  0x3D, 0x18, 0x61, 0x86, 0x38, 0xA6, 0xF0, 0x3C, 0x92, 0x51, 0x79, 0x04,
  0x30, 0x80, 0x3D, 0x18, 0x61, 0x86, 0x38, 0xA6, 0xF0, 0x81, 0x00, 0x3C,
  0x92, 0x53, 0x79, 0x45, 0x32, 0x88, 0x3D, 0x04, 0x18, 0x30, 0x60, 0x84,
  0xF0, 0xF9, 0x08, 0x84, 0x21, 0x08, 0x80, 0x45, 0x1C, 0x62, 0x8A, 0x28,
  0xA4, 0xF0, 0x8E, 0x28, 0xA4, 0x92, 0x8A, 0x30, 0xC0, 0x88, 0xC4, 0xE6,
  0x53, 0x2A, 0xA5, 0x53, 0x29, 0x98, 0xCC, 0x00, 0x32, 0x28, 0x50, 0xC1,
  0x87, 0x0A, 0x24, 0xCC, 0x8C, 0x94, 0xC6, 0x21, 0x08, 0x80, 0x7C, 0x21,
  0x04, 0x21, 0x84, 0x20, 0xF0, 0x39, 0x08, 0x84, 0x21, 0x10, 0x84, 0x30,
  0x89, 0x24, 0x92, 0x60, 0x38, 0x44, 0x21, 0x08, 0x44, 0x21, 0x38, 0x10,
  0xC2, 0x92, 0x84, 0xF0, 0x90, 0x3D, 0x34, 0x92, 0xCB, 0x66, 0x80, 0x20,
  0x82, 0x1E, 0x65, 0x14, 0xD2, 0xCA, 0xC0, 0x3A, 0x10, 0x88, 0x61, 0xC0,
  0x06, 0x08, 0x11, 0xE4, 0xC9, 0x12, 0x64, 0xD8, 0xD0, 0x3A, 0x52, 0xE8,
  0x61, 0xC0, 0x06, 0x10, 0x20, 0xE1, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81,
  0x0C, 0x00, 0x3D, 0x34, 0x92, 0xCB, 0x66, 0x84, 0x13, 0x80, 0x20, 0x82,
  0x16, 0x6D, 0x24, 0x92, 0x8A, 0x60, 0x24, 0x34, 0x92, 0x90, 0x08, 0x40,
  0x31, 0x08, 0x42, 0x21, 0x08, 0x4C, 0x00, 0x20, 0x82, 0x1B, 0x59, 0x47,
  0x14, 0x92, 0x40, 0x24, 0xB4, 0x92, 0x90, 0x5B, 0x36, 0xD2, 0x49, 0x24,
  0x94, 0x4A, 0x4C, 0x59, 0xB4, 0x92, 0x4A, 0x29, 0x80, 0x3A, 0x52, 0x98,
  0xE5, 0xC0, 0x2C, 0x64, 0x89, 0x32, 0x4C, 0x96, 0x20, 0x41, 0x80, 0x3D,
  0x34, 0x92, 0xCB, 0x66, 0x84, 0x10, 0x40, 0x5B, 0x10, 0x84, 0x42, 0x00,
  0x7A, 0x10, 0x41, 0x0B, 0x80, 0x22, 0x74, 0x44, 0x48, 0x60, 0x65, 0x14,
  0x92, 0x4B, 0x66, 0x80, 0x9C, 0xA9, 0x4C, 0x63, 0x00, 0x93, 0x66, 0xD6,
  0xAD, 0x9B, 0x26, 0x00, 0x24, 0xA1, 0x84, 0x31, 0xAC, 0x80, 0x26, 0x48,
  0xA1, 0x43, 0x06, 0x0C, 0x10, 0x61, 0x80, 0x78, 0x88, 0x44, 0x43, 0x80,
  0x18, 0x88, 0x42, 0x61, 0x08, 0x42, 0x18, 0xFF, 0xF8, 0x30, 0x84, 0x21,
  0x0C, 0x84, 0x21, 0x30, 0xF8,
};

const GFXglyph NotoSans_Condensed_Italic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 4, 3, 5, 1, -9 },
  { 7, 7, 9, 6, 0, -9 },
  { 15, 6, 11, 6, 0, -10 },
  { 24, 7, 9, 9, 1, -9 },
  { 32, 6, 9, 7, 0, -9 },
  { 39, 2, 3, 3, 1, -9 },
  { 40, 4, 11, 3, 0, -9 },
  { 46, 4, 11, 3, -1, -9 },
  { 52, 5, 5, 5, 1, -10 },
  { 56, 5, 6, 6, 1, -8 },
  { 60, 3, 3, 3, -1, -1 },
  { 62, 3, 1, 4, 0, -4 },
  { 63, 2, 2, 3, 0, -2 },
  { 64, 6, 9, 4, -1, -9 },
  { 71, 6, 9, 6, 0, -9 },
  { 78, 3, 9, 6, 2, -9 },
  { 82, 6, 9, 6, 0, -9 },
  { 89, 6, 9, 6, 0, -9 },
  { 96, 6, 9, 6, 0, -9 },
  { 103, 6, 9, 6, 0, -9 },
  { 110, 6, 9, 6, 0, -9 },
  { 117, 5, 9, 6, 1, -9 },
  { 123, 6, 9, 6, 0, -9 },
  { 130, 6, 9, 6, 0, -9 },
  { 137, 3, 7, 3, 0, -7 },
  { 140, 4, 9, 3, -1, -7 },
  { 145, 5, 6, 6, 1, -8 },
  { 149, 5, 3, 6, 1, -6 },
  { 151, 5, 6, 6, 1, -8 },
  { 155, 5, 9, 4, 0, -9 },
  { 161, 8, 10, 9, 0, -9 },
  { 171, 6, 9, 6, -1, -9 },
  { 178, 6, 9, 6, 0, -9 },
  { 185, 6, 9, 6, 1, -9 },
  { 192, 7, 9, 7, 0, -9 },
  { 200, 6, 9, 5, 0, -9 },
  { 207, 6, 9, 5, 0, -9 },
  { 214, 6, 9, 7, 1, -9 },
  { 221, 7, 9, 7, 0, -9 },
  { 229, 6, 9, 4, -1, -9 },
  { 236, 5, 11, 3, -2, -9 },
  { 243, 7, 9, 6, 0, -9 },
  { 251, 4, 9, 5, 0, -9 },
  { 256, 9, 9, 9, 0, -9 },
  { 267, 8, 9, 7, 0, -9 },
  { 276, 6, 9, 7, 1, -9 },
  { 283, 6, 9, 6, 0, -9 },
  { 290, 6, 11, 7, 1, -9 },
  { 299, 6, 9, 6, 0, -9 },
  { 306, 6, 9, 5, 0, -9 },
  { 313, 5, 9, 5, 1, -9 },
  { 319, 6, 9, 7, 1, -9 },
  { 326, 6, 9, 6, 1, -9 },
  { 333, 9, 9, 9, 1, -9 },
  { 344, 7, 9, 5, -1, -9 },
  { 352, 5, 9, 5, 1, -9 },
  { 358, 6, 9, 5, 0, -9 },
  { 365, 5, 11, 4, 0, -9 },
  { 372, 3, 9, 4, 1, -9 },
  { 376, 5, 11, 4, -1, -9 },
  { 383, 6, 5, 6, 0, -9 },
  { 387, 4, 1, 4, -1, 1 },
  { 388, 2, 2, 3, 2, -10 },
  { 389, 6, 7, 6, 0, -7 },
  { 395, 6, 10, 6, 0, -10 },
  { 403, 5, 7, 5, 0, -7 },
  { 408, 7, 10, 6, 0, -10 },
  { 417, 5, 7, 5, 0, -7 },
  { 422, 7, 13, 3, -2, -10 },
  { 434, 6, 10, 6, 0, -7 },
  { 442, 6, 10, 6, 0, -10 },
  { 450, 3, 10, 3, 0, -10 },
  { 454, 5, 13, 3, -2, -10 },
  { 463, 6, 10, 5, 0, -10 },
  { 471, 3, 10, 3, 0, -10 },
  { 475, 9, 7, 9, 0, -7 },
  { 483, 6, 7, 6, 0, -7 },
  { 489, 5, 7, 6, 0, -7 },
  { 494, 7, 10, 6, -1, -7 },
  { 503, 6, 10, 6, 0, -7 },
  { 511, 5, 7, 4, 0, -7 },
  { 516, 5, 7, 5, 0, -7 },
  { 521, 4, 9, 3, 0, -9 },
  { 526, 6, 7, 6, 0, -7 },
  { 532, 5, 7, 5, 1, -7 },
  { 537, 7, 7, 8, 1, -7 },
  { 544, 6, 7, 5, -1, -7 },
  { 550, 7, 10, 5, -1, -7 },
  { 559, 5, 7, 4, 0, -7 },
  { 564, 5, 11, 4, 0, -9 },
  { 571, 1, 13, 5, 2, -10 },
  { 573, 5, 11, 4, -1, -9 },
  { 580, 5, 1, 6, 1, -5 },
};

const GFXfont NotoSans_Condensed_Italic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic13pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_CONDENSED_ITALIC13PT7B_H_
