#ifndef _NOTOSANS_CONDENSED_ITALIC46PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x01, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x00, 0x7C,
  0x7B, 0xC3, 0x9E, 0x3C, 0xF1, 0xE7, 0x0F, 0x38, 0x71, 0xC3, 0x9E, 0x1C,
  0xE1, 0xE7, 0x0E, 0x38, 0x71, 0xC3, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0x38, 0x00, 0x70, 0x60, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07,
  0x00, 0x0C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE1, 0xC0,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0x0E, 0x1C, 0x00, 0x38, 0x38, 0x00,
  0x70, 0x70, 0x00, 0xE0, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E,
  0x0E, 0x00, 0x1C, 0x38, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFC, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x70, 0x70,
  0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x07, 0x00, 0x0E, 0x0E, 0x00,
  0x1C, 0x1C, 0x00, 0x78, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0,
  0x3C, 0xCE, 0x07, 0x8C, 0x20, 0x71, 0xC0, 0x0F, 0x18, 0x00, 0xF1, 0x80,
  0x0F, 0x18, 0x00, 0xF1, 0x80, 0x07, 0xB8, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x06,
  0xF8, 0x00, 0x67, 0x80, 0x0E, 0x38, 0x00, 0xC3, 0x80, 0x0C, 0x38, 0x00,
  0xC7, 0x80, 0x0C, 0x78, 0x61, 0xCF, 0x07, 0xDF, 0xF0, 0xFF, 0xFE, 0x07,
  0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x07, 0x03, 0xF8, 0x03, 0x81,
  0xFE, 0x01, 0xE0, 0xF1, 0xC0, 0x70, 0x38, 0x70, 0x38, 0x1C, 0x1C, 0x0E,
  0x07, 0x07, 0x07, 0x01, 0xC1, 0xC3, 0xC0, 0xE0, 0x70, 0xE0, 0x38, 0x38,
  0x70, 0x0E, 0x0E, 0x1C, 0x03, 0x83, 0x8E, 0x00, 0xE0, 0xE3, 0x80, 0x38,
  0x71, 0xC7, 0xCE, 0x1C, 0xF3, 0xFB, 0x87, 0x39, 0xFE, 0xE3, 0x9C, 0xF1,
  0xFF, 0xE7, 0x38, 0x7F, 0xF3, 0x9E, 0x1D, 0xF9, 0xE7, 0x07, 0x00, 0x71,
  0xC1, 0xC0, 0x38, 0xF0, 0x70, 0x0E, 0x38, 0x3C, 0x07, 0x0E, 0x0E, 0x01,
  0xC3, 0x83, 0x80, 0xE0, 0xE0, 0xE0, 0x78, 0x38, 0x78, 0x1C, 0x0E, 0x1C,
  0x0E, 0x03, 0x87, 0x03, 0x80, 0xE3, 0x81, 0xC0, 0x3D, 0xE0, 0xF0, 0x0F,
  0xF0, 0x38, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x07, 0x80, 0x3C, 0x1E,
  0x00, 0xF0, 0x78, 0x03, 0xC1, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x78, 0x00,
  0x71, 0xE0, 0x01, 0xEF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x71, 0xF7, 0x83, 0xC7, 0x8F, 0x0F,
  0x3C, 0x3C, 0x79, 0xE0, 0x79, 0xE7, 0x81, 0xEF, 0x1C, 0x03, 0xFC, 0xF0,
  0x0F, 0xE3, 0xC0, 0x3F, 0x0F, 0x00, 0x7C, 0x3C, 0x03, 0xF0, 0xF8, 0x1F,
  0xC1, 0xE0, 0xFF, 0x07, 0xFF, 0xDE, 0x0F, 0xFC, 0x78, 0x1F, 0xE0, 0xF0,
  0x3D, 0xE7, 0x9E, 0x79, 0xC7, 0x3C, 0xE3, 0x8E, 0x38, 0x00, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0xC1, 0xC0, 0xF1, 0x80, 0xFD, 0x86, 0x7F, 0xFF, 0x07, 0xFF, 0x07,
  0x87, 0x0F, 0xC0, 0x1C, 0xC0, 0x3C, 0xE0, 0xF8, 0xF0, 0x70, 0x70, 0x30,
  0x78, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x0F, 0x1E, 0x1E,
  0x1C, 0x3C, 0x38, 0x78, 0x70, 0x70, 0xE0, 0xFF, 0xFF, 0xFB, 0xFF, 0x00,
  0x77, 0xFF, 0xEF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xF0,
  0x07, 0xFF, 0x01, 0xF1, 0xE0, 0x3C, 0x1E, 0x0F, 0x03, 0xC3, 0xC0, 0x78,
  0x78, 0x0F, 0x0E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8E, 0x00, 0xF3,
  0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x71, 0xC0, 0x1E, 0x78, 0x03, 0xCF,
  0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xC7, 0x00, 0x78, 0xE0, 0x0F, 0x1C,
  0x01, 0xE7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE1, 0xC0, 0x78, 0x38,
  0x0F, 0x07, 0x83, 0xC0, 0xF0, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x1F,
  0xC0, 0x00, 0x00, 0x78, 0x0F, 0x80, 0xFC, 0x0F, 0xE0, 0xFF, 0x1F, 0x71,
  0xF7, 0x9F, 0x3C, 0x71, 0xE1, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xC3, 0xE0, 0x18, 0x0F, 0x80, 0x80, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0x3C, 0x3E, 0x03, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x80, 0x1F, 0x0C,
  0x07, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x3B, 0xC0, 0x01, 0xDC, 0x00, 0x1C, 0xE0, 0x01, 0xEF,
  0x00, 0x0E, 0x78, 0x00, 0xE3, 0xC0, 0x0E, 0x1C, 0x00, 0xF0, 0xE0, 0x07,
  0x0F, 0x00, 0x70, 0x78, 0x07, 0x83, 0xC0, 0x38, 0x1C, 0x03, 0x81, 0xE0,
  0x3C, 0x0F, 0x01, 0xC0, 0x78, 0x1C, 0x03, 0xC1, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x04, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x80,
  0x1F, 0x0C, 0x03, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xF8, 0x10, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0x83, 0x00, 0xF3, 0xF8, 0x1E, 0xFF, 0x83,
  0xBF, 0xF8, 0x7C, 0x0F, 0x1F, 0x01, 0xE3, 0xE0, 0x1C, 0x78, 0x03, 0x8F,
  0x00, 0x71, 0xE0, 0x0E, 0x38, 0x03, 0xC7, 0x00, 0x78, 0xE0, 0x0F, 0x1C,
  0x01, 0xC3, 0x80, 0x78, 0x78, 0x0F, 0x0F, 0x03, 0xC1, 0xF0, 0xF8, 0x1F,
  0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0xF1, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x01,
  0xFF, 0xE0, 0x3E, 0x1F, 0x03, 0xC0, 0xF0, 0x78, 0x07, 0x07, 0x80, 0x70,
  0x78, 0x07, 0x07, 0x80, 0x70, 0x78, 0x0F, 0x07, 0x80, 0xE0, 0x78, 0x1E,
  0x03, 0xC3, 0xC0, 0x3E, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0xE0, 0x0F, 0x9F, 0x01, 0xE0, 0xF8, 0x3C, 0x07, 0x87, 0x80,
  0x78, 0x78, 0x03, 0xC7, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0,
  0x03, 0x8F, 0x00, 0x78, 0x78, 0x07, 0x87, 0xC1, 0xF0, 0x3F, 0xFE, 0x03,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFE,
  0x03, 0xE3, 0xE0, 0xF8, 0x3C, 0x1E, 0x03, 0x87, 0x80, 0x78, 0xF0, 0x0F,
  0x1C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x3C,
  0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x3E, 0x3E, 0x0F, 0xC3, 0xFF, 0xF8,
  0x7F, 0xEE, 0x07, 0xFB, 0xC0, 0x3C, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0x81, 0x03, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0x83, 0xC1, 0xE1, 0xF0, 0xF8, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x83,
  0xC3, 0xE1, 0xF0, 0x70, 0x00, 0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1E, 0x01,
  0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70,
  0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0x80, 0x00, 0xF0, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x78, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xF8, 0xFF, 0xF0, 0xE1, 0xF1, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x01, 0xC0, 0x3C,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x71, 0xE0, 0x3F, 0x07, 0x1C, 0x0F, 0xF8, 0x73, 0x81, 0xFF, 0x87, 0x38,
  0x38, 0x70, 0x73, 0x87, 0x87, 0x07, 0x70, 0x70, 0x70, 0x77, 0x0E, 0x07,
  0x07, 0x60, 0xE0, 0xE0, 0xEE, 0x0E, 0x0E, 0x0E, 0xE1, 0xC0, 0xE0, 0xEE,
  0x1C, 0x0E, 0x0E, 0xE1, 0xC1, 0xC1, 0xCE, 0x1C, 0x1C, 0x1C, 0xC1, 0xC3,
  0xC1, 0x8C, 0x1C, 0x3C, 0x38, 0xC1, 0xC6, 0xC7, 0x0C, 0x1F, 0xEF, 0xE0,
  0xE0, 0xFC, 0xFC, 0x0E, 0x07, 0x87, 0x80, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xE0, 0x0C, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x3D, 0xC0, 0x01, 0xCE,
  0x00, 0x1E, 0x70, 0x00, 0xE3, 0x80, 0x0F, 0x1C, 0x00, 0x78, 0xE0, 0x07,
  0x87, 0x00, 0x3C, 0x38, 0x01, 0xC1, 0xC0, 0x1E, 0x0E, 0x00, 0xE0, 0x70,
  0x0F, 0x03, 0x80, 0x78, 0x1C, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE1, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC7,
  0x80, 0x1E, 0x3C, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3D, 0xE0, 0x01,
  0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x78, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0xFF, 0xFC, 0x07, 0x8F, 0xE0, 0x38, 0x0F, 0x83, 0xC0, 0x3C, 0x1E, 0x01,
  0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x38, 0x03, 0xC3, 0xC0, 0x1E, 0x1E,
  0x01, 0xE0, 0xF0, 0x1F, 0x07, 0x81, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0xF1, 0xFC, 0x07, 0x01, 0xF0, 0x78, 0x07, 0x83, 0xC0,
  0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x00, 0x3C, 0x78, 0x03, 0xE3,
  0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x8F, 0x00, 0xF8, 0x78, 0x3F,
  0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7E, 0x0C, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x18, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0xFC, 0x03, 0x80, 0xF8, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0xC1,
  0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0,
  0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F,
  0x1E, 0x00, 0x3C, 0x78, 0x01, 0xF1, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C,
  0x00, 0x78, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0E, 0x00, 0x7C, 0x78, 0x01,
  0xE1, 0xE0, 0x0F, 0x87, 0x80, 0x7C, 0x1E, 0x03, 0xE0, 0xF0, 0x1F, 0x03,
  0xC7, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x40, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xF8, 0x3E, 0x03, 0xE0, 0x04,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x07, 0xF8,
  0xF0, 0x0F, 0xF8, 0xF0, 0x0F, 0xF8, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x70,
  0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xE0,
  0xF0, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x7C, 0x01, 0xE0,
  0x3F, 0x03, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0x80, 0xF0, 0x03, 0xC0, 0x78, 0x01,
  0xE0, 0x38, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x38, 0x0F, 0x00,
  0x3C, 0x07, 0x80, 0x1E, 0x03, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0,
  0x07, 0x80, 0xF0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0x00, 0x1E, 0x07,
  0x80, 0x0F, 0x03, 0xC0, 0x07, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0xC0,
  0x70, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x70, 0x1E, 0x00, 0x78,
  0x0F, 0x00, 0x3C, 0x07, 0x00, 0x1E, 0x07, 0x80, 0x0E, 0x03, 0xC0, 0x0F,
  0x01, 0xE0, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x03, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x1F, 0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x7C, 0x03, 0xC0, 0x78, 0x03, 0x80,
  0xF0, 0x07, 0x81, 0xE0, 0x07, 0x83, 0xE0, 0x07, 0x83, 0xC0, 0x07, 0x87,
  0x80, 0x07, 0x0F, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3C,
  0x00, 0x0E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0x3C, 0x00, 0x78, 0x1E,
  0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x07,
  0x80, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x07,
  0x70, 0x01, 0xFE, 0x07, 0x70, 0x03, 0xDC, 0x07, 0x70, 0x03, 0xFC, 0x0F,
  0x70, 0x07, 0xBC, 0x0F, 0x78, 0x07, 0xBC, 0x0F, 0x78, 0x07, 0x3C, 0x0E,
  0x78, 0x0F, 0x38, 0x1E, 0x78, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1C, 0x78, 0x1C, 0x38, 0x3C, 0x78, 0x1C, 0x38, 0x38, 0x70, 0x3C,
  0x38, 0x78, 0xF0, 0x3C, 0x38, 0x70, 0xF0, 0x3C, 0x38, 0xF0, 0xF0, 0x38,
  0x38, 0xE0, 0xE0, 0x38, 0x39, 0xE1, 0xE0, 0x78, 0x39, 0xC1, 0xE0, 0x78,
  0x3B, 0xC1, 0xE0, 0x78, 0x3B, 0x81, 0xE0, 0x70, 0x3F, 0x81, 0xC0, 0xF0,
  0x3F, 0x03, 0xC0, 0xF0, 0x3F, 0x03, 0xC0, 0xF0, 0x3E, 0x03, 0xC0, 0xE0,
  0x3E, 0x03, 0xC0, 0xE0, 0x1C, 0x07, 0x80, 0x03, 0xE0, 0x03, 0xC0, 0xF8,
  0x00, 0xF0, 0x3E, 0x00, 0x3C, 0x0F, 0xC0, 0x0E, 0x03, 0xF0, 0x07, 0x81,
  0xFC, 0x01, 0xE0, 0x7F, 0x00, 0x78, 0x1D, 0xE0, 0x1E, 0x07, 0x78, 0x07,
  0x01, 0xDE, 0x03, 0xC0, 0xF3, 0x80, 0xF0, 0x3C, 0xE0, 0x3C, 0x0E, 0x3C,
  0x0E, 0x03, 0x8F, 0x03, 0x81, 0xE1, 0xC1, 0xE0, 0x78, 0x70, 0x78, 0x1E,
  0x1E, 0x1E, 0x07, 0x07, 0x87, 0x01, 0xC0, 0xE1, 0xC0, 0xF0, 0x38, 0xF0,
  0x3C, 0x0F, 0x3C, 0x0F, 0x03, 0xCF, 0x03, 0x80, 0xF3, 0x80, 0xE0, 0x1C,
  0xE0, 0x78, 0x07, 0x78, 0x1E, 0x01, 0xFE, 0x07, 0x80, 0x7F, 0x81, 0xC0,
  0x0F, 0xC0, 0xF0, 0x03, 0xF0, 0x3C, 0x00, 0xFC, 0x0F, 0x00, 0x3F, 0x03,
  0xC0, 0x0F, 0x80, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x1F, 0x87, 0xE0, 0x3C, 0x03, 0xC0, 0xF0, 0x07,
  0x83, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0xF8, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xEF, 0x00, 0x03, 0xDE,
  0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xC0,
  0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00,
  0x1E, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xE3, 0xE0, 0x07,
  0x83, 0xC0, 0x1E, 0x07, 0xC0, 0x7C, 0x0F, 0xC3, 0xF0, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0x81, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0,
  0x78, 0x0F, 0x07, 0x80, 0xF0, 0x70, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F,
  0x0F, 0x00, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xE1, 0xE0, 0x7C, 0x1E, 0x1F,
  0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x1F, 0x87, 0xE0, 0x3C, 0x03, 0xC0, 0xF0, 0x07, 0x83, 0xE0,
  0x07, 0x87, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0xF8, 0x00,
  0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07,
  0xBC, 0x00, 0x0F, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xF7,
  0x80, 0x01, 0xEF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78,
  0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xE3, 0xE0, 0x07, 0x83, 0xC0,
  0x1E, 0x07, 0xC0, 0x7C, 0x0F, 0xC3, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0x03, 0x81, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07,
  0x80, 0xF0, 0x70, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0,
  0xF0, 0x1E, 0x1E, 0x03, 0xE1, 0xE0, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0,
  0x1F, 0xF8, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C,
  0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x80,
  0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF8, 0xE0,
  0x07, 0x80, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0x1E,
  0x07, 0xC0, 0x20, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x80, 0x1E, 0x0E, 0x07, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x1E, 0x07, 0x80,
  0x1E, 0x07, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1C, 0x0F, 0x00,
  0x3C, 0x0E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00,
  0x78, 0x1E, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00,
  0x70, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x38, 0x00, 0xF0, 0x78, 0x00,
  0xF0, 0x78, 0x00, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0xF0, 0x01,
  0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03,
  0xC0, 0xF0, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xBC, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x3E, 0x78, 0x01, 0xE3, 0xC0,
  0x0F, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x78, 0x3C, 0x03, 0xC1,
  0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x1E, 0x01, 0xC0, 0xF0, 0x0E, 0x07,
  0x80, 0x70, 0x78, 0x03, 0x83, 0xC0, 0x1C, 0x3C, 0x00, 0xE1, 0xE0, 0x07,
  0x1E, 0x00, 0x38, 0xF0, 0x01, 0xC7, 0x00, 0x0E, 0x78, 0x00, 0x73, 0x80,
  0x03, 0xBC, 0x00, 0x1D, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0xF8, 0x01, 0xE0, 0x07, 0xBC, 0x00, 0xF0, 0x03, 0xDE, 0x00,
  0xF8, 0x03, 0xCF, 0x00, 0x7C, 0x01, 0xE7, 0x80, 0x7E, 0x01, 0xE3, 0xC0,
  0x3F, 0x00, 0xF1, 0xE0, 0x1F, 0x80, 0x78, 0xF0, 0x1D, 0xC0, 0x78, 0x78,
  0x0E, 0xE0, 0x3C, 0x3C, 0x0F, 0x70, 0x3C, 0x1E, 0x07, 0x38, 0x1E, 0x0F,
  0x03, 0x9C, 0x0E, 0x07, 0x83, 0x8E, 0x0F, 0x03, 0xC1, 0xC7, 0x07, 0x81,
  0xE1, 0xE3, 0x87, 0x80, 0xF0, 0xE1, 0xC3, 0xC0, 0x78, 0xF0, 0xE1, 0xC0,
  0x3C, 0x70, 0x71, 0xE0, 0x1E, 0x38, 0x38, 0xF0, 0x0F, 0x3C, 0x1C, 0xF0,
  0x07, 0x9C, 0x0E, 0x78, 0x03, 0xDE, 0x07, 0x38, 0x01, 0xEE, 0x03, 0xBC,
  0x00, 0xF7, 0x01, 0xDE, 0x00, 0x7F, 0x80, 0xEE, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F,
  0x80, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x0F, 0x3C, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x3D, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC3, 0x80,
  0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x03,
  0xC0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0xF8,
  0x01, 0xE0, 0x00, 0xF0, 0x03, 0xFE, 0x00, 0x7B, 0xC0, 0x1E, 0x38, 0x03,
  0xC7, 0x00, 0xF0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC1, 0xE0, 0x78, 0x3C,
  0x0F, 0x0F, 0x00, 0xE1, 0xE0, 0x1C, 0x78, 0x03, 0x8E, 0x00, 0x7B, 0xC0,
  0x0F, 0x70, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xE0, 0xE0, 0xE0, 0xF0, 0xF0, 0xF0,
  0x70, 0x70, 0x70, 0x70, 0x78, 0x78, 0x78, 0x78, 0x38, 0x38, 0x38, 0x38,
  0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1E, 0x1E, 0x1E, 0x1E, 0x0E,
  0x0E, 0x0E, 0x0F, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x77, 0x80, 0x1C, 0x70, 0x03,
  0x8F, 0x00, 0xE0, 0xE0, 0x3C, 0x1C, 0x07, 0x03, 0xC1, 0xE0, 0x38, 0x38,
  0x07, 0x0F, 0x00, 0xF1, 0xC0, 0x0E, 0x78, 0x01, 0xDE, 0x00, 0x3F, 0xC0,
  0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xF3, 0xC7, 0x9E, 0x38,
  0x71, 0xC0, 0x00, 0xFC, 0x70, 0x1F, 0xE7, 0x03, 0xFE, 0xF0, 0x7C, 0x7F,
  0x0F, 0x83, 0xE1, 0xF0, 0x3E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x3C, 0x01,
  0xC3, 0xC0, 0x3C, 0x38, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80,
  0x38, 0x78, 0x07, 0x87, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF0,
  0x0F, 0x07, 0x01, 0xF0, 0x78, 0x3F, 0x07, 0x87, 0xF0, 0x7F, 0xEE, 0x03,
  0xFC, 0xE0, 0x1F, 0x8E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x8F, 0x80, 0x79, 0xFC, 0x07,
  0xBF, 0xE0, 0x77, 0x1F, 0x07, 0xE0, 0xF0, 0xFC, 0x0F, 0x0F, 0x80, 0xF0,
  0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F,
  0x1E, 0x00, 0xF1, 0xC0, 0x1E, 0x1C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01,
  0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x78, 0x7C, 0x0F, 0x87, 0xE1,
  0xF0, 0x77, 0xFE, 0x07, 0x3F, 0xC0, 0xE3, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0xF8, 0x40, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x0F, 0x8F, 0x00, 0x7F, 0xBC,
  0x03, 0xFE, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1E,
  0x01, 0xE0, 0x78, 0x07, 0x83, 0xC0, 0x1C, 0x0F, 0x00, 0xF0, 0x78, 0x03,
  0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xE0, 0x78, 0x07, 0x81,
  0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0,
  0x7C, 0x07, 0x83, 0xF0, 0x1E, 0x1F, 0xC0, 0x7F, 0xEE, 0x00, 0xFF, 0x38,
  0x01, 0xF8, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xF0,
  0xF0, 0xF0, 0x38, 0xF0, 0x1C, 0x78, 0x0E, 0x78, 0x0F, 0x3C, 0x07, 0x9C,
  0x07, 0x9E, 0x0F, 0x8F, 0xFF, 0x87, 0xFF, 0x83, 0xFE, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x60, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x02, 0x3C,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x38, 0x07, 0xF9, 0xC0, 0x7F, 0xDE, 0x07, 0xC7, 0xE0, 0x7C, 0x1F,
  0x07, 0xC0, 0xF8, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x1E, 0x01, 0xE0, 0xF0,
  0x0F, 0x07, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xE0,
  0xF0, 0x0F, 0x07, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x3E, 0x1E, 0x01,
  0xE0, 0xF0, 0x1F, 0x03, 0xC1, 0xF8, 0x1E, 0x1F, 0xC0, 0xFF, 0xDC, 0x03,
  0xFC, 0xE0, 0x0F, 0xCF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x10, 0x0F, 0x80, 0xE0,
  0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x8F, 0x80, 0x7B, 0xFC, 0x07, 0xFF, 0xE0, 0x77, 0x1E, 0x07, 0xC0, 0xF0,
  0xF8, 0x0F, 0x0F, 0x80, 0xE0, 0xF0, 0x0E, 0x0F, 0x01, 0xE0, 0xE0, 0x1E,
  0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xC1, 0xE0, 0x3C, 0x1C, 0x03,
  0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0x83, 0xC0, 0x78, 0x38, 0x07, 0x83, 0x80,
  0x78, 0x78, 0x07, 0x87, 0x80, 0x70, 0x78, 0x0F, 0x07, 0x00, 0xF0, 0xF0,
  0x0F, 0x00, 0x00, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E,
  0x00, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x4F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0x78, 0x3C,
  0x07, 0x07, 0x80, 0x70, 0xF0, 0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0x0F, 0x7C,
  0x00, 0xE7, 0x80, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x80, 0x1F, 0x78, 0x03, 0xE7, 0x80, 0x3C, 0x38, 0x03, 0xC3, 0xC0, 0x38,
  0x3C, 0x03, 0x83, 0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x01, 0xE0, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38,
  0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x00, 0x03, 0x8F,
  0x81, 0xF0, 0x1C, 0xFF, 0x1F, 0xE0, 0x77, 0xFE, 0xFF, 0xC1, 0xDC, 0xFF,
  0x9F, 0x07, 0xC1, 0xF8, 0x3C, 0x1E, 0x07, 0xC0, 0xF0, 0xF8, 0x1F, 0x03,
  0xC3, 0xC0, 0x78, 0x0F, 0x0F, 0x01, 0xE0, 0x3C, 0x38, 0x07, 0x80, 0xF1,
  0xE0, 0x1C, 0x03, 0x87, 0x80, 0xF0, 0x1E, 0x1E, 0x03, 0xC0, 0x78, 0x78,
  0x0F, 0x01, 0xE1, 0xC0, 0x38, 0x07, 0x0F, 0x00, 0xE0, 0x1C, 0x3C, 0x07,
  0x80, 0xF0, 0xF0, 0x1E, 0x03, 0xC3, 0x80, 0x78, 0x0F, 0x0E, 0x01, 0xC0,
  0x38, 0x78, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0x1E,
  0x1C, 0x03, 0xC0, 0x78, 0xF0, 0x0E, 0x01, 0xC0, 0x03, 0x8F, 0x80, 0x7B,
  0xFE, 0x07, 0x7F, 0xE0, 0x77, 0x1E, 0x07, 0xC0, 0xF0, 0xFC, 0x0F, 0x0F,
  0x80, 0xE0, 0xF0, 0x0E, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x1E, 0x01, 0xE1,
  0xE0, 0x1E, 0x1E, 0x01, 0xC1, 0xE0, 0x3C, 0x1C, 0x03, 0xC3, 0xC0, 0x3C,
  0x3C, 0x03, 0x83, 0xC0, 0x78, 0x3C, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07,
  0x87, 0x80, 0x70, 0x78, 0x0F, 0x07, 0x00, 0xF0, 0xF0, 0x0F, 0x00, 0x00,
  0x7E, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0x1F, 0x0F, 0x03, 0xC7, 0x80,
  0xF1, 0xE0, 0x1C, 0xF0, 0x07, 0x3C, 0x01, 0xCF, 0x00, 0x77, 0x80, 0x3D,
  0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xF7, 0x00, 0x3D, 0xC0, 0x1E, 0xF0,
  0x07, 0xBC, 0x01, 0xE7, 0x00, 0xF1, 0xC0, 0x3C, 0x78, 0x1E, 0x1F, 0x0F,
  0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0xE3, 0xE0, 0x07,
  0x9F, 0xC0, 0x1C, 0xFF, 0x80, 0x77, 0x1F, 0x01, 0xF8, 0x3C, 0x07, 0xC0,
  0xF0, 0x3E, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0,
  0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1C, 0x01, 0xE0, 0x70,
  0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x70, 0x3C, 0x03, 0xC0, 0xF0, 0x0F,
  0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7E, 0x1F, 0x01, 0xFF, 0xF8, 0x07,
  0x3F, 0xC0, 0x1C, 0x7E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xFC, 0x70, 0x1F, 0xE7, 0x03, 0xFE, 0xF0, 0x7C, 0x7E, 0x0F, 0x03, 0xE1,
  0xF0, 0x3E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x3C, 0x03, 0xC3, 0xC0, 0x3C,
  0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x38, 0x78, 0x07,
  0x87, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01,
  0xF0, 0x78, 0x3F, 0x07, 0x87, 0xF0, 0x7F, 0xEE, 0x03, 0xFC, 0xE0, 0x1F,
  0x9E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x03, 0x8F, 0x07, 0x3F, 0x07, 0x7F, 0x07,
  0x7E, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xFF, 0x0F,
  0xFF, 0x1F, 0x06, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0xC0, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0x03, 0x80, 0x70,
  0x07, 0x00, 0xF0, 0x0F, 0x01, 0xFF, 0x7F, 0xEF, 0xFE, 0x1E, 0x01, 0xC0,
  0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78,
  0x07, 0x0F, 0x01, 0xE1, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xE1, 0xE0,
  0x1C, 0x38, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0x87, 0x80,
  0xF0, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1E, 0x1E, 0x03,
  0xC3, 0x80, 0xF8, 0x70, 0x1F, 0x0E, 0x07, 0xC1, 0xE1, 0xF8, 0x3F, 0xF7,
  0x07, 0xFC, 0xE0, 0x7F, 0x1C, 0x00, 0xE0, 0x07, 0xF0, 0x07, 0xB8, 0x03,
  0xDC, 0x03, 0xCE, 0x01, 0xE7, 0x01, 0xE3, 0x80, 0xF1, 0xC0, 0xF0, 0xE0,
  0x78, 0x70, 0x38, 0x3C, 0x3C, 0x1E, 0x1C, 0x0F, 0x1E, 0x07, 0x8E, 0x03,
  0xCF, 0x01, 0xE7, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xC0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x1E, 0x01, 0xFC, 0x03, 0xC0, 0x7B, 0x80, 0xF8, 0x0F, 0x70, 0x1F,
  0x03, 0xCE, 0x07, 0xE0, 0x79, 0xC0, 0xFC, 0x0E, 0x38, 0x3F, 0x83, 0xC7,
  0x07, 0x70, 0x78, 0xE0, 0xEE, 0x1E, 0x1C, 0x39, 0xC3, 0xC3, 0x87, 0x38,
  0x70, 0x71, 0xE7, 0x1E, 0x0E, 0x38, 0xE3, 0x81, 0xC7, 0x1C, 0xF0, 0x39,
  0xC3, 0x9E, 0x07, 0x38, 0x73, 0x80, 0xEF, 0x0E, 0xF0, 0x1D, 0xC1, 0xDC,
  0x03, 0xB8, 0x3B, 0x80, 0x7E, 0x07, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8,
  0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x07, 0x83, 0xC0,
  0x1C, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x9E, 0x00, 0x3C, 0xE0, 0x00, 0xEF,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3C, 0xE0,
  0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x01, 0xE1, 0xE0, 0x1E, 0x07, 0x80, 0xF0,
  0x3C, 0x0F, 0x01, 0xE0, 0xF0, 0x0F, 0x00, 0x01, 0xC0, 0x0F, 0x01, 0xC0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xE0,
  0x38, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x70, 0x01, 0xE0, 0xF0, 0x01, 0xE0,
  0xE0, 0x01, 0xE1, 0xE0, 0x01, 0xE1, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0xE3,
  0xC0, 0x00, 0xE7, 0x80, 0x00, 0xE7, 0x80, 0x00, 0xE7, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x8F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xF0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xF8, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x2F,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFC, 0x07, 0xF9, 0x00, 0x0C, 0x00,
};

const GFXglyph NotoSans_Condensed_Italic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 11, 33, 11, 1, -33 },
  { 47, 13, 12, 16, 5, -33 },
  { 67, 23, 33, 23, 0, -33 },
  { 162, 20, 38, 20, 0, -35 },
  { 257, 26, 33, 31, 3, -33 },
  { 365, 22, 33, 23, 0, -33 },
  { 456, 6, 12, 9, 5, -33 },
  { 465, 14, 40, 12, 1, -33 },
  { 535, 14, 40, 12, -3, -33 },
  { 605, 16, 17, 19, 5, -35 },
  { 639, 19, 22, 22, 2, -27 },
  { 692, 8, 11, 10, -2, -5 },
  { 703, 11, 3, 13, 1, -14 },
  { 708, 5, 5, 10, 1, -5 },
  { 712, 21, 33, 16, -2, -33 },
  { 799, 19, 33, 20, 1, -33 },
  { 878, 13, 33, 20, 5, -33 },
  { 932, 21, 33, 20, -1, -33 },
  { 1019, 20, 33, 20, 0, -33 },
  { 1102, 21, 33, 20, -1, -33 },
  { 1189, 20, 33, 20, 0, -33 },
  { 1272, 19, 33, 20, 2, -33 },
  { 1351, 20, 33, 20, 2, -33 },
  { 1434, 20, 33, 20, 0, -33 },
  { 1517, 19, 33, 20, 1, -33 },
  { 1596, 9, 25, 10, 0, -25 },
  { 1625, 12, 31, 10, -2, -25 },
  { 1672, 19, 21, 22, 2, -27 },
  { 1722, 19, 13, 22, 2, -23 },
  { 1753, 19, 21, 22, 2, -27 },
  { 1803, 15, 33, 15, 2, -33 },
  { 1865, 28, 37, 31, 2, -33 },
  { 1995, 21, 33, 21, -3, -33 },
  { 2082, 21, 33, 22, 1, -33 },
  { 2169, 22, 33, 21, 2, -33 },
  { 2260, 22, 33, 24, 1, -33 },
  { 2351, 20, 33, 19, 1, -33 },
  { 2434, 20, 33, 18, 1, -33 },
  { 2517, 24, 33, 25, 2, -33 },
  { 2616, 25, 33, 25, 1, -33 },
  { 2720, 18, 33, 13, -2, -33 },
  { 2795, 18, 42, 10, -7, -33 },
  { 2890, 24, 33, 21, 1, -33 },
  { 2989, 13, 33, 17, 1, -33 },
  { 3043, 32, 33, 32, 1, -33 },
  { 3175, 26, 33, 26, 1, -33 },
  { 3283, 23, 33, 26, 2, -33 },
  { 3378, 20, 33, 21, 1, -33 },
  { 3461, 23, 41, 26, 2, -33 },
  { 3579, 20, 33, 21, 1, -33 },
  { 3662, 20, 33, 19, 0, -33 },
  { 3745, 18, 33, 18, 4, -33 },
  { 3820, 24, 33, 25, 2, -33 },
  { 3919, 21, 33, 21, 4, -33 },
  { 4006, 33, 33, 33, 4, -33 },
  { 4143, 26, 33, 19, -3, -33 },
  { 4251, 19, 33, 18, 4, -33 },
  { 4330, 22, 33, 18, -1, -33 },
  { 4421, 17, 40, 13, -1, -33 },
  { 4506, 8, 33, 16, 5, -33 },
  { 4539, 17, 40, 13, -3, -33 },
  { 4624, 19, 19, 21, 1, -33 },
  { 4670, 16, 3, 15, -4, 4 },
  { 4676, 6, 7, 12, 7, -35 },
  { 4682, 20, 25, 21, 1, -25 },
  { 4745, 20, 35, 21, 0, -35 },
  { 4833, 17, 25, 16, 1, -25 },
  { 4887, 22, 35, 22, 1, -35 },
  { 4984, 17, 25, 19, 1, -25 },
  { 5038, 23, 46, 12, -6, -35 },
  { 5171, 21, 36, 22, 0, -25 },
  { 5266, 20, 35, 21, 0, -35 },
  { 5354, 11, 34, 10, 0, -34 },
  { 5401, 17, 45, 10, -6, -34 },
  { 5497, 20, 35, 18, 0, -35 },
  { 5585, 12, 35, 10, 0, -35 },
  { 5638, 30, 25, 32, 0, -25 },
  { 5732, 20, 25, 21, 0, -25 },
  { 5795, 18, 25, 21, 1, -25 },
  { 5852, 22, 36, 21, -2, -25 },
  { 5951, 20, 36, 22, 1, -25 },
  { 6041, 16, 25, 14, 0, -25 },
  { 6091, 16, 25, 16, 0, -25 },
  { 6141, 12, 30, 12, 2, -30 },
  { 6186, 19, 25, 21, 2, -25 },
  { 6246, 17, 25, 17, 3, -25 },
  { 6300, 27, 25, 27, 3, -25 },
  { 6385, 21, 25, 18, -2, -25 },
  { 6451, 24, 36, 17, -4, -25 },
  { 6559, 17, 25, 15, -1, -25 },
  { 6613, 17, 40, 15, 1, -33 },
  { 6698, 4, 46, 19, 8, -35 },
  { 6721, 16, 40, 15, -2, -33 },
  { 6801, 19, 6, 22, 2, -19 },
};

const GFXfont NotoSans_Condensed_Italic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic46pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_CONDENSED_ITALIC46PT7B_H_
