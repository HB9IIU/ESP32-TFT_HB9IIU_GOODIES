#ifndef _NOTOSANS_CONDENSED_ITALIC36PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0xE0, 0xF0, 0x38, 0x00, 0x71, 0xDC, 0x77, 0x39, 0x8E,
  0xE3, 0xB8, 0xEE, 0x33, 0x0C, 0xC7, 0x31, 0x80, 0x00, 0x61, 0x80, 0x18,
  0x60, 0x0E, 0x38, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x71, 0xC0, 0x18, 0x60,
  0x06, 0x18, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0x30, 0xC0, 0x0C, 0x30, 0x07,
  0x1C, 0x01, 0x86, 0x00, 0x61, 0x80, 0x38, 0xE0, 0x7F, 0xFF, 0x3F, 0xFF,
  0xC1, 0xC3, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x18, 0x03, 0x0E, 0x00,
  0xC3, 0x00, 0x30, 0xC0, 0x1C, 0x70, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x01, 0xFE, 0x07, 0xFF, 0x0F, 0x66, 0x0E, 0x60, 0x0C, 0x60, 0x1C,
  0x40, 0x1C, 0xC0, 0x0E, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF8, 0x01, 0xB8, 0x01, 0x38, 0x03, 0x18, 0x03, 0x18, 0x03,
  0x38, 0x83, 0x38, 0xF2, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x06, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x60, 0xFC, 0x06, 0x0E, 0x60,
  0x70, 0x63, 0x83, 0x07, 0x1C, 0x38, 0x30, 0xE1, 0x81, 0x86, 0x18, 0x0C,
  0x31, 0xC0, 0xE1, 0x8C, 0x07, 0x1C, 0xE0, 0x30, 0xE6, 0x39, 0x86, 0x77,
  0xEC, 0x77, 0x3F, 0x73, 0x33, 0x1D, 0xFB, 0x98, 0xEF, 0x19, 0xC7, 0x01,
  0xCC, 0x38, 0x0C, 0x61, 0x80, 0xC7, 0x0C, 0x0E, 0x38, 0x60, 0x61, 0x87,
  0x07, 0x0C, 0x30, 0x30, 0x63, 0x83, 0x03, 0x98, 0x38, 0x1F, 0xC1, 0x80,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0xE7, 0x80, 0x61, 0xC0, 0x70,
  0xE0, 0x38, 0x70, 0x1C, 0x30, 0x0E, 0x38, 0x07, 0x38, 0x03, 0x9C, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x77, 0x0E, 0x71, 0xC7,
  0x70, 0xE3, 0x38, 0x3B, 0xB8, 0x1F, 0x9C, 0x0F, 0xCE, 0x03, 0xC7, 0x01,
  0xE3, 0xC1, 0xF0, 0xF3, 0xFC, 0x7F, 0xCE, 0x1F, 0xC7, 0x80, 0x77, 0x77,
  0x6E, 0xEC, 0xCC, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x03,
  0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x01,
  0xC0, 0x18, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38,
  0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0x04, 0x00, 0x70, 0x07, 0x00,
  0x70, 0xC6, 0x0F, 0x61, 0x7F, 0xF0, 0xFF, 0x1F, 0x03, 0xB0, 0x73, 0x8F,
  0x38, 0x21, 0xC0, 0x10, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x38,
  0x70, 0xE3, 0x86, 0x1C, 0x30, 0xE0, 0xFF, 0xFF, 0xFF, 0x73, 0xFC, 0xE0,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xF0,
  0x1F, 0xF0, 0x78, 0xE0, 0xE1, 0xC3, 0x81, 0xC7, 0x03, 0x9C, 0x07, 0x38,
  0x0E, 0x70, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07,
  0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x03, 0x8E, 0x07, 0x1C,
  0x1C, 0x38, 0x78, 0x3D, 0xE0, 0x7F, 0x80, 0x7E, 0x00, 0x01, 0xC0, 0xE0,
  0xF8, 0x7E, 0x3F, 0xBC, 0xE6, 0x71, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x1C, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF,
  0xC0, 0x60, 0xE0, 0x20, 0x78, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F,
  0xFC, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x04, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C,
  0x07, 0xF0, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x80, 0x70,
  0xE3, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x6E, 0x00, 0xEC, 0x01, 0xDC, 0x01, 0x9C,
  0x03, 0x9C, 0x07, 0x1C, 0x06, 0x38, 0x0C, 0x38, 0x1C, 0x38, 0x38, 0x38,
  0x30, 0x30, 0x70, 0x70, 0xE0, 0x70, 0xFF, 0xFE, 0xFF, 0xFC, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xFF,
  0x03, 0xFF, 0x07, 0xFE, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x80, 0x70, 0xE1, 0xF0, 0xFF, 0xE0,
  0xFF, 0x80, 0x00, 0x7E, 0x01, 0xFC, 0x0F, 0xF8, 0x3C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xEF, 0x83, 0xBF,
  0x87, 0xE7, 0x8F, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0xF0, 0x39, 0xC0, 0x73,
  0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x0E, 0x1C, 0x3C, 0x3C, 0xF0, 0x3F,
  0xC0, 0x3F, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xC0, 0x00, 0x00, 0xF8, 0x03, 0xFE, 0x07, 0xDE, 0x07, 0x07,
  0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x0E, 0x0F, 0x1C,
  0x07, 0x3C, 0x03, 0xF0, 0x03, 0xE0, 0x0F, 0xF0, 0x1E, 0x70, 0x3C, 0x38,
  0x78, 0x38, 0x70, 0x1C, 0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38,
  0x70, 0x38, 0x78, 0xF0, 0x3F, 0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x07, 0xF8,
  0x1F, 0xF8, 0x78, 0x70, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x38,
  0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0xF1, 0xC1, 0xE3, 0x87, 0xC7, 0xFB,
  0x07, 0xEE, 0x02, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x78, 0x61, 0xE0, 0xFF, 0x81, 0xFC, 0x00, 0x04, 0x1C, 0x38,
  0xF0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x71,
  0xE3, 0xC7, 0x80, 0x01, 0x00, 0xE0, 0x3C, 0x0E, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x00, 0x00,
  0x04, 0x00, 0x70, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3E,
  0x00, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x03, 0x80,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x3C, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x0F, 0x00, 0x30,
  0x00, 0x0F, 0xC3, 0xFE, 0x3F, 0xF1, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01,
  0x80, 0x38, 0x03, 0x80, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0x0F,
  0x00, 0xF0, 0x0E, 0x07, 0x00, 0x18, 0x18, 0x00, 0x70, 0xC0, 0x00, 0xC7,
  0x07, 0xC3, 0x18, 0x3F, 0x8C, 0xE1, 0xCE, 0x33, 0x0E, 0x30, 0xDC, 0x70,
  0xC3, 0x61, 0x83, 0x0D, 0x86, 0x1C, 0x36, 0x38, 0x61, 0xF8, 0xC1, 0x86,
  0xE3, 0x0E, 0x1B, 0x8C, 0x38, 0xEC, 0x31, 0xE3, 0x30, 0xE5, 0x98, 0xC3,
  0xF7, 0xE3, 0x87, 0x8E, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x36, 0x00, 0x36, 0x00, 0x76,
  0x00, 0x66, 0x00, 0xE6, 0x00, 0xE6, 0x01, 0xC6, 0x01, 0xC6, 0x03, 0x87,
  0x03, 0x87, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF,
  0x1C, 0x07, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x78, 0x07, 0x70, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0x03, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xE0, 0xE0,
  0xF0, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x87,
  0x03, 0x83, 0x83, 0xC3, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0xE0, 0x70, 0x78,
  0x38, 0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x01, 0xC3, 0x80,
  0xE3, 0x80, 0xF1, 0xC0, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x00,
  0x00, 0xFE, 0x01, 0xFF, 0x07, 0xFF, 0x0F, 0x82, 0x0E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x7C, 0x60,
  0x3F, 0xE0, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x1C,
  0x1E, 0x07, 0x03, 0xC1, 0xC0, 0xF0, 0x70, 0x1C, 0x38, 0x07, 0x0E, 0x01,
  0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x78, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71,
  0xC0, 0x3C, 0x70, 0x0E, 0x38, 0x03, 0x8E, 0x01, 0xE3, 0x80, 0x70, 0xE0,
  0x3C, 0x38, 0x1E, 0x1C, 0x0F, 0x07, 0x07, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x07,
  0xFF, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0x3E, 0x02, 0x0E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x3F, 0x38, 0x1F, 0xCE, 0x07, 0xF3, 0x80, 0x1C, 0xE0,
  0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x3C, 0x07,
  0x07, 0x01, 0xC1, 0xF0, 0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x03, 0x80,
  0x70, 0x38, 0x07, 0x07, 0x00, 0x70, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x70,
  0x0E, 0x07, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x01, 0xC0, 0xE0, 0x1C, 0x0E,
  0x01, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1C, 0x03, 0x81,
  0xC0, 0x38, 0x38, 0x03, 0x83, 0x80, 0x70, 0x38, 0x07, 0x03, 0x80, 0x70,
  0x38, 0x07, 0x07, 0x00, 0x70, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x0E,
  0x0F, 0x00, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x7F, 0x83, 0xFE,
  0x00, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x0F, 0xE0, 0x3F, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x03, 0x83, 0xC0, 0x70, 0x70, 0x0E,
  0x1C, 0x01, 0xC7, 0x00, 0x71, 0xE0, 0x0E, 0x78, 0x01, 0xCE, 0x00, 0x3B,
  0x80, 0x0E, 0xF0, 0x01, 0xDC, 0x00, 0x3F, 0xC0, 0x07, 0xB8, 0x00, 0xE7,
  0x00, 0x38, 0xF0, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x87,
  0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x1E, 0x03,
  0x80, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0xFF, 0x7F, 0xFF,
  0xFC, 0x03, 0xC0, 0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x1F,
  0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x81, 0xB0, 0x07, 0xE0, 0x6C, 0x03, 0xB8,
  0x3B, 0x00, 0xEC, 0x0E, 0xE0, 0x37, 0x03, 0xB8, 0x1D, 0xC0, 0xEE, 0x06,
  0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xCE, 0x07, 0x38, 0x73, 0x81, 0xCE,
  0x18, 0xE0, 0x63, 0x8E, 0x38, 0x38, 0xE3, 0x0E, 0x0E, 0x39, 0xC7, 0x03,
  0x86, 0x61, 0xC0, 0xE1, 0xB8, 0x70, 0x30, 0x6E, 0x1C, 0x1C, 0x1F, 0x07,
  0x07, 0x07, 0xC3, 0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x38, 0x38, 0x1C,
  0x0E, 0x00, 0x03, 0x80, 0x38, 0x1E, 0x01, 0xC1, 0xF0, 0x0E, 0x0F, 0x80,
  0x70, 0x7C, 0x07, 0x03, 0x60, 0x38, 0x1B, 0x81, 0xC1, 0xDC, 0x0E, 0x0E,
  0xE0, 0x60, 0x73, 0x07, 0x03, 0x9C, 0x38, 0x38, 0xE1, 0xC1, 0xC7, 0x0E,
  0x0E, 0x18, 0x60, 0x70, 0xE7, 0x03, 0x87, 0x38, 0x38, 0x39, 0xC1, 0xC1,
  0xCE, 0x0E, 0x06, 0x60, 0x70, 0x3F, 0x03, 0x01, 0xF8, 0x38, 0x0F, 0xC1,
  0xC0, 0x3C, 0x0E, 0x01, 0xE0, 0x70, 0x0F, 0x07, 0x00, 0x78, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3C, 0x1E, 0x1E, 0x03, 0x87, 0x00,
  0xE3, 0xC0, 0x38, 0xE0, 0x0F, 0x78, 0x03, 0xDC, 0x00, 0xF7, 0x00, 0x3B,
  0xC0, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x1E, 0xE0,
  0x07, 0x38, 0x01, 0xCE, 0x00, 0xF3, 0x80, 0x38, 0xE0, 0x1E, 0x38, 0x07,
  0x0F, 0x03, 0x81, 0xE3, 0xE0, 0x3F, 0xF0, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x01, 0xFF, 0x01, 0xFF, 0xC0, 0xE1, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x1C,
  0x0E, 0x1C, 0x07, 0x0E, 0x07, 0x87, 0x03, 0x83, 0x81, 0xC3, 0x81, 0xE1,
  0xC1, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7F,
  0xF0, 0x3C, 0x1E, 0x1E, 0x03, 0x87, 0x00, 0xE3, 0xC0, 0x38, 0xE0, 0x0F,
  0x78, 0x03, 0xDC, 0x00, 0xF7, 0x00, 0x3B, 0xC0, 0x0E, 0xE0, 0x03, 0xB8,
  0x00, 0xEE, 0x00, 0x3B, 0x80, 0x1E, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00,
  0xF3, 0x80, 0x38, 0xE0, 0x1E, 0x38, 0x07, 0x0F, 0x03, 0x81, 0xE3, 0xE0,
  0x3F, 0xF0, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0x01, 0xFF,
  0xC0, 0xE1, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x1C, 0x0E, 0x1C, 0x07, 0x0E,
  0x07, 0x87, 0x03, 0x83, 0x81, 0xC3, 0xC1, 0xC1, 0xC3, 0xE0, 0xFF, 0xE0,
  0x7F, 0xC0, 0x39, 0xC0, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x0E,
  0x03, 0x83, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x3C, 0x78,
  0x0E, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0x02, 0x1E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x80, 0xF0,
  0xF7, 0xE0, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x3C, 0x70,
  0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x1C, 0x38, 0x07,
  0x0E, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x0E, 0x1C, 0x03, 0x87,
  0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x80,
  0x70, 0xE0, 0x38, 0x38, 0x0E, 0x0E, 0x07, 0x83, 0xE7, 0xC0, 0x7F, 0xE0,
  0x0F, 0xF0, 0x00, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x70, 0x60, 0x70, 0x60,
  0xF0, 0x60, 0xE0, 0x60, 0xE0, 0x61, 0xC0, 0x61, 0xC0, 0x73, 0x80, 0x73,
  0x80, 0x77, 0x00, 0x77, 0x00, 0x76, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xE0, 0x1C, 0x03, 0xF8, 0x07,
  0x00, 0xEE, 0x01, 0xC0, 0x3B, 0x80, 0xF0, 0x1C, 0xE0, 0x3C, 0x07, 0x38,
  0x1F, 0x03, 0x8E, 0x07, 0xC0, 0xE3, 0x81, 0xB0, 0x38, 0xE0, 0xEC, 0x1C,
  0x38, 0x33, 0x07, 0x0E, 0x1C, 0xC3, 0x83, 0x87, 0x30, 0xE0, 0xE1, 0x8C,
  0x38, 0x38, 0xE3, 0x1C, 0x0E, 0x30, 0xC7, 0x03, 0x9C, 0x33, 0x80, 0xE7,
  0x0C, 0xE0, 0x3B, 0x83, 0x38, 0x0E, 0xE0, 0xDC, 0x03, 0xB0, 0x37, 0x00,
  0xFC, 0x0D, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xF0, 0x03, 0xE0, 0x3C,
  0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x03, 0x80, 0xF0, 0x38,
  0x0E, 0x03, 0x81, 0xC0, 0x1C, 0x1C, 0x01, 0xC3, 0x80, 0x1C, 0x70, 0x01,
  0xC7, 0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xB8, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0xE3, 0x80, 0x1E, 0x18,
  0x01, 0xC1, 0xC0, 0x38, 0x1C, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x0E, 0x01,
  0xE0, 0xE0, 0x1F, 0xC0, 0x3B, 0x80, 0xE3, 0x81, 0xC7, 0x07, 0x0E, 0x0E,
  0x1C, 0x38, 0x38, 0xF0, 0x71, 0xC0, 0x67, 0x00, 0xCE, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xE0, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x01, 0xFC,
  0x07, 0xF0, 0x3F, 0x80, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xC3, 0x8E, 0x38, 0xE3, 0x86, 0x18,
  0x61, 0xC7, 0x1C, 0x71, 0xC3, 0x0C, 0x38, 0xE3, 0x8E, 0x38, 0xE1, 0x86,
  0x1C, 0x70, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x00, 0x60, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x1F, 0x00, 0x7E, 0x00, 0xCC, 0x03, 0x9C, 0x06, 0x18, 0x1C, 0x38, 0x30,
  0x70, 0xE0, 0x63, 0x80, 0xE7, 0x01, 0xDC, 0x01, 0xB8, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xF3, 0x9C, 0x73, 0x8C, 0x01, 0x81, 0x07, 0xE6, 0x0F, 0xF6,
  0x1E, 0x3E, 0x1C, 0x1E, 0x38, 0x1E, 0x38, 0x1C, 0x70, 0x1C, 0x70, 0x1C,
  0x70, 0x1C, 0x70, 0x18, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x78,
  0xE0, 0x70, 0xE0, 0xF0, 0x71, 0xF0, 0x7F, 0x70, 0x3E, 0x70, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x18, 0x0E, 0xFC, 0x0F, 0xFE, 0x0F, 0x8E, 0x0F, 0x0F, 0x1E, 0x07,
  0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E,
  0x38, 0x0E, 0x38, 0x1C, 0x78, 0x1C, 0x78, 0x3C, 0x78, 0x38, 0x7C, 0xF0,
  0x6F, 0xF0, 0xE7, 0xC0, 0x00, 0xC0, 0x3F, 0xC3, 0xFC, 0x3C, 0x21, 0xC0,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC6, 0x1F, 0xF0, 0x7F,
  0x00, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x03, 0x0E, 0x07, 0xE6, 0x07, 0xFF, 0x07, 0x8F,
  0x83, 0x83, 0xC3, 0x81, 0xE1, 0xC0, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0x70,
  0x1C, 0x78, 0x0C, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x03, 0xC3,
  0x81, 0xC1, 0xC1, 0xE0, 0xF1, 0xF0, 0x3F, 0xB8, 0x0F, 0x9C, 0x00, 0x00,
  0xC0, 0x3F, 0x83, 0xFE, 0x3C, 0x71, 0xC3, 0x9C, 0x1C, 0xE0, 0xEE, 0x0F,
  0x70, 0xF3, 0xFF, 0x3F, 0xE1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0xC3, 0x1F, 0xF8, 0x7F, 0x80, 0x00, 0x02, 0x00, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x81, 0xF9,
  0x81, 0xFE, 0xC1, 0xE3, 0xE0, 0xE0, 0xF0, 0xE0, 0x78, 0x70, 0x38, 0x70,
  0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x07, 0x0E, 0x03, 0x87, 0x01, 0xC3,
  0x80, 0xE1, 0xC0, 0xF0, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x7C, 0x0F, 0xEE,
  0x03, 0xE7, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x40, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x08, 0x0E, 0xFC, 0x1F, 0xFC, 0x3E, 0x38, 0x78, 0x71, 0xE0, 0xE3, 0x81,
  0xC7, 0x03, 0x8E, 0x07, 0x38, 0x0C, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE3,
  0x81, 0xCE, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x73, 0x81,
  0xC0, 0x01, 0x01, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x07,
  0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x07, 0x03,
  0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x00, 0x00, 0x08, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x80, 0x0E, 0x03, 0xF0, 0x0F, 0x80, 0x18, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0E, 0x01, 0x0E, 0x0E, 0x0E, 0x1C, 0x0E, 0x3C, 0x0C, 0x38, 0x1C,
  0x70, 0x1C, 0xE0, 0x1D, 0xC0, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0xC0, 0x3D,
  0xC0, 0x39, 0xC0, 0x38, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x70,
  0x70, 0x70, 0x70, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18,
  0x1C, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x00,
  0x00, 0x10, 0x18, 0x0E, 0xFC, 0x7E, 0x0F, 0xFE, 0xFE, 0x0D, 0x8F, 0x8F,
  0x0E, 0x0F, 0x07, 0x1E, 0x0E, 0x07, 0x1C, 0x0E, 0x0E, 0x1C, 0x0E, 0x0E,
  0x1C, 0x1C, 0x0E, 0x18, 0x1C, 0x0E, 0x38, 0x1C, 0x0E, 0x38, 0x1C, 0x1C,
  0x38, 0x1C, 0x1C, 0x38, 0x38, 0x1C, 0x70, 0x38, 0x1C, 0x70, 0x38, 0x18,
  0x70, 0x38, 0x38, 0x70, 0x30, 0x38, 0x70, 0x70, 0x38, 0xE0, 0x70, 0x38,
  0x00, 0x10, 0x1D, 0xF8, 0x3F, 0xF8, 0x7C, 0x70, 0xF0, 0xE3, 0xC1, 0xC7,
  0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x70, 0x1C, 0xE0, 0x71, 0xC0, 0xE3, 0x81,
  0xC7, 0x03, 0x9C, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE7,
  0x03, 0x80, 0x00, 0xC0, 0x1F, 0xC0, 0xFF, 0x87, 0x8F, 0x1C, 0x1C, 0xE0,
  0x73, 0x81, 0xDC, 0x07, 0x70, 0x1D, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x1C, 0xF0, 0xF1, 0xC7, 0x87, 0xFC, 0x0F,
  0xE0, 0x00, 0x0C, 0x03, 0xBF, 0x01, 0xFF, 0xC0, 0xD8, 0xE0, 0x78, 0x38,
  0x78, 0x1C, 0x3C, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x86, 0x03, 0x87, 0x01,
  0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x70, 0xF0, 0x38, 0x78, 0x3C, 0x3C,
  0x1C, 0x1F, 0x3C, 0x0D, 0xFE, 0x0E, 0x7C, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0x81, 0x07, 0xE6, 0x0F, 0xF6, 0x1E, 0x3E, 0x1C, 0x1E, 0x38,
  0x1E, 0x38, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x18, 0xE0,
  0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x78, 0xE0, 0xF0, 0xE0, 0xF0, 0xF1,
  0xF0, 0x7F, 0x70, 0x3E, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0x38, 0x77, 0xC3, 0x7C, 0x1B, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x7F, 0xC7,
  0xFC, 0x38, 0x23, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC6,
  0x1E, 0x3F, 0xE1, 0xFE, 0x00, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x1F,
  0xF7, 0xF8, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x8F, 0xC1, 0xF0, 0x1C,
  0x0E, 0x38, 0x1C, 0x70, 0x39, 0xC0, 0x63, 0x81, 0xC7, 0x03, 0x8E, 0x07,
  0x1C, 0x0E, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xC6, 0x07, 0x9C,
  0x0E, 0x38, 0x3C, 0x70, 0x78, 0xF3, 0xF0, 0xFE, 0xC1, 0xF9, 0x80, 0xE0,
  0x3F, 0x03, 0xB8, 0x1D, 0xC0, 0xEE, 0x0E, 0x70, 0x73, 0x87, 0x1C, 0x38,
  0xE3, 0x87, 0x1C, 0x19, 0xC0, 0xCE, 0x06, 0xE0, 0x37, 0x01, 0xB0, 0x0F,
  0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x70, 0x3F, 0x07, 0x83, 0xB8,
  0x3C, 0x1D, 0xC3, 0xE0, 0xEE, 0x1B, 0x0E, 0x70, 0xD8, 0x73, 0x8E, 0xC7,
  0x1C, 0x66, 0x38, 0xE7, 0x31, 0x87, 0x31, 0x9C, 0x39, 0x8C, 0xE1, 0xDC,
  0x6E, 0x0E, 0xC3, 0x70, 0x7E, 0x1B, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0,
  0xF8, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0E, 0x00, 0x07, 0x07, 0x83, 0x83,
  0x81, 0xC3, 0x80, 0x73, 0xC0, 0x39, 0xC0, 0x1D, 0xC0, 0x06, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x77, 0x00,
  0x73, 0x80, 0x39, 0xC0, 0x38, 0xE0, 0x38, 0x38, 0x3C, 0x1C, 0x3C, 0x0E,
  0x00, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07,
  0x01, 0xC1, 0xC0, 0x30, 0xE0, 0x0C, 0x38, 0x03, 0x1C, 0x00, 0xC7, 0x00,
  0x33, 0x80, 0x0C, 0xE0, 0x03, 0x30, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x03, 0x80, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x03, 0x80, 0x1C, 0x00,
  0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xFF, 0x0F,
  0xFC, 0x00, 0x00, 0x18, 0x07, 0xC0, 0x7E, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x03,
  0x80, 0x1F, 0x00, 0x78, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x1F, 0x00,
  0xF8, 0x01, 0xC0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0xF8,
  0x0F, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x7E, 0x03, 0xE0, 0x18, 0x00,
  0x7C, 0x07, 0xFC, 0x3F, 0xFF, 0xE0, 0x7E, 0x80, 0x20,
};

const GFXglyph NotoSans_Condensed_Italic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 26, 9, 0, -26 },
  { 31, 10, 10, 13, 4, -26 },
  { 44, 18, 26, 18, 0, -26 },
  { 103, 16, 29, 16, 0, -27 },
  { 161, 21, 26, 24, 2, -26 },
  { 230, 17, 26, 18, 0, -26 },
  { 286, 4, 10, 7, 4, -26 },
  { 291, 11, 32, 10, 1, -26 },
  { 335, 11, 32, 10, -3, -26 },
  { 379, 12, 14, 15, 4, -28 },
  { 400, 14, 17, 17, 2, -21 },
  { 430, 7, 9, 8, -2, -4 },
  { 438, 8, 3, 10, 1, -11 },
  { 441, 5, 4, 8, 0, -4 },
  { 444, 17, 26, 12, -2, -26 },
  { 500, 15, 26, 16, 1, -26 },
  { 549, 10, 26, 16, 4, -26 },
  { 582, 17, 26, 16, -1, -26 },
  { 638, 16, 26, 16, 0, -26 },
  { 690, 16, 26, 16, 0, -26 },
  { 742, 16, 26, 16, 0, -26 },
  { 794, 15, 26, 16, 1, -26 },
  { 843, 15, 26, 16, 2, -26 },
  { 892, 16, 26, 16, 0, -26 },
  { 944, 15, 26, 16, 0, -26 },
  { 993, 7, 20, 8, 0, -20 },
  { 1011, 10, 25, 8, -2, -20 },
  { 1043, 14, 16, 17, 2, -21 },
  { 1071, 14, 10, 17, 2, -18 },
  { 1089, 14, 16, 17, 2, -21 },
  { 1117, 12, 26, 12, 1, -26 },
  { 1156, 22, 29, 24, 1, -26 },
  { 1236, 16, 26, 16, -2, -26 },
  { 1288, 17, 26, 17, 0, -26 },
  { 1344, 16, 26, 16, 2, -26 },
  { 1396, 18, 26, 19, 0, -26 },
  { 1455, 16, 26, 15, 0, -26 },
  { 1507, 16, 26, 14, 0, -26 },
  { 1559, 18, 26, 20, 2, -26 },
  { 1618, 20, 26, 20, 0, -26 },
  { 1683, 14, 26, 10, -2, -26 },
  { 1729, 14, 33, 8, -5, -26 },
  { 1787, 19, 26, 16, 0, -26 },
  { 1849, 11, 26, 14, 0, -26 },
  { 1885, 26, 26, 25, 0, -26 },
  { 1970, 21, 26, 21, 0, -26 },
  { 2039, 18, 26, 20, 2, -26 },
  { 2098, 17, 26, 16, 0, -26 },
  { 2154, 18, 32, 20, 2, -26 },
  { 2226, 17, 26, 17, 0, -26 },
  { 2282, 16, 26, 15, 0, -26 },
  { 2334, 14, 26, 14, 3, -26 },
  { 2380, 18, 26, 19, 2, -26 },
  { 2439, 16, 26, 16, 3, -26 },
  { 2491, 26, 26, 26, 3, -26 },
  { 2576, 20, 26, 15, -2, -26 },
  { 2641, 15, 26, 14, 3, -26 },
  { 2690, 17, 26, 14, -1, -26 },
  { 2746, 14, 32, 10, -1, -26 },
  { 2802, 6, 26, 12, 4, -26 },
  { 2822, 13, 32, 10, -2, -26 },
  { 2874, 15, 15, 16, 1, -26 },
  { 2903, 12, 2, 12, -3, 3 },
  { 2906, 5, 6, 9, 5, -28 },
  { 2910, 16, 20, 17, 1, -20 },
  { 2950, 16, 27, 17, 0, -27 },
  { 3004, 13, 20, 13, 1, -20 },
  { 3037, 17, 27, 17, 1, -27 },
  { 3095, 13, 20, 15, 1, -20 },
  { 3128, 18, 37, 9, -4, -28 },
  { 3212, 17, 29, 17, 0, -20 },
  { 3274, 15, 27, 17, 0, -27 },
  { 3325, 9, 27, 8, 0, -27 },
  { 3356, 14, 36, 8, -5, -27 },
  { 3419, 16, 27, 14, 0, -27 },
  { 3473, 9, 27, 8, 0, -27 },
  { 3504, 24, 20, 25, 0, -20 },
  { 3564, 15, 20, 17, 0, -20 },
  { 3602, 14, 20, 16, 1, -20 },
  { 3637, 17, 28, 17, -1, -20 },
  { 3697, 16, 29, 17, 1, -20 },
  { 3755, 13, 20, 11, 0, -20 },
  { 3788, 13, 20, 13, 0, -20 },
  { 3821, 10, 24, 10, 1, -24 },
  { 3851, 15, 19, 17, 1, -19 },
  { 3887, 13, 19, 14, 2, -19 },
  { 3918, 21, 19, 21, 2, -19 },
  { 3968, 17, 19, 14, -2, -19 },
  { 4009, 18, 28, 14, -3, -19 },
  { 4072, 14, 19, 12, -1, -19 },
  { 4106, 13, 32, 12, 1, -26 },
  { 4158, 3, 36, 15, 6, -27 },
  { 4172, 13, 32, 12, -2, -26 },
  { 4224, 14, 5, 17, 2, -15 },
};

const GFXfont NotoSans_Condensed_Italic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic36pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_CONDENSED_ITALIC36PT7B_H_
