#ifndef _NOTOSANS_THIN55PT7B_H_
#define _NOTOSANS_THIN55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin55pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C,
  0x00, 0x00, 0x0D, 0xF0, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38,
  0x0A, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x20, 0x00, 0x0C,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x80, 0x00, 0x18, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x10, 0x01, 0x80, 0x00, 0x10,
  0x01, 0x00, 0x00, 0x10, 0x01, 0x00, 0x00, 0x30, 0x01, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x20, 0x03, 0x00, 0x00, 0x20,
  0x02, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x40,
  0x06, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0xC0,
  0x04, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x80,
  0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80,
  0x08, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x10, 0x00, 0x03, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x30, 0x00, 0x02, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x20, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xC0,
  0x70, 0x81, 0xC3, 0x02, 0x01, 0x18, 0x08, 0x00, 0xC0, 0x20, 0x02, 0x00,
  0x80, 0x08, 0x02, 0x00, 0x20, 0x08, 0x00, 0x80, 0x20, 0x02, 0x00, 0x80,
  0x08, 0x02, 0x00, 0x30, 0x08, 0x00, 0xC0, 0x20, 0x01, 0x80, 0x80, 0x03,
  0x02, 0x00, 0x07, 0x08, 0x00, 0x07, 0x20, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x0B, 0xC0, 0x00, 0x23, 0xC0, 0x00, 0x83, 0x80, 0x02, 0x03,
  0x00, 0x08, 0x06, 0x00, 0x20, 0x08, 0x00, 0x80, 0x30, 0x02, 0x00, 0xC0,
  0x08, 0x03, 0x00, 0x20, 0x0C, 0x00, 0x80, 0x30, 0x02, 0x00, 0x80, 0x08,
  0x02, 0x00, 0x20, 0x18, 0x00, 0x80, 0xC8, 0x02, 0x06, 0x3C, 0x08, 0xF0,
  0x3F, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x00, 0x7F, 0x80, 0x00, 0x20, 0x06,
  0x06, 0x00, 0x03, 0x00, 0x60, 0x18, 0x00, 0x30, 0x02, 0x00, 0xC0, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x18, 0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x02, 0x00, 0x40, 0x06, 0x00, 0x10, 0x06, 0x00,
  0x30, 0x00, 0x80, 0x20, 0x01, 0x80, 0x04, 0x03, 0x00, 0x0C, 0x00, 0x20,
  0x30, 0x00, 0x60, 0x01, 0x01, 0x00, 0x03, 0x00, 0x08, 0x18, 0x00, 0x18,
  0x00, 0x40, 0x80, 0x00, 0xC0, 0x02, 0x0C, 0x1F, 0x82, 0x00, 0x30, 0x41,
  0x8E, 0x10, 0x01, 0x86, 0x18, 0x18, 0xC0, 0x08, 0x21, 0x80, 0x62, 0x00,
  0xC3, 0x08, 0x01, 0x18, 0x04, 0x30, 0xC0, 0x0C, 0x60, 0x61, 0x04, 0x00,
  0x61, 0xFE, 0x18, 0x20, 0x01, 0x03, 0xC0, 0x83, 0x00, 0x08, 0x00, 0x0C,
  0x18, 0x00, 0x40, 0x00, 0x40, 0xC0, 0x02, 0x00, 0x06, 0x06, 0x00, 0x10,
  0x00, 0x20, 0x30, 0x00, 0x80, 0x03, 0x01, 0x80, 0x04, 0x00, 0x30, 0x0C,
  0x00, 0x20, 0x01, 0x00, 0x60, 0x01, 0x00, 0x18, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x40, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x08, 0x03, 0x00, 0x20, 0x00, 0x60, 0x10, 0x03, 0x00,
  0x01, 0x83, 0x80, 0x30, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x40, 0x00, 0x10, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xB0, 0x00,
  0x00, 0x03, 0x86, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x18, 0x60, 0x03, 0x00, 0x04, 0x30, 0x00, 0x60, 0x03, 0x18, 0x00,
  0x0C, 0x00, 0xC6, 0x00, 0x01, 0x80, 0x21, 0x00, 0x00, 0x30, 0x18, 0x40,
  0x00, 0x06, 0x04, 0x30, 0x00, 0x00, 0xC3, 0x0C, 0x00, 0x00, 0x18, 0x81,
  0x00, 0x00, 0x03, 0x40, 0x40, 0x00, 0x00, 0x70, 0x10, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x0D, 0x00, 0xC0, 0x00, 0x06, 0x20, 0x30, 0x00, 0x03,
  0x0C, 0x07, 0x00, 0x03, 0x81, 0x80, 0x70, 0x03, 0x80, 0x30, 0x07, 0xFF,
  0x80, 0x07, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xAA, 0xAA, 0xA0, 0x00,
  0xC0, 0x60, 0x30, 0x08, 0x06, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x60, 0x18, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80,
  0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0xC0,
  0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x80,
  0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x06, 0x00, 0x80, 0x20, 0x08, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20,
  0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x30, 0x08, 0x06, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x60,
  0x18, 0x06, 0xFC, 0x08, 0x3F, 0x0F, 0x08, 0xF0, 0x00, 0xEF, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x24, 0x00, 0x00, 0x42, 0x00, 0x00,
  0xC3, 0x00, 0x01, 0x81, 0x80, 0x01, 0x00, 0x80, 0x03, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0x30, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0xC4, 0x23, 0x18, 0x84, 0x63, 0x10, 0x8C, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0xDF, 0x00, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x00,
  0xC0, 0xC0, 0x00, 0x20, 0x40, 0x00, 0x18, 0x60, 0x00, 0x04, 0x20, 0x00,
  0x02, 0x10, 0x00, 0x01, 0x98, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x12, 0x00, 0x00, 0x09, 0x00, 0x00, 0x06, 0x80, 0x00, 0x03, 0x40,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x40, 0x00, 0x01, 0xA0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x26, 0x00, 0x00, 0x13, 0x00, 0x00, 0x08, 0x80, 0x00, 0x0C, 0x40, 0x00,
  0x06, 0x30, 0x00, 0x02, 0x08, 0x00, 0x03, 0x06, 0x00, 0x01, 0x01, 0x00,
  0x01, 0x80, 0xC0, 0x01, 0x80, 0x30, 0x01, 0x80, 0x0E, 0x01, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x01, 0xB0, 0x73,
  0x0C, 0x33, 0x83, 0x60, 0x3C, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x80, 0x0E,
  0x00, 0xE0, 0x38, 0x00, 0x30, 0x60, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x1C,
  0x00, 0x70, 0x70, 0x00, 0x18, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x80, 0x00, 0x38, 0xF8,
  0x00, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0xA0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00,
  0x61, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x40,
  0x40, 0x00, 0x03, 0x01, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x40, 0x10,
  0x00, 0x02, 0x00, 0x40, 0x00, 0x18, 0x01, 0x00, 0x00, 0xC0, 0x04, 0x00,
  0x02, 0x00, 0x10, 0x00, 0x18, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x40, 0x06, 0x00,
  0x01, 0x00, 0x30, 0x00, 0x04, 0x00, 0x80, 0x00, 0x10, 0x06, 0x00, 0x00,
  0x40, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x1F,
  0xFF, 0xF8, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x6F,
  0xFF, 0x80, 0x38, 0x01, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x70, 0x78, 0x01, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x7C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0xFF, 0x80, 0x83, 0xC1, 0xE0, 0x8E, 0x00, 0x38, 0x98, 0x00, 0x0C, 0xB0,
  0x00, 0x04, 0xA0, 0x00, 0x06, 0xE0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x20, 0x00, 0x02, 0x30, 0x00, 0x06, 0x18, 0x00, 0x04, 0x08,
  0x00, 0x0C, 0x0E, 0x00, 0x18, 0x03, 0x00, 0x60, 0x01, 0xFF, 0xC0, 0x00,
  0x08, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x0E, 0x00,
  0x60, 0x18, 0x00, 0x30, 0x30, 0x00, 0x18, 0x20, 0x00, 0x0C, 0x60, 0x00,
  0x0C, 0x40, 0x00, 0x04, 0x40, 0x00, 0x04, 0x40, 0x00, 0x04, 0x40, 0x00,
  0x04, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x18, 0x00,
  0x30, 0x1C, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x03, 0xC3, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0x87, 0x80, 0x0E, 0x00, 0xE0, 0x18, 0x00,
  0x30, 0x30, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x40, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0x80, 0x00, 0x02, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00,
  0x06, 0x60, 0x00, 0x04, 0x30, 0x00, 0x08, 0x18, 0x00, 0x30, 0x0E, 0x00,
  0xE0, 0x03, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF,
  0xE0, 0x03, 0x80, 0x38, 0x03, 0x00, 0x06, 0x03, 0x00, 0x01, 0x81, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x10, 0x80, 0x00, 0x0C, 0x40, 0x00, 0x02, 0x60,
  0x00, 0x01, 0x30, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x05, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x03,
  0x20, 0x00, 0x01, 0xD8, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xA3, 0x00, 0x00,
  0xD0, 0xC0, 0x01, 0xC8, 0x38, 0x01, 0x84, 0x0F, 0xFF, 0x82, 0x00, 0xFE,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x80, 0x1C, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x7C, 0x18, 0x71, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x18, 0x43, 0x0C,
  0x30, 0x82, 0x18, 0x61, 0x04, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xFF, 0x83, 0x80, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x3F, 0x80, 0x06, 0x30, 0x00, 0x7F, 0xFC, 0x00,
  0x98, 0x00, 0x30, 0x03, 0x00, 0x36, 0x00, 0x18, 0x00, 0xC0, 0x0D, 0x00,
  0x08, 0x00, 0x30, 0x01, 0x40, 0x06, 0x00, 0x0C, 0x00, 0x70, 0x03, 0x00,
  0x03, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0xC0, 0x07, 0x00, 0x20, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0x08, 0x00, 0x60, 0x06, 0x00, 0x02, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x80, 0x06, 0x00, 0x60, 0x00, 0x20, 0x01, 0x80, 0x18,
  0x00, 0x08, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x38, 0x01, 0x80, 0x01,
  0x80, 0x0F, 0x00, 0x20, 0x00, 0x60, 0x02, 0xC0, 0x0C, 0x00, 0x3C, 0x01,
  0xB0, 0x01, 0x00, 0x1B, 0x00, 0xC4, 0x00, 0x60, 0x0C, 0x60, 0x21, 0x80,
  0x0F, 0x0E, 0x0E, 0x70, 0x60, 0x00, 0xFE, 0x01, 0xF8, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x06, 0x20,
  0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x08, 0x10,
  0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x10, 0x08,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x20, 0x04,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x40, 0x02, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x80, 0x01, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x02, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00,
  0x60, 0x04, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00,
  0x10, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00,
  0x08, 0x30, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x04, 0x60, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x40, 0x01, 0xF8, 0x20, 0x00, 0x0E, 0x10, 0x00,
  0x01, 0x88, 0x00, 0x00, 0x64, 0x00, 0x00, 0x32, 0x00, 0x00, 0x09, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x03, 0x40, 0x00, 0x01, 0xA0, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x48, 0x00, 0x00, 0x24, 0x00, 0x00, 0x32, 0x00, 0x00, 0x31,
  0x00, 0x00, 0x30, 0x80, 0x00, 0x30, 0x40, 0x01, 0xE0, 0x3F, 0xFF, 0xE0,
  0x10, 0x00, 0x1E, 0x08, 0x00, 0x01, 0xC4, 0x00, 0x00, 0x32, 0x00, 0x00,
  0x09, 0x00, 0x00, 0x06, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0xA0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x05, 0x00, 0x00, 0x02, 0x80, 0x00, 0x03, 0x40, 0x00, 0x01, 0x20,
  0x00, 0x01, 0x90, 0x00, 0x01, 0x88, 0x00, 0x03, 0x84, 0x00, 0x3F, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x0E,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x10, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x68, 0x00, 0xFF, 0xFF, 0x00, 0x04,
  0x00, 0x1F, 0x00, 0x20, 0x00, 0x0E, 0x01, 0x00, 0x00, 0x1C, 0x08, 0x00,
  0x00, 0x70, 0x40, 0x00, 0x01, 0xC2, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x00, 0x44, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x09,
  0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x0A, 0x00,
  0x00, 0x00, 0x50, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x02, 0x80,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x00, 0x48, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x32, 0x00, 0x00, 0x03,
  0x10, 0x00, 0x00, 0x18, 0x80, 0x00, 0x01, 0x84, 0x00, 0x00, 0x18, 0x20,
  0x00, 0x01, 0x81, 0x00, 0x00, 0x38, 0x08, 0x00, 0x0F, 0x00, 0x40, 0x1F,
  0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xFF, 0xFD, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x60, 0x00, 0x02,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xFF,
  0x40, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x01,
  0x40, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x01,
  0x20, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x01,
  0x10, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x01,
  0x06, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x01,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0xFF, 0x86, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x63, 0xFE,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x81, 0xCF, 0xF8,
  0x10, 0x00, 0x80, 0x00, 0x07, 0x40, 0x00, 0x03, 0x20, 0x00, 0x03, 0x10,
  0x00, 0x03, 0x08, 0x00, 0x03, 0x04, 0x00, 0x03, 0x02, 0x00, 0x03, 0x01,
  0x00, 0x03, 0x00, 0x80, 0x03, 0x00, 0x40, 0x03, 0x00, 0x20, 0x03, 0x00,
  0x10, 0x03, 0x00, 0x08, 0x03, 0x00, 0x04, 0x03, 0x00, 0x02, 0x03, 0x00,
  0x01, 0x03, 0x00, 0x00, 0x83, 0x00, 0x00, 0x42, 0xC0, 0x00, 0x22, 0x30,
  0x00, 0x12, 0x08, 0x00, 0x0A, 0x06, 0x00, 0x06, 0x01, 0x80, 0x02, 0x00,
  0x60, 0x01, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x03, 0x00, 0x20,
  0x00, 0xC0, 0x10, 0x00, 0x60, 0x08, 0x00, 0x18, 0x04, 0x00, 0x06, 0x02,
  0x00, 0x01, 0x01, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x30, 0x40, 0x00, 0x0C,
  0x20, 0x00, 0x02, 0x10, 0x00, 0x01, 0x88, 0x00, 0x00, 0x64, 0x00, 0x00,
  0x1A, 0x00, 0x00, 0x0E, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1E,
  0xC0, 0x00, 0x00, 0x05, 0xB0, 0x00, 0x00, 0x03, 0x64, 0x00, 0x00, 0x00,
  0x99, 0x80, 0x00, 0x00, 0x66, 0x20, 0x00, 0x00, 0x11, 0x8C, 0x00, 0x00,
  0x04, 0x63, 0x00, 0x00, 0x03, 0x18, 0x40, 0x00, 0x00, 0x86, 0x18, 0x00,
  0x00, 0x61, 0x82, 0x00, 0x00, 0x10, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x30,
  0x00, 0x03, 0x06, 0x04, 0x00, 0x00, 0x81, 0x81, 0x80, 0x00, 0x60, 0x60,
  0x20, 0x00, 0x10, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x03, 0x00, 0x03, 0x01,
  0x80, 0x40, 0x00, 0x80, 0x60, 0x18, 0x00, 0x60, 0x18, 0x02, 0x00, 0x10,
  0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x04, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x60, 0x06, 0x00, 0x20, 0x10, 0x01, 0x80, 0x0C,
  0x0C, 0x00, 0x60, 0x01, 0x02, 0x00, 0x18, 0x00, 0x61, 0x80, 0x06, 0x00,
  0x18, 0x60, 0x01, 0x80, 0x02, 0x10, 0x00, 0x60, 0x00, 0xCC, 0x00, 0x18,
  0x00, 0x12, 0x00, 0x06, 0x00, 0x07, 0x80, 0x01, 0x80, 0x01, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xD0, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x07, 0x30, 0x00, 0x00, 0xE2, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x03,
  0x86, 0x00, 0x00, 0x70, 0x40, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x38, 0x08, 0x00, 0x07, 0x01, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x1C,
  0x01, 0x80, 0x03, 0x80, 0x30, 0x00, 0x70, 0x03, 0x00, 0x0E, 0x00, 0x30,
  0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0x60, 0x07, 0x00, 0x06, 0x00, 0xE0,
  0x00, 0xC0, 0x1C, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x18,
  0x0E, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x30, 0xE0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x23, 0x80, 0x00, 0x06,
  0x70, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x05, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x01,
  0x82, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0x98, 0x00,
  0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x00, 0x68,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x00, 0x22,
  0x00, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x06, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x70, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0xFF, 0xFE, 0x02,
  0x00, 0x1F, 0x08, 0x00, 0x0E, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x1A, 0x00,
  0x00, 0x28, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x48, 0x00,
  0x03, 0x20, 0x00, 0x38, 0x80, 0x0F, 0x83, 0xFF, 0xF0, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x01,
  0x82, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0x98, 0x00,
  0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x00, 0x68,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x00, 0x22,
  0x00, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x06, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0x00, 0x80,
  0x07, 0xC0, 0x80, 0x00, 0x70, 0x80, 0x00, 0x38, 0x80, 0x00, 0x18, 0x80,
  0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80,
  0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80,
  0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x08, 0x80, 0x00, 0x18, 0x80,
  0x00, 0x30, 0x80, 0x00, 0xE0, 0x80, 0x03, 0x80, 0xFF, 0xFE, 0x00, 0x80,
  0x0C, 0x00, 0x80, 0x04, 0x00, 0x80, 0x06, 0x00, 0x80, 0x03, 0x00, 0x80,
  0x03, 0x00, 0x80, 0x01, 0x80, 0x80, 0x00, 0x80, 0x80, 0x00, 0xC0, 0x80,
  0x00, 0x60, 0x80, 0x00, 0x60, 0x80, 0x00, 0x30, 0x80, 0x00, 0x10, 0x80,
  0x00, 0x18, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x06, 0x80,
  0x00, 0x02, 0x80, 0x00, 0x03, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xF8, 0x0E,
  0x00, 0x0E, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x38, 0xF0,
  0x00, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x10, 0x18, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x30, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x09, 0x80, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0x86, 0x00, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x30, 0x10, 0x00, 0x00, 0x40, 0x30, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03,
  0x00, 0x40, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x80, 0x00, 0x20,
  0x01, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x02, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x10, 0x01, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x01, 0x01, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x02,
  0x08, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x08,
  0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x40, 0x00, 0x0E,
  0x00, 0x00, 0x24, 0x00, 0x00, 0xB0, 0x00, 0x02, 0x60, 0x00, 0x0B, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x90, 0x00, 0x06, 0x20, 0x00, 0x19, 0x00, 0x00,
  0x42, 0x00, 0x01, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x11, 0x80, 0x00, 0xC3,
  0x00, 0x03, 0x08, 0x00, 0x08, 0x10, 0x00, 0x30, 0x80, 0x00, 0x81, 0x80,
  0x02, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x20, 0x40, 0x01, 0x80, 0x80, 0x06,
  0x04, 0x00, 0x10, 0x08, 0x00, 0x40, 0x60, 0x03, 0x00, 0xC0, 0x04, 0x06,
  0x00, 0x30, 0x0C, 0x00, 0xC0, 0x20, 0x02, 0x00, 0x40, 0x0C, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60,
  0x06, 0x01, 0x80, 0x10, 0x04, 0x00, 0x20, 0x18, 0x01, 0x80, 0x40, 0x02,
  0x01, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x10, 0x00, 0x80, 0xC0, 0x01, 0x03,
  0x00, 0x08, 0x08, 0x00, 0x10, 0x30, 0x00, 0xC1, 0x80, 0x01, 0x82, 0x00,
  0x0C, 0x18, 0x00, 0x18, 0x60, 0x00, 0x41, 0x00, 0x00, 0x86, 0x00, 0x06,
  0x10, 0x00, 0x08, 0x40, 0x00, 0x63, 0x00, 0x00, 0xC4, 0x00, 0x02, 0x30,
  0x00, 0x0C, 0xC0, 0x00, 0x22, 0x00, 0x00, 0x4C, 0x00, 0x03, 0x60, 0x00,
  0x04, 0x80, 0x00, 0x36, 0x00, 0x00, 0x68, 0x00, 0x01, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x14, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x80, 0x80, 0x00, 0x18, 0x0C,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x00, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x10, 0x00,
  0x04, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x04, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x04, 0x02, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x01, 0x80, 0x01,
  0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x40, 0x00,
  0x20, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x10, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x81, 0x80, 0x00, 0x18, 0x08,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x04, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x40, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x01, 0x80, 0x18, 0x00,
  0x18, 0x01, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x04, 0x02, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x02, 0x04, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x18, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03,
  0xFF, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x48, 0x00, 0x00, 0x33, 0x00, 0x00, 0x08,
  0x40, 0x00, 0x06, 0x18, 0x00, 0x01, 0x02, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x20, 0x10, 0x00, 0x18, 0x06, 0x00, 0x04, 0x00, 0x80, 0x03, 0x00, 0x30,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0x20, 0x0C, 0x00,
  0x0C, 0x06, 0x00, 0x01, 0x01, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x08, 0x20,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x44, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x02,
  0x80, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFC, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x3F, 0xF8,
  0x0F, 0x80, 0x70, 0x20, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x03, 0xFF, 0xE0, 0xF8,
  0x03, 0x1C, 0x00, 0x19, 0x80, 0x00, 0xD8, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x02, 0xF0, 0x00, 0x36, 0xC0, 0x03, 0x33, 0x80, 0x71, 0x8F,
  0xFE, 0x0C, 0x02, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x3C, 0x00, 0x81, 0xFF, 0xC0, 0x87,
  0x00, 0xE0, 0x8C, 0x00, 0x30, 0x98, 0x00, 0x18, 0xB0, 0x00, 0x0C, 0xA0,
  0x00, 0x04, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x04, 0xA0, 0x00, 0x0C, 0xB0, 0x00, 0x08, 0x90,
  0x00, 0x18, 0x98, 0x00, 0x70, 0x8E, 0x01, 0xC0, 0x83, 0xFF, 0x80, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xC0, 0x70, 0x06, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x01, 0x80, 0x7F, 0xF8, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x0E, 0x01, 0x01, 0xFF, 0xC1, 0x03, 0x80, 0x71, 0x0E, 0x00, 0x19,
  0x18, 0x00, 0x09, 0x18, 0x00, 0x0D, 0x30, 0x00, 0x05, 0x20, 0x00, 0x07,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x07,
  0x20, 0x00, 0x05, 0x30, 0x00, 0x0D, 0x18, 0x00, 0x09, 0x0C, 0x00, 0x11,
  0x07, 0x00, 0x61, 0x01, 0xFF, 0xC1, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x03, 0xFF, 0x80, 0x0E, 0x03, 0x80, 0x30, 0x01, 0x80, 0xC0, 0x01, 0x83,
  0x00, 0x01, 0x8C, 0x00, 0x03, 0x10, 0x00, 0x02, 0x60, 0x00, 0x06, 0xC0,
  0x00, 0x0D, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x20, 0x38, 0x01, 0xC0, 0x3F, 0xFE, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x3C, 0x70, 0x18, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x3F, 0xFE, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xC1, 0x03, 0x00, 0x71, 0x0E,
  0x00, 0x19, 0x18, 0x00, 0x0D, 0x10, 0x00, 0x05, 0x30, 0x00, 0x07, 0x20,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x07, 0x30, 0x00, 0x05, 0x30, 0x00, 0x0D, 0x18, 0x00, 0x09, 0x0C,
  0x00, 0x31, 0x07, 0x00, 0xE1, 0x01, 0xFF, 0xC1, 0x00, 0x0C, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x38, 0x1F, 0x00, 0xE0, 0x03, 0xFF, 0x80, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x18, 0x02, 0x0F,
  0xFE, 0x08, 0x70, 0x0E, 0x23, 0x00, 0x0C, 0x90, 0x00, 0x12, 0xC0, 0x00,
  0x6A, 0x00, 0x00, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x7F, 0xA0, 0x00, 0x00, 0x24,
  0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x00, 0xC0,
  0x70, 0x1C, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x60, 0x12, 0x1C, 0xFC, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x06, 0x80, 0x00, 0xC8, 0x00, 0x18, 0x80, 0x03, 0x08,
  0x00, 0x60, 0x80, 0x0C, 0x08, 0x01, 0x80, 0x80, 0x10, 0x08, 0x02, 0x00,
  0x80, 0x60, 0x08, 0x0C, 0x00, 0x81, 0x80, 0x08, 0x30, 0x00, 0x87, 0x80,
  0x08, 0xC8, 0x00, 0x98, 0xC0, 0x0B, 0x06, 0x00, 0xA0, 0x30, 0x0C, 0x01,
  0x00, 0x80, 0x18, 0x08, 0x00, 0xC0, 0x80, 0x06, 0x08, 0x00, 0x20, 0x80,
  0x03, 0x08, 0x00, 0x18, 0x80, 0x00, 0xC8, 0x00, 0x04, 0x80, 0x00, 0x68,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x0C,
  0x04, 0x1F, 0xF0, 0x0F, 0xFC, 0x23, 0x80, 0xE0, 0xE0, 0x39, 0x30, 0x01,
  0x0C, 0x00, 0x6B, 0x00, 0x0C, 0xC0, 0x03, 0x50, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x18, 0x02, 0x07, 0xFE, 0x08, 0x70, 0x0E, 0x23,
  0x00, 0x0C, 0x90, 0x00, 0x12, 0xC0, 0x00, 0x6A, 0x00, 0x00, 0xB0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xE0, 0x1C, 0x00,
  0xC0, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x0C,
  0x40, 0x00, 0x06, 0x60, 0x00, 0x01, 0x30, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x68, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x28, 0x00, 0x00, 0x34, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x04, 0x40, 0x00, 0x06, 0x30, 0x00, 0x02, 0x0C, 0x00, 0x03, 0x02,
  0x00, 0x03, 0x01, 0xC0, 0x03, 0x00, 0x38, 0x07, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x81, 0xFF, 0xC0, 0x87, 0x00, 0xE0,
  0x8C, 0x00, 0x30, 0x98, 0x00, 0x18, 0x90, 0x00, 0x0C, 0xA0, 0x00, 0x04,
  0xA0, 0x00, 0x06, 0xE0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06,
  0xE0, 0x00, 0x04, 0xA0, 0x00, 0x0C, 0xB0, 0x00, 0x08, 0x98, 0x00, 0x18,
  0x8C, 0x00, 0x30, 0x87, 0x00, 0xE0, 0x83, 0xFF, 0x80, 0x80, 0x10, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xFF, 0xC1, 0x07, 0x00, 0x61, 0x0C, 0x00, 0x31,
  0x18, 0x00, 0x09, 0x10, 0x00, 0x0D, 0x30, 0x00, 0x05, 0x20, 0x00, 0x07,
  0x60, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x07,
  0x20, 0x00, 0x05, 0x30, 0x00, 0x0D, 0x18, 0x00, 0x19, 0x0C, 0x00, 0x31,
  0x07, 0x00, 0xE1, 0x03, 0xFF, 0x81, 0x00, 0x18, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x83, 0xFF, 0x1C,
  0x02, 0x60, 0x05, 0x80, 0x0A, 0x00, 0x14, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xFE, 0x03, 0x00, 0x1C,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x0D, 0x00, 0x00, 0xCF, 0x00, 0x1C, 0x1F, 0xFF, 0x80, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x7F, 0xFF, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x08, 0x0F, 0xF0, 0x02, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x40, 0x00, 0x2B, 0x00, 0x03, 0x4C, 0x00, 0x32, 0x38,
  0x07, 0x10, 0xFF, 0xE0, 0x80, 0x20, 0x00, 0xC0, 0x00, 0x03, 0x40, 0x00,
  0x02, 0x40, 0x00, 0x06, 0x60, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x10, 0x00, 0x08, 0x10, 0x00, 0x18, 0x18, 0x00, 0x10, 0x08, 0x00,
  0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x20, 0x04, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x02, 0x00, 0x40, 0x02, 0x00, 0xC0, 0x03, 0x00, 0x80, 0x01, 0x01,
  0x80, 0x01, 0x81, 0x80, 0x00, 0x81, 0x00, 0x00, 0x83, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x66, 0x00, 0x00, 0x64, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x02, 0x40, 0x00, 0x70, 0x00, 0x24,
  0x00, 0x05, 0x00, 0x06, 0x60, 0x00, 0xD0, 0x00, 0x66, 0x00, 0x09, 0x80,
  0x04, 0x20, 0x00, 0x88, 0x00, 0x43, 0x00, 0x18, 0x80, 0x0C, 0x30, 0x01,
  0x0C, 0x00, 0xC1, 0x00, 0x10, 0xC0, 0x08, 0x10, 0x03, 0x04, 0x00, 0x81,
  0x80, 0x20, 0x60, 0x18, 0x08, 0x02, 0x06, 0x01, 0x00, 0x80, 0x60, 0x20,
  0x10, 0x0C, 0x04, 0x03, 0x03, 0x00, 0xC0, 0x40, 0x30, 0x30, 0x04, 0x0C,
  0x01, 0x02, 0x00, 0x40, 0x80, 0x18, 0x20, 0x06, 0x08, 0x01, 0x86, 0x00,
  0x21, 0x80, 0x08, 0x60, 0x02, 0x10, 0x00, 0xC4, 0x00, 0x31, 0x00, 0x0C,
  0x40, 0x03, 0x30, 0x00, 0x4C, 0x00, 0x12, 0x00, 0x04, 0xC0, 0x01, 0x20,
  0x00, 0x68, 0x00, 0x1E, 0x00, 0x02, 0x80, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x60, 0x00, 0x06,
  0x30, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x02, 0x00, 0x40, 0x03, 0x00, 0xC0, 0x01, 0x81, 0x80,
  0x00, 0x83, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x66, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x42, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x81, 0x80, 0x03, 0x00, 0xC0,
  0x02, 0x00, 0x40, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x08, 0x00, 0x10,
  0x18, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x40, 0x00, 0x02, 0x40, 0x00, 0x06, 0x60, 0x00, 0x04,
  0x20, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x10, 0x00, 0x08, 0x10, 0x00, 0x18,
  0x18, 0x00, 0x10, 0x08, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x20,
  0x04, 0x00, 0x60, 0x06, 0x00, 0x40, 0x02, 0x00, 0x40, 0x02, 0x00, 0xC0,
  0x03, 0x00, 0x80, 0x01, 0x01, 0x80, 0x01, 0x81, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x83, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x46, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x86, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x3F, 0x00, 0x60, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x78, 0x07, 0x00, 0x70, 0x00, 0xF0,
  0xE8, 0x00, 0x0F, 0xC0,
};

const GFXglyph NotoSans_Thin55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 3, 39, 12, 5, -39 },
  { 16, 10, 14, 18, 4, -39 },
  { 34, 32, 39, 36, 2, -39 },
  { 190, 22, 45, 31, 4, -42 },
  { 314, 37, 41, 44, 3, -40 },
  { 504, 34, 41, 39, 3, -40 },
  { 679, 2, 14, 9, 4, -39 },
  { 683, 10, 48, 14, 2, -39 },
  { 743, 10, 48, 14, 2, -39 },
  { 803, 24, 22, 30, 3, -42 },
  { 869, 25, 25, 31, 3, -32 },
  { 948, 5, 13, 10, 2, -6 },
  { 957, 14, 2, 18, 2, -16 },
  { 961, 3, 3, 12, 5, -3 },
  { 963, 16, 39, 18, 1, -39 },
  { 1041, 25, 41, 31, 3, -40 },
  { 1170, 12, 39, 31, 6, -39 },
  { 1229, 24, 40, 31, 3, -40 },
  { 1349, 24, 41, 31, 3, -40 },
  { 1472, 30, 39, 31, 1, -39 },
  { 1619, 24, 40, 31, 4, -39 },
  { 1739, 24, 41, 31, 4, -40 },
  { 1862, 25, 39, 31, 3, -39 },
  { 1984, 24, 41, 31, 4, -40 },
  { 2107, 25, 41, 31, 3, -40 },
  { 2236, 3, 29, 12, 5, -29 },
  { 2247, 6, 36, 12, 2, -29 },
  { 2274, 25, 24, 31, 3, -32 },
  { 2349, 25, 13, 31, 3, -26 },
  { 2390, 25, 24, 31, 3, -32 },
  { 2465, 19, 40, 23, 2, -40 },
  { 2560, 42, 45, 48, 3, -39 },
  { 2797, 32, 39, 32, 0, -39 },
  { 2953, 25, 39, 34, 6, -39 },
  { 3075, 29, 41, 34, 3, -40 },
  { 3224, 29, 39, 38, 6, -39 },
  { 3366, 21, 39, 30, 6, -39 },
  { 3469, 21, 39, 27, 6, -39 },
  { 3572, 32, 41, 40, 3, -40 },
  { 3736, 27, 39, 39, 6, -39 },
  { 3868, 9, 39, 16, 3, -39 },
  { 3912, 12, 49, 13, -5, -39 },
  { 3986, 25, 39, 31, 6, -39 },
  { 4108, 21, 39, 28, 6, -39 },
  { 4211, 34, 39, 46, 6, -39 },
  { 4377, 27, 39, 38, 6, -39 },
  { 4509, 35, 41, 41, 3, -40 },
  { 4689, 22, 39, 32, 6, -39 },
  { 4797, 35, 49, 41, 3, -40 },
  { 5012, 24, 39, 32, 6, -39 },
  { 5129, 24, 41, 30, 3, -40 },
  { 5252, 28, 39, 28, 0, -39 },
  { 5389, 29, 40, 39, 5, -39 },
  { 5534, 31, 39, 31, 0, -39 },
  { 5686, 44, 39, 48, 2, -39 },
  { 5901, 28, 39, 28, 0, -39 },
  { 6038, 28, 39, 28, 0, -39 },
  { 6175, 28, 39, 32, 2, -39 },
  { 6312, 11, 48, 17, 5, -39 },
  { 6378, 16, 39, 18, 1, -39 },
  { 6456, 11, 48, 17, 1, -39 },
  { 6522, 26, 25, 31, 3, -40 },
  { 6604, 22, 1, 22, 0, 5 },
  { 6607, 10, 9, 14, 2, -42 },
  { 6619, 21, 31, 28, 3, -30 },
  { 6701, 24, 43, 32, 5, -42 },
  { 6830, 21, 31, 26, 3, -30 },
  { 6912, 24, 43, 32, 3, -42 },
  { 7041, 23, 31, 30, 3, -30 },
  { 7131, 18, 42, 15, 1, -42 },
  { 7226, 24, 43, 32, 3, -30 },
  { 7355, 22, 42, 32, 5, -42 },
  { 7471, 3, 40, 11, 4, -40 },
  { 7486, 10, 53, 11, -3, -40 },
  { 7553, 20, 42, 25, 5, -42 },
  { 7658, 1, 42, 11, 5, -42 },
  { 7664, 37, 30, 47, 5, -30 },
  { 7803, 22, 30, 32, 5, -30 },
  { 7886, 25, 31, 32, 3, -30 },
  { 7983, 24, 43, 32, 5, -30 },
  { 8112, 24, 43, 32, 3, -30 },
  { 8241, 15, 29, 21, 5, -29 },
  { 8296, 21, 31, 25, 2, -30 },
  { 8378, 15, 37, 18, 1, -36 },
  { 8448, 21, 30, 32, 5, -29 },
  { 8527, 24, 29, 24, 0, -29 },
  { 8614, 36, 29, 38, 1, -29 },
  { 8745, 24, 29, 26, 1, -29 },
  { 8832, 24, 42, 24, 0, -29 },
  { 8958, 21, 29, 25, 2, -29 },
  { 9035, 16, 48, 19, 1, -39 },
  { 9131, 1, 56, 29, 14, -42 },
  { 9138, 15, 48, 19, 2, -39 },
  { 9228, 25, 5, 31, 3, -22 },
};

const GFXfont NotoSans_Thin55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin55pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_THIN55PT7B_H_
