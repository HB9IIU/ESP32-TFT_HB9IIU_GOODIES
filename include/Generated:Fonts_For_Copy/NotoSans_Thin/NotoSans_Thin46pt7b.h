#ifndef _NOTOSANS_THIN46PT7B_H_
#define _NOTOSANS_THIN46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin46pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x55, 0x55, 0x40, 0x03, 0xC0, 0xC1, 0xC1,
  0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0x41, 0x41, 0x00, 0x10,
  0x06, 0x00, 0x02, 0x00, 0x80, 0x00, 0x40, 0x10, 0x00, 0x08, 0x02, 0x00,
  0x03, 0x00, 0x40, 0x00, 0x40, 0x18, 0x00, 0x08, 0x02, 0x00, 0x01, 0x00,
  0x40, 0x00, 0x20, 0x08, 0x00, 0x0C, 0x01, 0x00, 0x01, 0x00, 0x20, 0x1F,
  0xFF, 0xFF, 0xF0, 0x04, 0x01, 0x00, 0x00, 0x80, 0x20, 0x00, 0x30, 0x04,
  0x00, 0x04, 0x00, 0x80, 0x00, 0x80, 0x30, 0x00, 0x10, 0x04, 0x00, 0x02,
  0x00, 0x80, 0x00, 0x40, 0x10, 0x00, 0x18, 0x02, 0x01, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF0, 0x08, 0x02, 0x00, 0x01, 0x00, 0x40, 0x00, 0x60,
  0x08, 0x00, 0x08, 0x03, 0x00, 0x01, 0x00, 0x40, 0x00, 0x20, 0x08, 0x00,
  0x04, 0x01, 0x00, 0x01, 0x80, 0x20, 0x00, 0x20, 0x04, 0x00, 0x04, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x03, 0xFF, 0x01,
  0x84, 0x38, 0x40, 0x80, 0x10, 0x10, 0x06, 0x02, 0x00, 0x80, 0x40, 0x10,
  0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x0C, 0x04, 0x00, 0x80, 0x80, 0x18,
  0x10, 0x01, 0x82, 0x00, 0x0C, 0x40, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x04, 0x60, 0x00, 0x83, 0x00, 0x10, 0x20, 0x02, 0x02, 0x00,
  0x40, 0x40, 0x08, 0x0C, 0x01, 0x01, 0x80, 0x20, 0x30, 0x04, 0x04, 0x00,
  0x80, 0x80, 0x10, 0x30, 0x02, 0x0C, 0xC0, 0x43, 0x0F, 0xFF, 0x80, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x80, 0x61, 0x80, 0x02, 0x01, 0x81, 0x80, 0x0C, 0x02, 0x01, 0x00, 0x10,
  0x0C, 0x03, 0x00, 0x60, 0x10, 0x02, 0x00, 0x80, 0x20, 0x04, 0x03, 0x00,
  0x40, 0x08, 0x04, 0x00, 0x80, 0x10, 0x10, 0x01, 0x00, 0x20, 0x20, 0x02,
  0x00, 0x40, 0x80, 0x04, 0x00, 0x83, 0x00, 0x08, 0x01, 0x04, 0x00, 0x10,
  0x02, 0x18, 0x7C, 0x20, 0x04, 0x21, 0x84, 0x60, 0x18, 0xC4, 0x04, 0x40,
  0x21, 0x18, 0x0C, 0xC0, 0xC4, 0x20, 0x08, 0xC3, 0x08, 0x40, 0x10, 0xFC,
  0x21, 0x80, 0x30, 0x00, 0xC3, 0x00, 0x60, 0x01, 0x04, 0x00, 0xC0, 0x06,
  0x08, 0x01, 0x80, 0x08, 0x10, 0x03, 0x00, 0x30, 0x20, 0x06, 0x00, 0x40,
  0x60, 0x0C, 0x01, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01,
  0x00, 0x40, 0x30, 0x02, 0x01, 0x80, 0x40, 0x02, 0x02, 0x01, 0x80, 0x06,
  0x0C, 0x02, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x04, 0x00, 0x80, 0x00, 0x80, 0x0C, 0x00, 0x08, 0x00, 0x40, 0x01, 0x80,
  0x04, 0x00, 0x18, 0x00, 0x40, 0x01, 0x80, 0x04, 0x00, 0x08, 0x00, 0x40,
  0x00, 0x80, 0x08, 0x00, 0x04, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x62,
  0x00, 0x60, 0x04, 0x40, 0x03, 0x00, 0x4C, 0x00, 0x18, 0x0C, 0x80, 0x00,
  0xC0, 0x88, 0x00, 0x06, 0x18, 0x80, 0x00, 0x31, 0x08, 0x00, 0x01, 0x30,
  0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x40, 0x40, 0x00, 0x0A, 0x06, 0x00,
  0x03, 0x10, 0x30, 0x00, 0x60, 0x81, 0xC0, 0x1C, 0x04, 0x07, 0xFF, 0x00,
  0x30, 0xFF, 0xFF, 0xF5, 0x03, 0x02, 0x04, 0x0C, 0x08, 0x10, 0x10, 0x30,
  0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x40, 0x40, 0x60, 0x20,
  0x20, 0x10, 0x10, 0x18, 0x08, 0x04, 0x06, 0x03, 0x80, 0x40, 0x60, 0x30,
  0x10, 0x18, 0x08, 0x0C, 0x04, 0x04, 0x06, 0x02, 0x02, 0x02, 0x02, 0x03,
  0x03, 0x03, 0x01, 0x01, 0x01, 0x01, 0x03, 0x03, 0x03, 0x02, 0x02, 0x02,
  0x02, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0xC0,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x20, 0x10, 0x0F, 0x02, 0x07, 0x1C, 0x47, 0x00, 0x7F, 0x00,
  0x01, 0x00, 0x00, 0x50, 0x00, 0x11, 0x00, 0x06, 0x30, 0x00, 0x82, 0x00,
  0x20, 0x20, 0x0C, 0x06, 0x03, 0x00, 0x60, 0x20, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x32, 0x22, 0x66, 0x44, 0xC8, 0x80,
  0xFF, 0xE0, 0xF0, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x60, 0x30, 0x18, 0x01, 0x81, 0x00, 0x0C, 0x20, 0x00, 0x42, 0x00, 0x06,
  0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0x40, 0x00, 0x34,
  0x00, 0x02, 0x40, 0x00, 0x22, 0x00, 0x06, 0x20, 0x00, 0x41, 0x00, 0x0C,
  0x18, 0x01, 0x80, 0xC0, 0x30, 0x03, 0xFC, 0x00, 0x00, 0xC0, 0x70, 0x64,
  0x31, 0x18, 0x58, 0x1C, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x07, 0xF8, 0x01, 0xC0, 0x60, 0x60, 0x03, 0x04, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0xE0, 0x1C, 0x1C, 0x00, 0x30, 0x80, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x32, 0x00, 0x03, 0x1E, 0x00,
  0x70, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x26, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x10, 0x60, 0x00, 0x18, 0x30, 0x00,
  0x08, 0x18, 0x00, 0x08, 0x0C, 0x00, 0x08, 0x06, 0x00, 0x0C, 0x03, 0x00,
  0x04, 0x01, 0x80, 0x04, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x02, 0x00, 0x18, 0x02, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x03, 0x00, 0x03,
  0x01, 0x00, 0x01, 0x81, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x1F, 0xFF, 0xC1, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x1E, 0x00, 0x3F,
  0xFE, 0x02, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x80, 0x01, 0x8E, 0x00, 0x70, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0xFF, 0x03,
  0x18, 0x0E, 0x13, 0x00, 0x18, 0xB0, 0x00, 0x65, 0x00, 0x01, 0x30, 0x00,
  0x05, 0x80, 0x00, 0x2C, 0x00, 0x01, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x68,
  0x00, 0x03, 0x40, 0x00, 0x12, 0x00, 0x00, 0x98, 0x00, 0x04, 0x40, 0x00,
  0x63, 0x00, 0x02, 0x08, 0x00, 0x30, 0x20, 0x03, 0x00, 0xC0, 0x30, 0x03,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0xC0, 0x30, 0x10, 0x00, 0x82, 0x00, 0x04, 0x60,
  0x00, 0x64, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x26,
  0x00, 0x06, 0x20, 0x00, 0x43, 0x00, 0x0C, 0x18, 0x01, 0x80, 0xE0, 0x60,
  0x03, 0x9C, 0x00, 0x0F, 0x00, 0x03, 0x9C, 0x00, 0xC0, 0x30, 0x18, 0x01,
  0x82, 0x00, 0x04, 0x60, 0x00, 0x24, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x03, 0x40,
  0x00, 0x26, 0x00, 0x06, 0x30, 0x00, 0xC1, 0x80, 0x38, 0x07, 0xFE, 0x00,
  0x07, 0xFC, 0x01, 0xC0, 0x60, 0x30, 0x01, 0x06, 0x00, 0x08, 0x40, 0x00,
  0xCC, 0x00, 0x04, 0x80, 0x00, 0x68, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x34, 0x00, 0x05, 0x60, 0x00, 0xD3, 0x00, 0x19, 0x18, 0x07, 0x10,
  0x7F, 0xC3, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x7F, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x33, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x22, 0x26, 0x64, 0x4C, 0x88, 0x00, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x3F, 0xE1, 0x80, 0x70, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x00, 0x63,
  0x00, 0x0F, 0xFC, 0x02, 0x20, 0x03, 0x00, 0x80, 0x26, 0x00, 0x40, 0x08,
  0x03, 0x40, 0x08, 0x00, 0x80, 0x34, 0x01, 0x80, 0x08, 0x01, 0x40, 0x10,
  0x00, 0x80, 0x14, 0x03, 0x00, 0x08, 0x01, 0xC0, 0x20, 0x00, 0x80, 0x1C,
  0x02, 0x00, 0x08, 0x01, 0xC0, 0x20, 0x00, 0x80, 0x1C, 0x02, 0x00, 0x08,
  0x03, 0xC0, 0x20, 0x01, 0x80, 0x34, 0x02, 0x00, 0x18, 0x02, 0x40, 0x30,
  0x01, 0x80, 0x24, 0x01, 0x00, 0x28, 0x04, 0x40, 0x18, 0x06, 0xC0, 0xC6,
  0x00, 0xE1, 0xC6, 0x18, 0x20, 0x03, 0xF0, 0x3F, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x05, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00,
  0x22, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x04, 0x00, 0x00, 0x20, 0x80,
  0x00, 0x0C, 0x18, 0x00, 0x01, 0x01, 0x00, 0x00, 0x60, 0x20, 0x00, 0x08,
  0x06, 0x00, 0x01, 0x00, 0x40, 0x00, 0x60, 0x0C, 0x00, 0x08, 0x00, 0x80,
  0x03, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x08, 0x00, 0x08, 0x02, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x10, 0x18, 0x00, 0x02, 0x02, 0x00, 0x00, 0x60, 0x40, 0x00,
  0x04, 0x10, 0x00, 0x00, 0x82, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x01, 0x10,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x60, 0xFF, 0xF0,
  0x04, 0x00, 0xF8, 0x20, 0x00, 0x71, 0x00, 0x00, 0xC8, 0x00, 0x02, 0x40,
  0x00, 0x12, 0x00, 0x00, 0xD0, 0x00, 0x02, 0x80, 0x00, 0x14, 0x00, 0x01,
  0xA0, 0x00, 0x09, 0x00, 0x00, 0x48, 0x00, 0x04, 0x40, 0x00, 0x62, 0x00,
  0x0C, 0x1F, 0xFF, 0x80, 0x80, 0x0F, 0x04, 0x00, 0x06, 0x20, 0x00, 0x19,
  0x00, 0x00, 0x68, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00, 0x00, 0x28,
  0x00, 0x02, 0x40, 0x00, 0x32, 0x00, 0x03, 0x10, 0x01, 0xE0, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0xE0, 0x07, 0x03, 0x80, 0x01, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x02, 0x00, 0x7F, 0xFC, 0xFF, 0xF0, 0x00, 0x80, 0x7F, 0x00, 0x80, 0x01,
  0xC0, 0x80, 0x00, 0x60, 0x80, 0x00, 0x30, 0x80, 0x00, 0x18, 0x80, 0x00,
  0x0C, 0x80, 0x00, 0x04, 0x80, 0x00, 0x06, 0x80, 0x00, 0x02, 0x80, 0x00,
  0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0x80, 0x00,
  0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00,
  0x08, 0x80, 0x00, 0x18, 0x80, 0x00, 0x30, 0x80, 0x00, 0x60, 0x80, 0x01,
  0xC0, 0x80, 0x1F, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xFF, 0xE8, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x38, 0x00, 0xF0, 0x18, 0x00, 0x04, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x14, 0x00, 0x00, 0x05,
  0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x48, 0x00, 0x00, 0x12, 0x00, 0x00,
  0x04, 0x40, 0x00, 0x01, 0x18, 0x00, 0x00, 0x43, 0x00, 0x00, 0x10, 0x30,
  0x00, 0x04, 0x07, 0x00, 0x07, 0x00, 0x3F, 0xFE, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0xFE, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0xFE, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x36, 0x1C, 0x7E, 0x00, 0x80, 0x00,
  0x34, 0x00, 0x03, 0x20, 0x00, 0x31, 0x00, 0x03, 0x08, 0x00, 0x30, 0x40,
  0x03, 0x02, 0x00, 0x30, 0x10, 0x03, 0x00, 0x80, 0x30, 0x04, 0x03, 0x00,
  0x20, 0x30, 0x01, 0x03, 0x00, 0x08, 0x30, 0x00, 0x43, 0x00, 0x02, 0x38,
  0x00, 0x13, 0x60, 0x00, 0xB1, 0x80, 0x07, 0x04, 0x00, 0x30, 0x10, 0x01,
  0x00, 0xC0, 0x08, 0x03, 0x00, 0x40, 0x08, 0x02, 0x00, 0x60, 0x10, 0x01,
  0x80, 0x80, 0x04, 0x04, 0x00, 0x10, 0x20, 0x00, 0xC1, 0x00, 0x03, 0x08,
  0x00, 0x08, 0x40, 0x00, 0x22, 0x00, 0x01, 0x90, 0x00, 0x06, 0x80, 0x00,
  0x18, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0B, 0x40,
  0x00, 0x00, 0xDA, 0x00, 0x00, 0x04, 0xC8, 0x00, 0x00, 0x26, 0x40, 0x00,
  0x03, 0x33, 0x00, 0x00, 0x11, 0x88, 0x00, 0x01, 0x8C, 0x40, 0x00, 0x08,
  0x61, 0x00, 0x00, 0x43, 0x08, 0x00, 0x06, 0x18, 0x60, 0x00, 0x20, 0xC1,
  0x00, 0x03, 0x06, 0x0C, 0x00, 0x10, 0x30, 0x20, 0x00, 0x81, 0x81, 0x00,
  0x08, 0x0C, 0x0C, 0x00, 0x40, 0x60, 0x20, 0x06, 0x03, 0x01, 0x80, 0x20,
  0x18, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x06, 0x01, 0x80, 0x80, 0x30,
  0x04, 0x0C, 0x01, 0x80, 0x30, 0x40, 0x0C, 0x00, 0x86, 0x00, 0x60, 0x04,
  0x20, 0x03, 0x00, 0x11, 0x00, 0x18, 0x00, 0x98, 0x00, 0xC0, 0x06, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x08,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xB0,
  0x00, 0x06, 0x40, 0x00, 0x19, 0x80, 0x00, 0x63, 0x00, 0x01, 0x84, 0x00,
  0x06, 0x18, 0x00, 0x18, 0x30, 0x00, 0x60, 0x40, 0x01, 0x80, 0x80, 0x06,
  0x03, 0x00, 0x18, 0x04, 0x00, 0x60, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x40, 0x18, 0x00, 0x80, 0x60, 0x03, 0x01, 0x80, 0x06, 0x06, 0x00, 0x08,
  0x18, 0x00, 0x30, 0x60, 0x00, 0x61, 0x80, 0x00, 0x86, 0x00, 0x03, 0x18,
  0x00, 0x06, 0x60, 0x00, 0x09, 0x80, 0x00, 0x36, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x04, 0x00, 0x7F, 0xF0, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x80, 0x00,
  0x08, 0x08, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01, 0x84, 0x00, 0x00, 0x04,
  0x60, 0x00, 0x00, 0x22, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x05, 0x80,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x60,
  0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x48, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x08, 0x06, 0x00, 0x00, 0x80, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x03, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x10, 0x0F, 0xC2,
  0x00, 0x0C, 0x40, 0x00, 0xC8, 0x00, 0x0D, 0x00, 0x00, 0xA0, 0x00, 0x14,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x24, 0x00, 0x0C, 0x80, 0x03, 0x10,
  0x07, 0x83, 0xFF, 0x80, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0x80, 0x18, 0x00, 0x03, 0x00, 0x80, 0x00, 0x08, 0x08, 0x00, 0x00, 0x20,
  0xC0, 0x00, 0x01, 0x84, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x22, 0x00,
  0x00, 0x00, 0x90, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x01, 0x40, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x09, 0x00, 0x00,
  0x00, 0x48, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x21, 0x00, 0x00, 0x01,
  0x08, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x81, 0x80, 0x00, 0x08, 0x06,
  0x00, 0x00, 0x80, 0x18, 0x00, 0x18, 0x00, 0x30, 0x03, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0xFF, 0xF0, 0x08, 0x03, 0xE0,
  0x80, 0x03, 0x08, 0x00, 0x08, 0x80, 0x00, 0xC8, 0x00, 0x04, 0x80, 0x00,
  0x68, 0x00, 0x06, 0x80, 0x00, 0x68, 0x00, 0x06, 0x80, 0x00, 0x68, 0x00,
  0x04, 0x80, 0x00, 0x48, 0x00, 0x0C, 0x80, 0x01, 0x88, 0x00, 0x30, 0x80,
  0x0E, 0x0F, 0xFF, 0x80, 0x80, 0x30, 0x08, 0x01, 0x00, 0x80, 0x18, 0x08,
  0x00, 0x80, 0x80, 0x04, 0x08, 0x00, 0x60, 0x80, 0x02, 0x08, 0x00, 0x30,
  0x80, 0x01, 0x08, 0x00, 0x08, 0x80, 0x00, 0xC8, 0x00, 0x04, 0x80, 0x00,
  0x68, 0x00, 0x02, 0x80, 0x00, 0x10, 0x07, 0xFF, 0x01, 0xC0, 0x1E, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x8C,
  0x00, 0x70, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00,
  0x03, 0x20, 0x00, 0x02, 0x30, 0x00, 0x06, 0x10, 0x00, 0x0C, 0x0C, 0x00,
  0x18, 0x07, 0x00, 0x70, 0x01, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x09, 0x80, 0x00, 0x06, 0x20, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x30, 0x40, 0x00, 0x08, 0x10, 0x00, 0x06,
  0x02, 0x00, 0x01, 0x00, 0x80, 0x00, 0x40, 0x30, 0x00, 0x30, 0x04, 0x00,
  0x08, 0x01, 0x00, 0x02, 0x00, 0x60, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x00, 0x40, 0x08, 0x00, 0x10, 0x02, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x80, 0x40, 0x00, 0x20, 0x10, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x41, 0x80, 0x00, 0x08, 0x40, 0x00, 0x02, 0x10, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x12, 0x00, 0x00, 0x04, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xA0, 0x00, 0x18, 0x00, 0x05, 0x80, 0x01, 0xC0,
  0x00, 0x64, 0x00, 0x0B, 0x00, 0x02, 0x20, 0x00, 0x48, 0x00, 0x11, 0x00,
  0x02, 0x40, 0x00, 0x84, 0x00, 0x23, 0x00, 0x0C, 0x20, 0x01, 0x08, 0x00,
  0x41, 0x00, 0x08, 0x40, 0x02, 0x0C, 0x00, 0xC2, 0x00, 0x30, 0x20, 0x04,
  0x18, 0x01, 0x01, 0x00, 0x20, 0x40, 0x08, 0x08, 0x01, 0x02, 0x00, 0x40,
  0x60, 0x18, 0x10, 0x06, 0x01, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x40, 0x20, 0x10, 0x18, 0x01, 0x03, 0x00, 0xC0, 0xC0, 0x08,
  0x10, 0x02, 0x04, 0x00, 0x40, 0x80, 0x10, 0x20, 0x03, 0x0C, 0x00, 0x83,
  0x00, 0x08, 0x40, 0x06, 0x10, 0x00, 0x42, 0x00, 0x10, 0x80, 0x02, 0x10,
  0x00, 0x8C, 0x00, 0x19, 0x80, 0x06, 0x60, 0x00, 0x48, 0x00, 0x12, 0x00,
  0x02, 0x40, 0x00, 0x90, 0x00, 0x12, 0x00, 0x05, 0x80, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x60, 0x00, 0x06, 0x20, 0x00, 0x0C, 0x30, 0x00,
  0x08, 0x18, 0x00, 0x18, 0x08, 0x00, 0x10, 0x0C, 0x00, 0x20, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x40, 0x03, 0x00, 0x80, 0x01, 0x01, 0x80, 0x00, 0x81,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x46, 0x00, 0x00, 0x64, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x83, 0x00, 0x01, 0x81, 0x00, 0x01, 0x01,
  0x80, 0x02, 0x00, 0x80, 0x06, 0x00, 0x40, 0x04, 0x00, 0x60, 0x0C, 0x00,
  0x20, 0x18, 0x00, 0x10, 0x10, 0x00, 0x18, 0x30, 0x00, 0x08, 0x60, 0x00,
  0x04, 0x40, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x80, 0x00,
  0x0D, 0x80, 0x00, 0x11, 0x00, 0x00, 0x43, 0x00, 0x00, 0x82, 0x00, 0x02,
  0x06, 0x00, 0x0C, 0x04, 0x00, 0x10, 0x04, 0x00, 0x60, 0x08, 0x00, 0x80,
  0x08, 0x03, 0x00, 0x18, 0x04, 0x00, 0x10, 0x18, 0x00, 0x30, 0x20, 0x00,
  0x20, 0x80, 0x00, 0x61, 0x00, 0x00, 0x44, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0xA0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0xFF, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0xFF, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x03, 0xFF, 0x00, 0x10, 0x00, 0x00, 0xE0, 0x00, 0x02,
  0x80, 0x00, 0x13, 0x00, 0x00, 0x44, 0x00, 0x02, 0x18, 0x00, 0x18, 0x20,
  0x00, 0x40, 0xC0, 0x03, 0x01, 0x00, 0x08, 0x06, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x30, 0x0C, 0x00, 0x40, 0x20, 0x01, 0x81, 0x80, 0x02, 0x04, 0x00,
  0x0C, 0x20, 0x00, 0x10, 0x80, 0x00, 0x64, 0x00, 0x00, 0xB0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x04, 0x03, 0x00, 0xF0,
  0x03, 0xFF, 0x83, 0x80, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x7F, 0x03, 0xF8, 0xC7, 0x00, 0x33, 0x00, 0x0D, 0x80, 0x03, 0x40, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xD0, 0x00, 0xD6,
  0x00, 0x64, 0xC0, 0x31, 0x1F, 0xF0, 0x40, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0xF8, 0x08, 0x78,
  0xF0, 0x8C, 0x01, 0x89, 0x00, 0x0C, 0xA0, 0x00, 0x4A, 0x00, 0x06, 0xC0,
  0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0xE0, 0x00,
  0x4A, 0x00, 0x0C, 0x90, 0x01, 0x88, 0xC0, 0x30, 0x87, 0xFC, 0x00, 0x00,
  0x3E, 0x01, 0xF3, 0xC3, 0x80, 0x23, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x01, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0xF8, 0x10, 0x79, 0xE1, 0x0C,
  0x01, 0x11, 0x00, 0x09, 0x20, 0x00, 0x56, 0x00, 0x05, 0x40, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x07, 0x40, 0x00, 0x52, 0x00,
  0x0D, 0x30, 0x00, 0x91, 0xC0, 0x31, 0x07, 0xFE, 0x10, 0x00, 0xF0, 0x00,
  0xF3, 0xC0, 0x30, 0x0C, 0x08, 0x00, 0xC2, 0x00, 0x0C, 0xC0, 0x00, 0x90,
  0x00, 0x12, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x06, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x01,
  0x81, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0xFF, 0xF0, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x00, 0xF8, 0x00, 0x7D, 0xE1,
  0x1C, 0x01, 0x91, 0x00, 0x0B, 0x20, 0x00, 0x76, 0x00, 0x07, 0x40, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x07, 0x60, 0x00, 0x72,
  0x00, 0x0F, 0x30, 0x01, 0xB0, 0xC0, 0x33, 0x07, 0xFC, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0xC4, 0x00, 0x18, 0x7C, 0x07, 0x00, 0x7F,
  0xC0, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x03, 0xE0, 0x43, 0xCF, 0x09, 0x80, 0x31, 0x20, 0x01, 0x28, 0x00,
  0x37, 0x00, 0x02, 0xC0, 0x00, 0x58, 0x00, 0x0B, 0x00, 0x01, 0x40, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0xFC, 0x00, 0x2A, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0x80, 0x03, 0x03,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x06, 0x8C, 0xF8, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x68, 0x00, 0x64, 0x00, 0x62,
  0x00, 0x61, 0x00, 0x60, 0x80, 0x60, 0x40, 0x20, 0x20, 0x20, 0x10, 0x20,
  0x08, 0x20, 0x04, 0x30, 0x02, 0x2C, 0x01, 0x33, 0x00, 0xB0, 0x80, 0x70,
  0x20, 0x30, 0x18, 0x10, 0x04, 0x08, 0x01, 0x04, 0x00, 0x42, 0x00, 0x31,
  0x00, 0x0C, 0x80, 0x02, 0x40, 0x00, 0xA0, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xE0, 0x03, 0xC1, 0x1E, 0x70, 0x3C, 0xE2, 0x60, 0x18,
  0xC0, 0x35, 0x80, 0x12, 0x00, 0x2A, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x02, 0x00, 0xF8, 0x10, 0xF3, 0xC2, 0x30, 0x0C, 0x48, 0x00,
  0x4A, 0x00, 0x0D, 0x80, 0x00, 0xB0, 0x00, 0x16, 0x00, 0x02, 0xC0, 0x00,
  0x50, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0xF0, 0x00, 0x3C, 0xF8, 0x03, 0x00, 0x60, 0x20,
  0x01, 0x82, 0x00, 0x06, 0x30, 0x00, 0x11, 0x00, 0x00, 0xD8, 0x00, 0x02,
  0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x16,
  0x00, 0x00, 0x90, 0x00, 0x04, 0x80, 0x00, 0x46, 0x00, 0x02, 0x18, 0x00,
  0x20, 0x60, 0x03, 0x01, 0x80, 0x60, 0x03, 0xFE, 0x00, 0x00, 0xF8, 0x08,
  0x7D, 0xF0, 0x8C, 0x01, 0x89, 0x80, 0x0C, 0xB0, 0x00, 0x4A, 0x00, 0x02,
  0xC0, 0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0xA0,
  0x00, 0x6B, 0x00, 0x0C, 0x98, 0x01, 0x88, 0xC0, 0x30, 0x87, 0xFE, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x79, 0xE1, 0x18, 0x03, 0x33, 0x00,
  0x0B, 0x20, 0x00, 0x74, 0x00, 0x07, 0x40, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x34, 0x00, 0x07, 0x40, 0x00, 0x72, 0x00, 0x0B, 0x30, 0x01,
  0xB1, 0x80, 0x33, 0x07, 0xFC, 0x30, 0x04, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x01, 0xEC, 0x7F,
  0xA6, 0x01, 0x60, 0x0A, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x00, 0x01, 0xF0, 0x0F, 0x9F, 0x8C, 0x00, 0x4C, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0D, 0x80, 0x0C, 0x7F, 0xF8, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x03, 0xFF, 0xE1, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0xFC, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0x40, 0x01, 0x58, 0x00, 0x93, 0x00,
  0xC4, 0x3F, 0xE1, 0xC0, 0x00, 0x34, 0x00, 0x02, 0x40, 0x00, 0x66, 0x00,
  0x04, 0x20, 0x00, 0x42, 0x00, 0x0C, 0x10, 0x00, 0x81, 0x00, 0x08, 0x18,
  0x01, 0x00, 0x80, 0x10, 0x08, 0x03, 0x00, 0x40, 0x20, 0x04, 0x02, 0x00,
  0x60, 0x40, 0x02, 0x04, 0x00, 0x20, 0xC0, 0x03, 0x08, 0x00, 0x10, 0x80,
  0x01, 0x18, 0x00, 0x09, 0x00, 0x00, 0x90, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x24, 0x00,
  0x38, 0x00, 0x90, 0x01, 0xA0, 0x02, 0x40, 0x04, 0x80, 0x19, 0x80, 0x13,
  0x00, 0x42, 0x00, 0xC4, 0x01, 0x08, 0x02, 0x10, 0x04, 0x30, 0x08, 0x40,
  0x20, 0x40, 0x60, 0x80, 0x81, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x18,
  0x18, 0x30, 0x10, 0x40, 0x20, 0x80, 0x41, 0x00, 0x82, 0x01, 0x04, 0x03,
  0x18, 0x02, 0x30, 0x04, 0x40, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0x4C,
  0x00, 0xC8, 0x01, 0xA0, 0x01, 0x60, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x60, 0x00, 0x62,
  0x00, 0x0C, 0x10, 0x00, 0x81, 0x80, 0x10, 0x08, 0x03, 0x00, 0x40, 0x20,
  0x06, 0x04, 0x00, 0x30, 0xC0, 0x01, 0x18, 0x00, 0x09, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x09, 0x00, 0x01, 0x18, 0x00, 0x30,
  0xC0, 0x02, 0x04, 0x00, 0x40, 0x20, 0x0C, 0x03, 0x01, 0x80, 0x10, 0x10,
  0x00, 0x82, 0x00, 0x0C, 0x60, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x34,
  0x00, 0x02, 0x40, 0x00, 0x66, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x0C,
  0x10, 0x00, 0x81, 0x00, 0x08, 0x18, 0x01, 0x00, 0x80, 0x10, 0x08, 0x03,
  0x00, 0x40, 0x20, 0x04, 0x02, 0x00, 0x60, 0x40, 0x02, 0x04, 0x00, 0x20,
  0xC0, 0x03, 0x08, 0x00, 0x10, 0x80, 0x01, 0x18, 0x00, 0x09, 0x00, 0x00,
  0x90, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x38, 0x0F, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x70,
  0x0F, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x0E, 0x00, 0x70, 0x18,
  0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x18, 0x0F, 0x00, 0x3F, 0x80, 0x0E, 0x07, 0x00, 0xE0, 0x0F, 0x1C, 0x00,
  0x0F, 0x00,
};

const GFXglyph NotoSans_Thin46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 2, 33, 10, 4, -33 },
  { 10, 8, 12, 15, 3, -33 },
  { 22, 27, 33, 30, 1, -33 },
  { 134, 19, 38, 26, 3, -35 },
  { 225, 31, 33, 36, 3, -33 },
  { 353, 28, 33, 32, 3, -33 },
  { 469, 2, 12, 8, 3, -33 },
  { 472, 8, 40, 12, 2, -33 },
  { 512, 8, 40, 12, 2, -33 },
  { 552, 19, 19, 25, 3, -35 },
  { 598, 21, 21, 26, 3, -27 },
  { 654, 4, 11, 8, 2, -5 },
  { 660, 11, 1, 15, 2, -13 },
  { 662, 2, 2, 10, 4, -2 },
  { 663, 13, 33, 15, 1, -33 },
  { 717, 20, 33, 26, 3, -33 },
  { 800, 10, 33, 26, 5, -33 },
  { 842, 20, 33, 26, 3, -33 },
  { 925, 21, 33, 26, 2, -33 },
  { 1012, 25, 33, 26, 1, -33 },
  { 1116, 20, 33, 26, 3, -33 },
  { 1199, 21, 33, 26, 3, -33 },
  { 1286, 20, 33, 26, 3, -33 },
  { 1369, 20, 33, 26, 3, -33 },
  { 1452, 20, 34, 26, 3, -33 },
  { 1537, 2, 24, 10, 4, -24 },
  { 1543, 4, 30, 10, 2, -24 },
  { 1558, 21, 21, 26, 3, -27 },
  { 1614, 21, 10, 26, 3, -21 },
  { 1641, 21, 21, 26, 3, -27 },
  { 1697, 15, 33, 19, 2, -33 },
  { 1759, 36, 37, 40, 2, -32 },
  { 1926, 27, 33, 27, 0, -33 },
  { 2038, 21, 33, 28, 5, -33 },
  { 2125, 24, 33, 28, 3, -33 },
  { 2224, 24, 33, 32, 5, -33 },
  { 2323, 17, 33, 25, 5, -33 },
  { 2394, 18, 33, 23, 5, -33 },
  { 2469, 26, 33, 33, 3, -33 },
  { 2577, 23, 33, 32, 5, -33 },
  { 2672, 7, 33, 13, 3, -33 },
  { 2701, 11, 41, 11, -5, -33 },
  { 2758, 21, 33, 26, 5, -33 },
  { 2845, 17, 33, 23, 5, -33 },
  { 2916, 29, 33, 39, 5, -33 },
  { 3036, 22, 33, 32, 5, -33 },
  { 3127, 29, 33, 35, 3, -33 },
  { 3247, 19, 33, 26, 5, -33 },
  { 3326, 29, 41, 35, 3, -33 },
  { 3475, 20, 33, 27, 5, -33 },
  { 3558, 20, 33, 25, 3, -33 },
  { 3641, 23, 33, 23, 0, -33 },
  { 3736, 24, 33, 33, 4, -33 },
  { 3835, 26, 33, 26, 0, -33 },
  { 3943, 37, 33, 40, 2, -33 },
  { 4096, 24, 33, 23, 0, -33 },
  { 4195, 23, 33, 23, 0, -33 },
  { 4290, 23, 33, 27, 2, -33 },
  { 4385, 9, 40, 14, 4, -33 },
  { 4430, 13, 33, 15, 1, -33 },
  { 4484, 9, 40, 14, 1, -33 },
  { 4529, 22, 20, 26, 2, -33 },
  { 4584, 18, 1, 18, 0, 4 },
  { 4587, 8, 7, 11, 2, -35 },
  { 4594, 18, 25, 24, 2, -25 },
  { 4651, 20, 35, 27, 4, -35 },
  { 4739, 17, 25, 22, 3, -25 },
  { 4793, 20, 35, 27, 3, -35 },
  { 4881, 19, 25, 25, 3, -25 },
  { 4941, 16, 35, 13, 0, -35 },
  { 5011, 20, 36, 27, 3, -25 },
  { 5101, 19, 35, 26, 4, -35 },
  { 5185, 2, 33, 10, 4, -33 },
  { 5194, 8, 44, 10, -2, -33 },
  { 5238, 17, 35, 21, 4, -35 },
  { 5313, 1, 35, 10, 4, -35 },
  { 5318, 31, 25, 39, 4, -25 },
  { 5415, 19, 25, 26, 4, -25 },
  { 5475, 21, 25, 26, 3, -25 },
  { 5541, 20, 36, 27, 4, -25 },
  { 5631, 20, 36, 27, 3, -25 },
  { 5721, 13, 25, 17, 4, -25 },
  { 5762, 17, 25, 21, 2, -25 },
  { 5816, 13, 30, 15, 0, -30 },
  { 5865, 18, 24, 26, 4, -24 },
  { 5919, 20, 24, 20, 0, -24 },
  { 5979, 30, 24, 32, 1, -24 },
  { 6069, 20, 24, 22, 1, -24 },
  { 6129, 20, 35, 20, 0, -24 },
  { 6217, 17, 24, 21, 2, -24 },
  { 6268, 13, 40, 16, 1, -33 },
  { 6333, 1, 47, 25, 12, -35 },
  { 6339, 12, 40, 16, 2, -33 },
  { 6399, 21, 4, 26, 3, -18 },
};

const GFXfont NotoSans_Thin46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin46pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_THIN46PT7B_H_
