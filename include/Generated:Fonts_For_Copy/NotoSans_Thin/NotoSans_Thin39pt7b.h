#ifndef _NOTOSANS_THIN39PT7B_H_
#define _NOTOSANS_THIN39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin39pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x55, 0x40, 0x0F, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x04, 0x00, 0x40, 0x20, 0x00, 0x80, 0x40, 0x01,
  0x00, 0x80, 0x02, 0x02, 0x00, 0x04, 0x04, 0x00, 0x10, 0x08, 0x00, 0x20,
  0x10, 0x00, 0x40, 0x20, 0x00, 0x80, 0x80, 0x7F, 0xFF, 0xFC, 0x04, 0x02,
  0x00, 0x08, 0x04, 0x00, 0x10, 0x08, 0x00, 0x20, 0x10, 0x00, 0x40, 0x40,
  0x01, 0x00, 0x80, 0x02, 0x01, 0x00, 0x04, 0x02, 0x03, 0xFF, 0xFF, 0xF0,
  0x10, 0x10, 0x00, 0x40, 0x20, 0x00, 0x80, 0x40, 0x01, 0x00, 0x80, 0x02,
  0x01, 0x00, 0x04, 0x04, 0x00, 0x18, 0x08, 0x00, 0x20, 0x10, 0x00, 0x40,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x0F, 0xFC, 0x30, 0x82,
  0x20, 0x80, 0x40, 0x80, 0x40, 0x80, 0xC0, 0x80, 0x40, 0x80, 0x40, 0x80,
  0x40, 0x80, 0x20, 0x80, 0x30, 0x80, 0x0C, 0x80, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x98, 0x00, 0x86, 0x00, 0x82, 0x00, 0x81, 0x00, 0x81, 0x00, 0x81,
  0x00, 0x81, 0x00, 0x81, 0x00, 0x81, 0x00, 0x82, 0x80, 0x84, 0x7C, 0xB8,
  0x05, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x1F, 0x00, 0x0C, 0x06, 0x10, 0x01,
  0x01, 0x81, 0x00, 0x40, 0x20, 0x20, 0x08, 0x04, 0x02, 0x02, 0x01, 0x80,
  0x40, 0x40, 0x20, 0x08, 0x10, 0x04, 0x01, 0x02, 0x00, 0x80, 0x20, 0x80,
  0x10, 0x04, 0x30, 0x02, 0x00, 0x84, 0x00, 0x60, 0x11, 0x0F, 0x84, 0x06,
  0x22, 0x18, 0x80, 0x88, 0x81, 0x98, 0x11, 0x10, 0x11, 0x04, 0x44, 0x02,
  0x1F, 0x08, 0x80, 0x40, 0x02, 0x10, 0x0C, 0x00, 0xC2, 0x00, 0x80, 0x10,
  0x40, 0x10, 0x04, 0x08, 0x02, 0x00, 0x81, 0x00, 0xC0, 0x20, 0x20, 0x10,
  0x04, 0x04, 0x02, 0x01, 0x00, 0x40, 0x40, 0x20, 0x08, 0x18, 0x08, 0x00,
  0x82, 0x03, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x06, 0x04, 0x00, 0x08,
  0x02, 0x00, 0x08, 0x01, 0x00, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x18,
  0x01, 0x00, 0x08, 0x03, 0x00, 0x08, 0x02, 0x00, 0x04, 0x04, 0x00, 0x02,
  0x08, 0x00, 0x03, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x0C,
  0x60, 0x00, 0x10, 0x30, 0x02, 0x20, 0x18, 0x02, 0x40, 0x0C, 0x02, 0x40,
  0x06, 0x04, 0x40, 0x03, 0x04, 0xC0, 0x01, 0x88, 0xC0, 0x00, 0xD8, 0x40,
  0x00, 0x70, 0x40, 0x00, 0x30, 0x40, 0x00, 0x58, 0x20, 0x00, 0x8C, 0x18,
  0x03, 0x06, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x06, 0x10, 0x20, 0x83, 0x04,
  0x08, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0xC0, 0x81, 0x03, 0x02, 0x04, 0x04, 0x0C, 0x08,
  0x0C, 0xC0, 0xC0, 0x80, 0x81, 0x81, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08,
  0x10, 0x60, 0x81, 0x04, 0x18, 0x21, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x03, 0x82, 0x0E, 0x39, 0x3C,
  0x03, 0xE0, 0x00, 0x60, 0x00, 0x50, 0x00, 0x44, 0x00, 0x61, 0x00, 0x20,
  0xC0, 0x20, 0x20, 0x30, 0x08, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x3F, 0xFF, 0xF0, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x13, 0x32,
  0x22, 0x64, 0x4C, 0xFF, 0x80, 0xF0, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0x03, 0xF8, 0x03, 0x01, 0x01, 0x00, 0x20, 0x40, 0x04, 0x20, 0x01, 0x08,
  0x00, 0x24, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x90, 0x00, 0x24, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x50, 0x00, 0x14, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x90,
  0x00, 0x22, 0x00, 0x08, 0x80, 0x04, 0x30, 0x01, 0x04, 0x00, 0x80, 0xC0,
  0x40, 0x1F, 0xE0, 0x01, 0x03, 0x0D, 0x19, 0x21, 0xC1, 0x81, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x07, 0xF0, 0x1C, 0x06, 0x18,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xF8, 0x18, 0x06, 0x30,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x7F,
  0x00, 0x00, 0x70, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x30, 0x03, 0x07, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x28,
  0x00, 0x01, 0x40, 0x00, 0x12, 0x00, 0x01, 0x10, 0x00, 0x18, 0x80, 0x00,
  0x84, 0x00, 0x08, 0x20, 0x00, 0x81, 0x00, 0x0C, 0x08, 0x00, 0x40, 0x40,
  0x04, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x04, 0x02, 0x00,
  0x20, 0x30, 0x01, 0x01, 0x00, 0x08, 0x10, 0x00, 0x41, 0xFF, 0xFF, 0xF0,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x3F, 0xFE, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x78, 0x07, 0xC7,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x03, 0x30, 0x06, 0x0F, 0xFE, 0x00, 0x01, 0xFE, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0xFE, 0x09, 0x80,
  0xC5, 0x80, 0x13, 0x00, 0x05, 0x80, 0x02, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x05, 0x00, 0x02, 0x80, 0x02,
  0x20, 0x01, 0x18, 0x01, 0x06, 0x01, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x07, 0xF8, 0x02, 0x01, 0x81, 0x00, 0x30, 0x80, 0x04, 0x20, 0x01, 0x90,
  0x00, 0x24, 0x00, 0x09, 0x80, 0x06, 0x20, 0x01, 0x0C, 0x00, 0xC1, 0x80,
  0x60, 0x30, 0x20, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x61, 0x80, 0x60, 0x18,
  0x30, 0x01, 0x18, 0x00, 0x64, 0x00, 0x09, 0x00, 0x02, 0xC0, 0x00, 0x50,
  0x00, 0x14, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x88, 0x00, 0x41, 0x80,
  0x60, 0x1F, 0xE0, 0x07, 0xF0, 0x06, 0x03, 0x02, 0x00, 0x61, 0x80, 0x08,
  0x40, 0x01, 0x10, 0x00, 0x48, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xA0,
  0x00, 0x28, 0x00, 0x0B, 0x00, 0x03, 0x40, 0x01, 0x90, 0x00, 0x62, 0x00,
  0x28, 0x60, 0x32, 0x0F, 0xF0, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x03, 0x00, 0xFF, 0x80, 0x74, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x13, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x13, 0x32, 0x22, 0x64,
  0x4C, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x10, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xC3, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x30,
  0x04, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x02, 0x20, 0x03, 0xE0, 0x09, 0x80, 0x30, 0x60, 0x34, 0x01,
  0x00, 0x80, 0x50, 0x08, 0x02, 0x01, 0xC0, 0x40, 0x08, 0x06, 0x01, 0x00,
  0x20, 0x18, 0x08, 0x00, 0x80, 0x60, 0x20, 0x02, 0x01, 0x80, 0x80, 0x08,
  0x06, 0x02, 0x00, 0x20, 0x18, 0x08, 0x00, 0x80, 0x60, 0x20, 0x06, 0x02,
  0x80, 0x40, 0x18, 0x09, 0x01, 0x00, 0xA0, 0x44, 0x03, 0x0C, 0x63, 0x10,
  0x03, 0xC0, 0xF0, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x40, 0x00, 0x04, 0x40, 0x00,
  0x08, 0x80, 0x00, 0x31, 0x00, 0x00, 0x41, 0x00, 0x00, 0x82, 0x00, 0x02,
  0x06, 0x00, 0x04, 0x04, 0x00, 0x18, 0x08, 0x00, 0x20, 0x08, 0x00, 0x40,
  0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x07, 0xFF, 0xC0, 0x10, 0x00,
  0xC0, 0x20, 0x00, 0x80, 0x80, 0x01, 0x01, 0x00, 0x01, 0x02, 0x00, 0x02,
  0x08, 0x00, 0x04, 0x10, 0x00, 0x04, 0x40, 0x00, 0x08, 0x80, 0x00, 0x19,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x30, 0xFF, 0xE0, 0x20, 0x07, 0x08, 0x00,
  0x32, 0x00, 0x04, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x02,
  0x80, 0x00, 0xA0, 0x00, 0x68, 0x00, 0x12, 0x00, 0x08, 0x80, 0x1C, 0x3F,
  0xFE, 0x08, 0x00, 0x62, 0x00, 0x04, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0A, 0x00, 0x02,
  0x80, 0x01, 0xA0, 0x00, 0xC8, 0x00, 0xC3, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x0C, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x04, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x08, 0x01, 0xC0, 0x80, 0x03, 0x08, 0x00, 0x18, 0x80, 0x00, 0xC8,
  0x00, 0x06, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x48, 0x00, 0x0C, 0x80,
  0x01, 0x88, 0x00, 0x30, 0x80, 0x1C, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x1F, 0xFF, 0xA0,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x07,
  0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x3F, 0xFF, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0x00,
  0x1C, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0x40, 0x00, 0x02, 0x80, 0x00, 0x05, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x16, 0x00, 0x00, 0x24, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x88, 0x00, 0x01, 0x08, 0x00, 0x02, 0x0C, 0x00, 0x04, 0x0E, 0x00,
  0x18, 0x07, 0xFF, 0xC0, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x47, 0xF0, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x03, 0x01, 0x43, 0x1E, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x48,
  0x00, 0x22, 0x00, 0x10, 0x80, 0x08, 0x20, 0x04, 0x08, 0x02, 0x02, 0x01,
  0x00, 0x80, 0x80, 0x20, 0x40, 0x08, 0x20, 0x02, 0x10, 0x00, 0x8C, 0x00,
  0x24, 0x80, 0x0A, 0x10, 0x03, 0x06, 0x00, 0x80, 0x80, 0x20, 0x10, 0x08,
  0x06, 0x02, 0x00, 0xC0, 0x80, 0x10, 0x20, 0x02, 0x08, 0x00, 0xC2, 0x00,
  0x10, 0x80, 0x02, 0x20, 0x00, 0x48, 0x00, 0x1A, 0x00, 0x03, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x07, 0xFF, 0xF0, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xB4, 0x00, 0x00, 0x5A, 0x00, 0x00, 0x4C, 0x80, 0x00, 0x26, 0x40, 0x00,
  0x33, 0x10, 0x00, 0x11, 0x88, 0x00, 0x08, 0xC4, 0x00, 0x08, 0x61, 0x00,
  0x04, 0x30, 0x80, 0x04, 0x18, 0x20, 0x02, 0x0C, 0x10, 0x01, 0x06, 0x0C,
  0x01, 0x03, 0x02, 0x00, 0x81, 0x81, 0x00, 0x80, 0xC0, 0x40, 0x40, 0x60,
  0x20, 0x60, 0x30, 0x18, 0x20, 0x18, 0x04, 0x10, 0x0C, 0x02, 0x10, 0x06,
  0x00, 0x88, 0x03, 0x00, 0x4C, 0x01, 0x80, 0x34, 0x00, 0xC0, 0x0A, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x01, 0x00, 0x10, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xD0, 0x00, 0x1B, 0x00, 0x03, 0x20, 0x00, 0x62, 0x00, 0x0C,
  0x60, 0x01, 0x84, 0x00, 0x30, 0x40, 0x06, 0x04, 0x00, 0xC0, 0xC0, 0x18,
  0x08, 0x03, 0x00, 0x80, 0x60, 0x18, 0x0C, 0x01, 0x01, 0x80, 0x10, 0x30,
  0x03, 0x06, 0x00, 0x20, 0xC0, 0x02, 0x18, 0x00, 0x63, 0x00, 0x04, 0x60,
  0x00, 0x4C, 0x00, 0x0D, 0x80, 0x00, 0xB0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x10, 0x00, 0xFF, 0xC0, 0x01, 0x80, 0x38, 0x01, 0x00, 0x06, 0x01,
  0x00, 0x01, 0x81, 0x00, 0x00, 0x61, 0x80, 0x00, 0x10, 0x80, 0x00, 0x0C,
  0xC0, 0x00, 0x02, 0x40, 0x00, 0x01, 0x20, 0x00, 0x00, 0x90, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x50, 0x00,
  0x00, 0x48, 0x00, 0x00, 0x26, 0x00, 0x00, 0x11, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x08, 0x20, 0x00, 0x08, 0x08, 0x00, 0x0C, 0x02, 0x00, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x80, 0x38, 0x80, 0x04,
  0x80, 0x02, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x18,
  0xFF, 0xE0, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0x80, 0x38, 0x01, 0x00, 0x06, 0x01,
  0x00, 0x01, 0x81, 0x00, 0x00, 0x61, 0x80, 0x00, 0x10, 0x80, 0x00, 0x0C,
  0xC0, 0x00, 0x02, 0x40, 0x00, 0x01, 0x20, 0x00, 0x00, 0x90, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x50, 0x00,
  0x00, 0x48, 0x00, 0x00, 0x26, 0x00, 0x00, 0x11, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x08, 0x20, 0x00, 0x0C, 0x08, 0x00, 0x0C, 0x02, 0x00, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0xFF, 0xC0, 0x40, 0x1C, 0x20, 0x01, 0x90, 0x00,
  0x48, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40,
  0x00, 0xA0, 0x00, 0x50, 0x00, 0x48, 0x00, 0x64, 0x00, 0x62, 0x03, 0xC1,
  0xFF, 0x80, 0x80, 0x60, 0x40, 0x10, 0x20, 0x04, 0x10, 0x02, 0x08, 0x00,
  0x84, 0x00, 0x62, 0x00, 0x11, 0x00, 0x04, 0x80, 0x02, 0x40, 0x00, 0xA0,
  0x00, 0x70, 0x00, 0x10, 0x07, 0xFE, 0x0C, 0x01, 0x88, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x20,
  0x03, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x24,
  0x00, 0x02, 0x60, 0x00, 0x43, 0x00, 0x0C, 0x18, 0x01, 0x00, 0x7F, 0xE0,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x24, 0x00, 0x00, 0x90, 0x00, 0x02, 0x20,
  0x00, 0x10, 0x80, 0x00, 0x42, 0x00, 0x03, 0x04, 0x00, 0x08, 0x10, 0x00,
  0x20, 0x20, 0x01, 0x00, 0x80, 0x04, 0x02, 0x00, 0x10, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x60, 0x18, 0x00, 0x80, 0x40, 0x02, 0x01, 0x00, 0x04,
  0x08, 0x00, 0x10, 0x20, 0x00, 0x40, 0x80, 0x00, 0x84, 0x00, 0x02, 0x10,
  0x00, 0x0C, 0xC0, 0x00, 0x12, 0x00, 0x00, 0x48, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x01, 0x00, 0x01, 0x40, 0x01, 0x80,
  0x02, 0x40, 0x01, 0x80, 0x02, 0x40, 0x02, 0x80, 0x02, 0x60, 0x02, 0x40,
  0x06, 0x20, 0x02, 0x40, 0x04, 0x20, 0x02, 0x40, 0x04, 0x20, 0x04, 0x40,
  0x04, 0x10, 0x04, 0x20, 0x08, 0x10, 0x04, 0x20, 0x08, 0x10, 0x04, 0x20,
  0x08, 0x10, 0x08, 0x30, 0x18, 0x08, 0x08, 0x10, 0x10, 0x08, 0x08, 0x10,
  0x10, 0x08, 0x10, 0x10, 0x10, 0x0C, 0x10, 0x08, 0x20, 0x04, 0x10, 0x08,
  0x20, 0x04, 0x10, 0x08, 0x20, 0x04, 0x20, 0x08, 0x60, 0x02, 0x20, 0x04,
  0x40, 0x02, 0x20, 0x04, 0x40, 0x02, 0x20, 0x04, 0x40, 0x02, 0x40, 0x02,
  0xC0, 0x01, 0x40, 0x02, 0x80, 0x01, 0x40, 0x02, 0x80, 0x01, 0xC0, 0x02,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x00, 0x80, 0x01, 0x00, 0x40, 0x00, 0x22,
  0x00, 0x04, 0x30, 0x00, 0x41, 0x00, 0x08, 0x08, 0x01, 0x80, 0x80, 0x10,
  0x04, 0x02, 0x00, 0x60, 0x60, 0x02, 0x04, 0x00, 0x10, 0x80, 0x01, 0x98,
  0x00, 0x09, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x09,
  0x00, 0x01, 0x98, 0x00, 0x10, 0x80, 0x02, 0x04, 0x00, 0x60, 0x60, 0x04,
  0x02, 0x00, 0x80, 0x10, 0x18, 0x01, 0x01, 0x00, 0x08, 0x20, 0x00, 0x42,
  0x00, 0x04, 0x40, 0x00, 0x28, 0x00, 0x03, 0x80, 0x00, 0x34, 0x00, 0x02,
  0x40, 0x00, 0x42, 0x00, 0x04, 0x30, 0x00, 0x81, 0x00, 0x08, 0x18, 0x01,
  0x00, 0x80, 0x10, 0x04, 0x02, 0x00, 0x40, 0x60, 0x02, 0x04, 0x00, 0x20,
  0xC0, 0x01, 0x08, 0x00, 0x11, 0x00, 0x00, 0x90, 0x00, 0x0A, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0xFF, 0xC0, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0xFF, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0xFF, 0x00, 0x40, 0x00, 0x28, 0x00, 0x0A, 0x00,
  0x04, 0x40, 0x01, 0x10, 0x00, 0x86, 0x00, 0x60, 0x80, 0x10, 0x30, 0x0C,
  0x04, 0x02, 0x01, 0x81, 0x00, 0x20, 0x40, 0x0C, 0x20, 0x01, 0x08, 0x00,
  0x64, 0x00, 0x09, 0x00, 0x03, 0x80, 0x00, 0x40, 0xFF, 0xFE, 0x83, 0x06,
  0x0C, 0x10, 0x30, 0x07, 0xE0, 0x70, 0x30, 0x80, 0x30, 0x00, 0x20, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x7C, 0x3F, 0x09,
  0x80, 0x16, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x17, 0x00, 0x2B, 0x01, 0x93, 0xFC, 0x20, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x41, 0xF8, 0x23, 0x03, 0x12, 0x00, 0x4A, 0x00, 0x15, 0x00,
  0x0B, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xA8, 0x00, 0x56, 0x00, 0x49, 0x80, 0xC4, 0x3F, 0xC0, 0x01,
  0xFC, 0x0C, 0x04, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60,
  0x10, 0x7F, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x81, 0xF8,
  0x43, 0x03, 0x22, 0x00, 0x52, 0x00, 0x19, 0x00, 0x0D, 0x00, 0x02, 0x80,
  0x01, 0x40, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0xC8, 0x00,
  0x66, 0x00, 0x51, 0x80, 0x48, 0x3F, 0xC4, 0x03, 0xF0, 0x06, 0x06, 0x06,
  0x01, 0x86, 0x00, 0x42, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x20, 0x7F, 0xE0, 0x00, 0xF8, 0x18, 0x41, 0x00, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x07, 0xFE, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x03, 0xF0, 0x86, 0x06, 0x44, 0x00, 0xA4,
  0x00, 0x32, 0x00, 0x1A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x05, 0x00,
  0x02, 0x80, 0x01, 0x40, 0x01, 0x90, 0x00, 0xCC, 0x00, 0xA3, 0x00, 0x90,
  0x7F, 0x88, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x66, 0x00, 0x60, 0xFF, 0xC0, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x0F, 0xC2, 0x60, 0x65, 0x00, 0x6C, 0x00, 0x58, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0xF0, 0x01, 0x55, 0x55, 0x55, 0x55,
  0x55, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x2F, 0x80, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x28, 0x01, 0x20, 0x08, 0x80, 0x42, 0x02, 0x08, 0x18,
  0x20, 0xC0, 0x86, 0x02, 0x10, 0x08, 0x80, 0x25, 0x00, 0xA2, 0x03, 0x0C,
  0x08, 0x10, 0x20, 0x20, 0x80, 0x42, 0x01, 0x88, 0x02, 0x20, 0x04, 0x80,
  0x0A, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0x8F, 0xC0, 0x7E, 0x24, 0x18,
  0x60, 0xCA, 0x01, 0x20, 0x0B, 0x00, 0x30, 0x02, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x06, 0x00, 0x20, 0x01, 0x80, 0x08, 0x00,
  0x60, 0x02, 0x00, 0x18, 0x00, 0x80, 0x06, 0x00, 0x20, 0x01, 0x80, 0x08,
  0x00, 0x60, 0x02, 0x00, 0x18, 0x00, 0x80, 0x06, 0x00, 0x20, 0x01, 0x80,
  0x08, 0x00, 0x60, 0x02, 0x00, 0x18, 0x00, 0x80, 0x06, 0x00, 0x20, 0x01,
  0x80, 0x08, 0x00, 0x40, 0x87, 0xE1, 0x30, 0x32, 0x80, 0x36, 0x00, 0x28,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x03, 0xF8, 0x03, 0x03,
  0x81, 0x80, 0x30, 0xC0, 0x04, 0x20, 0x00, 0x90, 0x00, 0x24, 0x00, 0x0D,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x14, 0x00, 0x05, 0x00, 0x02, 0x60, 0x00, 0x88, 0x00,
  0x41, 0x00, 0x30, 0x20, 0x18, 0x07, 0xF8, 0x00, 0x87, 0xE0, 0x4C, 0x0C,
  0x2C, 0x01, 0x1C, 0x00, 0x4C, 0x00, 0x24, 0x00, 0x0A, 0x00, 0x05, 0x00,
  0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x28, 0x00, 0x14,
  0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0xC0, 0x02, 0x60, 0x01, 0x28, 0x01,
  0x16, 0x01, 0x08, 0xFF, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x00,
  0x03, 0xF0, 0x86, 0x06, 0x44, 0x00, 0xA4, 0x00, 0x76, 0x00, 0x1A, 0x00,
  0x0D, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x02, 0x80, 0x03, 0x40, 0x01,
  0xB0, 0x00, 0xC8, 0x00, 0xA3, 0x01, 0x90, 0xFF, 0x88, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x8F, 0xE6, 0x0A, 0x03, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x0F, 0xE0, 0xC0, 0x74, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0xA0, 0x06, 0x7F, 0xE0, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x81, 0xFF, 0xC2, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x0C, 0x00, 0xFC, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x03, 0xC0, 0x03, 0x40, 0x05, 0x60, 0x05, 0x30, 0x19,
  0x1F, 0xE1, 0x80, 0x00, 0xC0, 0x00, 0x90, 0x00, 0x48, 0x00, 0x22, 0x00,
  0x21, 0x00, 0x10, 0x80, 0x10, 0x20, 0x08, 0x10, 0x04, 0x04, 0x04, 0x02,
  0x02, 0x01, 0x03, 0x00, 0x41, 0x00, 0x20, 0x80, 0x10, 0x80, 0x04, 0x40,
  0x02, 0x20, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x30, 0x00, 0x08, 0x00, 0x80,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x28, 0x02, 0x80, 0x24,
  0x01, 0x40, 0x12, 0x00, 0x90, 0x09, 0x00, 0x88, 0x08, 0x40, 0x44, 0x04,
  0x20, 0x21, 0x02, 0x10, 0x20, 0x81, 0x04, 0x10, 0x41, 0x02, 0x08, 0x10,
  0x81, 0x08, 0x08, 0x40, 0x84, 0x04, 0x20, 0x22, 0x01, 0x20, 0x12, 0x00,
  0x90, 0x09, 0x00, 0x48, 0x02, 0x80, 0x14, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x01, 0x00, 0xC0, 0x01, 0x20, 0x01, 0x08, 0x01, 0x82,
  0x00, 0x81, 0x80, 0x80, 0x40, 0x80, 0x10, 0xC0, 0x0C, 0x40, 0x02, 0x40,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x24, 0x00, 0x31, 0x00, 0x10,
  0x40, 0x10, 0x30, 0x10, 0x08, 0x18, 0x02, 0x08, 0x01, 0x88, 0x00, 0x4C,
  0x00, 0x18, 0x80, 0x00, 0xC0, 0x00, 0x90, 0x00, 0x48, 0x00, 0x22, 0x00,
  0x21, 0x00, 0x10, 0x80, 0x10, 0x20, 0x08, 0x10, 0x04, 0x0C, 0x04, 0x02,
  0x02, 0x01, 0x02, 0x00, 0x41, 0x00, 0x20, 0x80, 0x10, 0x80, 0x04, 0x40,
  0x02, 0x20, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x07, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x00, 0xFF, 0xFC, 0x00, 0xE0, 0x60, 0x10, 0x02,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0xC0, 0x70, 0x1C, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0x00, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x18, 0x01, 0xC0, 0x1C,
  0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x08, 0x1E, 0x00, 0x7F, 0x80,
  0x60, 0x18, 0x38, 0x01, 0xF0,
};

const GFXglyph NotoSans_Thin39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 28, 9, 3, -28 },
  { 8, 7, 10, 12, 3, -28 },
  { 17, 23, 28, 25, 1, -28 },
  { 98, 16, 32, 22, 2, -30 },
  { 162, 27, 28, 31, 2, -28 },
  { 257, 24, 28, 27, 2, -28 },
  { 341, 1, 10, 7, 3, -28 },
  { 343, 7, 34, 10, 2, -28 },
  { 373, 7, 34, 10, 1, -28 },
  { 403, 17, 16, 21, 2, -30 },
  { 437, 18, 18, 22, 2, -23 },
  { 478, 4, 10, 7, 1, -5 },
  { 483, 9, 1, 13, 2, -11 },
  { 485, 2, 2, 9, 3, -2 },
  { 486, 12, 28, 13, 0, -28 },
  { 528, 18, 28, 22, 2, -28 },
  { 591, 8, 28, 22, 4, -28 },
  { 619, 17, 28, 22, 2, -28 },
  { 679, 17, 28, 22, 2, -28 },
  { 739, 21, 28, 22, 1, -28 },
  { 813, 17, 28, 22, 3, -28 },
  { 873, 17, 28, 22, 3, -28 },
  { 933, 18, 28, 22, 2, -28 },
  { 996, 18, 28, 22, 2, -28 },
  { 1059, 18, 28, 22, 2, -28 },
  { 1122, 2, 21, 9, 3, -21 },
  { 1128, 4, 26, 9, 1, -21 },
  { 1141, 18, 18, 22, 2, -23 },
  { 1182, 18, 9, 22, 2, -18 },
  { 1203, 18, 18, 22, 2, -23 },
  { 1244, 14, 28, 16, 1, -28 },
  { 1293, 30, 32, 34, 2, -28 },
  { 1413, 23, 28, 23, 0, -28 },
  { 1494, 18, 28, 24, 4, -28 },
  { 1557, 21, 28, 24, 2, -28 },
  { 1631, 20, 28, 27, 4, -28 },
  { 1701, 15, 28, 21, 4, -28 },
  { 1754, 15, 28, 19, 4, -28 },
  { 1807, 23, 28, 28, 2, -28 },
  { 1888, 20, 28, 28, 4, -28 },
  { 1958, 7, 28, 11, 2, -28 },
  { 1983, 9, 35, 9, -4, -28 },
  { 2023, 18, 28, 22, 4, -28 },
  { 2086, 15, 28, 20, 4, -28 },
  { 2139, 25, 28, 33, 4, -28 },
  { 2227, 19, 28, 27, 4, -28 },
  { 2294, 25, 28, 29, 2, -28 },
  { 2382, 16, 28, 22, 4, -28 },
  { 2438, 25, 35, 29, 2, -28 },
  { 2548, 17, 28, 23, 4, -28 },
  { 2608, 17, 28, 21, 2, -28 },
  { 2668, 20, 28, 20, 0, -28 },
  { 2738, 20, 28, 28, 4, -28 },
  { 2808, 22, 28, 22, 0, -28 },
  { 2885, 32, 28, 34, 1, -28 },
  { 2997, 20, 28, 20, 0, -28 },
  { 3067, 20, 28, 20, 0, -28 },
  { 3137, 20, 28, 23, 1, -28 },
  { 3207, 8, 34, 12, 3, -28 },
  { 3241, 12, 28, 13, 0, -28 },
  { 3283, 8, 34, 12, 1, -28 },
  { 3317, 18, 17, 22, 2, -28 },
  { 3356, 15, 1, 15, 0, 4 },
  { 3358, 6, 6, 10, 2, -30 },
  { 3363, 15, 21, 20, 2, -21 },
  { 3403, 17, 30, 23, 3, -30 },
  { 3467, 15, 21, 18, 2, -21 },
  { 3507, 17, 30, 23, 2, -30 },
  { 3571, 17, 21, 21, 2, -21 },
  { 3616, 13, 30, 11, 0, -30 },
  { 3665, 17, 30, 23, 2, -21 },
  { 3729, 15, 30, 22, 4, -30 },
  { 3786, 2, 28, 8, 3, -28 },
  { 3793, 7, 37, 8, -2, -28 },
  { 3826, 14, 30, 18, 4, -30 },
  { 3879, 1, 30, 8, 4, -30 },
  { 3883, 26, 21, 33, 4, -21 },
  { 3952, 15, 21, 22, 4, -21 },
  { 3992, 18, 21, 22, 2, -21 },
  { 4040, 17, 30, 23, 4, -21 },
  { 4104, 17, 30, 23, 2, -21 },
  { 4168, 10, 21, 15, 4, -21 },
  { 4195, 14, 21, 18, 2, -21 },
  { 4232, 11, 26, 12, 0, -26 },
  { 4268, 16, 21, 22, 3, -21 },
  { 4310, 17, 21, 17, 0, -21 },
  { 4355, 25, 21, 27, 1, -21 },
  { 4421, 17, 21, 19, 1, -21 },
  { 4466, 17, 30, 17, 0, -21 },
  { 4530, 14, 21, 18, 2, -21 },
  { 4567, 11, 34, 13, 1, -28 },
  { 4614, 1, 40, 21, 10, -30 },
  { 4619, 11, 34, 13, 1, -28 },
  { 4666, 18, 3, 22, 2, -15 },
};

const GFXfont NotoSans_Thin39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin39pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_THIN39PT7B_H_
