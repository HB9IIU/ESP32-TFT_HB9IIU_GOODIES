#ifndef _NOTOSANS_THIN51PT7B_H_
#define _NOTOSANS_THIN51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin51pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x00,
  0x00, 0x0F, 0xF0, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x02,
  0x81, 0x40, 0xA0, 0x50, 0x28, 0x10, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x10,
  0x01, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x80,
  0x10, 0x00, 0x03, 0x00, 0x20, 0x00, 0x06, 0x00, 0x40, 0x00, 0x08, 0x01,
  0x80, 0x00, 0x10, 0x03, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0xC0, 0x08,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x20, 0x00, 0x04, 0x00, 0xC0,
  0x00, 0x08, 0x01, 0x00, 0x00, 0x10, 0x02, 0x00, 0x00, 0x60, 0x04, 0x00,
  0x00, 0x80, 0x08, 0x00, 0x01, 0x00, 0x30, 0x00, 0x02, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x80, 0x00, 0x18, 0x01, 0x00, 0x00, 0x20, 0x02, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0x80, 0x18, 0x00, 0x01, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x10, 0x03, 0x00, 0x00, 0x20,
  0x06, 0x00, 0x00, 0x40, 0x08, 0x00, 0x01, 0x80, 0x10, 0x00, 0x03, 0x00,
  0x20, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x08, 0x01, 0x80, 0x00, 0x10, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFC,
  0x00, 0x7A, 0xFC, 0x0C, 0x10, 0x30, 0xC0, 0x80, 0x0C, 0x04, 0x00, 0x40,
  0x20, 0x06, 0x01, 0x00, 0x30, 0x08, 0x01, 0x80, 0x40, 0x0C, 0x02, 0x00,
  0x60, 0x10, 0x01, 0x00, 0x80, 0x0C, 0x04, 0x00, 0x30, 0x20, 0x00, 0xC1,
  0x00, 0x03, 0x88, 0x00, 0x07, 0x40, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x8E, 0x00, 0x04, 0x18, 0x00, 0x20, 0x60, 0x01, 0x01, 0x80, 0x08,
  0x04, 0x00, 0x40, 0x30, 0x02, 0x01, 0x80, 0x10, 0x04, 0x00, 0x80, 0x60,
  0x04, 0x03, 0x00, 0x20, 0x18, 0x01, 0x00, 0x80, 0x08, 0x0C, 0x00, 0x40,
  0xCF, 0x02, 0x1C, 0x1F, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x0C, 0x03, 0x03, 0x00, 0x02, 0x00, 0x80, 0x60, 0x01, 0x00, 0x60, 0x08,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0x20, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x30, 0x04, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x20, 0x01, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x60, 0x02, 0x00, 0x10, 0x10, 0x00, 0x80, 0x04, 0x08, 0x00,
  0x20, 0x01, 0x06, 0x00, 0x0C, 0x00, 0xC1, 0x00, 0x03, 0x00, 0x30, 0xC3,
  0xF8, 0xC0, 0x0C, 0x21, 0x83, 0x10, 0x02, 0x18, 0xC0, 0x66, 0x01, 0x84,
  0x20, 0x09, 0x80, 0x43, 0x18, 0x03, 0x30, 0x30, 0x84, 0x00, 0xC7, 0x38,
  0x41, 0x00, 0x10, 0x78, 0x30, 0x40, 0x04, 0x00, 0x08, 0x10, 0x01, 0x00,
  0x06, 0x0C, 0x00, 0x40, 0x01, 0x03, 0x00, 0x10, 0x00, 0xC0, 0xC0, 0x04,
  0x00, 0x20, 0x30, 0x01, 0x00, 0x18, 0x04, 0x00, 0x40, 0x04, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x40, 0x04, 0x01, 0x80, 0x10, 0x03, 0x00, 0x40, 0x06,
  0x00, 0xC0, 0x30, 0x00, 0x80, 0x20, 0x08, 0x00, 0x30, 0x18, 0x06, 0x00,
  0x06, 0x0C, 0x03, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30,
  0x01, 0x00, 0x00, 0x40, 0x03, 0x00, 0x01, 0x80, 0x02, 0x00, 0x03, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x30, 0x01, 0x00, 0x00, 0x20, 0x06,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x60, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x46, 0x00, 0x60, 0x01,
  0x88, 0x00, 0x60, 0x02, 0x30, 0x00, 0x60, 0x04, 0x40, 0x00, 0x60, 0x19,
  0x80, 0x00, 0x60, 0x23, 0x00, 0x00, 0x60, 0xC6, 0x00, 0x00, 0x61, 0x0C,
  0x00, 0x00, 0x66, 0x18, 0x00, 0x00, 0x78, 0x30, 0x00, 0x00, 0x60, 0x20,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x06, 0x60, 0x60, 0x00, 0x18, 0x60, 0x60,
  0x00, 0x60, 0x60, 0x70, 0x03, 0x00, 0x60, 0x3F, 0xF8, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0x81, 0x81, 0x80, 0x80, 0xC0, 0x40,
  0x60, 0x20, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x04, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x00, 0xC0,
  0x20, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0xC0, 0x30, 0x0C, 0x02, 0x01,
  0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0x80, 0x60, 0x30, 0x08, 0x04,
  0x02, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x01, 0x80, 0x80,
  0x40, 0x60, 0x20, 0x30, 0x30, 0x10, 0x18, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x20, 0x08, 0x02, 0xF0, 0x20, 0x3C, 0x78, 0x87,
  0x80, 0x3E, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x20, 0x00,
  0x08, 0x40, 0x00, 0x61, 0x80, 0x01, 0x02, 0x00, 0x08, 0x04, 0x00, 0x60,
  0x18, 0x03, 0x00, 0x30, 0x08, 0x00, 0x80, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x11, 0x33, 0x32, 0x26, 0x44, 0x48, 0x80, 0xFF,
  0xF0, 0x7F, 0x80, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x07, 0x87, 0x00, 0x18, 0x03, 0x00, 0x60, 0x01, 0x01, 0x80,
  0x01, 0x02, 0x00, 0x03, 0x0C, 0x00, 0x02, 0x10, 0x00, 0x04, 0x60, 0x00,
  0x0C, 0xC0, 0x00, 0x09, 0x00, 0x00, 0x12, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x58, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x80,
  0x00, 0x09, 0x00, 0x00, 0x12, 0x00, 0x00, 0x26, 0x00, 0x00, 0xC4, 0x00,
  0x01, 0x08, 0x00, 0x02, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x10, 0x10, 0x00,
  0x60, 0x30, 0x01, 0x80, 0x38, 0x0E, 0x00, 0x1F, 0xF0, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x3C, 0x0C, 0x83, 0x11, 0xC2, 0x60, 0x78, 0x0A, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x01, 0xFC, 0x00, 0x3E, 0x1C, 0x01, 0x80, 0x18, 0x18,
  0x00, 0x10, 0x40, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00,
  0x0F, 0x8F, 0x80, 0x70, 0x01, 0x83, 0x80, 0x00, 0x84, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x07, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x33, 0x00,
  0x00, 0xC3, 0xC0, 0x07, 0x01, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0x18, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x41, 0x80, 0x00, 0x08,
  0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x18, 0x00, 0x02, 0x01, 0x80,
  0x00, 0x40, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x10,
  0x01, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x18,
  0x00, 0x80, 0x01, 0x80, 0x18, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x20,
  0x00, 0x18, 0x04, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0xF0,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x3F, 0x00, 0x1F, 0xFF, 0xC0, 0x20, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x62, 0x00, 0x03, 0x0F, 0x00, 0x38, 0x0F, 0xFF, 0x80,
  0x00, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x30, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0xFF,
  0xC0, 0x47, 0x80, 0xE0, 0x98, 0x00, 0x61, 0x60, 0x00, 0x67, 0x80, 0x00,
  0x6E, 0x00, 0x00, 0x5C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xA0, 0x00, 0x01,
  0x40, 0x00, 0x02, 0x80, 0x00, 0x05, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x24, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x08, 0x00, 0x02, 0x18,
  0x00, 0x0C, 0x10, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x18, 0x07, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x07, 0x8F, 0x80, 0x30, 0x01, 0x80, 0xC0, 0x01,
  0x83, 0x00, 0x01, 0x84, 0x00, 0x01, 0x08, 0x00, 0x02, 0x30, 0x00, 0x04,
  0x60, 0x00, 0x08, 0xC0, 0x00, 0x10, 0x80, 0x00, 0x21, 0x00, 0x00, 0xC3,
  0x00, 0x01, 0x03, 0x00, 0x06, 0x03, 0x00, 0x30, 0x03, 0x80, 0xC0, 0x01,
  0xE6, 0x00, 0x00, 0x70, 0x00, 0x07, 0xBC, 0x00, 0x38, 0x0E, 0x00, 0xC0,
  0x06, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x06, 0x40, 0x00,
  0x04, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xD0, 0x00, 0x01, 0x20, 0x00, 0x02, 0x60, 0x00, 0x0C,
  0x60, 0x00, 0x30, 0x60, 0x00, 0xC0, 0x70, 0x07, 0x00, 0x3F, 0xF8, 0x00,
  0x02, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0x1E, 0x00, 0x30, 0x07, 0x00,
  0x80, 0x03, 0x02, 0x00, 0x03, 0x0C, 0x00, 0x02, 0x10, 0x00, 0x06, 0x60,
  0x00, 0x04, 0xC0, 0x00, 0x09, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x28, 0x00, 0x00, 0x50, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x60, 0x00,
  0x07, 0x40, 0x00, 0x0C, 0x80, 0x00, 0x39, 0x80, 0x00, 0x51, 0x80, 0x03,
  0x21, 0x80, 0x0C, 0x41, 0xE1, 0xF0, 0x80, 0x7F, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x03, 0xFF,
  0x80, 0x00, 0xF0, 0x00, 0x00, 0x7D, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x19, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x46, 0x31, 0x88, 0x46, 0x21, 0x08,
  0x84, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x3E, 0x3C, 0x30, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00,
  0x08, 0x18, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x00, 0x10, 0xC0,
  0x00, 0xFE, 0x00, 0x33, 0x00, 0x07, 0xFF, 0x80, 0x26, 0x00, 0x30, 0x02,
  0x00, 0x48, 0x00, 0xC0, 0x04, 0x00, 0xF0, 0x03, 0x00, 0x08, 0x01, 0xE0,
  0x04, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0x20, 0x03, 0x00, 0x20, 0x00,
  0x40, 0x06, 0x00, 0xC0, 0x00, 0x80, 0x0C, 0x01, 0x80, 0x01, 0x00, 0x18,
  0x03, 0x00, 0x02, 0x00, 0x30, 0x06, 0x00, 0x04, 0x00, 0x60, 0x0C, 0x00,
  0x18, 0x01, 0xC0, 0x18, 0x00, 0x30, 0x03, 0x80, 0x30, 0x00, 0x60, 0x05,
  0x00, 0x20, 0x01, 0xC0, 0x1A, 0x00, 0x60, 0x02, 0x80, 0x26, 0x00, 0x40,
  0x0D, 0x80, 0xC4, 0x00, 0xE0, 0x31, 0x83, 0x08, 0x00, 0x7F, 0x81, 0xFC,
  0x18, 0x00, 0x10, 0x00, 0x40, 0x10, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x00, 0x1E, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x48, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x23, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x81, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x40,
  0x60, 0x00, 0x02, 0x01, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x00, 0x60,
  0x00, 0x18, 0x01, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x60, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x20, 0x01, 0x80,
  0x01, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x20, 0x04, 0x00, 0x01,
  0x80, 0x20, 0x00, 0x04, 0x03, 0x00, 0x00, 0x20, 0x10, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x04, 0x08, 0x00, 0x00, 0x30, 0x40, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x04, 0x20, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00,
  0x04, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0x81,
  0x80, 0x01, 0xC3, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0xB0, 0x00, 0x01, 0x60, 0x00, 0x02, 0xC0, 0x00, 0x05, 0x80,
  0x00, 0x0B, 0x00, 0x00, 0x16, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xD8, 0x00,
  0x03, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x70, 0xFF, 0xFF, 0x81, 0x80, 0x7F,
  0x83, 0x00, 0x01, 0xC6, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x19, 0x80, 0x00, 0xE3, 0x00,
  0x0F, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xE3, 0xF8,
  0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x3C, 0x03, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x98, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x58, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x1C, 0x03, 0x00, 0x3E, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xEC, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xEC, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x78, 0x1F, 0xC0,
  0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x02, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x03, 0x20, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30,
  0x1C, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xFF, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x20, 0x04, 0x00, 0xCF, 0xF8, 0x7E, 0x00, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x33, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x18, 0x00,
  0x30, 0x30, 0x00, 0xC0, 0x60, 0x03, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30,
  0x03, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00,
  0x30, 0xC0, 0x00, 0x63, 0xC0, 0x00, 0xCC, 0x80, 0x01, 0xB1, 0x80, 0x03,
  0xC1, 0x80, 0x07, 0x01, 0x00, 0x0C, 0x03, 0x00, 0x18, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x60, 0x02, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x06, 0x03, 0x00,
  0x06, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x08, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x1B, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x05, 0xD0, 0x00, 0x00, 0x0D, 0xD8, 0x00, 0x00, 0x09, 0xC8, 0x00,
  0x00, 0x19, 0xCC, 0x00, 0x00, 0x19, 0xC4, 0x00, 0x00, 0x11, 0xC4, 0x00,
  0x00, 0x31, 0xC6, 0x00, 0x00, 0x21, 0xC2, 0x00, 0x00, 0x61, 0xC3, 0x00,
  0x00, 0x41, 0xC1, 0x00, 0x00, 0x41, 0xC1, 0x00, 0x00, 0xC1, 0xC1, 0x80,
  0x00, 0x81, 0xC0, 0x80, 0x01, 0x81, 0xC0, 0xC0, 0x01, 0x01, 0xC0, 0x40,
  0x01, 0x01, 0xC0, 0x60, 0x03, 0x01, 0xC0, 0x60, 0x02, 0x01, 0xC0, 0x20,
  0x06, 0x01, 0xC0, 0x30, 0x04, 0x01, 0xC0, 0x10, 0x04, 0x01, 0xC0, 0x18,
  0x0C, 0x01, 0xC0, 0x08, 0x08, 0x01, 0xC0, 0x08, 0x18, 0x01, 0xC0, 0x0C,
  0x10, 0x01, 0xC0, 0x04, 0x30, 0x01, 0xC0, 0x06, 0x30, 0x01, 0xC0, 0x02,
  0x20, 0x01, 0xC0, 0x02, 0x60, 0x01, 0xC0, 0x03, 0x40, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x80, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x0E, 0x40, 0x00, 0x07, 0x30, 0x00, 0x03, 0x8C, 0x00, 0x01, 0xC2,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x70, 0x60, 0x00, 0x38, 0x10, 0x00, 0x1C,
  0x0C, 0x00, 0x0E, 0x03, 0x00, 0x07, 0x00, 0x80, 0x03, 0x80, 0x60, 0x01,
  0xC0, 0x18, 0x00, 0xE0, 0x04, 0x00, 0x70, 0x03, 0x00, 0x38, 0x00, 0xC0,
  0x1C, 0x00, 0x30, 0x0E, 0x00, 0x18, 0x07, 0x00, 0x06, 0x03, 0x80, 0x01,
  0x81, 0xC0, 0x00, 0x40, 0xE0, 0x00, 0x30, 0x70, 0x00, 0x0C, 0x38, 0x00,
  0x02, 0x1C, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x67, 0x00, 0x00, 0x13, 0x80,
  0x00, 0x0D, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x10, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x40,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x04, 0x30,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x80, 0x00, 0xFF,
  0xFE, 0x06, 0x00, 0x1C, 0x30, 0x00, 0x19, 0x80, 0x00, 0x6C, 0x00, 0x01,
  0x60, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x58, 0x00, 0x06, 0xC0, 0x00, 0x66, 0x00, 0x06, 0x30, 0x00,
  0xE1, 0xFF, 0xFC, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x00, 0xE0, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x08, 0x10, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x04, 0x20, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x02, 0x40, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x02, 0x20, 0x00,
  0x00, 0x06, 0x20, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x08, 0x08, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x60, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0xFF, 0xFF, 0x01, 0x80, 0x07, 0x83, 0x00, 0x01, 0x86, 0x00,
  0x01, 0x8C, 0x00, 0x01, 0x18, 0x00, 0x03, 0x30, 0x00, 0x02, 0x60, 0x00,
  0x04, 0xC0, 0x00, 0x09, 0x80, 0x00, 0x13, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x4C, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x10,
  0xC0, 0x00, 0x41, 0x80, 0x03, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0C,
  0x00, 0xC0, 0x18, 0x00, 0x80, 0x30, 0x01, 0x80, 0x60, 0x01, 0x80, 0xC0,
  0x01, 0x01, 0x80, 0x03, 0x03, 0x00, 0x02, 0x06, 0x00, 0x06, 0x0C, 0x00,
  0x06, 0x18, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x08, 0xC0, 0x00,
  0x19, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x16, 0x00, 0x00, 0x30, 0x00, 0xFF,
  0x00, 0x1F, 0x1F, 0xC1, 0xC0, 0x01, 0x8C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x38, 0x00,
  0x70, 0x7F, 0xFF, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x50, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x01, 0x60,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0x18, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x08, 0x18, 0x00, 0x03, 0x01, 0x80, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x00,
  0x1A, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0x40, 0x00, 0x01, 0x02, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x80, 0x40, 0x00, 0x04, 0x03, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x02, 0x00, 0x40, 0x00, 0x30, 0x03, 0x00, 0x01, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x40, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x10, 0x00, 0x08, 0x01,
  0x80, 0x00, 0x60, 0x08, 0x00, 0x01, 0x00, 0x40, 0x00, 0x08, 0x06, 0x00,
  0x00, 0x60, 0x20, 0x00, 0x01, 0x01, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x22,
  0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xB0, 0x00, 0x07, 0x00, 0x00, 0x48,
  0x00, 0x07, 0x80, 0x00, 0x64, 0x00, 0x02, 0x40, 0x00, 0x23, 0x00, 0x01,
  0x20, 0x00, 0x10, 0x80, 0x00, 0x98, 0x00, 0x18, 0x40, 0x00, 0xC4, 0x00,
  0x0C, 0x20, 0x00, 0x42, 0x00, 0x04, 0x18, 0x00, 0x21, 0x00, 0x02, 0x04,
  0x00, 0x30, 0xC0, 0x03, 0x02, 0x00, 0x10, 0x20, 0x01, 0x81, 0x80, 0x08,
  0x10, 0x00, 0x80, 0xC0, 0x04, 0x0C, 0x00, 0xC0, 0x20, 0x06, 0x02, 0x00,
  0x60, 0x10, 0x02, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x80, 0x10, 0x02,
  0x01, 0x80, 0x60, 0x18, 0x01, 0x00, 0xC0, 0x10, 0x0C, 0x00, 0x80, 0x40,
  0x08, 0x04, 0x00, 0x60, 0x20, 0x06, 0x02, 0x00, 0x10, 0x30, 0x03, 0x03,
  0x00, 0x08, 0x18, 0x00, 0x81, 0x00, 0x06, 0x08, 0x00, 0x40, 0x80, 0x03,
  0x04, 0x00, 0x30, 0xC0, 0x00, 0x86, 0x00, 0x08, 0x60, 0x00, 0x42, 0x00,
  0x04, 0x20, 0x00, 0x31, 0x00, 0x03, 0x10, 0x00, 0x09, 0x80, 0x01, 0x98,
  0x00, 0x04, 0xC0, 0x00, 0x4C, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x01,
  0xA0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x20, 0x20,
  0x00, 0x18, 0x0C, 0x00, 0x0C, 0x01, 0x00, 0x02, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x01, 0x00, 0x20, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x04,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x61, 0x80, 0x00, 0x08, 0x40, 0x00, 0x01,
  0x30, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x31, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x04, 0x08, 0x00, 0x03, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x40,
  0x08, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x60, 0x04, 0x00, 0x08, 0x03,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x40, 0x00, 0x08, 0x30, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x64, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x62, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x0C, 0x10,
  0x00, 0x02, 0x06, 0x00, 0x01, 0x80, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x20,
  0x04, 0x00, 0x18, 0x01, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x0C, 0x00,
  0x80, 0x01, 0x80, 0x60, 0x00, 0x20, 0x10, 0x00, 0x0C, 0x0C, 0x00, 0x01,
  0x02, 0x00, 0x00, 0x61, 0x80, 0x00, 0x08, 0x40, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x48, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xF8, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x7F,
  0xF0, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0xFF, 0xC0, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x07, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x02, 0x40, 0x00, 0x03, 0x30, 0x00, 0x01, 0x08, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x81, 0x00, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0x20, 0x00,
  0x40, 0x18, 0x00, 0x60, 0x04, 0x00, 0x20, 0x03, 0x00, 0x30, 0x00, 0x80,
  0x10, 0x00, 0x60, 0x18, 0x00, 0x10, 0x08, 0x00, 0x0C, 0x0C, 0x00, 0x02,
  0x04, 0x00, 0x01, 0x86, 0x00, 0x00, 0x42, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x0B, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x03, 0x03, 0xFF, 0x01, 0xE0, 0x18, 0x10, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x7F,
  0xF0, 0x3E, 0x03, 0x0C, 0x00, 0x33, 0x00, 0x03, 0x20, 0x00, 0x36, 0x00,
  0x03, 0x40, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x07, 0x40,
  0x00, 0x56, 0x00, 0x09, 0x20, 0x01, 0x93, 0x80, 0x61, 0x0F, 0xFC, 0x10,
  0x1C, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x83,
  0xFF, 0x02, 0x38, 0x06, 0x09, 0x80, 0x04, 0x2C, 0x00, 0x08, 0xA0, 0x00,
  0x33, 0x80, 0x00, 0x4C, 0x00, 0x01, 0xB0, 0x00, 0x02, 0x80, 0x00, 0x0A,
  0x00, 0x00, 0x28, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x28, 0x00, 0x00, 0xA0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x4E,
  0x00, 0x03, 0x28, 0x00, 0x18, 0x90, 0x00, 0xC2, 0x30, 0x0E, 0x08, 0x7F,
  0xE0, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xF0, 0x38, 0x02, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x02, 0x01, 0xFF, 0xE0,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x01,
  0xFF, 0x04, 0x1C, 0x07, 0x10, 0xC0, 0x06, 0x46, 0x00, 0x0D, 0x30, 0x00,
  0x14, 0x80, 0x00, 0x76, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x40, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x40, 0x00, 0x0D, 0x80, 0x00, 0x72,
  0x00, 0x01, 0x4C, 0x00, 0x0D, 0x18, 0x00, 0x64, 0x38, 0x03, 0x10, 0x3F,
  0xF0, 0x40, 0x04, 0x00, 0x01, 0xFF, 0x00, 0x38, 0x0E, 0x03, 0x00, 0x18,
  0x30, 0x00, 0x43, 0x00, 0x03, 0x10, 0x00, 0x09, 0x80, 0x00, 0x68, 0x00,
  0x01, 0x40, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x08, 0x38, 0x01,
  0x80, 0x7F, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x7F, 0x01, 0xC3, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0xFF, 0xF0, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x01, 0xFF, 0x84, 0x1C, 0x03, 0x10, 0xC0, 0x06, 0x46, 0x00, 0x0D, 0x30,
  0x00, 0x1C, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x40, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x40, 0x00, 0x0D, 0x80, 0x00,
  0x72, 0x00, 0x01, 0x4C, 0x00, 0x0D, 0x18, 0x00, 0x64, 0x38, 0x07, 0x10,
  0x3F, 0xF0, 0x40, 0x04, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x60, 0x00, 0x60, 0xF8, 0x07, 0x00, 0x7F, 0xF0, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x83, 0xFF, 0x08, 0xE0, 0x38, 0x98,
  0x00, 0xCB, 0x00, 0x06, 0xE0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x5F, 0x80, 0x00, 0x01, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49,
  0x24, 0x92, 0x49, 0x24, 0x00, 0x80, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01,
  0x80, 0x60, 0x12, 0x0C, 0xFC, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x01, 0xA0,
  0x00, 0xC8, 0x00, 0x62, 0x00, 0x10, 0x80, 0x08, 0x20, 0x06, 0x08, 0x03,
  0x02, 0x01, 0x80, 0x80, 0xC0, 0x20, 0x60, 0x08, 0x30, 0x02, 0x18, 0x00,
  0x87, 0x00, 0x22, 0x40, 0x09, 0x18, 0x02, 0x83, 0x00, 0xC0, 0x60, 0x30,
  0x08, 0x08, 0x03, 0x02, 0x00, 0x60, 0x80, 0x0C, 0x20, 0x01, 0x08, 0x00,
  0x62, 0x00, 0x0C, 0x80, 0x01, 0xA0, 0x00, 0x28, 0x00, 0x0C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x87, 0xFC, 0x07, 0xFC, 0x23, 0x01, 0x83, 0x81, 0xC9,
  0x00, 0x31, 0x80, 0x1A, 0x80, 0x04, 0xC0, 0x02, 0xC0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x83, 0xFE,
  0x08, 0xE0, 0x38, 0x98, 0x00, 0xCB, 0x00, 0x06, 0xA0, 0x00, 0x2C, 0x00,
  0x02, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x01, 0xFF, 0x80, 0x0E, 0x01, 0xC0,
  0x30, 0x00, 0xC0, 0xC0, 0x00, 0xC3, 0x00, 0x00, 0x84, 0x00, 0x01, 0x98,
  0x00, 0x01, 0x20, 0x00, 0x02, 0x40, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0D, 0x00, 0x00,
  0x1A, 0x00, 0x00, 0x26, 0x00, 0x00, 0x44, 0x00, 0x01, 0x8C, 0x00, 0x06,
  0x0C, 0x00, 0x08, 0x0C, 0x00, 0x30, 0x0E, 0x01, 0x80, 0x07, 0xFE, 0x00,
  0x00, 0x80, 0x00, 0x83, 0xFF, 0x02, 0x18, 0x06, 0x09, 0x80, 0x06, 0x24,
  0x00, 0x08, 0xA0, 0x00, 0x33, 0x80, 0x00, 0x4C, 0x00, 0x01, 0xB0, 0x00,
  0x02, 0xC0, 0x00, 0x0A, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x28, 0x00, 0x00, 0xB0, 0x00, 0x02, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0x4A, 0x00, 0x03, 0x2C, 0x00, 0x18, 0x98, 0x00, 0xC2,
  0x38, 0x0E, 0x08, 0x7F, 0xE0, 0x20, 0x18, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x04, 0x1C, 0x07, 0x10, 0xC0, 0x06, 0x44,
  0x00, 0x0D, 0x30, 0x00, 0x15, 0x80, 0x00, 0x74, 0x00, 0x00, 0xD0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x40, 0x00,
  0x0D, 0x80, 0x00, 0x52, 0x00, 0x01, 0x4C, 0x00, 0x09, 0x18, 0x00, 0x64,
  0x38, 0x06, 0x10, 0x3F, 0xF0, 0x40, 0x08, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x87, 0xFC, 0x60, 0x24, 0x01, 0x40, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x07,
  0xFF, 0x83, 0x80, 0x38, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x80, 0x00, 0xDC, 0x00,
  0x60, 0xFF, 0xF8, 0x00, 0x40, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x3F, 0xFF, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0F, 0xF0, 0x06, 0x00, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xA0, 0x00, 0x1D, 0x00, 0x01, 0xEC, 0x00, 0x0B, 0x30,
  0x01, 0x98, 0xE0, 0x18, 0xC3, 0xFF, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x0D, 0x00, 0x00, 0x24, 0x00, 0x00, 0x98, 0x00, 0x06, 0x20, 0x00, 0x10,
  0x80, 0x00, 0xC3, 0x00, 0x02, 0x04, 0x00, 0x08, 0x18, 0x00, 0x60, 0x20,
  0x01, 0x00, 0x80, 0x04, 0x03, 0x00, 0x30, 0x04, 0x00, 0x80, 0x18, 0x06,
  0x00, 0x20, 0x10, 0x00, 0x80, 0x40, 0x03, 0x03, 0x00, 0x04, 0x08, 0x00,
  0x10, 0x60, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x03, 0x30, 0x00, 0x04,
  0x80, 0x00, 0x12, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0xF0, 0x00, 0x30,
  0x00, 0x68, 0x00, 0x2C, 0x00, 0x26, 0x00, 0x12, 0x00, 0x13, 0x00, 0x09,
  0x00, 0x18, 0x80, 0x0C, 0xC0, 0x08, 0x40, 0x04, 0x60, 0x04, 0x30, 0x02,
  0x10, 0x02, 0x08, 0x03, 0x08, 0x03, 0x04, 0x01, 0x06, 0x01, 0x03, 0x00,
  0x81, 0x00, 0x81, 0x80, 0xC0, 0x80, 0xC0, 0x40, 0x40, 0x60, 0x60, 0x20,
  0x20, 0x10, 0x20, 0x18, 0x30, 0x08, 0x10, 0x04, 0x10, 0x06, 0x18, 0x02,
  0x08, 0x01, 0x08, 0x01, 0x8C, 0x00, 0x84, 0x00, 0xC4, 0x00, 0x62, 0x00,
  0x22, 0x00, 0x13, 0x00, 0x13, 0x00, 0x09, 0x00, 0x0D, 0x00, 0x06, 0x80,
  0x02, 0x80, 0x01, 0x40, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x60, 0x00, 0x18, 0x80, 0x00, 0x43, 0x00,
  0x03, 0x06, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x60, 0x18,
  0x00, 0xC0, 0xC0, 0x01, 0x02, 0x00, 0x02, 0x18, 0x00, 0x0C, 0xC0, 0x00,
  0x1A, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x33,
  0x00, 0x00, 0x84, 0x00, 0x06, 0x18, 0x00, 0x30, 0x30, 0x00, 0x80, 0x60,
  0x06, 0x00, 0x80, 0x30, 0x03, 0x00, 0x80, 0x06, 0x04, 0x00, 0x08, 0x30,
  0x00, 0x31, 0x80, 0x00, 0x6C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0D, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x98, 0x00, 0x06, 0x20, 0x00, 0x10, 0x80, 0x00,
  0xC3, 0x00, 0x02, 0x04, 0x00, 0x08, 0x18, 0x00, 0x60, 0x20, 0x01, 0x00,
  0x80, 0x04, 0x03, 0x00, 0x30, 0x04, 0x00, 0x80, 0x18, 0x06, 0x00, 0x20,
  0x10, 0x00, 0x80, 0x40, 0x03, 0x03, 0x00, 0x04, 0x08, 0x00, 0x10, 0x60,
  0x00, 0x61, 0x00, 0x00, 0x84, 0x00, 0x03, 0x30, 0x00, 0x04, 0x80, 0x00,
  0x12, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x7C, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x03, 0xC0, 0x07, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x30, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x01, 0xC0, 0x3C, 0x00, 0x3F, 0xC0, 0x02, 0xC0, 0xE0, 0x06,
  0x00, 0x70, 0x34, 0x00, 0x3F, 0xC0,
};

const GFXglyph NotoSans_Thin51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 36, 11, 4, -36 },
  { 15, 9, 13, 16, 4, -36 },
  { 30, 31, 36, 33, 1, -36 },
  { 170, 21, 42, 29, 3, -39 },
  { 281, 34, 38, 40, 3, -37 },
  { 443, 31, 38, 36, 3, -37 },
  { 591, 1, 13, 9, 4, -36 },
  { 593, 9, 44, 13, 2, -36 },
  { 643, 9, 44, 13, 2, -36 },
  { 693, 22, 21, 28, 3, -39 },
  { 751, 23, 24, 29, 3, -30 },
  { 820, 4, 13, 9, 2, -6 },
  { 827, 12, 1, 16, 2, -14 },
  { 829, 3, 3, 11, 4, -3 },
  { 831, 15, 36, 16, 1, -36 },
  { 899, 23, 38, 29, 3, -37 },
  { 1009, 11, 36, 29, 5, -36 },
  { 1059, 22, 37, 29, 3, -37 },
  { 1161, 23, 38, 29, 2, -37 },
  { 1271, 28, 37, 29, 1, -37 },
  { 1401, 22, 37, 29, 4, -36 },
  { 1503, 23, 38, 29, 3, -37 },
  { 1613, 23, 36, 29, 3, -36 },
  { 1717, 23, 38, 29, 3, -37 },
  { 1827, 23, 38, 29, 3, -37 },
  { 1937, 3, 27, 11, 4, -27 },
  { 1948, 5, 34, 11, 2, -27 },
  { 1970, 23, 23, 29, 3, -30 },
  { 2037, 23, 12, 29, 3, -24 },
  { 2072, 23, 23, 29, 3, -30 },
  { 2139, 17, 37, 21, 2, -37 },
  { 2218, 39, 41, 45, 3, -36 },
  { 2418, 29, 37, 29, 0, -37 },
  { 2553, 23, 36, 31, 5, -36 },
  { 2657, 27, 38, 31, 3, -37 },
  { 2786, 27, 36, 35, 5, -36 },
  { 2908, 20, 36, 28, 5, -36 },
  { 2998, 20, 36, 25, 5, -36 },
  { 3088, 30, 38, 37, 3, -37 },
  { 3231, 26, 36, 36, 5, -36 },
  { 3348, 8, 36, 14, 3, -36 },
  { 3384, 12, 45, 12, -5, -36 },
  { 3452, 23, 36, 28, 5, -36 },
  { 3556, 20, 36, 26, 5, -36 },
  { 3646, 32, 36, 43, 5, -36 },
  { 3790, 25, 36, 36, 5, -36 },
  { 3903, 32, 38, 38, 3, -37 },
  { 4055, 21, 36, 29, 5, -36 },
  { 4150, 32, 46, 38, 3, -37 },
  { 4334, 23, 36, 29, 5, -36 },
  { 4438, 22, 38, 28, 3, -37 },
  { 4543, 26, 36, 26, 0, -36 },
  { 4660, 27, 37, 36, 5, -36 },
  { 4785, 29, 36, 29, 0, -36 },
  { 4916, 41, 36, 44, 2, -36 },
  { 5101, 26, 36, 26, 0, -36 },
  { 5218, 26, 36, 26, 0, -36 },
  { 5335, 25, 36, 29, 2, -36 },
  { 5448, 11, 44, 16, 4, -36 },
  { 5509, 15, 36, 16, 1, -36 },
  { 5577, 10, 44, 16, 1, -36 },
  { 5632, 25, 23, 29, 2, -37 },
  { 5704, 20, 1, 20, 0, 5 },
  { 5707, 9, 8, 13, 2, -39 },
  { 5716, 20, 28, 26, 2, -27 },
  { 5786, 22, 40, 30, 5, -39 },
  { 5896, 20, 28, 24, 3, -27 },
  { 5966, 22, 40, 30, 3, -39 },
  { 6076, 21, 28, 28, 3, -27 },
  { 6150, 16, 39, 14, 1, -39 },
  { 6228, 22, 39, 30, 3, -27 },
  { 6336, 20, 39, 29, 5, -39 },
  { 6434, 3, 37, 11, 4, -37 },
  { 6448, 10, 49, 11, -3, -37 },
  { 6510, 18, 39, 23, 5, -39 },
  { 6598, 1, 39, 11, 5, -39 },
  { 6603, 34, 27, 43, 5, -27 },
  { 6718, 20, 27, 29, 5, -27 },
  { 6786, 23, 28, 29, 3, -27 },
  { 6867, 22, 39, 30, 5, -27 },
  { 6975, 22, 39, 30, 3, -27 },
  { 7083, 13, 27, 19, 5, -27 },
  { 7127, 19, 28, 23, 2, -27 },
  { 7194, 14, 35, 16, 1, -34 },
  { 7256, 21, 28, 29, 4, -27 },
  { 7330, 22, 27, 22, 0, -27 },
  { 7405, 33, 27, 35, 1, -27 },
  { 7517, 22, 27, 24, 1, -27 },
  { 7592, 22, 39, 22, 0, -27 },
  { 7700, 19, 27, 23, 2, -27 },
  { 7765, 14, 44, 17, 1, -36 },
  { 7842, 1, 52, 27, 13, -39 },
  { 7849, 14, 44, 17, 2, -36 },
  { 7926, 23, 4, 29, 3, -20 },
};

const GFXfont NotoSans_Thin51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin51pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_THIN51PT7B_H_
