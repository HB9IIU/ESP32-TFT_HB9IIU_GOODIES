#ifndef _NOTOSANS_THIN29PT7B_H_
#define _NOTOSANS_THIN29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin29pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x01, 0xC0, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x01, 0x04, 0x01, 0x02, 0x00, 0x81, 0x00, 0x41, 0x00, 0x20, 0x80, 0x10,
  0x40, 0x10, 0x20, 0xFF, 0xFF, 0x04, 0x08, 0x02, 0x08, 0x01, 0x04, 0x01,
  0x02, 0x00, 0x81, 0x00, 0x40, 0x83, 0xFF, 0xBC, 0x10, 0x40, 0x10, 0x20,
  0x08, 0x10, 0x04, 0x08, 0x02, 0x08, 0x01, 0x04, 0x00, 0x04, 0x00, 0x60,
  0x3D, 0xE4, 0x40, 0x84, 0x08, 0x40, 0x84, 0x08, 0x40, 0x84, 0x04, 0x40,
  0x34, 0x00, 0xE0, 0x05, 0x80, 0x44, 0x04, 0x20, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x20, 0x42, 0xC4, 0xC3, 0xE0, 0x04, 0x00, 0x40, 0x3C, 0x01, 0x08,
  0x40, 0x42, 0x08, 0x08, 0x41, 0x02, 0x08, 0x10, 0x81, 0x02, 0x10, 0x20,
  0x44, 0x04, 0x08, 0x80, 0x81, 0x23, 0x10, 0x44, 0x8A, 0x09, 0x20, 0xA1,
  0x24, 0x13, 0xC9, 0x02, 0x02, 0x20, 0x40, 0x44, 0x08, 0x10, 0x81, 0x02,
  0x10, 0x20, 0x82, 0x04, 0x10, 0x20, 0x84, 0x04, 0x21, 0x80, 0x78, 0x0F,
  0x80, 0x08, 0x20, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00,
  0x40, 0x80, 0x20, 0x80, 0x09, 0x80, 0x03, 0x00, 0x06, 0x80, 0x04, 0x20,
  0x14, 0x08, 0x0C, 0x02, 0x0A, 0x00, 0x85, 0x00, 0x24, 0x80, 0x0A, 0x40,
  0x02, 0x20, 0x02, 0x88, 0x06, 0x23, 0xFC, 0x08, 0xFF, 0x08, 0x84, 0x42,
  0x21, 0x08, 0x44, 0x21, 0x08, 0x42, 0x10, 0x82, 0x10, 0x84, 0x10, 0x82,
  0x08, 0x40, 0x82, 0x08, 0x41, 0x08, 0x41, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x21, 0x08, 0x84, 0x44, 0x00, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0xC4, 0x33, 0xDC, 0x06, 0x00, 0x60, 0x09, 0x01, 0x08, 0x20, 0x82,
  0x04, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x03, 0xFF,
  0xE0, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x29,
  0x25, 0x20, 0xFE, 0x70, 0x00, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x08,
  0x08, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10,
  0x10, 0x08, 0x08, 0x00, 0x0F, 0x81, 0x82, 0x10, 0x08, 0x80, 0x28, 0x01,
  0x40, 0x0A, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x02, 0x80, 0x12, 0x00, 0x90, 0x08, 0x40,
  0x81, 0xF8, 0x00, 0x04, 0x31, 0x59, 0x84, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x1F, 0x04, 0x0C, 0x80, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x00, 0xFF, 0xF0, 0x1F, 0xC1, 0x01, 0x10, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x03, 0xF0, 0x00, 0x60, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x05, 0x00, 0x67,
  0xFC, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x05, 0x00, 0x12, 0x00,
  0x24, 0x00, 0x88, 0x02, 0x10, 0x08, 0x20, 0x10, 0x40, 0x40, 0x81, 0x01,
  0x04, 0x02, 0x08, 0x04, 0x20, 0x08, 0x3F, 0xFF, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x3F, 0xE2, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0xFE, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x05, 0x00, 0xC7, 0xF8, 0x00, 0x07, 0xE0, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x8F, 0x84, 0x83, 0x38, 0x05, 0x80,
  0x28, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0A, 0x00, 0x90, 0x04,
  0x40, 0x41, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x00, 0x1F, 0x81, 0x03, 0x10, 0x08, 0x80, 0x28, 0x01, 0x40,
  0x09, 0x00, 0x48, 0x04, 0x30, 0xC0, 0x78, 0x03, 0x60, 0x60, 0x84, 0x02,
  0x40, 0x0A, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xA0, 0x04, 0x80, 0x43,
  0xFC, 0x00, 0x1F, 0x81, 0x02, 0x10, 0x09, 0x00, 0x48, 0x01, 0x40, 0x0A,
  0x00, 0x50, 0x02, 0x80, 0x14, 0x00, 0xE0, 0x0A, 0xC0, 0x91, 0xF9, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x07, 0xF0,
  0x00, 0xC0, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x00, 0x02, 0x92, 0x52,
  0x00, 0x00, 0x08, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x80, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x20, 0x0E,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x7E, 0x20, 0x60,
  0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x60, 0x20,
  0x08, 0x04, 0x01, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x40, 0x10, 0x00,
  0x03, 0xFF, 0x80, 0x30, 0x01, 0x01, 0x00, 0x02, 0x08, 0x00, 0x04, 0x40,
  0x00, 0x09, 0x00, 0xF0, 0x28, 0x0C, 0x20, 0x60, 0x40, 0x81, 0x82, 0x02,
  0x06, 0x08, 0x08, 0x18, 0x40, 0x20, 0x61, 0x00, 0x81, 0x84, 0x02, 0x06,
  0x08, 0x08, 0x18, 0x20, 0x60, 0xA0, 0x42, 0x44, 0x80, 0xF0, 0xE1, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x50, 0x00, 0x28,
  0x00, 0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x08, 0x20, 0x04, 0x10, 0x04,
  0x08, 0x02, 0x02, 0x01, 0x01, 0x01, 0xFF, 0xC0, 0x80, 0x20, 0x80, 0x10,
  0x40, 0x04, 0x20, 0x02, 0x20, 0x01, 0x10, 0x00, 0x48, 0x00, 0x28, 0x00,
  0x08, 0xFF, 0x84, 0x03, 0x20, 0x05, 0x00, 0x28, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x02, 0x80, 0x24, 0x06, 0x3F, 0xF1, 0x00, 0x68, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x05, 0x00, 0x4F, 0xFC, 0x00,
  0x03, 0xFC, 0x18, 0x04, 0x40, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x7F, 0xE0, 0xFE, 0x01, 0x01, 0xC2, 0x00, 0x44, 0x00, 0x48,
  0x00, 0x50, 0x00, 0xA0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x02, 0x80, 0x05,
  0x00, 0x12, 0x00, 0x44, 0x03, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0xFF, 0xC0,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0F,
  0xFE, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x7F, 0xF8, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x03, 0xFE, 0x06, 0x00, 0x84, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x0F, 0xF8, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x40, 0x00, 0x90, 0x00, 0x48, 0x00, 0x23, 0x00,
  0x10, 0x7F, 0xF0, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x04, 0xF2, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22,
  0x22, 0x22, 0xF0, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x05, 0xF0, 0x80, 0x0C, 0x00, 0xA0, 0x09, 0x00, 0x88, 0x08, 0x40, 0x82,
  0x08, 0x10, 0x80, 0x88, 0x04, 0xC0, 0x29, 0x01, 0x88, 0x08, 0x20, 0x40,
  0x82, 0x04, 0x10, 0x10, 0x80, 0x44, 0x01, 0x20, 0x09, 0x00, 0x28, 0x00,
  0x80, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x0F, 0xFE, 0x80, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0E, 0x80, 0x03, 0xA0, 0x01, 0x68, 0x00, 0x59, 0x00, 0x26, 0x40, 0x09,
  0x88, 0x02, 0x62, 0x01, 0x18, 0x80, 0x46, 0x10, 0x21, 0x84, 0x08, 0x60,
  0x82, 0x18, 0x21, 0x06, 0x08, 0x41, 0x81, 0x20, 0x60, 0x48, 0x18, 0x0A,
  0x06, 0x03, 0x01, 0x80, 0x40, 0x40, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x68,
  0x01, 0xA0, 0x06, 0x40, 0x18, 0x80, 0x62, 0x01, 0x84, 0x06, 0x08, 0x18,
  0x10, 0x60, 0x41, 0x80, 0x86, 0x01, 0x18, 0x04, 0x60, 0x09, 0x80, 0x16,
  0x00, 0x58, 0x00, 0xE0, 0x01, 0x80, 0x04, 0x07, 0xF8, 0x02, 0x01, 0x01,
  0x00, 0x20, 0x80, 0x04, 0x40, 0x00, 0x90, 0x00, 0x28, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x02, 0x40, 0x00, 0x90, 0x00, 0x42,
  0x00, 0x10, 0x60, 0x18, 0x07, 0xF8, 0x00, 0xFF, 0x08, 0x0C, 0x80, 0x28,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x4F,
  0xF0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x00, 0x07, 0xF8, 0x02, 0x01, 0x01, 0x00, 0x20, 0x80, 0x04,
  0x40, 0x00, 0x90, 0x00, 0x28, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x02, 0x40, 0x00, 0x90, 0x00, 0x42, 0x00, 0x10, 0x60, 0x18,
  0x07, 0xF8, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0xFD, 0x04, 0x06, 0x20, 0x09, 0x00, 0x28, 0x01, 0x40, 0x0A,
  0x00, 0x50, 0x02, 0x80, 0x24, 0x01, 0x20, 0x31, 0xFE, 0x08, 0x10, 0x40,
  0x42, 0x02, 0x10, 0x08, 0x80, 0x44, 0x01, 0x20, 0x05, 0x00, 0x28, 0x00,
  0x80, 0x1F, 0xC2, 0x03, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x06, 0xFF, 0x80, 0xFF, 0xFE, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x09, 0x00,
  0x11, 0x00, 0xC1, 0xFE, 0x00, 0x80, 0x01, 0x80, 0x01, 0x40, 0x01, 0x40,
  0x02, 0x40, 0x02, 0x20, 0x04, 0x20, 0x04, 0x10, 0x04, 0x10, 0x08, 0x10,
  0x08, 0x08, 0x08, 0x08, 0x10, 0x04, 0x10, 0x04, 0x20, 0x04, 0x20, 0x02,
  0x20, 0x02, 0x40, 0x02, 0x40, 0x01, 0x40, 0x01, 0x80, 0x00, 0x80, 0x80,
  0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0xA0, 0x0A, 0x01, 0x40, 0x14, 0x02,
  0x80, 0x48, 0x05, 0x00, 0x88, 0x11, 0x01, 0x10, 0x22, 0x04, 0x20, 0x44,
  0x08, 0x40, 0x84, 0x10, 0x42, 0x08, 0x20, 0x84, 0x10, 0x81, 0x08, 0x21,
  0x02, 0x20, 0x22, 0x02, 0x40, 0x48, 0x04, 0x80, 0x90, 0x09, 0x00, 0xA0,
  0x0C, 0x01, 0x40, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x80, 0x08, 0x80, 0x20, 0x80, 0x81, 0x01, 0x01, 0x04, 0x02,
  0x10, 0x02, 0x20, 0x02, 0x80, 0x05, 0x00, 0x04, 0x00, 0x14, 0x00, 0x48,
  0x00, 0x88, 0x02, 0x08, 0x08, 0x10, 0x10, 0x10, 0x40, 0x11, 0x00, 0x22,
  0x00, 0x28, 0x00, 0x20, 0x80, 0x02, 0x80, 0x09, 0x00, 0x11, 0x00, 0x42,
  0x01, 0x02, 0x02, 0x04, 0x08, 0x04, 0x10, 0x08, 0x40, 0x08, 0x80, 0x12,
  0x00, 0x14, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x7F, 0xFC, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x0F, 0xFF, 0xE0,
  0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x87, 0xC0, 0x80, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x02,
  0x00, 0x80, 0x40, 0x20, 0x08, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x07,
  0xF0, 0x01, 0x00, 0x0A, 0x00, 0x28, 0x01, 0x10, 0x04, 0x40, 0x20, 0x80,
  0x82, 0x04, 0x04, 0x10, 0x10, 0x80, 0x22, 0x00, 0x90, 0x01, 0x80, 0x04,
  0xFF, 0xE0, 0xC2, 0x08, 0x30, 0x06, 0x07, 0x18, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x1F, 0x1C, 0x2C, 0x05, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xD0, 0x19, 0xFD, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x8F, 0x0B, 0x0C, 0xC0, 0x28, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0xC0, 0x4B, 0xF8,
  0x07, 0x03, 0x0C, 0x80, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x06, 0x11, 0x8D, 0x40, 0x34,
  0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x14, 0x03, 0x60, 0x31, 0xFD, 0x02, 0x01, 0x8C, 0x20, 0x24,
  0x02, 0x80, 0x18, 0x01, 0x80, 0x1F, 0xFF, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0xFE, 0x07, 0xC2, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x03, 0xF8, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00, 0x06,
  0x01, 0x8D, 0x60, 0x34, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x03, 0x20, 0x71, 0xF9, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x24, 0x06, 0x3F, 0x80, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x23, 0xC5, 0x86, 0xC0, 0x50, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x40, 0xF0, 0x0A, 0xAA, 0xAA, 0xAA, 0x80, 0x18,
  0xC0, 0x00, 0x00, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x85, 0xC0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x06, 0x02, 0x81, 0x20, 0x88, 0x42, 0x20, 0x88, 0x24, 0x0A, 0x83,
  0x20, 0x84, 0x20, 0x88, 0x12, 0x04, 0x80, 0xA0, 0x10, 0xFF, 0xFF, 0xFC,
  0x06, 0x06, 0x16, 0x23, 0x1B, 0x02, 0x80, 0xC0, 0x20, 0x18, 0x04, 0x03,
  0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06,
  0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C,
  0x02, 0x01, 0x0F, 0x16, 0x1B, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x02, 0x00, 0xC6, 0x08, 0x08, 0x80, 0x28, 0x01, 0x40, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x20, 0x08, 0x80,
  0x83, 0xF8, 0x0F, 0x0B, 0x0C, 0xC0, 0x2C, 0x02, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x02, 0xE0,
  0x49, 0xF8, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x00, 0x0E, 0x03, 0x0D, 0x40, 0x34, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x03, 0x40, 0x53,
  0xF9, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x07, 0x63, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x0E, 0x06, 0x1D, 0x00, 0x20, 0x04, 0x00, 0x80, 0x18, 0x00,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x13, 0xFC,
  0x10, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x0F, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x40, 0x34, 0x05, 0x3F, 0x90, 0x80, 0x14, 0x01, 0x40, 0x24, 0x02,
  0x20, 0x22, 0x04, 0x10, 0x41, 0x04, 0x10, 0x80, 0x88, 0x09, 0x00, 0x90,
  0x05, 0x00, 0x60, 0x02, 0x00, 0xC0, 0x20, 0x28, 0x0C, 0x05, 0x01, 0x40,
  0xA0, 0x48, 0x12, 0x09, 0x04, 0x41, 0x20, 0x88, 0x42, 0x10, 0x88, 0x44,
  0x11, 0x08, 0x82, 0x40, 0x90, 0x48, 0x12, 0x05, 0x02, 0x80, 0xC0, 0x30,
  0x18, 0x06, 0x01, 0x00, 0x80, 0xC0, 0x34, 0x04, 0x20, 0x41, 0x08, 0x11,
  0x00, 0x90, 0x06, 0x00, 0x60, 0x0A, 0x00, 0x90, 0x10, 0x82, 0x04, 0x40,
  0x44, 0x02, 0x80, 0x10, 0x80, 0x14, 0x01, 0x40, 0x24, 0x02, 0x20, 0x22,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x80, 0x88, 0x09, 0x00, 0x90, 0x05, 0x00,
  0x60, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x0E,
  0x00, 0x7F, 0xE0, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x20,
  0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x3F, 0xF8, 0x05, 0x08,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0xC0, 0x60,
  0x20, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x0C, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x30, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x07, 0x06, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x10, 0x30, 0xC0, 0x30, 0x06, 0x70, 0x60, 0x7C,
};

const GFXglyph NotoSans_Thin29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 21, 6, 2, -21 },
  { 7, 5, 8, 9, 2, -21 },
  { 12, 17, 21, 19, 1, -21 },
  { 57, 12, 24, 17, 2, -22 },
  { 93, 19, 21, 23, 2, -21 },
  { 143, 17, 21, 20, 2, -21 },
  { 188, 1, 8, 5, 2, -21 },
  { 189, 5, 26, 7, 1, -21 },
  { 206, 5, 26, 7, 1, -21 },
  { 223, 12, 12, 16, 2, -22 },
  { 241, 13, 13, 17, 2, -17 },
  { 263, 3, 7, 5, 1, -3 },
  { 266, 7, 1, 9, 1, -8 },
  { 267, 2, 2, 6, 2, -2 },
  { 268, 9, 21, 9, 0, -21 },
  { 292, 13, 21, 17, 2, -21 },
  { 327, 6, 21, 17, 3, -21 },
  { 343, 12, 21, 17, 2, -21 },
  { 375, 13, 21, 17, 1, -21 },
  { 410, 15, 21, 17, 1, -21 },
  { 450, 13, 21, 17, 2, -21 },
  { 485, 13, 21, 17, 2, -21 },
  { 520, 13, 21, 17, 2, -21 },
  { 555, 13, 21, 17, 2, -21 },
  { 590, 13, 21, 17, 2, -21 },
  { 625, 2, 15, 6, 2, -15 },
  { 629, 3, 19, 6, 1, -15 },
  { 637, 13, 13, 17, 2, -17 },
  { 659, 13, 7, 17, 2, -14 },
  { 671, 13, 13, 17, 2, -17 },
  { 693, 10, 21, 12, 1, -21 },
  { 720, 22, 23, 25, 2, -20 },
  { 784, 17, 21, 17, 0, -21 },
  { 829, 13, 21, 18, 3, -21 },
  { 864, 15, 21, 18, 2, -21 },
  { 904, 15, 21, 20, 3, -21 },
  { 944, 11, 21, 16, 3, -21 },
  { 973, 11, 21, 14, 3, -21 },
  { 1002, 17, 21, 21, 2, -21 },
  { 1047, 14, 21, 20, 3, -21 },
  { 1084, 4, 21, 8, 2, -21 },
  { 1095, 7, 26, 7, -3, -21 },
  { 1118, 13, 21, 16, 3, -21 },
  { 1153, 11, 21, 15, 3, -21 },
  { 1182, 18, 21, 24, 3, -21 },
  { 1230, 14, 21, 20, 3, -21 },
  { 1267, 18, 21, 22, 2, -21 },
  { 1315, 12, 21, 17, 3, -21 },
  { 1347, 18, 26, 22, 2, -21 },
  { 1406, 13, 21, 17, 3, -21 },
  { 1441, 12, 21, 16, 2, -21 },
  { 1473, 15, 21, 15, 0, -21 },
  { 1513, 15, 21, 21, 3, -21 },
  { 1553, 16, 21, 16, 0, -21 },
  { 1595, 23, 21, 25, 1, -21 },
  { 1656, 15, 21, 15, 0, -21 },
  { 1696, 15, 21, 15, 0, -21 },
  { 1736, 15, 21, 17, 1, -21 },
  { 1776, 5, 26, 9, 3, -21 },
  { 1793, 9, 21, 9, 0, -21 },
  { 1817, 6, 26, 9, 1, -21 },
  { 1837, 14, 13, 17, 1, -21 },
  { 1860, 11, 1, 11, 0, 2 },
  { 1862, 5, 4, 7, 1, -22 },
  { 1865, 11, 16, 15, 1, -16 },
  { 1887, 12, 22, 17, 3, -22 },
  { 1920, 11, 16, 14, 2, -16 },
  { 1942, 12, 22, 17, 2, -22 },
  { 1975, 12, 16, 16, 2, -16 },
  { 1999, 10, 22, 8, 0, -22 },
  { 2027, 12, 23, 17, 2, -16 },
  { 2062, 11, 22, 17, 3, -22 },
  { 2093, 2, 21, 6, 2, -21 },
  { 2099, 5, 28, 6, -1, -21 },
  { 2117, 10, 22, 13, 3, -22 },
  { 2145, 1, 22, 6, 3, -22 },
  { 2148, 19, 16, 25, 3, -16 },
  { 2186, 11, 16, 17, 3, -16 },
  { 2208, 13, 16, 17, 2, -16 },
  { 2234, 12, 23, 17, 3, -16 },
  { 2269, 12, 23, 17, 2, -16 },
  { 2304, 7, 16, 11, 3, -16 },
  { 2318, 11, 16, 13, 1, -16 },
  { 2340, 8, 19, 9, 0, -19 },
  { 2359, 12, 15, 17, 2, -15 },
  { 2382, 12, 15, 12, 0, -15 },
  { 2405, 19, 15, 20, 0, -15 },
  { 2441, 12, 15, 14, 1, -15 },
  { 2464, 12, 22, 12, 0, -15 },
  { 2497, 11, 15, 13, 1, -15 },
  { 2518, 8, 26, 10, 1, -21 },
  { 2544, 1, 29, 16, 7, -22 },
  { 2548, 8, 26, 10, 1, -21 },
  { 2574, 13, 3, 17, 2, -12 },
};

const GFXfont NotoSans_Thin29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin29pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_THIN29PT7B_H_
