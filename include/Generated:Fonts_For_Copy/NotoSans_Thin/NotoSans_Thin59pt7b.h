#ifndef _NOTOSANS_THIN59PT7B_H_
#define _NOTOSANS_THIN59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin59pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB4, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x92, 0x00, 0x00, 0x07, 0xFC, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x16, 0x02, 0xC0, 0x58, 0x0B, 0x01, 0x60, 0x24, 0x04, 0x80,
  0x90, 0x10, 0x00, 0x02, 0x00, 0x10, 0x00, 0x01, 0x80, 0x04, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x02, 0x00, 0x18, 0x00, 0x00, 0x80, 0x04,
  0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x06, 0x00, 0x00, 0x20, 0x01, 0x00, 0x00, 0x08, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x10, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x40, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x80, 0x00, 0x04, 0x00, 0x20, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x10, 0x00, 0x01, 0x80, 0x04, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x02, 0x00, 0x18, 0x00, 0x00, 0x80, 0x04, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18,
  0x00, 0x03, 0xFF, 0xE0, 0x0F, 0x10, 0x7C, 0x18, 0x10, 0x08, 0x30, 0x10,
  0x00, 0x60, 0x10, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x10,
  0x00, 0x80, 0x10, 0x00, 0x80, 0x10, 0x00, 0x80, 0x10, 0x00, 0xC0, 0x10,
  0x00, 0xC0, 0x10, 0x00, 0x60, 0x10, 0x00, 0x60, 0x10, 0x00, 0x38, 0x10,
  0x00, 0x1C, 0x10, 0x00, 0x07, 0x10, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x13, 0xC0, 0x00, 0x10, 0xF0, 0x00, 0x10,
  0x38, 0x00, 0x10, 0x0C, 0x00, 0x10, 0x06, 0x00, 0x10, 0x06, 0x00, 0x10,
  0x02, 0x00, 0x10, 0x03, 0x00, 0x10, 0x03, 0x00, 0x10, 0x03, 0x00, 0x10,
  0x03, 0x00, 0x10, 0x02, 0x00, 0x10, 0x06, 0x00, 0x10, 0x06, 0x00, 0x10,
  0x0C, 0x00, 0x10, 0x1C, 0xC0, 0x10, 0x38, 0xFC, 0x11, 0xE0, 0x1F, 0xFF,
  0x80, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0x80, 0x1C,
  0x1C, 0x00, 0x03, 0x00, 0x18, 0x06, 0x00, 0x02, 0x00, 0x30, 0x06, 0x00,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x04, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x30, 0x00, 0x40, 0x01, 0x80, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0,
  0x01, 0x80, 0x80, 0x00, 0x40, 0x01, 0x81, 0x80, 0x00, 0x40, 0x01, 0x81,
  0x00, 0x00, 0x40, 0x01, 0x03, 0x03, 0xE0, 0x40, 0x01, 0x06, 0x0F, 0xF8,
  0x60, 0x03, 0x06, 0x18, 0x1C, 0x60, 0x03, 0x0C, 0x30, 0x0C, 0x20, 0x02,
  0x0C, 0x30, 0x06, 0x30, 0x06, 0x18, 0x60, 0x02, 0x18, 0x04, 0x10, 0x60,
  0x03, 0x1C, 0x1C, 0x30, 0x40, 0x03, 0x0F, 0xF8, 0x20, 0xC0, 0x03, 0x01,
  0xC0, 0x60, 0xC0, 0x03, 0x00, 0x00, 0x40, 0xC0, 0x01, 0x00, 0x00, 0xC0,
  0xC0, 0x01, 0x00, 0x01, 0x80, 0xC0, 0x01, 0x00, 0x01, 0x80, 0xC0, 0x01,
  0x00, 0x03, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x00, 0x60, 0x06, 0x00, 0x30, 0x00, 0x30, 0x06, 0x00, 0x60, 0x00,
  0x30, 0x0C, 0x00, 0x40, 0x00, 0x1C, 0x18, 0x00, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00,
  0x01, 0x9C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0x98, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC6, 0x00, 0x18, 0x00, 0x19, 0x80,
  0x01, 0x80, 0x02, 0x20, 0x00, 0x18, 0x00, 0x4C, 0x00, 0x01, 0x80, 0x19,
  0x80, 0x00, 0x18, 0x02, 0x20, 0x00, 0x01, 0x80, 0xC4, 0x00, 0x00, 0x18,
  0x10, 0x80, 0x00, 0x01, 0x86, 0x10, 0x00, 0x00, 0x19, 0x82, 0x00, 0x00,
  0x01, 0xA0, 0x60, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x00, 0xD8, 0x18, 0x00, 0x00, 0x71, 0x81, 0x80, 0x00, 0x1C, 0x18,
  0x1C, 0x00, 0x0E, 0x01, 0x81, 0xE0, 0x07, 0x80, 0x18, 0x0F, 0xFF, 0x80,
  0x01, 0x80, 0x16, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x54, 0x00, 0xE0,
  0x18, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00,
  0x60, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x02,
  0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0xE0, 0x0C, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x0C,
  0x00, 0x80, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18,
  0x02, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x80, 0x08, 0x01,
  0x70, 0x04, 0x03, 0xCF, 0x02, 0x0F, 0x80, 0xF1, 0x3C, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x60, 0x60, 0x00, 0x20, 0x18, 0x00, 0x30,
  0x04, 0x00, 0x30, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x08, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0xC6, 0x31, 0x88, 0xC6,
  0x31, 0x18, 0xC4, 0x23, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x38, 0x07, 0x00, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x18, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x19, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x09, 0x00, 0x00,
  0x06, 0x40, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x10, 0x80,
  0x00, 0x0C, 0x30, 0x00, 0x02, 0x04, 0x00, 0x01, 0x81, 0x80, 0x00, 0x40,
  0x30, 0x00, 0x30, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x18, 0x03, 0xC0, 0x36, 0x03, 0x30, 0x71,
  0x86, 0x0C, 0xE0, 0x6E, 0x03, 0xC0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xF0, 0x07, 0x00, 0x70,
  0x00, 0x60, 0x30, 0x00, 0x0C, 0x08, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0xF0, 0x03, 0x80, 0xE0, 0x00, 0x30, 0xE0, 0x00,
  0x06, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x03, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x32, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x1C, 0x1F, 0x00,
  0x1E, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x09, 0x00,
  0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x00, 0x41, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x01, 0x81, 0x00,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x06, 0x01, 0x00,
  0x00, 0x0C, 0x01, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x18, 0x01, 0x00,
  0x00, 0x30, 0x01, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x40, 0x01, 0x00,
  0x00, 0xC0, 0x01, 0x00, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x06, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x10, 0x00, 0x01, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x60, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFE, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0xFF, 0xE0, 0x03, 0xFC, 0x3F, 0x00, 0x40, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x88,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0xE0, 0x7C, 0x00, 0xF0, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x07,
  0x00, 0x10, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x0F, 0xF0, 0x0C, 0x1F, 0xFF, 0x03, 0x1E, 0x00, 0x70, 0xCE, 0x00, 0x06,
  0x36, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x13, 0x80, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x05, 0x00, 0x00, 0x01,
  0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x32, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x02, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x40, 0x80, 0x00, 0x30, 0x30,
  0x00, 0x18, 0x07, 0x00, 0x0C, 0x00, 0x70, 0x0E, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x70, 0x03, 0x80, 0x30,
  0x00, 0x30, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x82, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x18, 0x00, 0x00, 0x46, 0x00, 0x00,
  0x11, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00,
  0x3C, 0x0E, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x38, 0x0E, 0x00, 0x18, 0x00, 0xE0, 0x1C, 0x00, 0x0C, 0x0E, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x46, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x1C,
  0x00, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xA8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1C, 0x01, 0xC0, 0x06, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x08, 0x60, 0x00, 0x01, 0x88, 0x00, 0x00, 0x31, 0x00, 0x00,
  0x02, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x48, 0x00, 0x00,
  0x19, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x62, 0x00, 0x00, 0x1C, 0x60,
  0x00, 0x06, 0x86, 0x00, 0x01, 0x90, 0x60, 0x00, 0xE2, 0x07, 0x00, 0x78,
  0x40, 0x7F, 0xFC, 0x08, 0x00, 0xFC, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x04, 0x00, 0x70, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x1C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x61, 0x86, 0x18, 0x43, 0x0C, 0x30, 0x86, 0x18, 0x41, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0xE0, 0xF0, 0x07, 0x84, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x05, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x60, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x03, 0xF8, 0x00, 0x10, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x63,
  0x00, 0x07, 0x00, 0x10, 0x01, 0x98, 0x00, 0x30, 0x00, 0x40, 0x06, 0x60,
  0x01, 0x80, 0x01, 0x00, 0x09, 0x80, 0x0C, 0x00, 0x04, 0x00, 0x24, 0x00,
  0x30, 0x00, 0x10, 0x00, 0xF0, 0x01, 0x80, 0x00, 0xC0, 0x03, 0xC0, 0x06,
  0x00, 0x03, 0x00, 0x0F, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0xF0, 0x03, 0x00, 0x00, 0xC0, 0x03, 0xC0, 0x0C, 0x00,
  0x03, 0x00, 0x0F, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x2C, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0xB0, 0x03, 0x00, 0x00, 0xC0, 0x06, 0xC0, 0x0C, 0x00, 0x07,
  0x00, 0x1B, 0x00, 0x10, 0x00, 0x1C, 0x00, 0x4C, 0x00, 0x60, 0x00, 0xF0,
  0x03, 0x10, 0x00, 0x80, 0x02, 0x40, 0x08, 0x60, 0x03, 0x00, 0x19, 0x80,
  0x61, 0x80, 0x07, 0x01, 0xC3, 0x03, 0x06, 0x00, 0x0F, 0xFC, 0x07, 0xF8,
  0x0C, 0x00, 0x07, 0x80, 0x07, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x01, 0x30, 0x00,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x08, 0x60,
  0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x30, 0x01, 0x00, 0x00, 0x08, 0x00, 0x60, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x06, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0x20, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x03, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x02, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x04, 0x06,
  0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x00, 0x46, 0x00, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00,
  0x00, 0x30, 0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x7F, 0x03, 0x00, 0x00, 0x78,
  0x60, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x01, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x03, 0x18,
  0x00, 0x01, 0xC3, 0x00, 0x01, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x01, 0x80, 0x00, 0x3C, 0x30, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x30, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0xE0, 0xC0, 0x07, 0xF0, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x38, 0x00, 0x01, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x04, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0x80, 0x0F, 0xE0, 0x03, 0x00, 0x00, 0xF8, 0x06, 0x00, 0x00, 0x38,
  0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x03, 0x80, 0x60, 0x00, 0x3E, 0x00, 0xC0, 0x3F, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xD8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x03, 0x20, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70,
  0x00, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x30, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x7F, 0xC0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0xCC, 0x1E, 0x3F, 0xE0, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x30, 0x0C, 0x00,
  0x06, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x03, 0x0F,
  0x00, 0x00, 0x63, 0x30, 0x00, 0x0C, 0xC6, 0x00, 0x01, 0xB0, 0x60, 0x00,
  0x3C, 0x06, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x01,
  0x80, 0x01, 0x80, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x30, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0B, 0xE0,
  0x00, 0x00, 0x00, 0xDD, 0x00, 0x00, 0x00, 0x06, 0xEC, 0x00, 0x00, 0x00,
  0x27, 0x20, 0x00, 0x00, 0x03, 0x39, 0x80, 0x00, 0x00, 0x11, 0xCC, 0x00,
  0x00, 0x01, 0x8E, 0x20, 0x00, 0x00, 0x0C, 0x71, 0x80, 0x00, 0x00, 0x43,
  0x84, 0x00, 0x00, 0x06, 0x1C, 0x30, 0x00, 0x00, 0x20, 0xE1, 0x80, 0x00,
  0x03, 0x07, 0x06, 0x00, 0x00, 0x18, 0x38, 0x30, 0x00, 0x01, 0x81, 0xC0,
  0x80, 0x00, 0x0C, 0x0E, 0x06, 0x00, 0x00, 0x40, 0x70, 0x30, 0x00, 0x06,
  0x03, 0x80, 0xC0, 0x00, 0x20, 0x1C, 0x06, 0x00, 0x03, 0x00, 0xE0, 0x10,
  0x00, 0x18, 0x07, 0x00, 0xC0, 0x00, 0x80, 0x38, 0x02, 0x00, 0x0C, 0x01,
  0xC0, 0x18, 0x00, 0x40, 0x0E, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x02, 0x00,
  0x30, 0x03, 0x80, 0x18, 0x01, 0x00, 0x1C, 0x00, 0x40, 0x18, 0x00, 0xE0,
  0x03, 0x00, 0x80, 0x07, 0x00, 0x18, 0x0C, 0x00, 0x38, 0x00, 0x40, 0x60,
  0x01, 0xC0, 0x03, 0x02, 0x00, 0x0E, 0x00, 0x08, 0x30, 0x00, 0x70, 0x00,
  0x61, 0x00, 0x03, 0x80, 0x03, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0xC0, 0x00,
  0xE0, 0x00, 0x6C, 0x00, 0x07, 0x00, 0x01, 0x60, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x00, 0x00, 0x40,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x07, 0x30, 0x00,
  0x00, 0x39, 0x80, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00,
  0x70, 0x40, 0x00, 0x03, 0x83, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x07, 0x01, 0x80, 0x00, 0x38, 0x06, 0x00, 0x01, 0xC0, 0x18,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x70, 0x03, 0x00, 0x03, 0x80, 0x0C, 0x00,
  0x1C, 0x00, 0x60, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x06, 0x00, 0x38,
  0x00, 0x30, 0x01, 0xC0, 0x00, 0xC0, 0x0E, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x18, 0x03, 0x80, 0x00, 0x60, 0x1C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x0C,
  0x07, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x63, 0x80, 0x00, 0x03, 0x1C, 0x00,
  0x00, 0x0C, 0xE0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00,
  0x00, 0x19, 0x00, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x05, 0x80, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x03, 0x20,
  0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00,
  0x04, 0x60, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x18, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0xC0, 0x07, 0xE0, 0xC0, 0x00, 0x78, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0xF0, 0xC0, 0x7F, 0xC0, 0xFF, 0xFE, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x03, 0x00, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x00, 0x16, 0x00, 0x00,
  0x00, 0x00, 0xA0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x18, 0x01, 0xFC, 0x03, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x04, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x01, 0x18, 0x00, 0x00, 0x23, 0x00, 0x00, 0x04, 0x60, 0x00,
  0x00, 0x8C, 0x00, 0x00, 0x11, 0x80, 0x00, 0x02, 0x30, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x02, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x0F, 0x80, 0x3F,
  0xFF, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x30,
  0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0xC0, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18,
  0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x78, 0x00, 0xF8, 0x38, 0x00, 0x04, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x80, 0x00, 0x1C, 0x3E, 0x00, 0x1E, 0x03,
  0xFF, 0xFE, 0x00, 0x02, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x60, 0x03, 0xC0, 0x0F, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x00, 0x4C, 0x00, 0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0x21, 0x80,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x08, 0x18,
  0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x02, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x40, 0x00, 0x01, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x08, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x60, 0x00, 0x10, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x10, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x18,
  0x10, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x22, 0x00, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x40, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x60, 0x00, 0x02, 0x80, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0,
  0x00, 0x04, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x40,
  0x00, 0x0C, 0x30, 0x00, 0x04, 0x40, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x60,
  0x00, 0x18, 0x10, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x10, 0x00, 0x08, 0x20,
  0x00, 0x18, 0x18, 0x00, 0x08, 0x30, 0x00, 0x10, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x30, 0x08, 0x00, 0x18, 0x10, 0x00, 0x30, 0x0C, 0x00, 0x10, 0x10,
  0x00, 0x20, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x18,
  0x00, 0x60, 0x04, 0x00, 0x30, 0x08, 0x00, 0x60, 0x06, 0x00, 0x20, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x02, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x02, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x03, 0x00, 0x40, 0x06,
  0x00, 0x80, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x01, 0x00, 0xC0, 0x02,
  0x01, 0x80, 0x01, 0x80, 0x80, 0x02, 0x01, 0x00, 0x01, 0x81, 0x80, 0x03,
  0x03, 0x00, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x00, 0x81, 0x80, 0x01,
  0x03, 0x00, 0x00, 0xC1, 0x00, 0x01, 0x82, 0x00, 0x00, 0xC3, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x43, 0x00, 0x01, 0x86, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x84, 0x00, 0x00, 0x62, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x26, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x48, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x70, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x02, 0x02, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x40, 0x00, 0x10, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x40,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x08, 0x03, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0x0C, 0x10, 0x00, 0x00, 0x20, 0x60, 0x00, 0x01, 0x80, 0x80, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x30, 0x04, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x06,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x02, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x80, 0x40, 0x00, 0x03, 0x03, 0x00, 0x00, 0x04, 0x18,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xF0, 0xC0, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0xFF, 0xF0, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x18, 0x80, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x30, 0x40, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60,
  0x20, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x80, 0x10, 0x00, 0x18, 0x01, 0x80,
  0x01, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x04, 0x00, 0x60,
  0x00, 0x60, 0x04, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x01,
  0x01, 0x80, 0x00, 0x18, 0x30, 0x00, 0x00, 0x83, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xFF,
  0x01, 0xE0, 0x0E, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x07,
  0xC0, 0x1F, 0xFF, 0x03, 0xE0, 0x04, 0x38, 0x00, 0x13, 0x80, 0x00, 0x58,
  0x00, 0x01, 0x60, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0x70, 0x00, 0x0D,
  0x60, 0x00, 0x65, 0xC0, 0x03, 0x13, 0xC0, 0x38, 0x43, 0xFF, 0x81, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x0F, 0xC0, 0x0C,
  0x1F, 0xFE, 0x03, 0x0E, 0x00, 0xE0, 0xC6, 0x00, 0x0C, 0x33, 0x00, 0x01,
  0x8D, 0x80, 0x00, 0x33, 0xC0, 0x00, 0x0C, 0xF0, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x02, 0xE0,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x33, 0xC0, 0x00, 0x0C,
  0xD0, 0x00, 0x06, 0x36, 0x00, 0x03, 0x0C, 0xC0, 0x01, 0x83, 0x1E, 0x01,
  0xC0, 0xC1, 0xFF, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0xFC, 0x07, 0x80, 0x18, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x3F, 0xFE, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x03, 0xE0, 0x10, 0x0F, 0xFF, 0x04, 0x0F, 0x00, 0xE1, 0x07,
  0x00, 0x0C, 0x43, 0x00, 0x01, 0x91, 0x80, 0x00, 0x34, 0x60, 0x00, 0x05,
  0x30, 0x00, 0x01, 0xC8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x03, 0x60, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0D, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x05,
  0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x05, 0x18, 0x00, 0x03, 0x43, 0x00, 0x01, 0x90,
  0x60, 0x00, 0xC4, 0x0E, 0x00, 0xE1, 0x00, 0xFF, 0xE0, 0x40, 0x01, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x01, 0x80, 0xC0, 0x00, 0x60, 0x40, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x60,
  0x00, 0x06, 0x30, 0x00, 0x01, 0x10, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x05, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x08, 0x0F,
  0x00, 0x3C, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x0F, 0x1C, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0xFC, 0x10, 0x38, 0x01, 0x84, 0x18, 0x00, 0x31, 0x0C, 0x00, 0x02,
  0x46, 0x00, 0x00, 0xF1, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x07, 0x20, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x40,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x03, 0x40, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x03, 0x20, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x53, 0x00, 0x00, 0x34,
  0x60, 0x00, 0x09, 0x0C, 0x00, 0x06, 0xC1, 0x80, 0x03, 0x30, 0x38, 0x03,
  0x8C, 0x03, 0xFF, 0x83, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x70, 0x1F, 0xC0, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x3F, 0x00, 0xC1, 0xFF, 0xE0, 0xC7,
  0x80, 0x78, 0xCE, 0x00, 0x1C, 0xD8, 0x00, 0x0C, 0xD0, 0x00, 0x06, 0xF0,
  0x00, 0x06, 0xE0, 0x00, 0x02, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x5F, 0xE0, 0x00, 0x00, 0x0D, 0xB6, 0xDB,
  0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x00, 0x00, 0x40,
  0x1C, 0x03, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x64, 0x38, 0xFE, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xB0, 0x00,
  0x18, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0x0C, 0x00, 0x18, 0x30, 0x00, 0xC0,
  0xC0, 0x06, 0x03, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x00, 0xC0,
  0x60, 0x03, 0x03, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x60, 0x00, 0xC3, 0xC0,
  0x03, 0x19, 0x80, 0x0C, 0xC6, 0x00, 0x36, 0x0C, 0x00, 0xF0, 0x18, 0x03,
  0x80, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0x80, 0xC0, 0x03, 0x03, 0x00,
  0x04, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x63, 0x00, 0x00,
  0x8C, 0x00, 0x03, 0x30, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0xC3, 0xFF, 0x80, 0x7F, 0xF0, 0xC7, 0x01, 0xC0, 0xE0, 0x1C,
  0xCC, 0x00, 0x61, 0x80, 0x0C, 0xD8, 0x00, 0x33, 0x00, 0x06, 0xF0, 0x00,
  0x36, 0x00, 0x03, 0xE0, 0x00, 0x14, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x01, 0xC0,
  0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0xC0, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x01, 0xC0,
  0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x3F, 0x00, 0xC1, 0xFF, 0xE0, 0xC3, 0x80, 0x70, 0xCE, 0x00,
  0x1C, 0xC8, 0x00, 0x0C, 0xD0, 0x00, 0x06, 0xF0, 0x00, 0x06, 0xE0, 0x00,
  0x02, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x06, 0x20, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x09, 0x80,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00,
  0x50, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x05, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x14, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x02, 0x30, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x18, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x30, 0x0E, 0x00, 0x1C, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x30, 0x3F, 0xF8, 0x0C,
  0x38, 0x03, 0x83, 0x18, 0x00, 0x30, 0xCC, 0x00, 0x06, 0x36, 0x00, 0x00,
  0xCD, 0x00, 0x00, 0x33, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x2E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0B, 0x80, 0x00, 0x06, 0xE0,
  0x00, 0x01, 0xBC, 0x00, 0x00, 0x4F, 0x00, 0x00, 0x33, 0x60, 0x00, 0x18,
  0xCC, 0x00, 0x0C, 0x33, 0x80, 0x06, 0x0C, 0x38, 0x07, 0x03, 0x07, 0xFF,
  0x80, 0xC0, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0xF8, 0x10, 0x38, 0x03, 0x84, 0x18, 0x00, 0x31,
  0x0C, 0x00, 0x06, 0x46, 0x00, 0x00, 0xF1, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x07, 0x20, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0xC8, 0x00, 0x00, 0x53,
  0x00, 0x00, 0x3C, 0x60, 0x00, 0x1B, 0x1C, 0x00, 0x04, 0xC3, 0x80, 0x07,
  0x30, 0x78, 0x07, 0x0C, 0x07, 0xFF, 0x83, 0x00, 0x3E, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x3C, 0xC3, 0xFF, 0xC7, 0x00, 0xCC,
  0x00, 0xD8, 0x00, 0xD0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x0F, 0xFF, 0xC0, 0xE0, 0x03, 0x86, 0x00, 0x02, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1B, 0x00, 0x00, 0xCF, 0x80, 0x0E, 0x07, 0xFF,
  0xE0, 0x00, 0x70, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x81, 0x01, 0xFF, 0x00, 0x18,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x80, 0x00, 0x15, 0x80, 0x00, 0x69, 0x80, 0x01, 0x93, 0x80, 0x06, 0x23,
  0xC0, 0x38, 0x41, 0xFF, 0xC0, 0x80, 0x78, 0x00, 0xC0, 0x00, 0x00, 0xA0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x62, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x10, 0x40, 0x00, 0x18, 0x30, 0x00, 0x08, 0x18, 0x00, 0x0C,
  0x04, 0x00, 0x06, 0x03, 0x00, 0x02, 0x01, 0x80, 0x03, 0x00, 0x40, 0x01,
  0x80, 0x30, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x40, 0x03, 0x00,
  0x60, 0x00, 0x80, 0x30, 0x00, 0x60, 0x10, 0x00, 0x10, 0x18, 0x00, 0x0C,
  0x08, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x06, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x11, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x02, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x34, 0x00, 0x03, 0x80, 0x00, 0xD8,
  0x00, 0x0B, 0x00, 0x03, 0x60, 0x00, 0x2C, 0x00, 0x08, 0x80, 0x01, 0x90,
  0x00, 0x63, 0x00, 0x04, 0x40, 0x01, 0x8C, 0x00, 0x11, 0x80, 0x04, 0x30,
  0x00, 0xC2, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00, 0xC1, 0x80, 0x08, 0x30,
  0x03, 0x06, 0x00, 0x60, 0x40, 0x08, 0x08, 0x01, 0x01, 0x00, 0x20, 0x30,
  0x04, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x02, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x03, 0x00, 0x60,
  0x40, 0x04, 0x0C, 0x00, 0x81, 0x00, 0x18, 0x20, 0x02, 0x0C, 0x00, 0x61,
  0x80, 0x0C, 0x20, 0x00, 0x86, 0x00, 0x30, 0x80, 0x03, 0x10, 0x00, 0x46,
  0x00, 0x0C, 0x40, 0x01, 0x90, 0x00, 0x13, 0x00, 0x06, 0x40, 0x00, 0x6C,
  0x00, 0x0B, 0x00, 0x01, 0xA0, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x10, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x60, 0x02, 0x00,
  0xC0, 0x03, 0x00, 0xC0, 0x01, 0x81, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC3,
  0x00, 0x01, 0x81, 0x80, 0x03, 0x00, 0xC0, 0x02, 0x00, 0x40, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x30, 0x00,
  0x0C, 0x60, 0x00, 0x06, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xA0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x10, 0x40, 0x00, 0x18, 0x30, 0x00, 0x08, 0x18,
  0x00, 0x0C, 0x04, 0x00, 0x06, 0x03, 0x00, 0x02, 0x01, 0x80, 0x03, 0x00,
  0x40, 0x01, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x40,
  0x03, 0x00, 0x60, 0x00, 0x80, 0x30, 0x00, 0x60, 0x10, 0x00, 0x10, 0x18,
  0x00, 0x0C, 0x08, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x06, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x11, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x02,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x00, 0x3E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x0E, 0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x2E, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xE0,
};

const GFXglyph NotoSans_Thin59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 3, 42, 13, 5, -42 },
  { 17, 11, 15, 19, 4, -42 },
  { 38, 34, 42, 38, 2, -42 },
  { 217, 24, 48, 34, 4, -45 },
  { 361, 40, 44, 47, 3, -43 },
  { 581, 35, 44, 41, 4, -43 },
  { 774, 2, 15, 10, 4, -42 },
  { 778, 11, 51, 15, 2, -42 },
  { 849, 11, 51, 15, 2, -42 },
  { 920, 25, 24, 33, 4, -45 },
  { 995, 27, 27, 34, 3, -34 },
  { 1087, 5, 15, 11, 2, -7 },
  { 1097, 15, 2, 19, 2, -17 },
  { 1101, 3, 3, 13, 5, -3 },
  { 1103, 17, 42, 19, 1, -42 },
  { 1193, 26, 44, 34, 4, -43 },
  { 1336, 13, 42, 34, 6, -42 },
  { 1405, 26, 43, 34, 3, -43 },
  { 1545, 26, 44, 34, 3, -43 },
  { 1688, 32, 42, 34, 1, -42 },
  { 1856, 26, 43, 34, 4, -42 },
  { 1996, 26, 44, 34, 4, -43 },
  { 2139, 27, 42, 34, 3, -42 },
  { 2281, 26, 44, 34, 4, -43 },
  { 2424, 27, 44, 34, 3, -43 },
  { 2573, 3, 31, 13, 5, -31 },
  { 2585, 6, 39, 13, 2, -31 },
  { 2615, 27, 27, 34, 3, -35 },
  { 2707, 27, 14, 34, 3, -28 },
  { 2755, 27, 27, 34, 3, -35 },
  { 2847, 20, 43, 24, 2, -43 },
  { 2955, 46, 48, 52, 3, -42 },
  { 3231, 34, 42, 34, 0, -42 },
  { 3410, 27, 42, 36, 6, -42 },
  { 3552, 30, 44, 36, 4, -43 },
  { 3717, 31, 42, 41, 6, -42 },
  { 3880, 23, 42, 32, 6, -42 },
  { 4001, 23, 42, 29, 6, -42 },
  { 4122, 34, 44, 42, 4, -43 },
  { 4309, 30, 42, 42, 6, -42 },
  { 4467, 9, 42, 17, 4, -42 },
  { 4515, 14, 52, 14, -6, -42 },
  { 4606, 27, 42, 33, 6, -42 },
  { 4748, 23, 42, 30, 6, -42 },
  { 4869, 37, 42, 49, 6, -42 },
  { 5064, 29, 42, 41, 6, -42 },
  { 5217, 37, 44, 44, 4, -43 },
  { 5421, 24, 42, 34, 6, -42 },
  { 5547, 37, 53, 44, 4, -43 },
  { 5793, 27, 42, 34, 6, -42 },
  { 5935, 26, 44, 32, 3, -43 },
  { 6078, 30, 42, 30, 0, -42 },
  { 6236, 30, 43, 42, 6, -42 },
  { 6398, 33, 42, 33, 0, -42 },
  { 6572, 48, 42, 51, 2, -42 },
  { 6824, 30, 42, 30, 0, -42 },
  { 6982, 30, 42, 30, 0, -42 },
  { 7140, 30, 42, 34, 2, -42 },
  { 7298, 12, 51, 18, 5, -42 },
  { 7375, 17, 42, 19, 1, -42 },
  { 7465, 12, 51, 18, 1, -42 },
  { 7542, 28, 26, 34, 3, -42 },
  { 7633, 23, 2, 23, 0, 5 },
  { 7639, 10, 9, 15, 2, -45 },
  { 7651, 22, 33, 30, 3, -32 },
  { 7742, 26, 46, 34, 5, -45 },
  { 7892, 23, 33, 28, 3, -32 },
  { 7987, 26, 46, 34, 3, -45 },
  { 8137, 25, 33, 32, 3, -32 },
  { 8241, 19, 45, 16, 1, -45 },
  { 8348, 26, 46, 34, 3, -32 },
  { 8498, 24, 45, 34, 5, -45 },
  { 8633, 3, 43, 12, 5, -43 },
  { 8650, 11, 57, 12, -3, -43 },
  { 8729, 22, 45, 27, 5, -45 },
  { 8853, 2, 45, 12, 5, -45 },
  { 8865, 40, 32, 50, 5, -32 },
  { 9025, 24, 32, 34, 5, -32 },
  { 9121, 27, 33, 34, 3, -32 },
  { 9233, 26, 46, 34, 5, -32 },
  { 9383, 26, 46, 34, 3, -32 },
  { 9533, 16, 32, 22, 5, -32 },
  { 9597, 22, 33, 27, 2, -32 },
  { 9688, 16, 40, 19, 1, -39 },
  { 9768, 23, 32, 34, 5, -31 },
  { 9860, 25, 31, 25, 0, -31 },
  { 9957, 38, 31, 40, 1, -31 },
  { 10105, 24, 31, 28, 2, -31 },
  { 10198, 25, 45, 25, 0, -31 },
  { 10339, 22, 31, 27, 2, -31 },
  { 10425, 16, 51, 20, 2, -42 },
  { 10527, 1, 60, 32, 15, -45 },
  { 10535, 16, 51, 20, 2, -42 },
  { 10637, 27, 5, 34, 3, -23 },
};

const GFXfont NotoSans_Thin59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin59pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_THIN59PT7B_H_
