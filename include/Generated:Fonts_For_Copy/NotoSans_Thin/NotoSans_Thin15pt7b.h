#ifndef _NOTOSANS_THIN15PT7B_H_
#define _NOTOSANS_THIN15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x20, 0xB6, 0xD0, 0x09, 0x08, 0x84, 0x4F, 0xF1, 0x20, 0x90,
  0x89, 0xFF, 0x24, 0x12, 0x09, 0x00, 0x7A, 0x9A, 0x28, 0xE0, 0xC2, 0x89,
  0x24, 0x9F, 0x88, 0x61, 0x24, 0x49, 0x22, 0x48, 0x95, 0xA5, 0x96, 0xA4,
  0x49, 0x12, 0x48, 0x92, 0x3C, 0x38, 0x22, 0x11, 0x08, 0x82, 0x83, 0x82,
  0x23, 0x09, 0x83, 0x41, 0x9F, 0x20, 0xF0, 0x5A, 0xAA, 0xAA, 0x40, 0xA5,
  0x55, 0x56, 0x80, 0x10, 0x4D, 0xCC, 0x49, 0x20, 0x10, 0x20, 0x47, 0xF1,
  0x02, 0x04, 0x00, 0xF0, 0xE0, 0x80, 0x08, 0x84, 0x22, 0x10, 0x88, 0x44,
  0x20, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x09, 0xE0, 0x2E,
  0x92, 0x49, 0x24, 0x80, 0x7A, 0x10, 0x41, 0x04, 0x20, 0x84, 0x21, 0x0F,
  0xC0, 0x7A, 0x10, 0x41, 0x05, 0xE0, 0x41, 0x04, 0x1F, 0x80, 0x02, 0x04,
  0x0A, 0x12, 0x12, 0x22, 0x42, 0xFF, 0x02, 0x02, 0x02, 0x7D, 0x02, 0x04,
  0x0F, 0x01, 0x80, 0x81, 0x02, 0x0B, 0xE0, 0x3C, 0x82, 0x04, 0x0B, 0x98,
  0xA0, 0xC1, 0x83, 0x05, 0xF0, 0xFE, 0x04, 0x10, 0x20, 0x81, 0x04, 0x08,
  0x10, 0x40, 0x80, 0x79, 0x0A, 0x14, 0x24, 0x87, 0x31, 0x41, 0x83, 0x05,
  0xF0, 0x79, 0x0A, 0x14, 0x18, 0x30, 0x9E, 0x81, 0x04, 0x0B, 0xE0, 0x81,
  0x83, 0xC0, 0x06, 0x31, 0x84, 0x06, 0x03, 0x01, 0x80, 0xFE, 0x03, 0xF8,
  0x80, 0xC0, 0x60, 0x30, 0xCE, 0x20, 0x00, 0xF0, 0x42, 0x11, 0x11, 0x08,
  0x00, 0x10, 0x0F, 0x06, 0x19, 0x00, 0xC3, 0x19, 0x93, 0x22, 0x64, 0x4C,
  0x89, 0x93, 0x31, 0x99, 0x00, 0x10, 0x81, 0xE0, 0x08, 0x0C, 0x05, 0x02,
  0x82, 0x41, 0x11, 0xF8, 0x82, 0x41, 0x40, 0xA0, 0x20, 0xFA, 0x18, 0x61,
  0x87, 0xE8, 0x61, 0x86, 0x1F, 0x80, 0x3F, 0x40, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x40, 0x3F, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x0B, 0xE0, 0xFC, 0x21, 0x08, 0x7E, 0x10, 0x84, 0x3E, 0xFC, 0x21,
  0x08, 0x7E, 0x10, 0x84, 0x20, 0x1F, 0x30, 0x10, 0x10, 0x08, 0x04, 0x7A,
  0x03, 0x01, 0x80, 0xA0, 0x4F, 0xC0, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xE0,
  0xC1, 0x83, 0x06, 0x08, 0xD5, 0x55, 0x5C, 0x24, 0x92, 0x49, 0x24, 0x93,
  0x80, 0x86, 0x29, 0x28, 0xC2, 0x8A, 0x24, 0x8A, 0x18, 0x40, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x3E, 0x80, 0xC0, 0x60, 0x70, 0x3C, 0x2D, 0x16,
  0x8B, 0x49, 0x94, 0xCC, 0x62, 0x20, 0x83, 0x06, 0x0E, 0x1A, 0x32, 0x64,
  0xC5, 0x87, 0x0E, 0x08, 0x3E, 0x20, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xA0, 0x4F, 0xC0, 0xF2, 0x38, 0x61, 0x86, 0x2F, 0x20, 0x82,
  0x08, 0x00, 0x3E, 0x20, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xA0, 0x4E, 0xC0, 0x80, 0x20, 0x08, 0xFA, 0x18, 0x61, 0x86, 0x2F, 0x24,
  0x8A, 0x18, 0x40, 0x7E, 0x08, 0x20, 0xC0, 0xC0, 0xC1, 0x04, 0x1F, 0x80,
  0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x3E, 0x81, 0x81,
  0x41, 0x41, 0x42, 0x22, 0x24, 0x24, 0x14, 0x18, 0x08, 0x82, 0x0A, 0x10,
  0x51, 0x44, 0x8A, 0x24, 0x51, 0x12, 0x90, 0xA2, 0x85, 0x14, 0x28, 0xA0,
  0x82, 0x04, 0x10, 0x81, 0x42, 0x44, 0x24, 0x18, 0x10, 0x18, 0x24, 0x44,
  0x42, 0x81, 0x81, 0x82, 0x42, 0x44, 0x24, 0x18, 0x10, 0x10, 0x10, 0x10,
  0x10, 0xFE, 0x04, 0x10, 0x41, 0x02, 0x08, 0x20, 0x41, 0x03, 0xF8, 0xF2,
  0x49, 0x24, 0x92, 0x4E, 0x84, 0x10, 0x84, 0x10, 0x82, 0x10, 0x82, 0xE4,
  0x92, 0x49, 0x24, 0x9E, 0x10, 0x60, 0xA2, 0x44, 0x50, 0xA0, 0x80, 0xFC,
  0x90, 0xF8, 0x42, 0x7C, 0xC6, 0x3F, 0x81, 0x02, 0x07, 0xE8, 0x30, 0x60,
  0xC1, 0x83, 0x07, 0xF0, 0x7E, 0x08, 0x20, 0x82, 0x08, 0x1F, 0x04, 0x10,
  0x5F, 0x86, 0x18, 0x61, 0x86, 0x17, 0xC0, 0x7A, 0x18, 0x7F, 0x82, 0x08,
  0x1F, 0x3A, 0x11, 0xE4, 0x21, 0x08, 0x42, 0x10, 0x7E, 0x18, 0x61, 0x86,
  0x18, 0x5F, 0x04, 0x18, 0x5E, 0x82, 0x08, 0x3F, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x40, 0x9F, 0xE0, 0x20, 0x12, 0x49, 0x24, 0x92, 0x70, 0x82, 0x08,
  0x23, 0x8A, 0x4A, 0x34, 0x92, 0x28, 0x40, 0xFF, 0xE0, 0xFB, 0xD0, 0x86,
  0x10, 0xC2, 0x18, 0x43, 0x08, 0x61, 0x0C, 0x21, 0xFE, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x79, 0x0A, 0x0C, 0x18, 0x30, 0x61, 0x3E, 0xBD, 0x86, 0x0C,
  0x18, 0x30, 0x60, 0xFE, 0x81, 0x02, 0x00, 0x7E, 0x18, 0x61, 0x86, 0x18,
  0x5F, 0x04, 0x10, 0x40, 0xF8, 0x88, 0x88, 0x88, 0xFC, 0x20, 0xC1, 0x04,
  0x3F, 0x44, 0xF4, 0x44, 0x44, 0x47, 0x86, 0x18, 0x61, 0x86, 0x18, 0x5F,
  0x86, 0x14, 0x52, 0x48, 0xA3, 0x04, 0x84, 0x61, 0x14, 0xC5, 0x2A, 0x52,
  0x94, 0xA2, 0x10, 0x84, 0x42, 0x88, 0xA0, 0x81, 0x05, 0x11, 0x41, 0x86,
  0x14, 0x52, 0x48, 0xA3, 0x04, 0x20, 0x82, 0x30, 0xF8, 0x44, 0x42, 0x22,
  0x1F, 0x19, 0x08, 0x42, 0x13, 0x08, 0x21, 0x08, 0x43, 0x80, 0xFF, 0xFE,
  0x84, 0x44, 0x44, 0x32, 0x44, 0x44, 0xC0, 0xFE,
};

const GFXglyph NotoSans_Thin15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 11, 3, 1, -11 },
  { 3, 3, 4, 5, 1, -11 },
  { 5, 9, 11, 10, 0, -11 },
  { 18, 6, 12, 9, 1, -11 },
  { 27, 10, 11, 12, 1, -11 },
  { 41, 9, 11, 11, 1, -11 },
  { 54, 1, 4, 3, 1, -11 },
  { 55, 2, 13, 4, 1, -11 },
  { 59, 2, 13, 4, 1, -11 },
  { 63, 6, 6, 8, 1, -11 },
  { 68, 7, 7, 9, 1, -9 },
  { 75, 1, 4, 3, 1, -2 },
  { 76, 3, 1, 5, 1, -5 },
  { 77, 1, 1, 3, 1, -1 },
  { 78, 5, 11, 5, 0, -11 },
  { 85, 7, 11, 9, 1, -11 },
  { 95, 3, 11, 9, 2, -11 },
  { 100, 6, 11, 9, 1, -11 },
  { 109, 6, 11, 9, 1, -11 },
  { 118, 8, 11, 9, 0, -11 },
  { 129, 7, 11, 9, 1, -11 },
  { 139, 7, 11, 9, 1, -11 },
  { 149, 7, 11, 9, 1, -11 },
  { 159, 7, 11, 9, 1, -11 },
  { 169, 7, 11, 9, 1, -11 },
  { 179, 1, 8, 3, 1, -8 },
  { 180, 1, 10, 3, 1, -8 },
  { 182, 7, 7, 9, 1, -9 },
  { 189, 7, 3, 9, 1, -7 },
  { 192, 7, 7, 9, 1, -9 },
  { 199, 5, 11, 6, 1, -11 },
  { 206, 11, 13, 13, 1, -11 },
  { 224, 9, 11, 9, 0, -11 },
  { 237, 6, 11, 9, 2, -11 },
  { 246, 8, 11, 9, 1, -11 },
  { 257, 7, 11, 10, 2, -11 },
  { 267, 5, 11, 8, 2, -11 },
  { 274, 5, 11, 7, 2, -11 },
  { 281, 9, 11, 11, 1, -11 },
  { 294, 7, 11, 11, 2, -11 },
  { 304, 2, 11, 4, 1, -11 },
  { 307, 3, 14, 3, -1, -11 },
  { 313, 6, 11, 8, 2, -11 },
  { 322, 5, 11, 8, 2, -11 },
  { 329, 9, 11, 13, 2, -11 },
  { 342, 7, 11, 10, 2, -11 },
  { 352, 9, 11, 11, 1, -11 },
  { 365, 6, 11, 9, 2, -11 },
  { 374, 9, 14, 11, 1, -11 },
  { 390, 6, 11, 9, 2, -11 },
  { 399, 6, 11, 8, 1, -11 },
  { 408, 8, 11, 8, 0, -11 },
  { 419, 8, 11, 11, 1, -11 },
  { 430, 8, 11, 8, 0, -11 },
  { 441, 13, 11, 13, 0, -11 },
  { 459, 8, 11, 8, 0, -11 },
  { 470, 8, 11, 8, 0, -11 },
  { 481, 7, 11, 9, 1, -11 },
  { 491, 3, 13, 5, 1, -11 },
  { 496, 5, 11, 5, 0, -11 },
  { 503, 3, 13, 5, 0, -11 },
  { 508, 7, 7, 9, 1, -11 },
  { 515, 6, 1, 6, 0, 1 },
  { 516, 2, 2, 4, 1, -11 },
  { 517, 5, 8, 8, 1, -8 },
  { 522, 7, 11, 9, 1, -11 },
  { 532, 6, 8, 7, 1, -8 },
  { 538, 6, 11, 9, 1, -11 },
  { 547, 6, 8, 8, 1, -8 },
  { 553, 5, 11, 4, 0, -11 },
  { 560, 6, 12, 9, 1, -8 },
  { 569, 6, 11, 9, 1, -11 },
  { 578, 1, 11, 3, 1, -11 },
  { 580, 3, 15, 3, -1, -11 },
  { 586, 6, 11, 7, 1, -11 },
  { 595, 1, 11, 3, 1, -11 },
  { 597, 11, 8, 13, 1, -8 },
  { 608, 6, 8, 9, 1, -8 },
  { 614, 7, 8, 9, 1, -8 },
  { 621, 7, 11, 9, 1, -8 },
  { 631, 6, 11, 9, 1, -8 },
  { 640, 4, 8, 6, 1, -8 },
  { 644, 5, 8, 7, 1, -8 },
  { 649, 4, 10, 5, 0, -10 },
  { 654, 6, 8, 9, 1, -8 },
  { 660, 6, 8, 6, 0, -8 },
  { 666, 10, 8, 10, 0, -8 },
  { 676, 7, 8, 7, 0, -8 },
  { 683, 6, 12, 6, 0, -8 },
  { 692, 5, 8, 7, 1, -8 },
  { 697, 5, 13, 5, 0, -11 },
  { 706, 1, 15, 8, 3, -11 },
  { 708, 4, 13, 5, 1, -11 },
  { 715, 7, 1, 9, 1, -6 },
};

const GFXfont NotoSans_Thin15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin15pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_THIN15PT7B_H_
