#ifndef _NOTOSANS_THIN42PT7B_H_
#define _NOTOSANS_THIN42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin42pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0xA8, 0x00, 0xF0, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x00, 0x20, 0x18, 0x00, 0x10,
  0x08, 0x00, 0x08, 0x04, 0x00, 0x0C, 0x02, 0x00, 0x04, 0x01, 0x00, 0x02,
  0x00, 0x80, 0x01, 0x00, 0x80, 0x00, 0x80, 0x40, 0x00, 0x40, 0x20, 0x00,
  0x40, 0x10, 0x0F, 0xFF, 0xFF, 0xE0, 0x10, 0x08, 0x00, 0x08, 0x04, 0x00,
  0x04, 0x02, 0x00, 0x04, 0x01, 0x00, 0x02, 0x00, 0x80, 0x01, 0x00, 0x80,
  0x00, 0x80, 0x40, 0x00, 0x40, 0x20, 0x1F, 0xFF, 0xFF, 0xC0, 0x20, 0x08,
  0x00, 0x10, 0x0C, 0x00, 0x08, 0x04, 0x00, 0x04, 0x02, 0x00, 0x06, 0x01,
  0x00, 0x02, 0x00, 0x80, 0x01, 0x00, 0xC0, 0x00, 0x80, 0x40, 0x00, 0x40,
  0x20, 0x00, 0x60, 0x10, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x03,
  0xFF, 0x83, 0x08, 0x22, 0x04, 0x03, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80,
  0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x0C, 0x08, 0x03, 0x04, 0x00, 0xC2,
  0x00, 0x19, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x26, 0x00, 0x10, 0xC0,
  0x08, 0x30, 0x04, 0x08, 0x02, 0x06, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40,
  0xC0, 0x20, 0x40, 0x10, 0x20, 0x08, 0x24, 0x04, 0x33, 0xFB, 0xE0, 0x0B,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x1F, 0x80, 0x03, 0x01, 0x82, 0x00,
  0x10, 0x08, 0x08, 0x01, 0x00, 0x80, 0x40, 0x18, 0x04, 0x03, 0x00, 0x80,
  0x20, 0x08, 0x0C, 0x01, 0x00, 0x40, 0x40, 0x08, 0x02, 0x04, 0x00, 0xC0,
  0x10, 0x20, 0x06, 0x00, 0x82, 0x00, 0x10, 0x04, 0x10, 0x00, 0x80, 0x21,
  0x00, 0x04, 0x01, 0x18, 0xFC, 0x20, 0x18, 0x8C, 0x11, 0x00, 0x8C, 0x40,
  0xC4, 0x04, 0x44, 0x02, 0x30, 0x44, 0x20, 0x10, 0xFC, 0x21, 0x00, 0xC0,
  0x02, 0x18, 0x02, 0x00, 0x10, 0x80, 0x10, 0x01, 0x04, 0x00, 0x80, 0x18,
  0x20, 0x04, 0x00, 0x81, 0x00, 0x20, 0x0C, 0x0C, 0x01, 0x00, 0x40, 0x20,
  0x18, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x04, 0x02, 0x00, 0x60, 0x60,
  0x10, 0x01, 0x82, 0x01, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0x02, 0x03,
  0x00, 0x02, 0x00, 0xC0, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x18, 0x03, 0x00, 0x04,
  0x01, 0x00, 0x01, 0x01, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x30, 0x30, 0x01,
  0x30, 0x0C, 0x00, 0x90, 0x03, 0x00, 0xD0, 0x00, 0xC0, 0x48, 0x00, 0x30,
  0x24, 0x00, 0x0C, 0x22, 0x00, 0x03, 0x31, 0x00, 0x00, 0xD0, 0x80, 0x00,
  0x30, 0x40, 0x00, 0x1C, 0x10, 0x00, 0x13, 0x0C, 0x00, 0x10, 0xC3, 0x00,
  0x30, 0x30, 0x7F, 0xE0, 0x0C, 0xFF, 0xE0, 0x06, 0x08, 0x20, 0xC1, 0x06,
  0x08, 0x10, 0x40, 0x81, 0x06, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x80, 0x81, 0x02, 0x06, 0x04, 0x08, 0x08, 0x10,
  0x10, 0x30, 0x20, 0x20, 0x80, 0x81, 0x81, 0x01, 0x02, 0x02, 0x04, 0x08,
  0x08, 0x10, 0x20, 0x40, 0xC0, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x83, 0x04, 0x08, 0x10, 0x60, 0x81, 0x06, 0x08, 0x30, 0x41, 0x06, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x03, 0x02, 0x06, 0xF1, 0x1E, 0x07, 0xF0, 0x00, 0x40, 0x00, 0x50,
  0x00, 0x44, 0x00, 0x22, 0x00, 0x20, 0x80, 0x20, 0x20, 0x30, 0x18, 0x10,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x0F, 0xFF, 0xFF, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x24, 0xB4, 0x96, 0x90, 0xFF, 0xC0, 0xF0, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x07, 0xF8, 0x02, 0x01, 0x81, 0x00,
  0x20, 0x80, 0x04, 0x60, 0x01, 0x90, 0x00, 0x24, 0x00, 0x0B, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x0D, 0x00, 0x02,
  0x40, 0x00, 0x98, 0x00, 0x62, 0x00, 0x10, 0x40, 0x08, 0x08, 0x04, 0x01,
  0xFE, 0x00, 0x00, 0x81, 0xC1, 0xA1, 0x93, 0x0B, 0x07, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x07, 0xF8, 0x03, 0x00, 0xC1, 0x80, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFC, 0x07, 0x00, 0x41, 0x80, 0x04, 0x40, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x38, 0x01, 0xFC, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x02, 0x40, 0x00, 0xCE, 0x00, 0x60, 0x7F, 0xF8, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x24, 0x00,
  0x00, 0xC8, 0x00, 0x01, 0x10, 0x00, 0x04, 0x20, 0x00, 0x10, 0x40, 0x00,
  0x60, 0x80, 0x00, 0x81, 0x00, 0x02, 0x02, 0x00, 0x08, 0x04, 0x00, 0x30,
  0x08, 0x00, 0x40, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x18, 0x00,
  0x80, 0x20, 0x01, 0x00, 0x80, 0x02, 0x02, 0x00, 0x04, 0x0C, 0x00, 0x08,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x3F, 0xFF, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x4F, 0xF0, 0x1E, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x1A, 0x00, 0x0C, 0xE0, 0x0C, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x60, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x7F, 0xC1, 0x38, 0x06, 0x2C, 0x00, 0x65, 0x00,
  0x04, 0xC0, 0x00, 0x58, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x44, 0x00,
  0x18, 0x80, 0x02, 0x08, 0x00, 0x80, 0xC0, 0x60, 0x0F, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x07,
  0xF8, 0x06, 0x01, 0x82, 0x00, 0x11, 0x80, 0x06, 0x40, 0x00, 0x90, 0x00,
  0x24, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x98, 0x00, 0x43, 0x00, 0x30,
  0x60, 0x18, 0x0E, 0x18, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x30, 0x70, 0x10,
  0x06, 0x08, 0x00, 0x44, 0x00, 0x0B, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x34, 0x00, 0x09,
  0x80, 0x04, 0x30, 0x06, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0x00, 0xC0,
  0xC0, 0x0C, 0x10, 0x00, 0xC4, 0x00, 0x08, 0x80, 0x00, 0x90, 0x00, 0x16,
  0x00, 0x02, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x14,
  0x00, 0x06, 0x80, 0x00, 0xC8, 0x00, 0x29, 0x80, 0x09, 0x18, 0x06, 0x20,
  0xFF, 0x84, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x7F, 0xE0, 0x00, 0x80, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x33, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x22, 0x64, 0x44, 0xC8, 0x80, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xC2, 0x00, 0xC0, 0x01, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x60,
  0x20, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x02,
  0x10, 0x01, 0xFF, 0x00, 0x98, 0x03, 0x00, 0x80, 0x48, 0x03, 0x00, 0x40,
  0x24, 0x03, 0x00, 0x20, 0x12, 0x01, 0x00, 0x10, 0x0F, 0x01, 0x80, 0x08,
  0x03, 0x00, 0x80, 0x04, 0x01, 0x80, 0x40, 0x02, 0x00, 0xC0, 0x20, 0x01,
  0x00, 0xE0, 0x10, 0x01, 0x80, 0x50, 0x08, 0x00, 0xC0, 0x28, 0x04, 0x00,
  0x60, 0x16, 0x03, 0x00, 0x30, 0x19, 0x00, 0x80, 0x28, 0x08, 0x80, 0x60,
  0x26, 0x08, 0x40, 0x0F, 0xE1, 0xF8, 0x10, 0x00, 0x80, 0x10, 0x08, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x02, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x14, 0x00, 0x00, 0x34, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x22, 0x00, 0x00, 0x42, 0x00, 0x00, 0x41, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x80, 0x80, 0x01, 0x00, 0x80, 0x01, 0x00, 0xC0, 0x03,
  0x00, 0x40, 0x02, 0x00, 0x40, 0x02, 0x00, 0x20, 0x04, 0x00, 0x20, 0x04,
  0x00, 0x30, 0x07, 0xFF, 0xF0, 0x08, 0x00, 0x10, 0x08, 0x00, 0x18, 0x18,
  0x00, 0x08, 0x10, 0x00, 0x08, 0x10, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20,
  0x00, 0x06, 0x60, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xFF, 0xF8, 0x10, 0x00, 0xE2, 0x00, 0x06, 0x40, 0x00, 0x68,
  0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x48, 0x00, 0x11, 0x00, 0x3C, 0x3F,
  0xFF, 0x04, 0x00, 0x18, 0x80, 0x00, 0xD0, 0x00, 0x0A, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x40, 0x00, 0xC8, 0x00, 0x71, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x1C, 0x00, 0xC1, 0x80, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x80, 0x7F, 0xF8, 0xFF, 0xF8, 0x02,
  0x00, 0x3C, 0x08, 0x00, 0x18, 0x20, 0x00, 0x10, 0x80, 0x00, 0x22, 0x00,
  0x00, 0x48, 0x00, 0x01, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x28, 0x00, 0x00,
  0xA0, 0x00, 0x04, 0x80, 0x00, 0x32, 0x00, 0x00, 0x88, 0x00, 0x0C, 0x20,
  0x00, 0x60, 0x80, 0x0E, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x03, 0xFF, 0xFD, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x07, 0xFF, 0xFC,
  0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xFE, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0x80, 0x07, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00,
  0x01, 0x60, 0x00, 0x01, 0x20, 0x00, 0x01, 0x10, 0x00, 0x01, 0x18, 0x00,
  0x01, 0x06, 0x00, 0x01, 0x03, 0x80, 0x07, 0x00, 0xFF, 0xF8, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x33, 0xF0, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18,
  0x0C, 0xFE, 0x00, 0x80, 0x00, 0x70, 0x00, 0x1A, 0x00, 0x06, 0x40, 0x01,
  0x88, 0x00, 0x61, 0x00, 0x18, 0x20, 0x06, 0x04, 0x01, 0x80, 0x80, 0x60,
  0x10, 0x18, 0x02, 0x06, 0x00, 0x41, 0x80, 0x08, 0x60, 0x01, 0x1C, 0x00,
  0x26, 0x40, 0x05, 0x8C, 0x00, 0xE0, 0xC0, 0x18, 0x08, 0x02, 0x00, 0x80,
  0x40, 0x18, 0x08, 0x01, 0x81, 0x00, 0x10, 0x20, 0x01, 0x04, 0x00, 0x30,
  0x80, 0x02, 0x10, 0x00, 0x22, 0x00, 0x06, 0x40, 0x00, 0x68, 0x00, 0x05,
  0x00, 0x00, 0x40, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x80, 0x00,
  0x02, 0xD8, 0x00, 0x00, 0x59, 0x00, 0x00, 0x13, 0x20, 0x00, 0x02, 0x62,
  0x00, 0x00, 0xCC, 0x40, 0x00, 0x11, 0x8C, 0x00, 0x02, 0x30, 0x80, 0x00,
  0x86, 0x10, 0x00, 0x10, 0xC1, 0x00, 0x06, 0x18, 0x20, 0x00, 0x83, 0x06,
  0x00, 0x10, 0x60, 0x40, 0x04, 0x0C, 0x08, 0x00, 0x81, 0x80, 0x80, 0x30,
  0x30, 0x10, 0x04, 0x06, 0x03, 0x00, 0x80, 0xC0, 0x20, 0x20, 0x18, 0x04,
  0x04, 0x03, 0x00, 0x41, 0x00, 0x60, 0x08, 0x20, 0x0C, 0x01, 0x8C, 0x01,
  0x80, 0x11, 0x00, 0x30, 0x03, 0x20, 0x06, 0x00, 0x28, 0x00, 0xC0, 0x05,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x40, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x60, 0x00, 0x19, 0x00, 0x00, 0xCC, 0x00,
  0x06, 0x30, 0x00, 0x30, 0x80, 0x01, 0x82, 0x00, 0x0C, 0x18, 0x00, 0x60,
  0x40, 0x03, 0x01, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x20, 0x06, 0x00, 0x80,
  0x30, 0x06, 0x01, 0x80, 0x10, 0x0C, 0x00, 0x40, 0x60, 0x03, 0x03, 0x00,
  0x08, 0x18, 0x00, 0x20, 0xC0, 0x01, 0x86, 0x00, 0x04, 0x30, 0x00, 0x11,
  0x80, 0x00, 0xCC, 0x00, 0x03, 0x60, 0x00, 0x0B, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x04, 0x00, 0xFF, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x00, 0xC0, 0x60, 0x00, 0x18, 0x10, 0x00, 0x02, 0x08, 0x00, 0x00, 0x46,
  0x00, 0x00, 0x11, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0xA0, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x90, 0x00, 0x00, 0x24, 0x00, 0x00, 0x09, 0x80, 0x00, 0x04, 0x20, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x81, 0x80, 0x00, 0x40, 0x30, 0x00, 0x20, 0x03,
  0x00, 0x30, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x20, 0x07, 0x08, 0x00,
  0x32, 0x00, 0x04, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xA0,
  0x00, 0x48, 0x00, 0x22, 0x00, 0x30, 0xFF, 0xF0, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0xC0,
  0x60, 0x00, 0x18, 0x10, 0x00, 0x02, 0x08, 0x00, 0x00, 0x46, 0x00, 0x00,
  0x11, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x90, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x09, 0x80, 0x00, 0x04, 0x20, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x40, 0x30, 0x00, 0x20, 0x03, 0x00, 0x30,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x0C, 0x00, 0xFF, 0xF0, 0x10, 0x03, 0xC2, 0x00, 0x0C, 0x40, 0x00,
  0xC8, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x34, 0x00, 0x02, 0x80, 0x00,
  0xD0, 0x00, 0x1A, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x19, 0x00, 0x06,
  0x20, 0x01, 0x84, 0x07, 0xC0, 0xFF, 0xE0, 0x10, 0x06, 0x02, 0x00, 0x40,
  0x40, 0x0C, 0x08, 0x00, 0x81, 0x00, 0x08, 0x20, 0x01, 0x84, 0x00, 0x10,
  0x80, 0x03, 0x10, 0x00, 0x22, 0x00, 0x02, 0x40, 0x00, 0x68, 0x00, 0x05,
  0x00, 0x00, 0xC0, 0x07, 0xFF, 0x03, 0x80, 0x18, 0xC0, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xCC, 0x00, 0x70,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x02, 0x40, 0x00, 0x09, 0x80, 0x00, 0x62, 0x00, 0x01,
  0x04, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x0F, 0xFC, 0x00, 0x80, 0x00, 0x03,
  0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x04, 0x20, 0x00, 0x04,
  0x20, 0x00, 0x0C, 0x30, 0x00, 0x08, 0x10, 0x00, 0x08, 0x10, 0x00, 0x10,
  0x08, 0x00, 0x10, 0x08, 0x00, 0x10, 0x0C, 0x00, 0x20, 0x04, 0x00, 0x20,
  0x04, 0x00, 0x60, 0x06, 0x00, 0x40, 0x02, 0x00, 0x40, 0x02, 0x00, 0x80,
  0x01, 0x00, 0x80, 0x01, 0x01, 0x80, 0x01, 0x81, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x83, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x42, 0x00, 0x00, 0x44, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x50, 0x00, 0x30, 0x00, 0x14,
  0x00, 0x0C, 0x00, 0x0D, 0x00, 0x02, 0x80, 0x02, 0x20, 0x01, 0x20, 0x00,
  0x88, 0x00, 0x48, 0x00, 0x22, 0x00, 0x13, 0x00, 0x10, 0xC0, 0x04, 0x40,
  0x04, 0x10, 0x02, 0x10, 0x01, 0x04, 0x00, 0x84, 0x00, 0xC1, 0x00, 0x20,
  0x80, 0x20, 0x20, 0x18, 0x20, 0x08, 0x08, 0x04, 0x08, 0x02, 0x02, 0x01,
  0x02, 0x01, 0x80, 0x80, 0x40, 0x40, 0x40, 0x10, 0x30, 0x10, 0x10, 0x04,
  0x08, 0x04, 0x0C, 0x01, 0x02, 0x01, 0x82, 0x00, 0x60, 0x80, 0x20, 0x80,
  0x08, 0x40, 0x08, 0x20, 0x02, 0x10, 0x02, 0x18, 0x00, 0x84, 0x00, 0x44,
  0x00, 0x13, 0x00, 0x11, 0x00, 0x04, 0x80, 0x04, 0xC0, 0x01, 0x20, 0x01,
  0xA0, 0x00, 0x48, 0x00, 0x28, 0x00, 0x0E, 0x00, 0x0A, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x18, 0x80, 0x00, 0xC3, 0x00, 0x02, 0x04, 0x00, 0x18, 0x08, 0x00,
  0x40, 0x30, 0x02, 0x00, 0x40, 0x18, 0x00, 0x80, 0x40, 0x03, 0x02, 0x00,
  0x04, 0x18, 0x00, 0x08, 0x40, 0x00, 0x22, 0x00, 0x00, 0x58, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x48, 0x00, 0x02, 0x20,
  0x00, 0x18, 0x40, 0x00, 0x41, 0x80, 0x02, 0x02, 0x00, 0x18, 0x04, 0x00,
  0x40, 0x18, 0x02, 0x00, 0x20, 0x18, 0x00, 0x40, 0x40, 0x01, 0x82, 0x00,
  0x02, 0x18, 0x00, 0x04, 0x40, 0x00, 0x1B, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x0A, 0x00, 0x00, 0x98, 0x00, 0x04, 0x40, 0x00, 0x43, 0x00, 0x02, 0x08,
  0x00, 0x20, 0x20, 0x03, 0x01, 0x00, 0x10, 0x04, 0x01, 0x80, 0x20, 0x08,
  0x00, 0x80, 0xC0, 0x04, 0x04, 0x00, 0x10, 0x40, 0x00, 0xC2, 0x00, 0x02,
  0x20, 0x00, 0x19, 0x00, 0x00, 0x50, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0xFF, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x01, 0xFF, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFF, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0xD0, 0x00, 0x09, 0x80, 0x01, 0x88, 0x00,
  0x10, 0xC0, 0x02, 0x04, 0x00, 0x20, 0x60, 0x04, 0x02, 0x00, 0x40, 0x30,
  0x08, 0x01, 0x00, 0x80, 0x18, 0x10, 0x00, 0x83, 0x00, 0x0C, 0x20, 0x00,
  0x46, 0x00, 0x06, 0x40, 0x00, 0x2C, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x00, 0x40, 0x0F, 0xF8, 0x30, 0x04,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x07, 0x07, 0xFD, 0x1C, 0x01, 0x20, 0x01, 0x40, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x05, 0x40, 0x0D,
  0x60, 0x19, 0x1F, 0xE1, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x38, 0x08, 0xF3, 0xC2, 0x60, 0x18, 0xB0, 0x03, 0x38, 0x00, 0x6C,
  0x00, 0x0B, 0x00, 0x02, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x06, 0xC0, 0x01, 0x28, 0x00, 0x89,
  0x80, 0xC2, 0x3F, 0xE0, 0x00, 0x10, 0x01, 0xF7, 0xC1, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x04, 0x0F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x0C, 0x04, 0x1F, 0x70, 0x86, 0x01, 0x91, 0x00, 0x1A,
  0x60, 0x01, 0x48, 0x00, 0x1B, 0x00, 0x03, 0x40, 0x00, 0x68, 0x00, 0x0D,
  0x00, 0x00, 0xA0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x50, 0x00, 0x0A,
  0x00, 0x03, 0x40, 0x00, 0x68, 0x00, 0x0D, 0x00, 0x01, 0x90, 0x00, 0x72,
  0x00, 0x0A, 0x20, 0x02, 0x43, 0x00, 0xC8, 0x3F, 0xE1, 0x00, 0x60, 0x01,
  0xEF, 0x00, 0xC0, 0x20, 0x60, 0x04, 0x30, 0x00, 0x88, 0x00, 0x26, 0x00,
  0x0D, 0x00, 0x01, 0x40, 0x00, 0x50, 0x00, 0x14, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x20, 0x3F,
  0xF0, 0x00, 0xFC, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x0F, 0xFE, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x00, 0x60, 0x00,
  0xFB, 0xC4, 0x30, 0x0C, 0x88, 0x00, 0x53, 0x00, 0x0A, 0x40, 0x00, 0xD8,
  0x00, 0x1A, 0x00, 0x03, 0x40, 0x00, 0x68, 0x00, 0x05, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x1A, 0x00, 0x03, 0x40,
  0x00, 0x68, 0x00, 0x0C, 0x80, 0x02, 0x90, 0x00, 0x51, 0x00, 0x12, 0x18,
  0x04, 0x41, 0xFF, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x10, 0x00, 0x61, 0xC0,
  0x38, 0x07, 0xF8, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0xF0, 0x23, 0xFF, 0x13, 0x00, 0xCA, 0x00, 0x26, 0x00, 0x0B, 0x00, 0x05,
  0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0xF0, 0x00, 0x55, 0x55, 0x55, 0x55, 0x55, 0x50, 0x06, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x83, 0x7C, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x34, 0x00, 0xC8, 0x01, 0x10, 0x04, 0x20, 0x10, 0x40,
  0x40, 0x81, 0x01, 0x06, 0x02, 0x18, 0x04, 0x60, 0x09, 0xE0, 0x12, 0x40,
  0x28, 0x40, 0x60, 0x40, 0x80, 0xC1, 0x00, 0x82, 0x00, 0x84, 0x00, 0x88,
  0x01, 0x90, 0x01, 0x20, 0x01, 0x40, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0x80, 0x0C, 0x08, 0xFF, 0x07, 0xFC, 0x90, 0x18, 0xC0, 0x6A, 0x00, 0xD0,
  0x02, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x18, 0x00, 0x20, 0x01, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x20, 0x01, 0x80, 0x02, 0x00, 0x18, 0x00, 0x20, 0x01,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x20, 0x01, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x20, 0x01, 0x80, 0x02, 0x00, 0x18, 0x00, 0x20, 0x01, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x20, 0x01, 0x80, 0x02, 0x00, 0x10, 0x01, 0xE0, 0x47, 0xBC,
  0x26, 0x01, 0x94, 0x00, 0x4C, 0x00, 0x16, 0x00, 0x0A, 0x00, 0x05, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x20, 0x00,
  0x3D, 0xE0, 0x0C, 0x03, 0x01, 0x80, 0x08, 0x30, 0x00, 0x42, 0x00, 0x04,
  0x60, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x24, 0x00,
  0x02, 0x40, 0x00, 0x26, 0x00, 0x06, 0x20, 0x00, 0x43, 0x00, 0x0C, 0x18,
  0x01, 0x80, 0xC0, 0x30, 0x03, 0xFC, 0x00, 0x00, 0xC0, 0x21, 0xEF, 0x09,
  0x80, 0x62, 0xC0, 0x04, 0xA0, 0x01, 0xB0, 0x00, 0x2C, 0x00, 0x0A, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x2C,
  0x00, 0x0B, 0x80, 0x04, 0xB0, 0x03, 0x26, 0x01, 0x88, 0xFF, 0x82, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0xF7, 0x84, 0x30, 0x0C, 0x88, 0x00, 0xD2, 0x00, 0x0A, 0x40, 0x01,
  0xD0, 0x00, 0x1A, 0x00, 0x03, 0x40, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1A, 0x00, 0x03,
  0x40, 0x00, 0x68, 0x00, 0x0D, 0x80, 0x02, 0x90, 0x00, 0x51, 0x00, 0x12,
  0x30, 0x0C, 0x41, 0xFF, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x01, 0x91, 0xFE, 0x40, 0x50, 0x0C, 0x01,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x00, 0x03, 0x80, 0x3F, 0xF8, 0x80, 0x0A, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x60, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x58, 0x01, 0x9F, 0xFC, 0x00, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0xFF, 0xF0, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x3F, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0x40, 0x01, 0xA0, 0x00, 0xD0, 0x00, 0xE4, 0x00, 0x53, 0x00, 0xC8,
  0x7F, 0x84, 0x80, 0x00, 0x50, 0x00, 0x24, 0x00, 0x09, 0x80, 0x06, 0x20,
  0x01, 0x08, 0x00, 0x41, 0x00, 0x20, 0x40, 0x08, 0x10, 0x02, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x30, 0x30, 0x04, 0x08, 0x01, 0x02, 0x00, 0x21, 0x00,
  0x08, 0x40, 0x03, 0x30, 0x00, 0x48, 0x00, 0x12, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00,
  0x28, 0x01, 0x20, 0x05, 0x00, 0x24, 0x00, 0x90, 0x04, 0x80, 0x32, 0x01,
  0x88, 0x04, 0x40, 0x21, 0x00, 0x84, 0x04, 0x20, 0x30, 0x80, 0x86, 0x04,
  0x10, 0x30, 0x40, 0x81, 0x04, 0x08, 0x30, 0x20, 0x81, 0x04, 0x04, 0x10,
  0x10, 0x80, 0xC4, 0x02, 0x30, 0x08, 0x80, 0x44, 0x01, 0x10, 0x0C, 0x80,
  0x32, 0x00, 0xB0, 0x02, 0x80, 0x14, 0x00, 0x50, 0x02, 0x80, 0x0A, 0x00,
  0x30, 0x00, 0xC0, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x88, 0x00, 0x43,
  0x00, 0x20, 0x40, 0x18, 0x08, 0x04, 0x01, 0x02, 0x00, 0x61, 0x80, 0x08,
  0x40, 0x01, 0x20, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x20,
  0x00, 0x8C, 0x00, 0x61, 0x00, 0x10, 0x20, 0x08, 0x04, 0x06, 0x01, 0x81,
  0x00, 0x20, 0x80, 0x04, 0x40, 0x01, 0xB0, 0x00, 0x20, 0x80, 0x00, 0x50,
  0x00, 0x24, 0x00, 0x09, 0x80, 0x06, 0x20, 0x01, 0x08, 0x00, 0x41, 0x00,
  0x20, 0x40, 0x08, 0x10, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x30, 0x30,
  0x04, 0x08, 0x01, 0x02, 0x00, 0x21, 0x00, 0x08, 0x40, 0x03, 0x30, 0x00,
  0x48, 0x00, 0x12, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x03, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xF0, 0x38, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x08, 0x03, 0x00, 0xE0, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x1C, 0x00, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x03, 0x00, 0x30, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x80, 0x10, 0x02, 0x00, 0x30, 0x03, 0x81, 0x80, 0x20, 0x0C, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x20, 0x38, 0x0C, 0x00, 0x0C, 0x00, 0x07, 0x3C,
  0x01, 0xC0, 0x30, 0x68, 0x00, 0xF8,
};

const GFXglyph NotoSans_Thin42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 2, 30, 9, 4, -30 },
  { 9, 7, 11, 13, 3, -30 },
  { 19, 25, 30, 27, 1, -30 },
  { 113, 17, 34, 24, 3, -32 },
  { 186, 29, 30, 33, 2, -30 },
  { 295, 25, 30, 29, 3, -30 },
  { 389, 1, 11, 7, 3, -30 },
  { 391, 7, 37, 11, 2, -30 },
  { 424, 7, 37, 11, 2, -30 },
  { 457, 17, 17, 23, 3, -32 },
  { 494, 20, 19, 24, 2, -24 },
  { 542, 3, 10, 8, 2, -5 },
  { 546, 10, 1, 14, 2, -12 },
  { 548, 2, 2, 9, 4, -2 },
  { 549, 12, 30, 14, 1, -30 },
  { 594, 18, 30, 24, 3, -30 },
  { 662, 9, 30, 24, 4, -30 },
  { 696, 19, 30, 24, 2, -30 },
  { 768, 19, 30, 24, 2, -30 },
  { 840, 23, 30, 24, 1, -30 },
  { 927, 18, 30, 24, 3, -30 },
  { 995, 19, 30, 24, 3, -30 },
  { 1067, 19, 30, 24, 2, -30 },
  { 1139, 18, 30, 24, 3, -30 },
  { 1207, 19, 31, 24, 2, -30 },
  { 1281, 2, 22, 9, 4, -22 },
  { 1287, 4, 27, 9, 2, -22 },
  { 1301, 20, 19, 24, 2, -25 },
  { 1349, 20, 10, 24, 2, -20 },
  { 1374, 20, 19, 24, 2, -25 },
  { 1422, 14, 30, 17, 2, -30 },
  { 1475, 33, 34, 37, 2, -30 },
  { 1616, 24, 30, 24, 0, -30 },
  { 1706, 19, 30, 26, 4, -30 },
  { 1778, 21, 30, 26, 3, -30 },
  { 1857, 22, 30, 29, 4, -30 },
  { 1940, 17, 30, 23, 4, -30 },
  { 2004, 17, 30, 21, 4, -30 },
  { 2068, 24, 30, 30, 3, -30 },
  { 2158, 21, 30, 30, 4, -30 },
  { 2237, 6, 30, 12, 3, -30 },
  { 2260, 10, 37, 10, -4, -30 },
  { 2307, 19, 30, 23, 4, -30 },
  { 2379, 16, 30, 21, 4, -30 },
  { 2439, 27, 30, 35, 4, -30 },
  { 2541, 21, 30, 29, 4, -30 },
  { 2620, 26, 30, 32, 3, -30 },
  { 2718, 18, 30, 24, 4, -30 },
  { 2786, 26, 37, 32, 3, -30 },
  { 2907, 19, 30, 24, 4, -30 },
  { 2979, 19, 30, 23, 2, -30 },
  { 3051, 21, 30, 21, 0, -30 },
  { 3130, 22, 30, 30, 4, -30 },
  { 3213, 24, 30, 24, 0, -30 },
  { 3303, 34, 30, 37, 1, -30 },
  { 3431, 22, 30, 21, 0, -30 },
  { 3514, 21, 30, 21, 0, -30 },
  { 3593, 21, 30, 24, 2, -30 },
  { 3672, 8, 37, 13, 4, -30 },
  { 3709, 12, 30, 14, 1, -30 },
  { 3754, 8, 37, 13, 1, -30 },
  { 3791, 20, 18, 24, 2, -30 },
  { 3836, 17, 1, 16, 0, 4 },
  { 3839, 7, 7, 10, 2, -32 },
  { 3846, 16, 23, 21, 2, -23 },
  { 3892, 18, 32, 24, 4, -32 },
  { 3964, 17, 23, 20, 2, -23 },
  { 4013, 19, 32, 24, 2, -32 },
  { 4089, 18, 23, 23, 2, -23 },
  { 4141, 14, 32, 12, 0, -32 },
  { 4197, 19, 33, 24, 2, -23 },
  { 4276, 17, 32, 24, 4, -32 },
  { 4344, 2, 30, 9, 3, -30 },
  { 4352, 7, 40, 9, -2, -30 },
  { 4387, 15, 32, 19, 4, -32 },
  { 4447, 1, 32, 9, 4, -32 },
  { 4451, 28, 23, 36, 4, -23 },
  { 4532, 17, 23, 24, 4, -23 },
  { 4581, 20, 23, 24, 2, -23 },
  { 4639, 18, 33, 24, 4, -23 },
  { 4714, 19, 33, 24, 2, -23 },
  { 4793, 11, 23, 16, 4, -23 },
  { 4825, 15, 23, 19, 2, -23 },
  { 4869, 12, 28, 13, 0, -28 },
  { 4911, 17, 22, 24, 3, -22 },
  { 4958, 18, 22, 18, 0, -22 },
  { 5008, 27, 22, 29, 1, -22 },
  { 5083, 18, 22, 20, 1, -22 },
  { 5133, 18, 32, 18, 0, -22 },
  { 5205, 15, 22, 19, 2, -22 },
  { 5247, 12, 37, 14, 1, -30 },
  { 5303, 1, 43, 22, 11, -32 },
  { 5309, 11, 37, 14, 2, -30 },
  { 5360, 20, 4, 24, 2, -17 },
};

const GFXfont NotoSans_Thin42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin42pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_THIN42PT7B_H_
