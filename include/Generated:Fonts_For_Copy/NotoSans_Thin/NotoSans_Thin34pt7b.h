#ifndef _NOTOSANS_THIN34PT7B_H_
#define _NOTOSANS_THIN34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin34pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xA0, 0x0F, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x84, 0x00, 0x81, 0x80, 0x08, 0x10, 0x01, 0x01, 0x00, 0x10, 0x10,
  0x01, 0x01, 0x00, 0x10, 0x20, 0x01, 0x02, 0x07, 0xFF, 0xFF, 0x02, 0x02,
  0x00, 0x20, 0x20, 0x02, 0x02, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x40,
  0x40, 0x04, 0x04, 0x0F, 0xFF, 0xFE, 0x04, 0x08, 0x00, 0x40, 0x80, 0x08,
  0x08, 0x00, 0x80, 0x80, 0x08, 0x08, 0x00, 0x81, 0x00, 0x08, 0x10, 0x01,
  0x01, 0x00, 0x01, 0x00, 0x04, 0x00, 0xFE, 0x0C, 0x46, 0x41, 0x01, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x04, 0x10, 0x08, 0x40, 0x19,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x4C, 0x01, 0x08, 0x04, 0x30, 0x10, 0x40,
  0x41, 0x01, 0x04, 0x04, 0x10, 0x10, 0x80, 0x46, 0xF1, 0x60, 0x1E, 0x00,
  0x10, 0x00, 0x40, 0x08, 0x00, 0x20, 0x66, 0x00, 0x81, 0x04, 0x01, 0x02,
  0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40, 0x40,
  0x41, 0x00, 0x80, 0x84, 0x01, 0x01, 0x08, 0x02, 0x02, 0x21, 0xC4, 0x04,
  0x4C, 0x44, 0x09, 0x10, 0x48, 0x22, 0x40, 0x8C, 0x88, 0x80, 0x84, 0x11,
  0x01, 0x00, 0x42, 0x02, 0x01, 0x04, 0x04, 0x02, 0x08, 0x08, 0x08, 0x10,
  0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x40, 0x80, 0x81, 0x02, 0x00, 0x82,
  0x0C, 0x00, 0xF8, 0x01, 0xC0, 0x00, 0x31, 0x80, 0x02, 0x02, 0x00, 0x20,
  0x10, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x01, 0x00,
  0x08, 0x18, 0x00, 0x61, 0x80, 0x01, 0x10, 0x00, 0x07, 0x00, 0x00, 0x58,
  0x00, 0x0C, 0x60, 0x00, 0x81, 0x00, 0x48, 0x04, 0x02, 0xC0, 0x10, 0x24,
  0x00, 0x41, 0x20, 0x01, 0x11, 0x00, 0x04, 0x88, 0x00, 0x18, 0x20, 0x00,
  0xC1, 0x00, 0x09, 0x06, 0x01, 0x84, 0x1F, 0xF0, 0x18, 0xFF, 0x80, 0x04,
  0x21, 0x04, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0x81,
  0x04, 0x10, 0x41, 0x02, 0x08, 0x20, 0x41, 0x02, 0x04, 0xC0, 0x82, 0x04,
  0x10, 0x20, 0x82, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x20, 0x82, 0x10, 0x42, 0x08, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x03, 0x04, 0x33, 0x97, 0x01, 0xE0, 0x03, 0x00, 0x12,
  0x00, 0x44, 0x02, 0x08, 0x10, 0x20, 0x40, 0x40, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x24, 0x94, 0x94, 0xFF, 0x80, 0xF0, 0x00, 0x60,
  0x08, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x80, 0x10, 0x06, 0x00, 0x01, 0xC0, 0x18, 0x60, 0x40,
  0x21, 0x00, 0x44, 0x00, 0x48, 0x00, 0x90, 0x00, 0xA0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x05, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x44, 0x00,
  0x88, 0x02, 0x08, 0x08, 0x0F, 0xE0, 0x03, 0x05, 0x19, 0x21, 0xC1, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x07, 0x80, 0x30, 0xC1, 0x80, 0x40,
  0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0xFF, 0xFE, 0x07, 0x00, 0x70, 0xE3, 0x00, 0x64, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x03, 0x01, 0xFC, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02,
  0x40, 0x0C, 0x7F, 0xE0, 0x00, 0x08, 0x00, 0x05, 0x00, 0x02, 0x40, 0x00,
  0x90, 0x00, 0x44, 0x00, 0x21, 0x00, 0x10, 0x40, 0x04, 0x10, 0x02, 0x04,
  0x01, 0x01, 0x00, 0xC0, 0x40, 0x20, 0x10, 0x10, 0x04, 0x08, 0x01, 0x02,
  0x00, 0x41, 0x00, 0x10, 0xFF, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x7F, 0xF9,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x80, 0x02, 0x18, 0x0F, 0x9E, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0x68, 0x03, 0x1F, 0xF0, 0x00, 0xF8, 0x06, 0x08, 0x30, 0x00, 0x80, 0x01,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x1F,
  0x84, 0xC0, 0xCA, 0x00, 0x58, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x05, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x24, 0x00, 0x48, 0x01, 0x0C,
  0x04, 0x07, 0xF0, 0xFF, 0xFE, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00,
  0x01, 0xC0, 0x38, 0x60, 0x80, 0x21, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90,
  0x01, 0x20, 0x02, 0x20, 0x04, 0x60, 0x10, 0x60, 0xC0, 0x36, 0x00, 0x7C,
  0x03, 0x06, 0x08, 0x02, 0x20, 0x02, 0x40, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x28, 0x00, 0x50, 0x01, 0x18, 0x04, 0x0F, 0xF0, 0x03,
  0x80, 0x38, 0xC0, 0x80, 0x42, 0x00, 0x44, 0x00, 0x50, 0x00, 0xA0, 0x01,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x34, 0x00, 0x64,
  0x03, 0x46, 0x18, 0x83, 0xC1, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x7F, 0x80, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x33, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x22, 0x22,
  0x44, 0x48, 0x00, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x0E, 0x1C, 0x00, 0x60, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x60, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x08, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x60, 0x0C,
  0x00, 0x60, 0x00, 0xC0, 0x20, 0x00, 0x08, 0x10, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x09, 0x00, 0x7F, 0x02, 0x40, 0x60, 0x40, 0x60,
  0x20, 0x10, 0x18, 0x08, 0x04, 0x06, 0x04, 0x01, 0x01, 0x81, 0x00, 0x40,
  0x60, 0x40, 0x10, 0x18, 0x10, 0x04, 0x06, 0x04, 0x01, 0x01, 0x81, 0x00,
  0x40, 0xA0, 0x40, 0x30, 0x28, 0x08, 0x12, 0x12, 0x01, 0xF8, 0xF8, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x80, 0x08, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x90, 0x00, 0x09, 0x00, 0x00, 0x90, 0x00, 0x10,
  0x80, 0x01, 0x08, 0x00, 0x20, 0x80, 0x02, 0x04, 0x00, 0x20, 0x40, 0x04,
  0x02, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x10, 0x0F, 0xFF, 0x01,
  0x00, 0x10, 0x10, 0x00, 0x81, 0x00, 0x08, 0x20, 0x00, 0x42, 0x00, 0x04,
  0x40, 0x00, 0x44, 0x00, 0x02, 0x40, 0x00, 0x28, 0x00, 0x03, 0xFF, 0xF0,
  0x80, 0x0C, 0x80, 0x06, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x38, 0xFF, 0xF0, 0x80, 0x0C,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x02, 0x80, 0x06, 0x80, 0x18, 0xFF, 0xE0, 0x00, 0x18,
  0x00, 0xF0, 0xF0, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x01, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x20, 0x03, 0x08,
  0x00, 0x22, 0x00, 0x04, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x28,
  0x00, 0x0A, 0x00, 0x04, 0x80, 0x03, 0x20, 0x01, 0x88, 0x01, 0x83, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x3F, 0xFE, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0xFF, 0xFA, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x00, 0x1C, 0x00, 0x1C, 0x1E, 0x06, 0x00, 0x20, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x03, 0xFF,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00,
  0x14, 0x00, 0x01, 0x20, 0x00, 0x11, 0x00, 0x01, 0x08, 0x00, 0x10, 0x60,
  0x03, 0x01, 0xFF, 0xC0, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xFC, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x3F, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x5F, 0x00, 0x80, 0x03, 0x80, 0x04, 0x80,
  0x08, 0x80, 0x10, 0x80, 0x20, 0x80, 0x40, 0x80, 0x80, 0x81, 0x00, 0x82,
  0x00, 0x84, 0x00, 0x8C, 0x00, 0x92, 0x00, 0xA3, 0x00, 0xC1, 0x00, 0x80,
  0x80, 0x80, 0x40, 0x80, 0x40, 0x80, 0x20, 0x80, 0x10, 0x80, 0x08, 0x80,
  0x08, 0x80, 0x04, 0x80, 0x02, 0x80, 0x03, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0E, 0x80, 0x00, 0x3A, 0x00, 0x01, 0x68, 0x00, 0x05,
  0x90, 0x00, 0x16, 0x40, 0x00, 0x98, 0x80, 0x02, 0x62, 0x00, 0x11, 0x84,
  0x00, 0x46, 0x10, 0x01, 0x18, 0x40, 0x08, 0x60, 0x80, 0x21, 0x82, 0x01,
  0x06, 0x04, 0x04, 0x18, 0x10, 0x20, 0x60, 0x40, 0x81, 0x80, 0x82, 0x06,
  0x02, 0x10, 0x18, 0x04, 0x40, 0x60, 0x12, 0x01, 0x80, 0x48, 0x06, 0x00,
  0xA0, 0x18, 0x03, 0x00, 0x60, 0x04, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x68,
  0x00, 0x32, 0x00, 0x19, 0x00, 0x0C, 0x40, 0x06, 0x10, 0x03, 0x08, 0x01,
  0x82, 0x00, 0xC0, 0x80, 0x60, 0x60, 0x30, 0x10, 0x18, 0x04, 0x0C, 0x03,
  0x06, 0x00, 0x83, 0x00, 0x21, 0x80, 0x18, 0xC0, 0x04, 0x60, 0x01, 0x30,
  0x00, 0xD8, 0x00, 0x2C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x00, 0x30,
  0x00, 0x1C, 0x38, 0x03, 0x00, 0x30, 0x20, 0x00, 0xC3, 0x00, 0x02, 0x10,
  0x00, 0x09, 0x00, 0x00, 0x48, 0x00, 0x01, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x02,
  0x80, 0x00, 0x22, 0x00, 0x01, 0x08, 0x00, 0x10, 0x60, 0x01, 0x00, 0x80,
  0x30, 0x03, 0xFE, 0x00, 0xFF, 0xE1, 0x00, 0x32, 0x00, 0x34, 0x00, 0x28,
  0x00, 0x50, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x05, 0x00, 0x0A, 0x00,
  0x24, 0x00, 0xC8, 0x0E, 0x1F, 0xC0, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x1C, 0x38, 0x03, 0x00, 0x30, 0x20, 0x00, 0xC3,
  0x00, 0x02, 0x10, 0x00, 0x09, 0x00, 0x00, 0x48, 0x00, 0x01, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0A, 0x00, 0x00,
  0x50, 0x00, 0x02, 0x80, 0x00, 0x22, 0x00, 0x01, 0x08, 0x00, 0x10, 0x60,
  0x01, 0x00, 0x80, 0x30, 0x03, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0xFF,
  0xE0, 0x80, 0x18, 0x80, 0x0C, 0x80, 0x04, 0x80, 0x04, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x30, 0xFF,
  0xC0, 0x80, 0x80, 0x80, 0x40, 0x80, 0x20, 0x80, 0x20, 0x80, 0x10, 0x80,
  0x10, 0x80, 0x08, 0x80, 0x04, 0x80, 0x04, 0x80, 0x02, 0x80, 0x03, 0x01,
  0x80, 0x38, 0x78, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x40, 0x00, 0x80, 0x03, 0x40, 0x0C, 0xFF, 0xE0, 0xFF, 0xFF,
  0x80, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x14, 0x00, 0x05, 0x00, 0x02, 0x40, 0x00,
  0x88, 0x00, 0x41, 0x80, 0x20, 0x1F, 0xF0, 0x80, 0x00, 0x28, 0x00, 0x09,
  0x00, 0x01, 0x20, 0x00, 0x22, 0x00, 0x08, 0x40, 0x01, 0x04, 0x00, 0x20,
  0x80, 0x08, 0x10, 0x01, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x40, 0x40, 0x08, 0x08, 0x00, 0x81, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00,
  0x22, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x80, 0x04, 0x00, 0x34, 0x00, 0x60, 0x02, 0x40,
  0x0A, 0x00, 0x24, 0x00, 0xA0, 0x02, 0x40, 0x09, 0x00, 0x42, 0x00, 0x90,
  0x04, 0x20, 0x11, 0x00, 0x42, 0x01, 0x10, 0x08, 0x20, 0x10, 0x80, 0x81,
  0x01, 0x08, 0x08, 0x10, 0x20, 0x80, 0x81, 0x02, 0x08, 0x10, 0x08, 0x20,
  0x41, 0x00, 0x84, 0x04, 0x10, 0x08, 0x40, 0x42, 0x00, 0x84, 0x02, 0x20,
  0x04, 0x40, 0x22, 0x00, 0x48, 0x02, 0x20, 0x04, 0x80, 0x24, 0x00, 0x48,
  0x01, 0x40, 0x02, 0x80, 0x14, 0x00, 0x30, 0x01, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x80, 0x40, 0x01, 0x90, 0x00, 0x84, 0x00, 0x82, 0x00,
  0x80, 0x80, 0x40, 0x40, 0x40, 0x10, 0x40, 0x04, 0x20, 0x02, 0x20, 0x00,
  0x90, 0x00, 0x30, 0x00, 0x10, 0x00, 0x14, 0x00, 0x09, 0x00, 0x08, 0x80,
  0x0C, 0x20, 0x04, 0x08, 0x04, 0x04, 0x06, 0x01, 0x02, 0x00, 0xC2, 0x00,
  0x21, 0x00, 0x09, 0x00, 0x05, 0x00, 0x01, 0x80, 0x00, 0xA0, 0x00, 0x88,
  0x00, 0x44, 0x00, 0x41, 0x00, 0x20, 0x80, 0x20, 0x20, 0x30, 0x10, 0x10,
  0x04, 0x10, 0x02, 0x08, 0x00, 0x88, 0x00, 0x44, 0x00, 0x14, 0x00, 0x0A,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x0F, 0xE0, 0xC0, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x03,
  0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x1F, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x02, 0x40, 0x04, 0x40, 0x04, 0x20,
  0x08, 0x20, 0x08, 0x10, 0x10, 0x10, 0x10, 0x08, 0x20, 0x08, 0x20, 0x04,
  0x40, 0x04, 0x40, 0x02, 0x80, 0x02, 0x80, 0x01, 0xFF, 0xF8, 0xC1, 0x82,
  0x04, 0x0C, 0x1F, 0xC3, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x04,
  0x00, 0x20, 0x01, 0x0F, 0xF9, 0x80, 0x50, 0x03, 0x00, 0x18, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x05, 0xC0, 0x49, 0xFC, 0x40, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x8F,
  0xE1, 0x20, 0x22, 0x80, 0x26, 0x00, 0x2C, 0x00, 0x50, 0x00, 0xA0, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x50,
  0x00, 0xB0, 0x01, 0x60, 0x04, 0xB0, 0x11, 0x3F, 0xC0, 0x07, 0xF8, 0xC0,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x7F, 0xC0, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x0F, 0xE2, 0x20, 0x24, 0x80, 0x2A,
  0x00, 0x34, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x28, 0x00, 0xD0, 0x01, 0xB0, 0x05,
  0x30, 0x12, 0x1F, 0xC4, 0x0F, 0xE0, 0x40, 0x42, 0x00, 0x90, 0x02, 0x40,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x04, 0x3F, 0xE0,
  0x03, 0xF0, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0xFF, 0x80, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x0F, 0xE2, 0x20, 0x34, 0x80, 0x2A, 0x00, 0x34, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x28, 0x00, 0xD0, 0x01, 0x90, 0x05, 0x30, 0x12, 0x1F,
  0xC4, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x06,
  0x60, 0x18, 0x3F, 0xC0, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x8F, 0xE2, 0xC0, 0x4A, 0x00, 0xB0,
  0x02, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x10, 0xE1, 0xFF, 0xFF, 0x80, 0x04, 0x10, 0x40, 0x00, 0x00, 0x01,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x42, 0xF8, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x34, 0x03, 0x20,
  0x11, 0x01, 0x08, 0x10, 0x41, 0x02, 0x10, 0x11, 0x00, 0x9C, 0x05, 0x20,
  0x30, 0x81, 0x82, 0x08, 0x18, 0x40, 0x42, 0x01, 0x10, 0x04, 0x80, 0x24,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x9F, 0xC3, 0xF9, 0x40, 0x48, 0x0B,
  0x00, 0xA0, 0x0E, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x8F, 0xE2,
  0xC0, 0x4A, 0x00, 0xB0, 0x02, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x0F, 0xF0, 0x10, 0x18, 0x20, 0x04,
  0x40, 0x04, 0x40, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x40, 0x02, 0x40, 0x04,
  0x20, 0x04, 0x10, 0x18, 0x0F, 0xE0, 0x8F, 0xE1, 0x20, 0x32, 0x80, 0x26,
  0x00, 0x2C, 0x00, 0x50, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0xB0, 0x01, 0x50, 0x04,
  0xB0, 0x11, 0x1F, 0xC2, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x00, 0x0F, 0xE2, 0x20, 0x24, 0x80,
  0x2A, 0x00, 0x34, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xD0, 0x01, 0xA0,
  0x05, 0x30, 0x12, 0x3F, 0xC4, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x9F, 0xD0, 0x30, 0x18,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x00, 0x1F, 0xF1, 0x00, 0x50, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x80, 0x13, 0xFE, 0x00, 0x10,
  0x04, 0x01, 0x00, 0x40, 0xFF, 0xC4, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x08, 0x03, 0xF0, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x68, 0x03, 0x60, 0x29, 0xFE, 0x40, 0x80, 0x06, 0x80,
  0x09, 0x00, 0x12, 0x00, 0x42, 0x00, 0x84, 0x01, 0x08, 0x04, 0x08, 0x08,
  0x10, 0x20, 0x10, 0x40, 0x20, 0x80, 0x42, 0x00, 0x44, 0x00, 0x90, 0x00,
  0xA0, 0x01, 0x40, 0x03, 0x00, 0x02, 0x00, 0x80, 0x20, 0x06, 0x00, 0xC0,
  0x28, 0x03, 0x00, 0x90, 0x14, 0x02, 0x40, 0x48, 0x09, 0x01, 0x20, 0x44,
  0x08, 0x81, 0x08, 0x21, 0x04, 0x20, 0x84, 0x10, 0x84, 0x10, 0x81, 0x10,
  0x22, 0x04, 0x40, 0x88, 0x12, 0x02, 0x40, 0x48, 0x05, 0x00, 0xA0, 0x14,
  0x03, 0x00, 0x50, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x0D, 0x00,
  0x22, 0x01, 0x04, 0x08, 0x10, 0x20, 0x21, 0x00, 0x48, 0x00, 0xE0, 0x03,
  0x00, 0x0C, 0x00, 0x48, 0x03, 0x10, 0x08, 0x40, 0x40, 0x82, 0x01, 0x08,
  0x04, 0x40, 0x0A, 0x00, 0x10, 0x80, 0x06, 0x80, 0x09, 0x00, 0x12, 0x00,
  0x42, 0x00, 0x84, 0x01, 0x08, 0x04, 0x08, 0x08, 0x10, 0x20, 0x10, 0x40,
  0x20, 0x80, 0x42, 0x00, 0x44, 0x00, 0x90, 0x00, 0xA0, 0x01, 0x40, 0x03,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00,
  0x04, 0x00, 0x08, 0x01, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x07, 0xFF, 0xC0,
  0x03, 0x86, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x02, 0x01, 0x01, 0x83, 0x00, 0x60, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0x78, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF0, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x1C, 0x08, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x20, 0xF0, 0x00, 0x18, 0x00, 0xCE, 0x06, 0x03, 0xB8, 0x00, 0x80,
};

const GFXglyph NotoSans_Thin34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 2, 24, 8, 3, -24 },
  { 7, 6, 9, 11, 2, -24 },
  { 14, 20, 24, 22, 1, -24 },
  { 74, 14, 28, 19, 2, -26 },
  { 123, 23, 25, 27, 2, -25 },
  { 195, 21, 25, 24, 2, -25 },
  { 261, 1, 9, 6, 2, -24 },
  { 263, 6, 29, 9, 1, -24 },
  { 285, 6, 29, 9, 1, -24 },
  { 307, 14, 14, 19, 2, -26 },
  { 332, 16, 16, 19, 2, -20 },
  { 364, 3, 8, 6, 1, -4 },
  { 367, 9, 1, 11, 1, -10 },
  { 369, 2, 2, 7, 3, -2 },
  { 370, 11, 24, 11, 0, -24 },
  { 403, 15, 25, 19, 2, -25 },
  { 450, 8, 24, 19, 3, -24 },
  { 474, 15, 25, 19, 2, -25 },
  { 521, 15, 25, 19, 2, -25 },
  { 568, 18, 24, 19, 1, -24 },
  { 622, 14, 24, 19, 3, -24 },
  { 664, 15, 25, 19, 2, -25 },
  { 711, 15, 24, 19, 2, -24 },
  { 756, 15, 25, 19, 2, -25 },
  { 803, 15, 25, 19, 2, -25 },
  { 850, 2, 18, 7, 3, -18 },
  { 855, 4, 22, 7, 1, -18 },
  { 866, 15, 15, 19, 2, -20 },
  { 895, 16, 8, 19, 2, -16 },
  { 911, 15, 15, 19, 2, -20 },
  { 940, 12, 25, 14, 1, -25 },
  { 978, 26, 27, 30, 2, -24 },
  { 1066, 20, 24, 20, 0, -24 },
  { 1126, 16, 24, 21, 3, -24 },
  { 1174, 18, 25, 21, 2, -25 },
  { 1231, 18, 24, 24, 3, -24 },
  { 1285, 14, 24, 19, 3, -24 },
  { 1327, 14, 24, 17, 3, -24 },
  { 1369, 20, 25, 24, 2, -25 },
  { 1432, 18, 24, 24, 3, -24 },
  { 1486, 6, 24, 10, 2, -24 },
  { 1504, 7, 30, 8, -3, -24 },
  { 1531, 16, 24, 19, 3, -24 },
  { 1579, 14, 24, 17, 3, -24 },
  { 1621, 22, 24, 28, 3, -24 },
  { 1687, 17, 24, 24, 3, -24 },
  { 1738, 21, 25, 26, 2, -25 },
  { 1804, 15, 24, 19, 3, -24 },
  { 1849, 21, 31, 26, 2, -25 },
  { 1931, 16, 24, 20, 3, -24 },
  { 1979, 15, 25, 18, 2, -25 },
  { 2026, 17, 24, 17, 0, -24 },
  { 2077, 18, 24, 24, 3, -24 },
  { 2131, 19, 24, 19, 0, -24 },
  { 2188, 28, 24, 30, 1, -24 },
  { 2272, 17, 24, 17, 0, -24 },
  { 2323, 17, 24, 17, 0, -24 },
  { 2374, 17, 24, 20, 1, -24 },
  { 2425, 7, 29, 11, 3, -24 },
  { 2451, 11, 24, 11, 0, -24 },
  { 2484, 7, 29, 11, 1, -24 },
  { 2510, 16, 15, 19, 2, -24 },
  { 2540, 13, 1, 13, 0, 3 },
  { 2542, 6, 5, 8, 1, -26 },
  { 2546, 13, 18, 17, 2, -18 },
  { 2576, 15, 26, 20, 3, -26 },
  { 2625, 13, 18, 16, 2, -18 },
  { 2655, 15, 26, 20, 2, -26 },
  { 2704, 14, 18, 18, 2, -18 },
  { 2736, 12, 26, 9, 0, -26 },
  { 2775, 15, 26, 20, 2, -18 },
  { 2824, 14, 26, 19, 3, -26 },
  { 2870, 1, 25, 7, 3, -25 },
  { 2874, 6, 33, 7, -2, -25 },
  { 2899, 13, 26, 15, 3, -26 },
  { 2942, 1, 26, 7, 3, -26 },
  { 2946, 23, 18, 29, 3, -18 },
  { 2998, 14, 18, 19, 3, -18 },
  { 3030, 16, 18, 20, 2, -18 },
  { 3066, 15, 26, 20, 3, -18 },
  { 3115, 15, 26, 20, 2, -18 },
  { 3164, 9, 18, 13, 3, -18 },
  { 3185, 13, 18, 16, 1, -18 },
  { 3215, 10, 22, 11, 0, -22 },
  { 3243, 13, 18, 19, 3, -18 },
  { 3273, 15, 18, 15, 0, -18 },
  { 3307, 22, 18, 23, 1, -18 },
  { 3357, 14, 18, 16, 1, -18 },
  { 3389, 15, 26, 15, 0, -18 },
  { 3438, 13, 18, 16, 1, -18 },
  { 3468, 9, 29, 11, 1, -24 },
  { 3501, 1, 35, 18, 9, -26 },
  { 3506, 10, 29, 11, 1, -24 },
  { 3543, 15, 4, 19, 2, -14 },
};

const GFXfont NotoSans_Thin34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin34pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_THIN34PT7B_H_
