#ifndef _NOTOSANS_THIN62PT7B_H_
#define _NOTOSANS_THIN62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin62pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0x0E, 0xFE, 0x40,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x18, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x00, 0x80, 0x02, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x06, 0x00, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x10, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x18, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x40, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x00, 0x80, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x00, 0x10, 0x00, 0x40, 0x00, 0x01, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x78, 0x41, 0xF0, 0x70, 0x20, 0x18,
  0x60, 0x10, 0x00, 0x60, 0x08, 0x00, 0x30, 0x04, 0x00, 0x30, 0x02, 0x00,
  0x18, 0x01, 0x00, 0x0C, 0x00, 0x80, 0x06, 0x00, 0x40, 0x03, 0x00, 0x20,
  0x01, 0x80, 0x10, 0x00, 0xC0, 0x08, 0x00, 0x30, 0x04, 0x00, 0x18, 0x02,
  0x00, 0x06, 0x01, 0x00, 0x01, 0x80, 0x80, 0x00, 0x70, 0x40, 0x00, 0x0E,
  0x20, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x02, 0x78, 0x00, 0x01, 0x0F, 0x00, 0x00, 0x81, 0xC0, 0x00, 0x40, 0x30,
  0x00, 0x20, 0x0C, 0x00, 0x10, 0x06, 0x00, 0x08, 0x01, 0x80, 0x04, 0x00,
  0xC0, 0x02, 0x00, 0x60, 0x01, 0x00, 0x30, 0x00, 0x80, 0x18, 0x00, 0x40,
  0x0C, 0x00, 0x20, 0x06, 0x00, 0x10, 0x02, 0x00, 0x08, 0x03, 0x00, 0x04,
  0x03, 0x00, 0x02, 0x03, 0x98, 0x01, 0x03, 0x8F, 0xE0, 0x8F, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x40, 0x03,
  0xFE, 0x00, 0x00, 0x20, 0x01, 0x81, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x30,
  0x00, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x80, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x60, 0x00, 0x20, 0x00, 0x60, 0x18, 0x00, 0x08, 0x00, 0x18, 0x0C, 0x00,
  0x02, 0x00, 0x06, 0x03, 0x00, 0x00, 0x80, 0x01, 0x81, 0x80, 0x00, 0x20,
  0x00, 0x40, 0x40, 0x00, 0x0C, 0x00, 0x10, 0x30, 0x3F, 0x03, 0x00, 0x0C,
  0x08, 0x3C, 0xF0, 0xC0, 0x03, 0x06, 0x1C, 0x06, 0x10, 0x00, 0xC3, 0x06,
  0x00, 0xC6, 0x00, 0x20, 0xC3, 0x00, 0x31, 0x80, 0x18, 0x60, 0x80, 0x04,
  0x30, 0x0C, 0x18, 0x60, 0x01, 0x86, 0x07, 0x0C, 0x18, 0x00, 0x60, 0xFF,
  0x82, 0x06, 0x00, 0x18, 0x0F, 0x81, 0x81, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x40, 0x00, 0x80, 0x00, 0x30, 0x10, 0x00, 0x20, 0x00, 0x18, 0x04, 0x00,
  0x08, 0x00, 0x06, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x10, 0x00, 0x20, 0x00, 0x60, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x01, 0x80, 0x60, 0x03, 0x00, 0x00, 0x38, 0x30, 0x01, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x20, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x18, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00,
  0x00, 0x6F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0x98, 0x00, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x0E,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x01, 0x8C, 0x00, 0x18, 0x00,
  0x0C, 0x60, 0x00, 0x60, 0x00, 0x46, 0x00, 0x01, 0x80, 0x06, 0x20, 0x00,
  0x06, 0x00, 0x33, 0x00, 0x00, 0x18, 0x01, 0x18, 0x00, 0x00, 0x60, 0x18,
  0xC0, 0x00, 0x01, 0x80, 0x86, 0x00, 0x00, 0x06, 0x0C, 0x30, 0x00, 0x00,
  0x18, 0xC1, 0x80, 0x00, 0x00, 0x64, 0x0C, 0x00, 0x00, 0x01, 0xE0, 0x60,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x78, 0x0C, 0x00, 0x00, 0x06,
  0x60, 0x30, 0x00, 0x00, 0x61, 0x80, 0xC0, 0x00, 0x0E, 0x06, 0x03, 0x00,
  0x01, 0xC0, 0x18, 0x0F, 0x00, 0x3C, 0x00, 0x60, 0x1F, 0xFF, 0x80, 0x01,
  0x80, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xE0, 0x30, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18,
  0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0xE0, 0x06,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x08, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20,
  0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30,
  0x04, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x80, 0x0C, 0x00, 0x78, 0x03, 0x00, 0x77, 0xC0, 0xC0,
  0xF8, 0x3E, 0x21, 0xE0, 0x00, 0xFB, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x48, 0x00, 0x00, 0x23, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x0C, 0x08, 0x00, 0x02, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x80, 0x38, 0x00, 0x70, 0x04, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x31, 0x86, 0x18, 0x61, 0x0C, 0x30,
  0xC2, 0x18, 0x61, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xEF, 0xE4, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x0E, 0x00, 0xE0,
  0x03, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x10, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x84, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x24, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x09, 0x80, 0x00, 0x01,
  0x30, 0x00, 0x00, 0x62, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x04, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0,
  0x1C, 0x00, 0x30, 0x00, 0xE0, 0x3C, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x06, 0xC0, 0x73, 0x03, 0x8C, 0x38,
  0x31, 0xC0, 0xCC, 0x03, 0xE0, 0x0D, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0xF0, 0x07, 0x00, 0xE0, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x60,
  0xF0, 0x00, 0x03, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x0E, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x00, 0x90, 0x00,
  0x00, 0x00, 0xC8, 0x00, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x00, 0x61, 0x00, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x30, 0x08,
  0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x10, 0x02, 0x00, 0x00, 0x18, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x18, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x06, 0x00, 0x01, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x06, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0x20, 0x03, 0x00,
  0x00, 0x10, 0x03, 0x00, 0x00, 0x08, 0x01, 0x00, 0x00, 0x04, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xFF, 0xFF,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0xFF, 0xFC, 0x01, 0xF8,
  0x03, 0xC0, 0x20, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x80, 0x00, 0x0C, 0x30, 0x00,
  0x0E, 0x0F, 0xC0, 0x1F, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x3F, 0xF0, 0x04, 0x1F, 0x87, 0xC0, 0xC3, 0x80,
  0x06, 0x0C, 0xE0, 0x00, 0x30, 0xCC, 0x00, 0x01, 0x8D, 0x80, 0x00, 0x0C,
  0xF0, 0x00, 0x00, 0x4E, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x41, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1E, 0x00,
  0x70, 0x07, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x20, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x61, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x62, 0x00, 0x00, 0x08, 0x60,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x06,
  0x00, 0xC0, 0x01, 0x80, 0x0E, 0x00, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x0E, 0x03, 0xC0,
  0x07, 0x00, 0x1C, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x13, 0x00, 0x00, 0x06, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0x80,
  0x3C, 0x00, 0xE0, 0x00, 0xE0, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x00, 0x30,
  0x30, 0x00, 0x01, 0x82, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x04, 0x40, 0x00, 0x00, 0x64, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x07, 0x60, 0x00, 0x00, 0x73, 0x00, 0x00, 0x0F, 0x30, 0x00, 0x01, 0xB1,
  0x80, 0x00, 0x33, 0x0C, 0x00, 0x06, 0x30, 0x70, 0x01, 0xC3, 0x01, 0xFF,
  0xF0, 0x30, 0x07, 0xFC, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x01, 0x00, 0x3C,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x6F, 0xE6, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xEF,
  0xE4, 0x0C, 0x3C, 0x70, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x61, 0x83, 0x06, 0x0C, 0x10, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x20,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0xF8, 0x3C, 0x00, 0xF0, 0x80, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x18, 0x00, 0x07, 0xFF, 0x80, 0x06, 0x30, 0x00, 0x1E,
  0x03, 0xC0, 0x06, 0x30, 0x00, 0x38, 0x00, 0xC0, 0x02, 0x20, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x60, 0x01, 0x80,
  0x00, 0xC0, 0x03, 0x60, 0x01, 0x00, 0x00, 0xC0, 0x03, 0x40, 0x03, 0x00,
  0x00, 0xC0, 0x03, 0xC0, 0x02, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x06, 0x00,
  0x00, 0xC0, 0x01, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x03, 0xC0, 0x06, 0x00,
  0x00, 0xC0, 0x03, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x03, 0xC0, 0x06, 0x00,
  0x00, 0x80, 0x03, 0xC0, 0x06, 0x00, 0x00, 0x80, 0x03, 0xC0, 0x06, 0x00,
  0x01, 0x80, 0x03, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x02, 0xC0, 0x06, 0x00,
  0x01, 0x80, 0x06, 0x40, 0x03, 0x00, 0x03, 0xC0, 0x06, 0x40, 0x03, 0x00,
  0x02, 0xC0, 0x0C, 0x60, 0x01, 0x80, 0x06, 0x40, 0x08, 0x60, 0x01, 0xC0,
  0x0C, 0x60, 0x18, 0x60, 0x00, 0xF0, 0x78, 0x38, 0xF0, 0x30, 0x00, 0x3F,
  0xE0, 0x1F, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x00, 0x18, 0x80, 0x00,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x03, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00,
  0x40, 0x30, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x08, 0x01, 0x80, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0x08,
  0x30, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x07, 0xE0, 0x30, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x02, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x78, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x03, 0x00,
  0x00, 0x1C, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01,
  0x60, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x05, 0x80, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x70, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x01, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x02, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x60, 0x00, 0xFE, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x18,
  0x00, 0x00, 0x78, 0x0C, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x04, 0xC0,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x07, 0x00,
  0x60, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x03, 0x80, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00,
  0x03, 0x03, 0x80, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xC3, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC3, 0xFF, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x80, 0x63, 0xFF,
  0x03, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x06,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x06, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x70, 0x00, 0x01,
  0x86, 0xC0, 0x00, 0x0C, 0x66, 0x00, 0x00, 0x66, 0x18, 0x00, 0x03, 0x60,
  0x60, 0x00, 0x1E, 0x01, 0x80, 0x00, 0xE0, 0x0C, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x60, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0E,
  0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0xC0, 0x00,
  0x00, 0x00, 0xDD, 0x80, 0x00, 0x00, 0x01, 0xB9, 0x00, 0x00, 0x00, 0x02,
  0x73, 0x00, 0x00, 0x00, 0x0C, 0xE6, 0x00, 0x00, 0x00, 0x19, 0xC6, 0x00,
  0x00, 0x00, 0x63, 0x8C, 0x00, 0x00, 0x00, 0xC7, 0x08, 0x00, 0x00, 0x01,
  0x0E, 0x18, 0x00, 0x00, 0x06, 0x1C, 0x30, 0x00, 0x00, 0x08, 0x38, 0x30,
  0x00, 0x00, 0x30, 0x70, 0x60, 0x00, 0x00, 0x60, 0xE0, 0x40, 0x00, 0x01,
  0x81, 0xC0, 0xC0, 0x00, 0x03, 0x03, 0x81, 0x80, 0x00, 0x04, 0x07, 0x01,
  0x80, 0x00, 0x18, 0x0E, 0x03, 0x00, 0x00, 0x30, 0x1C, 0x02, 0x00, 0x00,
  0xC0, 0x38, 0x06, 0x00, 0x01, 0x80, 0x70, 0x0C, 0x00, 0x02, 0x00, 0xE0,
  0x0C, 0x00, 0x0C, 0x01, 0xC0, 0x18, 0x00, 0x18, 0x03, 0x80, 0x18, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x00, 0xC0, 0x0E, 0x00, 0x20, 0x01, 0x00, 0x1C,
  0x00, 0x60, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x08, 0x00, 0x70, 0x00, 0xC0,
  0x30, 0x00, 0xE0, 0x01, 0x80, 0x60, 0x01, 0xC0, 0x01, 0x00, 0x80, 0x03,
  0x80, 0x03, 0x03, 0x00, 0x07, 0x00, 0x06, 0x04, 0x00, 0x0E, 0x00, 0x06,
  0x18, 0x00, 0x1C, 0x00, 0x0C, 0x30, 0x00, 0x38, 0x00, 0x08, 0xC0, 0x00,
  0x70, 0x00, 0x19, 0x80, 0x00, 0xE0, 0x00, 0x32, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3D, 0x80, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x01, 0xE3, 0x00, 0x00,
  0x03, 0xC3, 0x00, 0x00, 0x07, 0x86, 0x00, 0x00, 0x0F, 0x06, 0x00, 0x00,
  0x1E, 0x06, 0x00, 0x00, 0x3C, 0x0C, 0x00, 0x00, 0x78, 0x0C, 0x00, 0x00,
  0xF0, 0x0C, 0x00, 0x01, 0xE0, 0x18, 0x00, 0x03, 0xC0, 0x18, 0x00, 0x07,
  0x80, 0x18, 0x00, 0x0F, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x30, 0x00, 0x3C,
  0x00, 0x30, 0x00, 0x78, 0x00, 0x60, 0x00, 0xF0, 0x00, 0x60, 0x01, 0xE0,
  0x00, 0x60, 0x03, 0xC0, 0x00, 0xC0, 0x07, 0x80, 0x00, 0xC0, 0x0F, 0x00,
  0x00, 0xC0, 0x1E, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x01, 0x80, 0x78, 0x00,
  0x01, 0x80, 0xF0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x03, 0x03, 0xC0, 0x00,
  0x03, 0x07, 0x80, 0x00, 0x03, 0x0F, 0x00, 0x00, 0x06, 0x1E, 0x00, 0x00,
  0x06, 0x3C, 0x00, 0x00, 0x06, 0x78, 0x00, 0x00, 0x0C, 0xF0, 0x00, 0x00,
  0x0D, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x00, 0x00,
  0x8C, 0x00, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x03, 0x20, 0x00,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x00,
  0x0B, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x00, 0x00, 0x48, 0x00, 0x00, 0x00, 0x01, 0x90,
  0x00, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x00, 0x08, 0x40, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x17, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0xFC,
  0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x06, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x07, 0x83, 0x00, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x00, 0x00, 0x48, 0x00, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x08, 0x40, 0x00,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x17, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x01, 0x80, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x3F, 0x80, 0xC0, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x08, 0xC0, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x80, 0xC0, 0x03, 0xE0, 0x0F, 0xFF,
  0xF8, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0,
  0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x0E, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0x21, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x38, 0x7E, 0x00, 0x3E, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x38,
  0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x03, 0xA0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x00, 0x40, 0xC0, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x02, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x02, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0x18, 0x00, 0x20, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x10, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x00, 0x44, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x34, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x09, 0x80,
  0x00, 0x05, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x60, 0x00, 0x01, 0x88,
  0x00, 0x00, 0xC8, 0x00, 0x00, 0x43, 0x00, 0x00, 0x32, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x08, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x02, 0x30, 0x00, 0x03,
  0x04, 0x00, 0x01, 0x84, 0x00, 0x00, 0x81, 0x80, 0x00, 0x61, 0x80, 0x00,
  0x60, 0x60, 0x00, 0x10, 0x60, 0x00, 0x18, 0x08, 0x00, 0x04, 0x08, 0x00,
  0x04, 0x02, 0x00, 0x03, 0x02, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0xC0,
  0x00, 0xC0, 0x30, 0x00, 0x20, 0x30, 0x00, 0x30, 0x04, 0x00, 0x18, 0x04,
  0x00, 0x08, 0x01, 0x80, 0x06, 0x01, 0x80, 0x06, 0x00, 0x60, 0x01, 0x80,
  0x60, 0x01, 0x80, 0x18, 0x00, 0x40, 0x18, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x02, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x02,
  0x00, 0x30, 0x03, 0x00, 0x04, 0x00, 0x80, 0x04, 0x00, 0x80, 0x01, 0x00,
  0x60, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x60, 0x18, 0x00, 0x18,
  0x04, 0x00, 0x18, 0x06, 0x00, 0x02, 0x03, 0x00, 0x02, 0x03, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00,
  0x0C, 0x08, 0x00, 0x04, 0x08, 0x00, 0x01, 0x06, 0x00, 0x01, 0x06, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x61, 0x80, 0x00, 0x18, 0x40, 0x00, 0x18, 0x60,
  0x00, 0x02, 0x30, 0x00, 0x02, 0x10, 0x00, 0x00, 0x8C, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x0C,
  0xC0, 0x00, 0x01, 0x60, 0x00, 0x01, 0x20, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x00, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x04, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x18, 0x10, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x00, 0xC1, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x02, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x30, 0x00, 0x80, 0x00, 0x20, 0x03,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0xFF, 0xF0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x61, 0x80, 0x00, 0x02,
  0x04, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x00, 0x80, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x80, 0x10, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x02, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x40, 0x03, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x08, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x20, 0x40, 0x00, 0x01, 0x86, 0x00, 0x00, 0x04,
  0x20, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x00, 0xFF, 0xC0, 0x07, 0xC0,
  0xF0, 0x1C, 0x00, 0x38, 0x10, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0xFF, 0x01, 0xF8, 0x03, 0x0F, 0x00,
  0x03, 0x1C, 0x00, 0x03, 0x30, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0B, 0x60, 0x00, 0x1B, 0x60, 0x00,
  0x33, 0x30, 0x00, 0x63, 0x1C, 0x03, 0xC3, 0x0F, 0xFF, 0x03, 0x00, 0xE0,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x0F,
  0xFE, 0x02, 0x0F, 0x03, 0xE0, 0x86, 0x00, 0x1C, 0x23, 0x00, 0x01, 0x89,
  0x80, 0x00, 0x32, 0xC0, 0x00, 0x0C, 0xA0, 0x00, 0x01, 0xB8, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x01, 0x28, 0x00, 0x00, 0xCB, 0x00, 0x00, 0x62, 0x60, 0x00, 0x30,
  0x8C, 0x00, 0x18, 0x21, 0xC0, 0x3C, 0x08, 0x1F, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x01, 0xF0, 0x3C, 0x0E, 0x00, 0x08, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x81, 0xE0, 0x07, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x1F, 0xF8, 0x18, 0x1F, 0x03, 0xC3, 0x07, 0x00, 0x1C,
  0x61, 0x80, 0x00, 0xCC, 0x60, 0x00, 0x0D, 0x98, 0x00, 0x00, 0xB3, 0x00,
  0x00, 0x1E, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x3A, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xD0,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x07, 0x60, 0x00, 0x01, 0xE6, 0x00, 0x00,
  0x2C, 0xC0, 0x00, 0x0D, 0x8C, 0x00, 0x03, 0x30, 0xE0, 0x00, 0xC6, 0x0F,
  0x00, 0x70, 0xC0, 0x7F, 0xF8, 0x18, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x78, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x38, 0x00, 0x30, 0x18, 0x00,
  0x06, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x80, 0x00, 0x06, 0x60,
  0x00, 0x01, 0x90, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x10, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x07, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x60, 0x7C, 0x0F, 0x0C, 0x1C, 0x00, 0x31, 0x86, 0x00, 0x03, 0x31,
  0x80, 0x00, 0x36, 0x60, 0x00, 0x02, 0xCC, 0x00, 0x00, 0x7B, 0x00, 0x00,
  0x07, 0x60, 0x00, 0x00, 0xE8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x40, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0x1D, 0x80, 0x00, 0x07, 0x98, 0x00, 0x00, 0xB3, 0x80, 0x00, 0x36,
  0x38, 0x00, 0x0C, 0xC3, 0x80, 0x03, 0x18, 0x3C, 0x03, 0xC3, 0x01, 0xFF,
  0xE0, 0x60, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x60, 0xF8, 0x00, 0x38, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0xFF,
  0xC0, 0x83, 0xC0, 0xF0, 0x8E, 0x00, 0x18, 0x98, 0x00, 0x0C, 0x90, 0x00,
  0x06, 0xB0, 0x00, 0x06, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x5F, 0xF0, 0x00, 0x00, 0x04, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x00, 0x40, 0x1C, 0x03, 0x80, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x01,
  0x80, 0x33, 0xFC, 0x3E, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x01, 0xA0, 0x00,
  0x0C, 0x80, 0x00, 0x62, 0x00, 0x03, 0x08, 0x00, 0x18, 0x20, 0x00, 0xE0,
  0x80, 0x03, 0x02, 0x00, 0x18, 0x08, 0x00, 0xC0, 0x20, 0x06, 0x00, 0x80,
  0x30, 0x02, 0x01, 0x80, 0x08, 0x0C, 0x00, 0x20, 0x60, 0x00, 0x83, 0x80,
  0x02, 0x1E, 0x00, 0x08, 0x4C, 0x00, 0x23, 0x18, 0x00, 0x98, 0x30, 0x02,
  0xC0, 0xC0, 0x0E, 0x01, 0x80, 0x30, 0x03, 0x00, 0x80, 0x06, 0x02, 0x00,
  0x18, 0x08, 0x00, 0x30, 0x20, 0x00, 0x60, 0x80, 0x00, 0xC2, 0x00, 0x03,
  0x08, 0x00, 0x06, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x68,
  0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x81, 0xFF, 0x00,
  0x1F, 0xF0, 0x21, 0xE0, 0xF0, 0x1E, 0x0F, 0x08, 0xC0, 0x0E, 0x0C, 0x00,
  0x62, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0xB0, 0x00, 0x33, 0x00, 0x01, 0xA8,
  0x00, 0x07, 0x80, 0x00, 0x6C, 0x00, 0x01, 0xE0, 0x00, 0x0B, 0x00, 0x00,
  0x30, 0x00, 0x02, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x03, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x20, 0x00, 0x03, 0x80, 0x00, 0x08, 0x00, 0x00, 0xE0,
  0x00, 0x02, 0x00, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x80, 0x00, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x03, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x80, 0xFF, 0xC0, 0x83, 0xC0, 0xF0, 0x8E, 0x00, 0x18,
  0x9C, 0x00, 0x0C, 0x90, 0x00, 0x06, 0xB0, 0x00, 0x06, 0xA0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x7F, 0xE0, 0x00, 0x1E, 0x07,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x04, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x30, 0x06, 0x00, 0x0E, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x80, 0xFF, 0xE0, 0x10, 0x7C, 0x1F, 0x02,
  0x1C, 0x00, 0x70, 0x46, 0x00, 0x03, 0x09, 0x80, 0x00, 0x31, 0x60, 0x00,
  0x06, 0x2C, 0x00, 0x00, 0x67, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x05, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x05, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x9C, 0x00, 0x00, 0x33, 0x80, 0x00, 0x06,
  0x58, 0x00, 0x01, 0x8B, 0x80, 0x00, 0x61, 0x30, 0x00, 0x1C, 0x23, 0x80,
  0x07, 0x04, 0x3C, 0x03, 0x80, 0x81, 0xFF, 0xE0, 0x10, 0x03, 0xC0, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x20,
  0x3E, 0x07, 0x84, 0x0E, 0x00, 0x38, 0x83, 0x00, 0x01, 0x90, 0xC0, 0x00,
  0x1A, 0x30, 0x00, 0x03, 0x44, 0x00, 0x00, 0x39, 0x80, 0x00, 0x07, 0x30,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x50, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xA0, 0x00, 0x00, 0x14, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1C,
  0xC0, 0x00, 0x02, 0x8C, 0x00, 0x00, 0xD1, 0x80, 0x00, 0x32, 0x18, 0x00,
  0x0E, 0x41, 0x80, 0x03, 0x88, 0x1E, 0x01, 0xC1, 0x00, 0xFF, 0xF0, 0x20,
  0x01, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x81,
  0xFF, 0x87, 0x83, 0x8C, 0x00, 0x98, 0x00, 0xB0, 0x00, 0xA0, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0x81, 0xFC, 0x30,
  0x00, 0x10, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x06, 0x7E, 0x00,
  0x78, 0x1F, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x01, 0x00, 0xFF, 0x80, 0x0E,
  0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xD0, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0xF6, 0x00, 0x00, 0xD9, 0x80, 0x00, 0xCC, 0x60,
  0x00, 0xC6, 0x1C, 0x03, 0xC3, 0x03, 0xFF, 0x81, 0x80, 0x1E, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x40,
  0x80, 0x00, 0x18, 0x18, 0x00, 0x02, 0x01, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x18, 0x06, 0x00, 0x02, 0x00, 0x40, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x10, 0x00, 0x20, 0x06,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x10, 0x00, 0x08, 0x06, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x10, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x04, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x08, 0x80, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0x40, 0x00, 0x1C, 0x00, 0x03, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x60, 0x00, 0x16, 0x00, 0x02, 0x60, 0x00, 0x36, 0x00, 0x06, 0x30, 0x00,
  0x32, 0x00, 0x06, 0x30, 0x00, 0x23, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00,
  0x04, 0x10, 0x00, 0x61, 0x00, 0x0C, 0x18, 0x00, 0x41, 0x80, 0x0C, 0x18,
  0x00, 0xC1, 0x80, 0x0C, 0x08, 0x00, 0xC0, 0x80, 0x08, 0x0C, 0x00, 0x80,
  0xC0, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x60, 0x10, 0x06, 0x03, 0x00, 0x60, 0x30, 0x06, 0x03,
  0x00, 0x20, 0x30, 0x02, 0x02, 0x00, 0x30, 0x20, 0x03, 0x06, 0x00, 0x30,
  0x60, 0x03, 0x06, 0x00, 0x10, 0x60, 0x03, 0x04, 0x00, 0x18, 0x60, 0x01,
  0x0C, 0x00, 0x18, 0x40, 0x01, 0x8C, 0x00, 0x08, 0xC0, 0x01, 0x88, 0x00,
  0x0C, 0xC0, 0x00, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x98, 0x00, 0x04, 0x80,
  0x00, 0xD0, 0x00, 0x05, 0x80, 0x00, 0xD0, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x18, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x00, 0x60, 0x01, 0x80,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x0C,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x30,
  0x00, 0x18, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x01, 0x80, 0x20, 0x00, 0x30, 0x18, 0x00, 0x06, 0x0C,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x40, 0x80, 0x00, 0x18, 0x18, 0x00, 0x02, 0x01, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x18, 0x06, 0x00, 0x02, 0x00, 0x40, 0x00, 0xC0, 0x0C, 0x00, 0x18,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x10, 0x00, 0x20,
  0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x10, 0x00, 0x08, 0x06, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x10, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x04, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0x80, 0x00,
  0x01, 0x30, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0xF8, 0x00,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x01, 0xF0, 0x03, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x0F,
  0xE0, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x5E,
  0x03, 0x80, 0x07, 0xC0, 0x07, 0x80, 0x68, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xC0,
};

const GFXglyph NotoSans_Thin62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 45, 14, 5, -44 },
  { 24, 10, 16, 20, 5, -44 },
  { 44, 36, 44, 40, 2, -44 },
  { 242, 25, 51, 35, 4, -47 },
  { 402, 42, 46, 49, 4, -45 },
  { 644, 37, 46, 44, 4, -45 },
  { 857, 1, 16, 11, 5, -44 },
  { 859, 11, 54, 16, 3, -44 },
  { 934, 11, 54, 16, 2, -44 },
  { 1009, 26, 25, 34, 4, -47 },
  { 1091, 29, 28, 35, 3, -36 },
  { 1193, 6, 15, 11, 2, -7 },
  { 1205, 15, 2, 20, 2, -18 },
  { 1209, 4, 4, 14, 5, -3 },
  { 1211, 18, 44, 20, 1, -44 },
  { 1310, 27, 46, 35, 4, -45 },
  { 1466, 14, 44, 35, 6, -44 },
  { 1543, 26, 45, 35, 4, -45 },
  { 1690, 28, 46, 35, 3, -45 },
  { 1851, 33, 45, 35, 2, -45 },
  { 2037, 26, 45, 35, 5, -44 },
  { 2184, 28, 46, 35, 4, -45 },
  { 2345, 28, 44, 35, 4, -44 },
  { 2499, 27, 46, 35, 4, -45 },
  { 2655, 28, 46, 35, 3, -45 },
  { 2816, 4, 34, 14, 5, -33 },
  { 2833, 7, 41, 14, 2, -33 },
  { 2869, 29, 27, 35, 3, -36 },
  { 2967, 29, 14, 35, 3, -29 },
  { 3018, 29, 27, 35, 3, -36 },
  { 3116, 21, 46, 26, 2, -45 },
  { 3237, 48, 50, 54, 3, -44 },
  { 3537, 36, 44, 36, 0, -44 },
  { 3735, 29, 44, 38, 6, -44 },
  { 3895, 32, 46, 38, 4, -45 },
  { 4079, 33, 44, 43, 6, -44 },
  { 4261, 24, 44, 34, 6, -44 },
  { 4393, 24, 44, 31, 6, -44 },
  { 4525, 36, 46, 45, 4, -45 },
  { 4732, 31, 44, 44, 6, -44 },
  { 4903, 10, 44, 18, 4, -44 },
  { 4958, 14, 55, 14, -6, -44 },
  { 5055, 29, 44, 35, 6, -44 },
  { 5215, 24, 44, 31, 6, -44 },
  { 5347, 39, 44, 52, 6, -44 },
  { 5562, 31, 44, 43, 6, -44 },
  { 5733, 39, 46, 47, 4, -45 },
  { 5958, 26, 44, 36, 6, -44 },
  { 6101, 39, 56, 47, 4, -45 },
  { 6374, 28, 44, 36, 6, -44 },
  { 6528, 27, 46, 34, 3, -45 },
  { 6684, 31, 44, 31, 0, -44 },
  { 6855, 32, 45, 44, 6, -44 },
  { 7035, 35, 44, 35, 0, -44 },
  { 7228, 50, 44, 54, 2, -44 },
  { 7503, 32, 44, 32, 0, -44 },
  { 7679, 31, 44, 31, 0, -44 },
  { 7850, 31, 44, 36, 2, -44 },
  { 8021, 13, 54, 19, 5, -44 },
  { 8109, 18, 44, 20, 1, -44 },
  { 8208, 12, 54, 19, 2, -44 },
  { 8289, 29, 28, 35, 3, -45 },
  { 8391, 24, 1, 24, 0, 6 },
  { 8394, 11, 9, 15, 2, -47 },
  { 8407, 24, 34, 32, 3, -33 },
  { 8509, 26, 48, 36, 6, -47 },
  { 8665, 23, 34, 29, 4, -33 },
  { 8763, 27, 48, 36, 4, -47 },
  { 8925, 26, 34, 33, 4, -33 },
  { 9036, 20, 47, 17, 1, -47 },
  { 9154, 27, 48, 36, 4, -33 },
  { 9316, 24, 47, 36, 6, -47 },
  { 9457, 3, 45, 13, 5, -45 },
  { 9474, 11, 60, 13, -3, -45 },
  { 9557, 22, 47, 28, 6, -47 },
  { 9687, 1, 47, 13, 6, -47 },
  { 9693, 42, 33, 53, 6, -33 },
  { 9867, 24, 33, 36, 6, -33 },
  { 9966, 28, 34, 36, 4, -33 },
  { 10085, 27, 47, 36, 6, -33 },
  { 10244, 27, 47, 36, 3, -33 },
  { 10403, 16, 33, 23, 6, -33 },
  { 10469, 23, 34, 28, 2, -33 },
  { 10567, 17, 42, 20, 1, -41 },
  { 10657, 25, 34, 36, 5, -33 },
  { 10764, 27, 33, 27, 0, -33 },
  { 10876, 40, 33, 42, 1, -33 },
  { 11041, 26, 33, 30, 2, -33 },
  { 11149, 27, 48, 27, 0, -33 },
  { 11311, 23, 33, 28, 3, -33 },
  { 11406, 17, 54, 21, 2, -44 },
  { 11521, 1, 63, 33, 16, -47 },
  { 11529, 17, 54, 21, 2, -44 },
  { 11644, 29, 6, 35, 3, -25 },
};

const GFXfont NotoSans_Thin62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin62pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_THIN62PT7B_H_
