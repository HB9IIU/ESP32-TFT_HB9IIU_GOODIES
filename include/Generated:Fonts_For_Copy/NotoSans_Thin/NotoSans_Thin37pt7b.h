#ifndef _NOTOSANS_THIN37PT7B_H_
#define _NOTOSANS_THIN37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin37pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x55, 0x00, 0xF0, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x84, 0x00, 0x40, 0x40, 0x02, 0x01, 0x00, 0x08, 0x04, 0x00,
  0x20, 0x20, 0x00, 0x80, 0x80, 0x02, 0x02, 0x00, 0x10, 0x08, 0x00, 0x40,
  0x20, 0x7F, 0xFF, 0xFC, 0x04, 0x04, 0x00, 0x10, 0x10, 0x00, 0x40, 0x40,
  0x02, 0x01, 0x00, 0x08, 0x08, 0x00, 0x20, 0x20, 0x00, 0x80, 0x80, 0x02,
  0x02, 0x03, 0xFF, 0xFF, 0xC0, 0x40, 0x40, 0x01, 0x01, 0x00, 0x04, 0x04,
  0x00, 0x10, 0x10, 0x00, 0x80, 0x40, 0x02, 0x01, 0x00, 0x08, 0x08, 0x00,
  0x20, 0x20, 0x00, 0x01, 0x00, 0x02, 0x00, 0x1F, 0xC0, 0xC8, 0x62, 0x10,
  0x08, 0x20, 0x10, 0x40, 0x40, 0x80, 0x81, 0x01, 0x82, 0x01, 0x04, 0x03,
  0x08, 0x03, 0x10, 0x01, 0xA0, 0x00, 0xE0, 0x00, 0xB0, 0x01, 0x18, 0x02,
  0x08, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x81,
  0x01, 0x07, 0x02, 0x1B, 0xE5, 0xC0, 0x1C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x0E, 0x00, 0x08, 0x18, 0x80, 0x08, 0x18, 0x20, 0x08, 0x08, 0x08, 0x04,
  0x04, 0x04, 0x04, 0x04, 0x02, 0x02, 0x02, 0x01, 0x02, 0x01, 0x00, 0x81,
  0x00, 0x80, 0x41, 0x00, 0x40, 0x20, 0x80, 0x20, 0x10, 0x80, 0x10, 0x08,
  0x87, 0xC4, 0x04, 0x44, 0x32, 0x02, 0x44, 0x09, 0x82, 0x22, 0x02, 0x62,
  0x22, 0x01, 0x0E, 0x11, 0x00, 0x80, 0x10, 0x80, 0x40, 0x08, 0x40, 0x20,
  0x08, 0x20, 0x10, 0x08, 0x10, 0x08, 0x04, 0x08, 0x04, 0x04, 0x04, 0x02,
  0x02, 0x01, 0x01, 0x02, 0x00, 0x81, 0x01, 0x00, 0x61, 0x81, 0x00, 0x1F,
  0x80, 0x01, 0xE0, 0x00, 0x0C, 0x30, 0x00, 0x20, 0x10, 0x00, 0x40, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00,
  0x08, 0x04, 0x00, 0x18, 0x10, 0x00, 0x18, 0x40, 0x00, 0x13, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xD8, 0x00, 0x06, 0x18, 0x00, 0x18, 0x18, 0x02, 0x60,
  0x10, 0x04, 0x80, 0x10, 0x13, 0x00, 0x10, 0x24, 0x00, 0x10, 0x88, 0x00,
  0x11, 0x10, 0x00, 0x14, 0x10, 0x00, 0x10, 0x20, 0x00, 0x50, 0x20, 0x01,
  0x10, 0x20, 0x0C, 0x10, 0x3F, 0xE0, 0x18, 0xFF, 0x80, 0x0C, 0x61, 0x08,
  0x21, 0x04, 0x10, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x10, 0x41, 0x02, 0x08, 0x10, 0x40, 0x81, 0xC0, 0x40, 0xC0,
  0x80, 0x81, 0x02, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x60, 0x81, 0x02, 0x04, 0x10, 0x20, 0x81, 0x04, 0x18,
  0x60, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xC0,
  0x83, 0x38, 0x9C, 0x07, 0x60, 0x01, 0x80, 0x02, 0x40, 0x02, 0x40, 0x04,
  0x20, 0x08, 0x10, 0x18, 0x08, 0x10, 0x08, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x32, 0x22, 0x24, 0x44,
  0x80, 0xFF, 0x80, 0xF0, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x18, 0x00, 0x01, 0xE0, 0x06, 0x0C, 0x04, 0x01, 0x06, 0x00,
  0x42, 0x00, 0x22, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x50, 0x00, 0x48, 0x00, 0x24, 0x00,
  0x12, 0x00, 0x08, 0x80, 0x08, 0x40, 0x04, 0x10, 0x04, 0x04, 0x04, 0x01,
  0xFC, 0x00, 0x03, 0x0D, 0x19, 0x21, 0xC1, 0x81, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x03, 0xC0, 0x1C, 0x30, 0x60, 0x08, 0x40, 0x04,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0x07, 0xE0,
  0x38, 0x18, 0x60, 0x04, 0x80, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x70,
  0x0F, 0xE0, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x06,
  0xC0, 0x0C, 0x7F, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0A, 0x00,
  0x01, 0xA0, 0x00, 0x12, 0x00, 0x02, 0x20, 0x00, 0x42, 0x00, 0x0C, 0x20,
  0x00, 0x82, 0x00, 0x10, 0x20, 0x02, 0x02, 0x00, 0x20, 0x20, 0x04, 0x02,
  0x00, 0x80, 0x20, 0x10, 0x02, 0x01, 0x00, 0x20, 0x20, 0x02, 0x04, 0x00,
  0x20, 0xC0, 0x02, 0x0F, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x3F, 0xFC, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x4F, 0xC0, 0x70, 0x30,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C,
  0x80, 0x18, 0x7F, 0xE0, 0x00, 0xFC, 0x06, 0x04, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x8F, 0xF0, 0x90, 0x08, 0xA0, 0x04, 0xC0, 0x02, 0x80, 0x02,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x10, 0x08, 0x0F, 0xF0, 0xFF, 0xFF,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x03, 0xE0, 0x06, 0x0C, 0x04, 0x01,
  0x04, 0x00, 0x46, 0x00, 0x22, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x20,
  0x02, 0x10, 0x03, 0x06, 0x03, 0x01, 0x82, 0x00, 0x3E, 0x00, 0x1B, 0x00,
  0x30, 0x60, 0x60, 0x0C, 0x20, 0x02, 0x20, 0x00, 0x90, 0x00, 0x50, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0D, 0x00, 0x04, 0x80, 0x02, 0x20, 0x02, 0x08,
  0x02, 0x03, 0xFE, 0x00, 0x03, 0xC0, 0x0E, 0x18, 0x0C, 0x03, 0x0C, 0x00,
  0x84, 0x00, 0x26, 0x00, 0x12, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40,
  0x00, 0xA0, 0x00, 0x50, 0x00, 0x24, 0x00, 0x2A, 0x00, 0x18, 0x80, 0x14,
  0x30, 0x72, 0x07, 0xC1, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x1F,
  0xF0, 0x00, 0xF4, 0x00, 0x00, 0x00, 0x0F, 0x33, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x32, 0x22, 0x24, 0x44, 0x80, 0x00, 0x00, 0x80, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x00, 0x1F, 0x07, 0x07, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x0C,
  0x00, 0xC0, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x08, 0x00,
  0x01, 0x00, 0x80, 0x00, 0x04, 0x08, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00,
  0x84, 0x00, 0xF8, 0x02, 0x40, 0x18, 0x30, 0x12, 0x01, 0x00, 0x80, 0xB0,
  0x10, 0x04, 0x05, 0x01, 0x00, 0x20, 0x28, 0x08, 0x01, 0x00, 0xC0, 0x40,
  0x08, 0x06, 0x02, 0x00, 0x40, 0x70, 0x10, 0x02, 0x02, 0x80, 0x80, 0x10,
  0x14, 0x04, 0x01, 0x80, 0xA0, 0x20, 0x0C, 0x05, 0x01, 0x80, 0xA0, 0x44,
  0x06, 0x08, 0x84, 0x20, 0x1F, 0x83, 0xC1, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x14, 0x00, 0x00, 0x90, 0x00, 0x08,
  0x80, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x20, 0x80, 0x01, 0x02, 0x00,
  0x18, 0x10, 0x00, 0x80, 0xC0, 0x04, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x40, 0x10, 0x02, 0x01, 0xFF, 0xF0, 0x08, 0x00, 0x40, 0x80, 0x02, 0x04,
  0x00, 0x18, 0x20, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x09, 0x00, 0x00,
  0x48, 0x00, 0x02, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x40, 0xFF, 0xF8, 0x40,
  0x06, 0x20, 0x00, 0x90, 0x00, 0x68, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x05,
  0x00, 0x02, 0x80, 0x02, 0x40, 0x01, 0x20, 0x01, 0x10, 0x0F, 0x0F, 0xFF,
  0x84, 0x00, 0x22, 0x00, 0x09, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x0D, 0x00, 0x0C,
  0x80, 0x1C, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x1C, 0x0E, 0x06, 0x00,
  0x10, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x02, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x10, 0x01, 0x82, 0x00, 0x0C, 0x40, 0x00, 0xC8, 0x00,
  0x09, 0x00, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x40, 0x00,
  0x28, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x44, 0x00, 0x30, 0x80, 0x38,
  0x1F, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0xFF, 0xFA, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0xFF,
  0xF0, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03,
  0xFF, 0xE8, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x07, 0x01, 0xE0, 0x30, 0x00, 0x83, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x05, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x50, 0x00, 0x01, 0x60, 0x00, 0x04, 0x80, 0x00, 0x11,
  0x00, 0x00, 0x46, 0x00, 0x01, 0x0C, 0x00, 0x04, 0x0C, 0x00, 0x30, 0x0F,
  0xFF, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x13, 0xF0, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x0D, 0xFC, 0x80, 0x03, 0x40,
  0x03, 0x20, 0x03, 0x10, 0x03, 0x08, 0x03, 0x04, 0x03, 0x02, 0x02, 0x01,
  0x02, 0x00, 0x82, 0x00, 0x42, 0x00, 0x22, 0x00, 0x12, 0x80, 0x0A, 0x20,
  0x06, 0x18, 0x02, 0x04, 0x01, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x20,
  0x08, 0x10, 0x02, 0x08, 0x01, 0x84, 0x00, 0x42, 0x00, 0x11, 0x00, 0x04,
  0x80, 0x03, 0x40, 0x00, 0xC0, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x03, 0xFF, 0xF0, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x2D,
  0x00, 0x00, 0x5A, 0x00, 0x00, 0xB2, 0x00, 0x02, 0x64, 0x00, 0x04, 0xC4,
  0x00, 0x11, 0x88, 0x00, 0x23, 0x10, 0x00, 0x46, 0x10, 0x01, 0x0C, 0x20,
  0x02, 0x18, 0x20, 0x08, 0x30, 0x40, 0x10, 0x60, 0x80, 0x20, 0xC0, 0x80,
  0x81, 0x81, 0x01, 0x03, 0x01, 0x04, 0x06, 0x02, 0x08, 0x0C, 0x06, 0x30,
  0x18, 0x04, 0x40, 0x30, 0x08, 0x80, 0x60, 0x0A, 0x00, 0xC0, 0x14, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x20, 0x04, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x06, 0x80, 0x01, 0x90, 0x00, 0x66, 0x00, 0x18, 0x80, 0x06, 0x10, 0x01,
  0x86, 0x00, 0x60, 0x80, 0x18, 0x10, 0x06, 0x06, 0x01, 0x80, 0x80, 0x60,
  0x10, 0x18, 0x06, 0x06, 0x00, 0x81, 0x80, 0x10, 0x60, 0x06, 0x18, 0x00,
  0x86, 0x00, 0x11, 0x80, 0x02, 0x60, 0x00, 0x98, 0x00, 0x16, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x10, 0x00, 0x3E, 0x00, 0x03, 0x81, 0xC0, 0x06,
  0x00, 0x20, 0x08, 0x00, 0x10, 0x10, 0x00, 0x08, 0x20, 0x00, 0x04, 0x20,
  0x00, 0x04, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40,
  0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40,
  0x00, 0x02, 0x40, 0x00, 0x02, 0x60, 0x00, 0x04, 0x20, 0x00, 0x04, 0x30,
  0x00, 0x08, 0x10, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x60, 0x01,
  0xFF, 0x80, 0xFF, 0xE1, 0x00, 0x32, 0x00, 0x14, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x14, 0x00,
  0x28, 0x01, 0x90, 0x0E, 0x3F, 0xE0, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0x81, 0xC0, 0x06, 0x00, 0x20,
  0x08, 0x00, 0x10, 0x10, 0x00, 0x08, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04,
  0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02,
  0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x02, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02,
  0x40, 0x00, 0x02, 0x60, 0x00, 0x04, 0x20, 0x00, 0x04, 0x30, 0x00, 0x08,
  0x10, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x60, 0x01, 0xFF, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0xFF, 0xF0, 0x80, 0x18, 0x80, 0x04,
  0x80, 0x06, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x04, 0x80, 0x08, 0x80, 0x30, 0xFF, 0xC0, 0x80, 0xC0,
  0x80, 0x40, 0x80, 0x60, 0x80, 0x20, 0x80, 0x10, 0x80, 0x18, 0x80, 0x08,
  0x80, 0x0C, 0x80, 0x04, 0x80, 0x02, 0x80, 0x03, 0x80, 0x01, 0x03, 0xF0,
  0x1C, 0x0E, 0x30, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x06,
  0x80, 0x0C, 0x7F, 0xF0, 0xFF, 0xFF, 0xE0, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x05, 0x80, 0x00, 0x90, 0x00,
  0x21, 0x00, 0x0C, 0x18, 0x03, 0x01, 0xFF, 0x80, 0x80, 0x00, 0x1A, 0x00,
  0x00, 0x90, 0x00, 0x04, 0xC0, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x10,
  0x40, 0x01, 0x02, 0x00, 0x08, 0x10, 0x00, 0x80, 0x40, 0x04, 0x02, 0x00,
  0x20, 0x18, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x08, 0x08, 0x00,
  0x40, 0x40, 0x02, 0x04, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x03, 0x10,
  0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x80, 0x03, 0x00, 0x05, 0x00, 0x0C, 0x00,
  0x34, 0x00, 0x30, 0x00, 0x90, 0x01, 0x20, 0x02, 0x20, 0x04, 0x80, 0x08,
  0x80, 0x12, 0x00, 0x42, 0x00, 0x48, 0x01, 0x08, 0x02, 0x10, 0x04, 0x10,
  0x08, 0x40, 0x10, 0x40, 0x21, 0x00, 0x81, 0x00, 0x82, 0x02, 0x04, 0x04,
  0x08, 0x08, 0x08, 0x10, 0x20, 0x40, 0x20, 0x40, 0x81, 0x00, 0x82, 0x01,
  0x04, 0x01, 0x08, 0x04, 0x10, 0x04, 0x20, 0x10, 0x80, 0x10, 0x80, 0x42,
  0x00, 0x44, 0x00, 0x88, 0x00, 0x90, 0x02, 0x60, 0x02, 0x40, 0x09, 0x00,
  0x09, 0x00, 0x14, 0x00, 0x28, 0x00, 0x50, 0x00, 0x60, 0x01, 0x80, 0x01,
  0x80, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x60, 0x00, 0x44, 0x00, 0x10,
  0x40, 0x04, 0x08, 0x00, 0x80, 0x80, 0x20, 0x08, 0x0C, 0x01, 0x01, 0x00,
  0x10, 0x40, 0x03, 0x18, 0x00, 0x22, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00,
  0x04, 0x00, 0x01, 0x40, 0x00, 0x6C, 0x00, 0x08, 0x80, 0x02, 0x08, 0x00,
  0xC1, 0x00, 0x10, 0x10, 0x04, 0x01, 0x01, 0x80, 0x20, 0x20, 0x02, 0x08,
  0x00, 0x21, 0x00, 0x04, 0x40, 0x00, 0x50, 0x00, 0x0C, 0xC0, 0x00, 0x68,
  0x00, 0x08, 0x80, 0x02, 0x10, 0x00, 0xC1, 0x00, 0x10, 0x20, 0x04, 0x02,
  0x00, 0x80, 0x40, 0x20, 0x04, 0x04, 0x00, 0x81, 0x00, 0x08, 0x20, 0x01,
  0x88, 0x00, 0x11, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x1F, 0xFF,
  0xFC, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xC0, 0x08, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0xFE, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0xFF, 0x00, 0x80, 0x00, 0x60, 0x00, 0x50, 0x00, 0x24, 0x00, 0x22, 0x00,
  0x10, 0x80, 0x10, 0x40, 0x08, 0x10, 0x08, 0x08, 0x04, 0x02, 0x04, 0x01,
  0x06, 0x00, 0x42, 0x00, 0x23, 0x00, 0x09, 0x00, 0x05, 0x00, 0x01, 0x80,
  0x00, 0x80, 0xFF, 0xFE, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x40, 0x07, 0xC0,
  0xE0, 0xC4, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x0F, 0xF1, 0xC0, 0x58, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0x54, 0x02, 0x4F, 0xF1, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x83, 0xE0, 0x8C, 0x18, 0x90, 0x04, 0xA0, 0x02, 0xC0, 0x02, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x02, 0xC0, 0x02, 0xA0,
  0x04, 0x90, 0x08, 0x8F, 0xF0, 0x01, 0xF8, 0x38, 0x11, 0x80, 0x0C, 0x00,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x80, 0x41, 0xFF, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x03, 0xE1, 0x0C, 0x19,
  0x10, 0x05, 0x20, 0x03, 0x40, 0x03, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x40, 0x01, 0x40, 0x03, 0x40, 0x03, 0x20, 0x05, 0x10, 0x0D, 0x0F, 0xF1,
  0x03, 0xE0, 0x0C, 0x18, 0x10, 0x04, 0x20, 0x04, 0x40, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x80, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x02, 0x07, 0xFC, 0x03, 0xF8, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0xFF, 0xC0, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x03, 0xF1, 0x0C, 0x09, 0x10, 0x05, 0x20, 0x03, 0x40, 0x03,
  0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x01, 0x40, 0x03, 0x60, 0x03,
  0x20, 0x05, 0x18, 0x0D, 0x0F, 0xF1, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x40, 0x06, 0x70, 0x18, 0x0F, 0xE0,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x83, 0xE1, 0x18, 0x32, 0xC0, 0x15, 0x00, 0x2C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0xB8, 0x02, 0xAA, 0xAA, 0xAA, 0xAA, 0xA8,
  0x04, 0x0C, 0x10, 0x00, 0x00, 0x00, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x27, 0x80, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x0A,
  0x00, 0x48, 0x02, 0x20, 0x18, 0x80, 0xC2, 0x06, 0x08, 0x10, 0x20, 0x80,
  0x84, 0x02, 0x30, 0x09, 0x20, 0x28, 0xC0, 0xC1, 0x02, 0x02, 0x08, 0x04,
  0x20, 0x18, 0x80, 0x22, 0x00, 0x48, 0x00, 0xA0, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x87, 0xC0, 0x7C, 0x4C, 0x18, 0xC1, 0xA8, 0x04, 0x80, 0x54, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x10, 0x83, 0xE1, 0x18, 0x32, 0x40, 0x15, 0x00, 0x2C,
  0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x03, 0xF0, 0x06, 0x06, 0x04, 0x01,
  0x84, 0x00, 0x44, 0x00, 0x12, 0x00, 0x09, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0A, 0x00, 0x05,
  0x00, 0x04, 0x80, 0x02, 0x20, 0x03, 0x18, 0x01, 0x06, 0x03, 0x00, 0xFF,
  0x00, 0x83, 0xE0, 0x8C, 0x18, 0x90, 0x04, 0xA0, 0x02, 0xA0, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xA0, 0x02, 0xA0,
  0x04, 0x98, 0x0C, 0x8F, 0xF0, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x03,
  0xE1, 0x0C, 0x19, 0x10, 0x05, 0x20, 0x03, 0x40, 0x03, 0x40, 0x01, 0x40,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x40, 0x01, 0x40, 0x03, 0x40, 0x03, 0x20, 0x05, 0x10,
  0x09, 0x0F, 0xF1, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x87, 0xE6, 0x0A,
  0x02, 0x80, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x07, 0xE0,
  0x60, 0x72, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x3C, 0x01, 0x9F, 0xF8, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x0F, 0xFE, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x3F, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x40, 0x06, 0x80, 0x14, 0x80, 0x48, 0xFF, 0x10, 0x80, 0x01, 0x80, 0x01,
  0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x10, 0x08,
  0x10, 0x08, 0x10, 0x10, 0x08, 0x10, 0x08, 0x10, 0x04, 0x20, 0x04, 0x20,
  0x04, 0x40, 0x02, 0x40, 0x02, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x80, 0x10, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0xC0, 0x18, 0x02,
  0x40, 0x24, 0x02, 0x40, 0x24, 0x04, 0x40, 0x24, 0x04, 0x20, 0x42, 0x04,
  0x20, 0x42, 0x04, 0x20, 0x42, 0x08, 0x20, 0x81, 0x08, 0x10, 0x81, 0x08,
  0x10, 0x81, 0x08, 0x11, 0x00, 0x90, 0x09, 0x00, 0x90, 0x09, 0x00, 0x90,
  0x0A, 0x00, 0x50, 0x0A, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x20,
  0xC0, 0x02, 0x40, 0x04, 0x20, 0x04, 0x30, 0x08, 0x10, 0x10, 0x08, 0x30,
  0x04, 0x20, 0x04, 0x40, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0xC0,
  0x04, 0x40, 0x04, 0x20, 0x08, 0x30, 0x10, 0x10, 0x30, 0x08, 0x20, 0x04,
  0x40, 0x06, 0x80, 0x03, 0x80, 0x01, 0x80, 0x03, 0x40, 0x02, 0x40, 0x02,
  0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x10, 0x08, 0x10, 0x08, 0x10, 0x10,
  0x08, 0x10, 0x08, 0x10, 0x04, 0x20, 0x04, 0x20, 0x04, 0x40, 0x02, 0x40,
  0x02, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x01, 0xFF, 0xF0, 0x03,
  0xC1, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x03, 0x80, 0x30, 0x04, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01,
  0x00, 0x60, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x02, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x80, 0x30, 0x03, 0x01, 0x80, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x01, 0x83, 0x80,
  0x1C, 0x00, 0x31, 0xC0, 0x60, 0x1C, 0xC0, 0x01, 0x00,
};

const GFXglyph NotoSans_Thin37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 26, 8, 3, -26 },
  { 8, 6, 9, 12, 3, -26 },
  { 15, 22, 26, 24, 1, -26 },
  { 87, 15, 30, 21, 2, -28 },
  { 144, 25, 27, 29, 2, -27 },
  { 229, 23, 27, 26, 2, -27 },
  { 307, 1, 9, 6, 3, -26 },
  { 309, 6, 32, 9, 2, -26 },
  { 333, 7, 32, 9, 1, -26 },
  { 361, 16, 15, 20, 2, -28 },
  { 391, 17, 17, 21, 2, -22 },
  { 428, 4, 9, 7, 1, -4 },
  { 433, 9, 1, 12, 1, -11 },
  { 435, 2, 2, 8, 3, -2 },
  { 436, 11, 26, 12, 0, -26 },
  { 472, 17, 27, 21, 2, -27 },
  { 530, 8, 26, 21, 4, -26 },
  { 556, 16, 27, 21, 2, -27 },
  { 610, 16, 27, 21, 2, -27 },
  { 664, 20, 27, 21, 1, -27 },
  { 732, 16, 26, 21, 3, -26 },
  { 784, 16, 27, 21, 3, -27 },
  { 838, 17, 26, 21, 2, -26 },
  { 894, 17, 27, 21, 2, -27 },
  { 952, 17, 27, 21, 2, -27 },
  { 1010, 2, 20, 8, 3, -20 },
  { 1015, 4, 25, 8, 1, -20 },
  { 1028, 17, 17, 21, 2, -22 },
  { 1065, 17, 8, 21, 2, -17 },
  { 1082, 17, 17, 21, 2, -22 },
  { 1119, 13, 27, 15, 1, -27 },
  { 1163, 29, 30, 32, 2, -26 },
  { 1272, 21, 26, 21, 0, -26 },
  { 1341, 17, 26, 23, 4, -26 },
  { 1397, 20, 27, 23, 2, -27 },
  { 1465, 19, 26, 26, 4, -26 },
  { 1527, 14, 26, 20, 4, -26 },
  { 1573, 14, 26, 18, 4, -26 },
  { 1619, 22, 27, 27, 2, -27 },
  { 1694, 18, 26, 26, 4, -26 },
  { 1753, 6, 26, 10, 2, -26 },
  { 1773, 9, 32, 9, -4, -26 },
  { 1809, 17, 26, 21, 4, -26 },
  { 1865, 14, 26, 19, 4, -26 },
  { 1911, 23, 26, 31, 4, -26 },
  { 1986, 18, 26, 26, 4, -26 },
  { 2045, 24, 27, 28, 2, -27 },
  { 2126, 15, 26, 21, 4, -26 },
  { 2175, 24, 33, 28, 2, -27 },
  { 2274, 16, 26, 21, 4, -26 },
  { 2326, 16, 27, 20, 2, -27 },
  { 2380, 19, 26, 19, 0, -26 },
  { 2442, 19, 26, 26, 4, -26 },
  { 2504, 21, 26, 21, 0, -26 },
  { 2573, 30, 26, 32, 1, -26 },
  { 2671, 19, 26, 19, 0, -26 },
  { 2733, 19, 26, 19, 0, -26 },
  { 2795, 19, 26, 21, 1, -26 },
  { 2857, 8, 32, 12, 3, -26 },
  { 2889, 11, 26, 12, 0, -26 },
  { 2925, 7, 32, 12, 1, -26 },
  { 2953, 17, 17, 21, 2, -27 },
  { 2990, 15, 1, 14, 0, 3 },
  { 2992, 7, 6, 9, 1, -28 },
  { 2998, 14, 20, 19, 2, -20 },
  { 3033, 16, 28, 22, 3, -28 },
  { 3089, 14, 20, 17, 2, -20 },
  { 3124, 16, 28, 22, 2, -28 },
  { 3180, 16, 20, 20, 2, -20 },
  { 3220, 13, 28, 10, 0, -28 },
  { 3266, 16, 29, 22, 2, -20 },
  { 3324, 15, 28, 21, 3, -28 },
  { 3377, 2, 27, 8, 3, -27 },
  { 3384, 7, 36, 8, -2, -27 },
  { 3416, 14, 28, 17, 3, -28 },
  { 3465, 1, 28, 8, 3, -28 },
  { 3469, 25, 20, 32, 3, -20 },
  { 3532, 15, 20, 21, 3, -20 },
  { 3570, 17, 20, 21, 2, -20 },
  { 3613, 16, 29, 22, 3, -20 },
  { 3671, 16, 29, 22, 2, -20 },
  { 3729, 10, 20, 14, 3, -20 },
  { 3754, 14, 20, 17, 1, -20 },
  { 3789, 11, 24, 12, 0, -24 },
  { 3822, 15, 20, 21, 3, -20 },
  { 3860, 16, 20, 16, 0, -20 },
  { 3900, 24, 20, 25, 1, -20 },
  { 3960, 16, 20, 18, 1, -20 },
  { 4000, 16, 29, 16, 0, -20 },
  { 4058, 13, 20, 17, 2, -20 },
  { 4091, 10, 32, 12, 1, -26 },
  { 4131, 1, 37, 20, 9, -28 },
  { 4136, 10, 32, 12, 1, -26 },
  { 4176, 17, 4, 21, 2, -15 },
};

const GFXfont NotoSans_Thin37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin37pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_THIN37PT7B_H_
