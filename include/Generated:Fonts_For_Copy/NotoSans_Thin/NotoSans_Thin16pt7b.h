#ifndef _NOTOSANS_THIN16PT7B_H_
#define _NOTOSANS_THIN16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x20, 0xB6, 0xD0, 0x09, 0x02, 0x41, 0x11, 0xFF, 0x11, 0x04,
  0x81, 0x23, 0xBE, 0x22, 0x08, 0x82, 0x40, 0x10, 0xFA, 0x44, 0x89, 0x0E,
  0x06, 0x0A, 0x12, 0x24, 0x57, 0xC1, 0x00, 0x60, 0x12, 0x12, 0x44, 0x45,
  0x08, 0xA1, 0x2B, 0xA5, 0x8B, 0x51, 0x0A, 0x22, 0x44, 0x48, 0x90, 0xE0,
  0x38, 0x11, 0x04, 0x21, 0x08, 0x24, 0x06, 0x06, 0x82, 0x12, 0x84, 0xA0,
  0xC8, 0x31, 0xF3, 0xF0, 0x72, 0x49, 0x24, 0x92, 0x44, 0x40, 0x95, 0x55,
  0x55, 0xA0, 0x10, 0x23, 0x79, 0x82, 0x89, 0x80, 0x10, 0x20, 0x47, 0xF1,
  0x02, 0x04, 0x00, 0xF0, 0xF0, 0x80, 0x08, 0x84, 0x22, 0x10, 0x88, 0x44,
  0x20, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x05, 0x0B, 0xE0,
  0x74, 0x92, 0x49, 0x24, 0x80, 0x39, 0x88, 0x10, 0x10, 0x40, 0x82, 0x04,
  0x10, 0x41, 0x07, 0xF0, 0x79, 0x08, 0x08, 0x10, 0x41, 0x1D, 0x01, 0x02,
  0x04, 0x0F, 0xE0, 0x02, 0x03, 0x02, 0x82, 0x42, 0x21, 0x11, 0x09, 0xFF,
  0x02, 0x01, 0x00, 0x80, 0x7C, 0x82, 0x04, 0x07, 0xC0, 0x40, 0x81, 0x02,
  0x07, 0xF0, 0x1C, 0x41, 0x04, 0x08, 0x1F, 0xA0, 0xC1, 0x83, 0x05, 0x09,
  0xE0, 0xFE, 0x04, 0x10, 0x20, 0x81, 0x02, 0x08, 0x10, 0x40, 0x80, 0x38,
  0x8A, 0x0C, 0x14, 0x47, 0x1B, 0x41, 0x83, 0x06, 0x0B, 0xE0, 0x39, 0x8A,
  0x0C, 0x18, 0x30, 0x61, 0xBD, 0x02, 0x04, 0x17, 0xC0, 0x80, 0x80, 0x81,
  0xE0, 0x06, 0x31, 0x86, 0x03, 0x01, 0x80, 0x80, 0xFE, 0x03, 0xF8, 0xC0,
  0x70, 0x10, 0x31, 0x8C, 0x20, 0x00, 0xF0, 0x42, 0x10, 0x88, 0x88, 0x40,
  0x00, 0x80, 0x1F, 0xC6, 0x02, 0x40, 0x18, 0xF9, 0x90, 0x99, 0x09, 0x90,
  0x99, 0x09, 0x9B, 0xB8, 0x44, 0x40, 0x02, 0x08, 0x1F, 0x00, 0x08, 0x0A,
  0x05, 0x02, 0x42, 0x21, 0x10, 0xFC, 0x82, 0x40, 0xC0, 0x60, 0x20, 0xFD,
  0x06, 0x0C, 0x1F, 0x51, 0xA0, 0xC1, 0x83, 0x07, 0xF0, 0x1F, 0x20, 0x40,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x3F, 0xFC, 0x82, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0xFC, 0xFE, 0x08, 0x20, 0xFA,
  0x08, 0x20, 0x82, 0x0F, 0xC0, 0xFE, 0x08, 0x20, 0x83, 0xF8, 0x20, 0x82,
  0x08, 0x00, 0x0F, 0x18, 0x50, 0x10, 0x08, 0x04, 0x02, 0x1F, 0x01, 0x80,
  0xC0, 0x50, 0x27, 0xF0, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0xE9, 0x24, 0x92, 0x4B, 0x80, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x1E, 0x87, 0x12, 0x45, 0x0C, 0x14, 0x24, 0x44, 0x89, 0x0A,
  0x08, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0xC0, 0x80, 0x60,
  0x3C, 0x0F, 0x05, 0xA1, 0x68, 0x9A, 0x26, 0x49, 0x94, 0x62, 0x18, 0x84,
  0x81, 0x81, 0xC1, 0xA1, 0x91, 0x91, 0x89, 0x85, 0x85, 0x83, 0x81, 0x1E,
  0x08, 0x44, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14,
  0x08, 0xFC, 0xFE, 0x18, 0x61, 0x87, 0xE8, 0x20, 0x82, 0x08, 0x00, 0x1E,
  0x08, 0x44, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14,
  0x08, 0xF4, 0x02, 0x00, 0x40, 0x10, 0xFD, 0x0A, 0x0C, 0x28, 0x5F, 0x24,
  0x44, 0x85, 0x0A, 0x08, 0x3D, 0x86, 0x04, 0x08, 0x0C, 0x06, 0x03, 0x02,
  0x04, 0x0F, 0xE0, 0xFF, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82,
  0x7C, 0x80, 0xC0, 0x50, 0x48, 0x22, 0x21, 0x10, 0x88, 0x28, 0x14, 0x0A,
  0x02, 0x00, 0x84, 0x18, 0x61, 0x86, 0x18, 0x91, 0x49, 0x24, 0x92, 0x49,
  0x25, 0x0C, 0x30, 0xC2, 0x0C, 0x20, 0x40, 0xC1, 0x42, 0x24, 0x14, 0x18,
  0x08, 0x14, 0x24, 0x42, 0x42, 0x81, 0x81, 0x42, 0x42, 0x24, 0x24, 0x18,
  0x08, 0x08, 0x08, 0x08, 0x08, 0xFE, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20,
  0x40, 0x40, 0x80, 0xFF, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0x82,
  0x10, 0x82, 0x10, 0x42, 0x10, 0x42, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x1F, 0x10, 0x20, 0xA1, 0x24, 0x48, 0x60, 0xC1, 0xFC, 0x90, 0x78, 0x10,
  0x41, 0x7E, 0x18, 0x61, 0xFC, 0x81, 0x02, 0x05, 0xEC, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0F, 0xE0, 0x3D, 0x08, 0x20, 0x82, 0x08, 0x20, 0x7C, 0x02,
  0x04, 0x09, 0xD4, 0x70, 0x60, 0xC1, 0x83, 0x06, 0x0B, 0xF0, 0x38, 0x8A,
  0x0C, 0x1F, 0xF0, 0x20, 0x40, 0x7C, 0x39, 0x09, 0xE2, 0x10, 0x84, 0x21,
  0x08, 0x40, 0x38, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x7E, 0x04, 0x08,
  0x1F, 0xC0, 0x81, 0x02, 0x05, 0xEC, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x10, 0x8F, 0xF0, 0x20, 0x02, 0x49, 0x24, 0x92, 0x4E, 0x82, 0x08, 0x21,
  0x8A, 0x49, 0x28, 0xD2, 0x28, 0xA1, 0xFF, 0xF0, 0x39, 0xD8, 0xC6, 0x10,
  0xC2, 0x18, 0x43, 0x08, 0x61, 0x0C, 0x21, 0x84, 0x20, 0x3D, 0x86, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x82, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x7C, 0x3D, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xE1, 0xBD, 0x02, 0x04, 0x08,
  0x00, 0x30, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x7E, 0x04, 0x08, 0x10,
  0x20, 0x3E, 0x21, 0x08, 0x42, 0x10, 0x80, 0x7A, 0x08, 0x20, 0x70, 0x20,
  0x41, 0xF8, 0x42, 0x3E, 0x84, 0x21, 0x08, 0x42, 0x0E, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xBF, 0x83, 0x09, 0x12, 0x22, 0x85, 0x0C, 0x08, 0x84,
  0x28, 0x89, 0x29, 0x25, 0x24, 0x94, 0x63, 0x0C, 0x21, 0x04, 0x42, 0x48,
  0xA0, 0x81, 0x84, 0x91, 0x61, 0x83, 0x09, 0x12, 0x22, 0x85, 0x0C, 0x08,
  0x10, 0x40, 0x86, 0x00, 0xFC, 0x21, 0x08, 0x21, 0x08, 0x3F, 0x39, 0x08,
  0x42, 0x13, 0x04, 0x21, 0x08, 0x42, 0x0C, 0xFF, 0xFF, 0xC4, 0x44, 0x42,
  0x12, 0x44, 0x44, 0x48, 0xFE,
};

const GFXglyph NotoSans_Thin16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 11, 4, 1, -11 },
  { 3, 3, 4, 5, 1, -11 },
  { 5, 10, 11, 10, 0, -11 },
  { 19, 7, 13, 9, 1, -12 },
  { 31, 11, 12, 13, 1, -12 },
  { 48, 10, 12, 11, 1, -12 },
  { 63, 1, 4, 3, 1, -11 },
  { 64, 3, 14, 4, 1, -11 },
  { 70, 2, 14, 4, 1, -11 },
  { 74, 7, 6, 9, 1, -12 },
  { 80, 7, 7, 9, 1, -9 },
  { 87, 1, 4, 3, 1, -2 },
  { 88, 4, 1, 5, 1, -5 },
  { 89, 1, 1, 4, 1, -1 },
  { 90, 5, 11, 5, 0, -11 },
  { 97, 7, 12, 9, 1, -12 },
  { 108, 3, 11, 9, 2, -11 },
  { 113, 7, 12, 9, 1, -12 },
  { 124, 7, 12, 9, 1, -12 },
  { 135, 9, 11, 9, 0, -11 },
  { 148, 7, 11, 9, 1, -11 },
  { 158, 7, 12, 9, 1, -12 },
  { 169, 7, 11, 9, 1, -11 },
  { 179, 7, 12, 9, 1, -12 },
  { 190, 7, 12, 9, 1, -12 },
  { 201, 1, 9, 4, 1, -9 },
  { 203, 1, 11, 4, 1, -9 },
  { 205, 7, 7, 9, 1, -9 },
  { 212, 7, 3, 9, 1, -7 },
  { 215, 7, 7, 9, 1, -9 },
  { 222, 5, 12, 7, 1, -12 },
  { 230, 12, 13, 14, 1, -11 },
  { 250, 9, 11, 9, 0, -11 },
  { 263, 7, 11, 10, 2, -11 },
  { 273, 8, 12, 10, 1, -12 },
  { 285, 8, 11, 11, 2, -11 },
  { 296, 6, 11, 9, 2, -11 },
  { 305, 6, 11, 8, 2, -11 },
  { 314, 9, 12, 12, 1, -12 },
  { 328, 8, 11, 11, 2, -11 },
  { 339, 3, 11, 5, 1, -11 },
  { 344, 4, 14, 4, -2, -11 },
  { 351, 7, 11, 9, 2, -11 },
  { 361, 6, 11, 8, 2, -11 },
  { 370, 10, 11, 13, 2, -11 },
  { 384, 8, 11, 11, 2, -11 },
  { 395, 10, 12, 12, 1, -12 },
  { 410, 6, 11, 9, 2, -11 },
  { 419, 10, 15, 12, 1, -12 },
  { 438, 7, 11, 9, 2, -11 },
  { 448, 7, 12, 9, 1, -12 },
  { 459, 8, 11, 8, 0, -11 },
  { 470, 8, 11, 11, 2, -11 },
  { 481, 9, 11, 9, 0, -11 },
  { 494, 12, 11, 14, 1, -11 },
  { 511, 8, 11, 8, 0, -11 },
  { 522, 8, 11, 8, 0, -11 },
  { 533, 8, 11, 9, 1, -11 },
  { 544, 4, 14, 5, 1, -11 },
  { 551, 5, 11, 5, 0, -11 },
  { 558, 4, 14, 5, 0, -11 },
  { 565, 7, 8, 9, 1, -12 },
  { 572, 6, 1, 6, 0, 1 },
  { 573, 2, 2, 4, 1, -12 },
  { 574, 6, 9, 8, 1, -9 },
  { 581, 7, 12, 9, 1, -12 },
  { 592, 6, 9, 8, 1, -9 },
  { 599, 7, 12, 9, 1, -12 },
  { 610, 7, 9, 9, 1, -9 },
  { 618, 5, 12, 4, 0, -12 },
  { 626, 7, 13, 9, 1, -9 },
  { 638, 7, 12, 9, 1, -12 },
  { 649, 1, 12, 3, 1, -12 },
  { 651, 3, 16, 3, -1, -12 },
  { 657, 6, 12, 7, 1, -12 },
  { 666, 1, 12, 3, 1, -12 },
  { 668, 11, 9, 14, 1, -9 },
  { 681, 7, 9, 9, 1, -9 },
  { 689, 7, 9, 9, 1, -9 },
  { 697, 7, 13, 9, 1, -9 },
  { 709, 7, 13, 9, 1, -9 },
  { 721, 5, 9, 6, 1, -9 },
  { 727, 6, 9, 7, 1, -9 },
  { 734, 5, 11, 5, 0, -11 },
  { 741, 7, 8, 9, 1, -8 },
  { 748, 7, 8, 7, 0, -8 },
  { 755, 11, 8, 11, 0, -8 },
  { 766, 7, 8, 8, 0, -8 },
  { 773, 7, 12, 7, 0, -8 },
  { 784, 6, 8, 7, 1, -8 },
  { 790, 5, 14, 5, 0, -11 },
  { 799, 1, 16, 9, 4, -12 },
  { 801, 4, 14, 5, 1, -11 },
  { 808, 7, 1, 9, 1, -6 },
};

const GFXfont NotoSans_Thin16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin16pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_THIN16PT7B_H_
