#ifndef _NOTOSANS_THIN48PT7B_H_
#define _NOTOSANS_THIN48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin48pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x48, 0x00,
  0x02, 0xFC, 0xC0, 0xA0, 0x50, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x81, 0x40,
  0xA0, 0x50, 0x28, 0x10, 0x00, 0x08, 0x03, 0x00, 0x00, 0xC0, 0x10, 0x00,
  0x04, 0x00, 0x80, 0x00, 0x20, 0x04, 0x00, 0x01, 0x00, 0x20, 0x00, 0x08,
  0x03, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x04, 0x00, 0x80, 0x00, 0x20, 0x04,
  0x00, 0x01, 0x00, 0x20, 0x00, 0x08, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x06, 0x00, 0x80, 0x00, 0x20, 0x04, 0x00, 0x01, 0x00, 0x20, 0x00, 0x08,
  0x03, 0x00, 0x00, 0x40, 0x18, 0x00, 0x06, 0x00, 0x80, 0x00, 0x20, 0x04,
  0x00, 0x01, 0x00, 0x20, 0x00, 0x08, 0x01, 0x00, 0x00, 0x40, 0x18, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x20, 0x04, 0x00, 0x01, 0x00, 0x20, 0x00, 0x08,
  0x01, 0x00, 0x00, 0x40, 0x18, 0x00, 0x06, 0x00, 0x80, 0x00, 0x20, 0x04,
  0x00, 0x01, 0x00, 0x20, 0x00, 0x08, 0x01, 0x00, 0x00, 0x40, 0x18, 0x00,
  0x06, 0x00, 0x80, 0x00, 0x30, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x01, 0xF8, 0x00, 0xF5, 0xF8, 0x18, 0x40, 0xC2, 0x04, 0x00, 0x40,
  0x40, 0x0C, 0x04, 0x00, 0xC0, 0x40, 0x08, 0x04, 0x00, 0x80, 0x40, 0x08,
  0x04, 0x00, 0xC0, 0x40, 0x04, 0x04, 0x00, 0x60, 0x40, 0x03, 0x04, 0x00,
  0x0C, 0x40, 0x00, 0x34, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x46,
  0x00, 0x04, 0x18, 0x00, 0x40, 0xC0, 0x04, 0x06, 0x00, 0x40, 0x20, 0x04,
  0x02, 0x00, 0x40, 0x20, 0x04, 0x03, 0x00, 0x40, 0x20, 0x04, 0x02, 0x00,
  0x40, 0x60, 0x04, 0x04, 0x00, 0x40, 0xCE, 0x04, 0x38, 0x3F, 0xFE, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0xC0, 0x30, 0x60, 0x00, 0x80, 0x60, 0x30,
  0x01, 0x80, 0x40, 0x10, 0x01, 0x00, 0xC0, 0x10, 0x03, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0x80, 0x18, 0x04, 0x00, 0x80, 0x08, 0x04, 0x00, 0x80, 0x08,
  0x08, 0x00, 0x80, 0x08, 0x18, 0x00, 0x80, 0x08, 0x10, 0x00, 0x80, 0x08,
  0x30, 0x00, 0x80, 0x08, 0x20, 0x00, 0x80, 0x18, 0x61, 0xF0, 0xC0, 0x18,
  0x43, 0x1C, 0xC0, 0x10, 0xC6, 0x04, 0x40, 0x10, 0x8C, 0x02, 0x60, 0x31,
  0x08, 0x02, 0x30, 0x63, 0x08, 0x03, 0x1D, 0xC2, 0x18, 0x01, 0x0F, 0x06,
  0x18, 0x01, 0x00, 0x04, 0x10, 0x01, 0x00, 0x0C, 0x10, 0x01, 0x00, 0x08,
  0x10, 0x01, 0x00, 0x18, 0x10, 0x01, 0x00, 0x10, 0x10, 0x01, 0x00, 0x20,
  0x10, 0x01, 0x00, 0x60, 0x18, 0x01, 0x00, 0x40, 0x08, 0x03, 0x00, 0xC0,
  0x08, 0x03, 0x00, 0x80, 0x0C, 0x02, 0x01, 0x80, 0x04, 0x06, 0x01, 0x00,
  0x06, 0x0C, 0x03, 0x00, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x80, 0x20, 0x00, 0x08, 0x00, 0x80, 0x00, 0xC0, 0x06, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x40, 0x03, 0x00, 0x03, 0x00, 0x10, 0x00, 0x08, 0x01,
  0x80, 0x00, 0x20, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03,
  0x86, 0x00, 0x00, 0x30, 0x18, 0x00, 0x23, 0x00, 0x60, 0x01, 0x30, 0x01,
  0x80, 0x19, 0x00, 0x06, 0x00, 0x98, 0x00, 0x18, 0x0C, 0x80, 0x00, 0x60,
  0x44, 0x00, 0x01, 0x86, 0x20, 0x00, 0x06, 0x21, 0x00, 0x00, 0x1B, 0x0C,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x81, 0x00, 0x00, 0x36, 0x0C, 0x00,
  0x03, 0x18, 0x30, 0x00, 0x30, 0x60, 0xE0, 0x06, 0x01, 0x81, 0xFF, 0xC0,
  0x06, 0xD5, 0x55, 0x55, 0x03, 0x81, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x40,
  0x60, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x60, 0x30, 0x08, 0x04,
  0x02, 0x01, 0x80, 0x40, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10,
  0x0C, 0x03, 0x00, 0xC0, 0xC0, 0x60, 0x20, 0x30, 0x10, 0x08, 0x08, 0x0C,
  0x04, 0x06, 0x02, 0x02, 0x02, 0x03, 0x03, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x03, 0x02, 0x02, 0x02, 0x06,
  0x04, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x60, 0x40, 0x80, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x80, 0x20, 0x1F, 0x02, 0x0F, 0x0E, 0x27, 0x80, 0x1F, 0x80, 0x00,
  0x60, 0x00, 0x0D, 0x00, 0x00, 0x98, 0x00, 0x10, 0x80, 0x03, 0x04, 0x00,
  0x60, 0x60, 0x04, 0x03, 0x00, 0x80, 0x18, 0x18, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x33,
  0x32, 0x22, 0x64, 0x44, 0xC8, 0xFF, 0xFF, 0xFF, 0x5F, 0x80, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x1C, 0x78, 0x03, 0x00, 0x60, 0x10, 0x01, 0x81, 0x00, 0x06, 0x18,
  0x00, 0x10, 0x80, 0x00, 0xCC, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00, 0x00,
  0xD0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0A, 0x00, 0x00, 0xD0, 0x00, 0x04, 0x80, 0x00, 0x22,
  0x00, 0x01, 0x10, 0x00, 0x10, 0xC0, 0x00, 0x83, 0x00, 0x08, 0x0C, 0x00,
  0xC0, 0x30, 0x1C, 0x00, 0xFF, 0x80, 0x00, 0xC0, 0x70, 0x64, 0x31, 0x18,
  0x58, 0x1C, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x00, 0xF0, 0x00, 0x7D, 0xF0, 0x0E, 0x00, 0xC0, 0xC0, 0x01, 0x04,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFC, 0x00,
  0x1F, 0xFE, 0x01, 0x80, 0x0C, 0x18, 0x00, 0x18, 0x40, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x63, 0xC0, 0x07, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x03, 0x20, 0x00, 0x00, 0x88, 0x00, 0x00, 0x42, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x18, 0x20, 0x00, 0x04, 0x08, 0x00, 0x02, 0x02, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x40, 0x20, 0x00, 0x20, 0x08, 0x00, 0x18, 0x02, 0x00, 0x0C,
  0x00, 0x80, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x02, 0x00,
  0x60, 0x00, 0x80, 0x10, 0x00, 0x20, 0x08, 0x00, 0x08, 0x06, 0x00, 0x02,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x3F, 0xFF, 0xC2, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x7F, 0xFE, 0x06, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC8, 0x00, 0x18, 0xE0, 0x07, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x03, 0xE1, 0x80, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x0F, 0xE0, 0x31, 0xE0, 0x60, 0xCC, 0x00,
  0x63, 0x60, 0x00, 0xCF, 0x00, 0x01, 0x28, 0x00, 0x06, 0xC0, 0x00, 0x0B,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x40, 0x00, 0x0D, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x98, 0x00, 0x02, 0x20, 0x00, 0x08, 0x80, 0x00,
  0x61, 0x00, 0x01, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x18, 0x07, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x3E, 0xF8, 0x03, 0x00, 0x30, 0x20, 0x00, 0xC2, 0x00, 0x02, 0x10, 0x00,
  0x19, 0x80, 0x00, 0x4C, 0x00, 0x02, 0x40, 0x00, 0x13, 0x00, 0x00, 0x98,
  0x00, 0x0C, 0x40, 0x00, 0x43, 0x00, 0x04, 0x0C, 0x00, 0x60, 0x18, 0x0C,
  0x00, 0x71, 0xC0, 0x00, 0xF8, 0x00, 0x0E, 0xE0, 0x01, 0x80, 0xC0, 0x38,
  0x01, 0x83, 0x00, 0x06, 0x10, 0x00, 0x19, 0x00, 0x00, 0x48, 0x00, 0x03,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xA0, 0x00, 0x0D, 0x00, 0x00, 0x44, 0x00, 0x06, 0x30, 0x00, 0x60,
  0x60, 0x0C, 0x01, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x3D, 0xF0, 0x06, 0x00,
  0xC0, 0x60, 0x01, 0x86, 0x00, 0x04, 0x20, 0x00, 0x33, 0x00, 0x00, 0x90,
  0x00, 0x06, 0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0x40,
  0x00, 0x3B, 0x00, 0x03, 0x48, 0x00, 0x32, 0x30, 0x03, 0x10, 0xF1, 0xE1,
  0x80, 0xFC, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x1F, 0xFC,
  0x00, 0x1E, 0x00, 0x00, 0x5F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x02, 0xFC, 0x11, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x18, 0xC4, 0x21, 0x18, 0x84, 0x23, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x7F, 0xF0, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00,
  0x08, 0x18, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x00, 0x43, 0x00,
  0x0F, 0xFC, 0x01, 0x88, 0x00, 0x60, 0x18, 0x02, 0x20, 0x06, 0x00, 0x60,
  0x09, 0x80, 0x10, 0x01, 0x80, 0x24, 0x00, 0x80, 0x06, 0x00, 0x90, 0x06,
  0x00, 0x10, 0x03, 0x40, 0x10, 0x00, 0x40, 0x0D, 0x00, 0x40, 0x01, 0x00,
  0x34, 0x03, 0x00, 0x04, 0x00, 0xF0, 0x0C, 0x00, 0x10, 0x03, 0xC0, 0x30,
  0x00, 0x40, 0x09, 0x00, 0xC0, 0x01, 0x00, 0x24, 0x01, 0x00, 0x0C, 0x00,
  0x90, 0x04, 0x00, 0x30, 0x06, 0x40, 0x10, 0x00, 0xC0, 0x11, 0x00, 0x60,
  0x05, 0x80, 0xC6, 0x00, 0xC0, 0x22, 0x06, 0x18, 0x01, 0xE7, 0x06, 0x70,
  0x20, 0x01, 0xF0, 0x0F, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x09, 0x80, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x10, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x60, 0x60, 0x00, 0x04, 0x02, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x08, 0x01, 0x00, 0x00, 0x80, 0x10, 0x00, 0x18, 0x01,
  0x80, 0x01, 0x00, 0x08, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x40, 0x07, 0xFF, 0xFE, 0x00, 0x40, 0x00, 0x20, 0x04, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x30, 0x08, 0x00, 0x01, 0x01, 0x80, 0x00, 0x18,
  0x10, 0x00, 0x01, 0x81, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x04, 0x60, 0x00, 0x00, 0x44, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x02, 0x00, 0x0F, 0x08, 0x00, 0x06,
  0x20, 0x00, 0x0C, 0x80, 0x00, 0x12, 0x00, 0x00, 0x68, 0x00, 0x01, 0xA0,
  0x00, 0x02, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x68, 0x00, 0x01, 0xA0, 0x00,
  0x04, 0x80, 0x00, 0x32, 0x00, 0x01, 0x88, 0x00, 0x1C, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x02, 0x00, 0x03, 0x88, 0x00, 0x03, 0x20, 0x00, 0x06, 0x80,
  0x00, 0x0A, 0x00, 0x00, 0x28, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x80, 0x00, 0x0A,
  0x00, 0x00, 0x48, 0x00, 0x03, 0x20, 0x00, 0x38, 0x80, 0x07, 0x83, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x30, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x01,
  0x80, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x40, 0x03, 0xC0, 0x20, 0x00,
  0x38, 0x10, 0x00, 0x06, 0x08, 0x00, 0x00, 0x84, 0x00, 0x00, 0x22, 0x00,
  0x00, 0x19, 0x00, 0x00, 0x04, 0x80, 0x00, 0x03, 0x40, 0x00, 0x00, 0xA0,
  0x00, 0x00, 0x50, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x05, 0x00, 0x00, 0x02, 0x80, 0x00, 0x01, 0x40, 0x00,
  0x01, 0x20, 0x00, 0x00, 0x90, 0x00, 0x00, 0x88, 0x00, 0x00, 0xC4, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0xC1, 0x00, 0x03, 0x80, 0x80, 0x0F, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xA0, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xE1, 0xFC, 0x00, 0xE0, 0x00, 0xE0,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x03, 0x40, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x32,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x03, 0x03, 0x80, 0x00, 0x30, 0x0E, 0x00, 0x0E,
  0x00, 0x3F, 0xFF, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x18, 0x06, 0x81, 0x9F, 0xE0, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xC8,
  0x00, 0x06, 0x20, 0x00, 0x30, 0x80, 0x01, 0x82, 0x00, 0x0C, 0x08, 0x00,
  0x60, 0x20, 0x03, 0x00, 0x80, 0x18, 0x02, 0x00, 0xC0, 0x08, 0x06, 0x00,
  0x20, 0x30, 0x00, 0x81, 0x80, 0x02, 0x0C, 0x00, 0x08, 0x70, 0x00, 0x23,
  0x40, 0x00, 0x99, 0x80, 0x02, 0xC3, 0x00, 0x0E, 0x04, 0x00, 0x30, 0x08,
  0x00, 0x80, 0x30, 0x02, 0x00, 0x60, 0x08, 0x00, 0x80, 0x20, 0x03, 0x00,
  0x80, 0x06, 0x02, 0x00, 0x0C, 0x08, 0x00, 0x10, 0x20, 0x00, 0x60, 0x80,
  0x00, 0xC2, 0x00, 0x01, 0x08, 0x00, 0x02, 0x20, 0x00, 0x0C, 0x80, 0x00,
  0x1A, 0x00, 0x00, 0x30, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3A, 0x00, 0x00, 0x01, 0x68, 0x00, 0x00, 0x05,
  0x90, 0x00, 0x00, 0x36, 0x40, 0x00, 0x00, 0x99, 0x80, 0x00, 0x06, 0x62,
  0x00, 0x00, 0x11, 0x8C, 0x00, 0x00, 0x46, 0x10, 0x00, 0x03, 0x18, 0x40,
  0x00, 0x08, 0x61, 0x80, 0x00, 0x61, 0x82, 0x00, 0x01, 0x06, 0x0C, 0x00,
  0x04, 0x18, 0x10, 0x00, 0x30, 0x60, 0x40, 0x00, 0x81, 0x81, 0x80, 0x06,
  0x06, 0x02, 0x00, 0x10, 0x18, 0x0C, 0x00, 0x40, 0x60, 0x10, 0x03, 0x01,
  0x80, 0x40, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x02, 0x01, 0x00, 0x60,
  0x0C, 0x0C, 0x01, 0x80, 0x10, 0x20, 0x06, 0x00, 0x40, 0x80, 0x18, 0x01,
  0x86, 0x00, 0x60, 0x02, 0x10, 0x01, 0x80, 0x0C, 0xC0, 0x06, 0x00, 0x12,
  0x00, 0x18, 0x00, 0x68, 0x00, 0x60, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xA0, 0x00, 0x03, 0x90, 0x00, 0x03, 0x98, 0x00, 0x03, 0x8C,
  0x00, 0x03, 0x84, 0x00, 0x03, 0x86, 0x00, 0x03, 0x83, 0x00, 0x03, 0x81,
  0x00, 0x03, 0x81, 0x80, 0x03, 0x80, 0xC0, 0x03, 0x80, 0x40, 0x03, 0x80,
  0x60, 0x03, 0x80, 0x30, 0x03, 0x80, 0x10, 0x03, 0x80, 0x18, 0x03, 0x80,
  0x0C, 0x03, 0x80, 0x04, 0x03, 0x80, 0x06, 0x03, 0x80, 0x03, 0x03, 0x80,
  0x01, 0x03, 0x80, 0x01, 0x83, 0x80, 0x00, 0xC3, 0x80, 0x00, 0x43, 0x80,
  0x00, 0x63, 0x80, 0x00, 0x33, 0x80, 0x00, 0x13, 0x80, 0x00, 0x0B, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x01, 0x81, 0x00, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00,
  0x64, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00,
  0x26, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x80, 0x80, 0x00, 0x04, 0x01, 0x80, 0x00, 0x30, 0x03,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x08, 0x00, 0x70, 0x80, 0x01, 0x88, 0x00, 0x04, 0x80, 0x00, 0x68,
  0x00, 0x02, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00,
  0x68, 0x00, 0x0C, 0x80, 0x01, 0x88, 0x00, 0x70, 0xFF, 0xF8, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xC0, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x01, 0x81, 0x00,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x11, 0x80, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x09, 0x00, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x80, 0x80, 0x00, 0x04, 0x01, 0x80, 0x00, 0x30,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFC, 0x04, 0x00, 0x38, 0x20,
  0x00, 0x31, 0x00, 0x00, 0xC8, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00, 0x00,
  0xD0, 0x00, 0x06, 0x80, 0x00, 0x34, 0x00, 0x01, 0xA0, 0x00, 0x0D, 0x00,
  0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x32, 0x00, 0x01, 0x10, 0x00, 0x30,
  0x80, 0x03, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0x00, 0x30, 0x08, 0x00,
  0x80, 0x40, 0x06, 0x02, 0x00, 0x18, 0x10, 0x00, 0x40, 0x80, 0x03, 0x04,
  0x00, 0x08, 0x20, 0x00, 0x61, 0x00, 0x01, 0x88, 0x00, 0x04, 0x40, 0x00,
  0x32, 0x00, 0x00, 0x90, 0x00, 0x06, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x40,
  0x00, 0xFC, 0x00, 0x7D, 0xFC, 0x18, 0x00, 0x73, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xCC, 0x00,
  0x38, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x58, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x23, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x30,
  0x00, 0x30, 0x0E, 0x00, 0x70, 0x01, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x00,
  0x68, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x08, 0x60, 0x00, 0x03, 0x04, 0x00, 0x00, 0x60, 0x80, 0x00, 0x08,
  0x18, 0x00, 0x03, 0x01, 0x00, 0x00, 0x40, 0x20, 0x00, 0x08, 0x06, 0x00,
  0x03, 0x00, 0x40, 0x00, 0x40, 0x0C, 0x00, 0x18, 0x00, 0x80, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x20, 0x02, 0x00, 0x04, 0x00,
  0x40, 0x00, 0xC0, 0x18, 0x00, 0x08, 0x02, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x10, 0x10, 0x00, 0x02, 0x02, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x04, 0x10,
  0x00, 0x00, 0x82, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x10, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x50, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xD0, 0x00, 0x14, 0x00, 0x02, 0x40,
  0x00, 0x58, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x66, 0x00, 0x0C, 0x80,
  0x01, 0x08, 0x00, 0x23, 0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x30, 0xC0,
  0x06, 0x10, 0x00, 0xC1, 0x00, 0x10, 0x40, 0x02, 0x04, 0x00, 0x41, 0x80,
  0x08, 0x10, 0x01, 0x02, 0x00, 0x60, 0x60, 0x0C, 0x08, 0x01, 0x00, 0x80,
  0x20, 0x30, 0x04, 0x02, 0x00, 0x80, 0xC0, 0x10, 0x08, 0x02, 0x01, 0x00,
  0xC0, 0x30, 0x18, 0x04, 0x02, 0x00, 0x40, 0x40, 0x18, 0x08, 0x01, 0x01,
  0x00, 0x20, 0x60, 0x06, 0x0C, 0x00, 0x81, 0x80, 0x08, 0x20, 0x02, 0x04,
  0x00, 0x20, 0x80, 0x0C, 0x10, 0x00, 0x82, 0x00, 0x10, 0xC0, 0x03, 0x18,
  0x00, 0x42, 0x00, 0x04, 0x40, 0x01, 0x88, 0x00, 0x11, 0x00, 0x02, 0x60,
  0x00, 0x44, 0x00, 0x09, 0x80, 0x01, 0xB0, 0x00, 0x24, 0x00, 0x02, 0x80,
  0x00, 0xD0, 0x00, 0x0A, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x04, 0x00, 0x03, 0x03, 0x00, 0x01, 0x00, 0xC0,
  0x01, 0x80, 0x20, 0x00, 0x80, 0x18, 0x00, 0x80, 0x04, 0x00, 0xC0, 0x01,
  0x00, 0x40, 0x00, 0xC0, 0x40, 0x00, 0x20, 0x60, 0x00, 0x18, 0x20, 0x00,
  0x06, 0x30, 0x00, 0x01, 0x30, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x09, 0x80, 0x00, 0x0C, 0x40,
  0x00, 0x04, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x02, 0x00, 0x02, 0x01,
  0x80, 0x03, 0x00, 0x40, 0x03, 0x00, 0x10, 0x01, 0x00, 0x0C, 0x01, 0x80,
  0x02, 0x01, 0x80, 0x00, 0x80, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x10, 0xC0,
  0x00, 0x0C, 0x40, 0x00, 0x03, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03,
  0x40, 0x00, 0x02, 0x60, 0x00, 0x06, 0x20, 0x00, 0x04, 0x10, 0x00, 0x0C,
  0x18, 0x00, 0x08, 0x08, 0x00, 0x18, 0x0C, 0x00, 0x10, 0x04, 0x00, 0x20,
  0x06, 0x00, 0x20, 0x02, 0x00, 0x40, 0x03, 0x00, 0xC0, 0x01, 0x00, 0x80,
  0x01, 0x81, 0x80, 0x00, 0x81, 0x00, 0x00, 0x43, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x34, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF,
  0xFF, 0xF0, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x30, 0xFF, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0x20, 0x00, 0x06, 0x60, 0x00, 0x08, 0x40,
  0x00, 0x30, 0xC0, 0x00, 0x40, 0x80, 0x01, 0x81, 0x80, 0x02, 0x01, 0x00,
  0x0C, 0x03, 0x00, 0x10, 0x02, 0x00, 0x40, 0x06, 0x00, 0x80, 0x04, 0x02,
  0x00, 0x0C, 0x0C, 0x00, 0x08, 0x10, 0x00, 0x18, 0x60, 0x00, 0x10, 0x80,
  0x00, 0x33, 0x00, 0x00, 0x24, 0x00, 0x00, 0x78, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x01,
  0x00, 0xF8, 0x01, 0xFB, 0xE0, 0x60, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x0F, 0xFE, 0x0F, 0x00, 0xC6, 0x00, 0x19,
  0x80, 0x03, 0x60, 0x00, 0x68, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xD0, 0x00, 0x5B, 0x00, 0x1B, 0x30, 0x0C, 0x63,
  0xFF, 0x0C, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x3F, 0x01, 0x8F, 0x8E, 0x08, 0xC0, 0x0C,
  0x4C, 0x00, 0x32, 0xC0, 0x00, 0x94, 0x00, 0x06, 0xA0, 0x00, 0x16, 0x00,
  0x00, 0xB0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0x60, 0x00, 0x0B, 0x80, 0x00, 0xDC,
  0x00, 0x04, 0xB0, 0x00, 0x64, 0xC0, 0x06, 0x23, 0x00, 0xE1, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0xF8, 0xF0, 0x60, 0x04, 0x30, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x40, 0xFF, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x3F, 0x06, 0x0F, 0x1E, 0x30, 0xC0, 0x19, 0x8C, 0x00,
  0x2C, 0xC0, 0x01, 0xA4, 0x00, 0x05, 0x40, 0x00, 0x3A, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xA0, 0x00, 0x0D, 0x00, 0x00, 0xEC, 0x00, 0x05,
  0x30, 0x00, 0x68, 0xC0, 0x06, 0x43, 0x00, 0x62, 0x0F, 0xFC, 0x10, 0x00,
  0xF8, 0x00, 0x78, 0xF0, 0x0C, 0x01, 0x81, 0x80, 0x0C, 0x30, 0x00, 0x42,
  0x00, 0x06, 0x60, 0x00, 0x24, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x60, 0x3F, 0xF8, 0x00, 0x7C, 0x03, 0xFC, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x0F, 0xFE, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x3E, 0x78, 0xC3, 0x00, 0x26, 0x30, 0x00,
  0xB3, 0x00, 0x03, 0x90, 0x00, 0x1D, 0x00, 0x00, 0x68, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x06, 0x80, 0x00, 0x34, 0x00, 0x03, 0xB0, 0x00, 0x1C,
  0xC0, 0x01, 0x63, 0x00, 0x1B, 0x0C, 0x03, 0x98, 0x1F, 0xF0, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x10, 0x00, 0x10, 0xE0, 0x03,
  0x01, 0xFF, 0xF0, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x03, 0xF0, 0x63, 0xE7, 0x8C, 0xC0,
  0x19, 0xB0, 0x01, 0xBC, 0x00, 0x1D, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x10, 0xBC, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x02, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02,
  0x02, 0x06, 0xFC, 0x20, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x0B, 0x00, 0x04, 0xC0, 0x02, 0x30, 0x01, 0x8C,
  0x00, 0xC3, 0x00, 0x60, 0xC0, 0x30, 0x30, 0x18, 0x0C, 0x0C, 0x03, 0x02,
  0x00, 0xC1, 0x00, 0x30, 0x80, 0x0C, 0x70, 0x03, 0x26, 0x00, 0xD8, 0x80,
  0x3C, 0x10, 0x0E, 0x06, 0x03, 0x00, 0xC0, 0xC0, 0x10, 0x30, 0x02, 0x0C,
  0x00, 0xC3, 0x00, 0x18, 0xC0, 0x02, 0x30, 0x00, 0x4C, 0x00, 0x1B, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0,
  0x01, 0xF0, 0x43, 0xCE, 0x07, 0x9E, 0x26, 0x01, 0x86, 0x01, 0x92, 0x00,
  0x66, 0x00, 0x6A, 0x00, 0x16, 0x00, 0x17, 0x00, 0x06, 0x00, 0x0F, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x80, 0x00, 0xE0,
  0x00, 0x40, 0x00, 0x70, 0x00, 0x20, 0x00, 0x38, 0x00, 0x10, 0x00, 0x1C,
  0x00, 0x08, 0x00, 0x0E, 0x00, 0x04, 0x00, 0x07, 0x00, 0x02, 0x00, 0x03,
  0x80, 0x01, 0x00, 0x01, 0xC0, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x40, 0x00,
  0x70, 0x00, 0x20, 0x00, 0x38, 0x00, 0x10, 0x00, 0x1C, 0x00, 0x08, 0x00,
  0x0E, 0x00, 0x04, 0x00, 0x07, 0x00, 0x02, 0x00, 0x03, 0x80, 0x01, 0x00,
  0x01, 0xC0, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x40, 0x00, 0x40, 0x00, 0xFC,
  0x10, 0xF1, 0xE2, 0x30, 0x06, 0x48, 0x00, 0x6B, 0x00, 0x07, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x04,
  0x00, 0xFC, 0x00, 0x1F, 0x3E, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x18, 0x30,
  0x00, 0x30, 0x80, 0x00, 0x44, 0x00, 0x01, 0x90, 0x00, 0x02, 0xC0, 0x00,
  0x0A, 0x00, 0x00, 0x28, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0B, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x90, 0x00, 0x06, 0x60, 0x00, 0x10, 0x80, 0x00,
  0xC3, 0x00, 0x02, 0x06, 0x00, 0x10, 0x0E, 0x01, 0x80, 0x0F, 0xFC, 0x00,
  0x00, 0xFC, 0x04, 0x1E, 0x78, 0x23, 0x00, 0x31, 0x30, 0x00, 0xC9, 0x00,
  0x02, 0x50, 0x00, 0x1B, 0x80, 0x00, 0x58, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x2E, 0x00, 0x01, 0x70, 0x00, 0x13, 0x40, 0x01,
  0x9B, 0x00, 0x18, 0xCE, 0x01, 0x86, 0x1F, 0xF0, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x3C, 0x78, 0xC3, 0x00, 0x66, 0x20, 0x01,
  0xB2, 0x00, 0x07, 0xB0, 0x00, 0x1D, 0x00, 0x00, 0xE8, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x74, 0x00, 0x03, 0xB0, 0x00, 0x3C,
  0x80, 0x01, 0x62, 0x00, 0x13, 0x0C, 0x03, 0x18, 0x3F, 0xF0, 0xC0, 0x10,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x01, 0xF6, 0x3D, 0xF6, 0x01, 0xA0, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x01,
  0xF8, 0x03, 0xC7, 0xE3, 0x00, 0x09, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x0A, 0x00, 0x04, 0xE0, 0x07, 0x0F, 0xFF, 0x00, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x3F, 0xFF,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x7F, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x34, 0x00, 0x0A, 0x80, 0x01, 0x48, 0x00,
  0xC8, 0xC0, 0x31, 0x0F, 0xF8, 0x20, 0xC0, 0x00, 0x1A, 0x00, 0x00, 0x90,
  0x00, 0x0C, 0xC0, 0x00, 0x42, 0x00, 0x06, 0x18, 0x00, 0x20, 0x40, 0x01,
  0x02, 0x00, 0x18, 0x18, 0x00, 0x80, 0x40, 0x04, 0x02, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x30, 0x03, 0x01, 0x00, 0x08, 0x08, 0x00, 0x40, 0xC0,
  0x01, 0x04, 0x00, 0x08, 0x60, 0x00, 0x62, 0x00, 0x01, 0x10, 0x00, 0x09,
  0x80, 0x00, 0x68, 0x00, 0x01, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x0D, 0x00, 0x0E, 0x00, 0x12,
  0x00, 0x16, 0x00, 0x26, 0x00, 0x24, 0x00, 0x4C, 0x00, 0xC8, 0x01, 0x88,
  0x01, 0x18, 0x02, 0x10, 0x02, 0x10, 0x04, 0x30, 0x0C, 0x20, 0x18, 0x20,
  0x10, 0x60, 0x30, 0x40, 0x20, 0x40, 0x40, 0xC0, 0xC0, 0x80, 0x81, 0x81,
  0x01, 0x03, 0x01, 0x02, 0x01, 0x04, 0x02, 0x0C, 0x02, 0x08, 0x06, 0x10,
  0x04, 0x10, 0x04, 0x20, 0x04, 0x60, 0x08, 0xC0, 0x08, 0x80, 0x11, 0x00,
  0x11, 0x00, 0x32, 0x00, 0x32, 0x00, 0x2C, 0x00, 0x2C, 0x00, 0x50, 0x00,
  0x50, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x00, 0x01,
  0x00, 0x60, 0x00, 0x31, 0x80, 0x03, 0x04, 0x00, 0x30, 0x30, 0x01, 0x00,
  0xC0, 0x18, 0x02, 0x01, 0x80, 0x08, 0x08, 0x00, 0x60, 0x80, 0x01, 0x0C,
  0x00, 0x04, 0xC0, 0x00, 0x34, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x68, 0x00, 0x02, 0x60, 0x00, 0x21, 0x80, 0x03, 0x04, 0x00, 0x10, 0x10,
  0x01, 0x00, 0xC0, 0x18, 0x03, 0x01, 0x80, 0x08, 0x08, 0x00, 0x60, 0xC0,
  0x01, 0x8C, 0x00, 0x04, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x1A, 0x00, 0x00,
  0x90, 0x00, 0x0C, 0xC0, 0x00, 0x42, 0x00, 0x06, 0x18, 0x00, 0x20, 0x40,
  0x01, 0x02, 0x00, 0x18, 0x18, 0x00, 0x80, 0x40, 0x04, 0x02, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x40, 0x30, 0x03, 0x01, 0x00, 0x08, 0x08, 0x00, 0x40,
  0xC0, 0x03, 0x04, 0x00, 0x08, 0x60, 0x00, 0x62, 0x00, 0x01, 0x10, 0x00,
  0x09, 0x80, 0x00, 0x68, 0x00, 0x01, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x01, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x30, 0x0F, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x30,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xF8, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00,
  0xE0, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x03, 0x80, 0x70, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00,
  0x18, 0x01, 0x80, 0xF8, 0x06, 0x00, 0x00, 0x3F, 0x80, 0x05, 0x83, 0x80,
  0x38, 0x03, 0x81, 0xA0, 0x01, 0xF8,
};

const GFXglyph NotoSans_Thin48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 3, 34, 11, 4, -34 },
  { 14, 9, 12, 15, 3, -34 },
  { 28, 29, 34, 31, 1, -34 },
  { 152, 20, 39, 27, 3, -36 },
  { 250, 32, 35, 38, 3, -35 },
  { 390, 29, 35, 34, 3, -35 },
  { 517, 2, 12, 8, 3, -34 },
  { 520, 9, 42, 12, 2, -34 },
  { 568, 8, 42, 12, 2, -34 },
  { 610, 20, 19, 26, 3, -36 },
  { 658, 22, 22, 27, 3, -28 },
  { 719, 4, 12, 9, 2, -6 },
  { 725, 12, 2, 15, 2, -14 },
  { 728, 3, 3, 11, 4, -3 },
  { 730, 14, 34, 15, 1, -34 },
  { 790, 21, 35, 27, 3, -35 },
  { 882, 10, 34, 27, 5, -34 },
  { 925, 21, 35, 27, 3, -35 },
  { 1017, 22, 35, 27, 2, -35 },
  { 1114, 26, 34, 27, 1, -34 },
  { 1225, 20, 34, 27, 4, -34 },
  { 1310, 22, 35, 27, 3, -35 },
  { 1407, 21, 34, 27, 3, -34 },
  { 1497, 21, 35, 27, 3, -35 },
  { 1589, 21, 36, 27, 3, -35 },
  { 1684, 3, 26, 11, 4, -26 },
  { 1694, 5, 32, 11, 2, -26 },
  { 1714, 22, 21, 27, 3, -28 },
  { 1772, 22, 11, 27, 3, -22 },
  { 1803, 22, 21, 27, 3, -28 },
  { 1861, 16, 35, 20, 2, -35 },
  { 1931, 38, 39, 42, 2, -34 },
  { 2117, 28, 34, 28, 0, -34 },
  { 2236, 22, 34, 29, 5, -34 },
  { 2330, 25, 35, 29, 3, -35 },
  { 2440, 25, 34, 33, 5, -34 },
  { 2547, 18, 34, 26, 5, -34 },
  { 2624, 18, 34, 24, 5, -34 },
  { 2701, 28, 35, 35, 3, -35 },
  { 2824, 24, 34, 34, 5, -34 },
  { 2926, 8, 34, 14, 3, -34 },
  { 2960, 11, 42, 11, -5, -34 },
  { 3018, 22, 34, 27, 5, -34 },
  { 3112, 18, 34, 24, 5, -34 },
  { 3189, 30, 34, 40, 5, -34 },
  { 3317, 24, 34, 34, 5, -34 },
  { 3419, 30, 35, 36, 3, -35 },
  { 3551, 20, 34, 28, 5, -34 },
  { 3636, 30, 43, 36, 3, -35 },
  { 3798, 21, 34, 28, 5, -34 },
  { 3888, 20, 35, 26, 3, -35 },
  { 3976, 24, 34, 24, 0, -34 },
  { 4078, 25, 34, 34, 5, -34 },
  { 4185, 27, 34, 27, 0, -34 },
  { 4300, 38, 34, 42, 2, -34 },
  { 4462, 25, 34, 24, 0, -34 },
  { 4569, 24, 34, 24, 0, -34 },
  { 4671, 24, 34, 28, 2, -34 },
  { 4773, 10, 42, 15, 4, -34 },
  { 4826, 14, 34, 15, 1, -34 },
  { 4886, 10, 42, 15, 1, -34 },
  { 4939, 23, 22, 27, 2, -35 },
  { 5003, 19, 2, 19, 0, 4 },
  { 5008, 8, 8, 12, 2, -37 },
  { 5016, 19, 26, 25, 2, -26 },
  { 5078, 21, 36, 28, 4, -36 },
  { 5173, 18, 26, 23, 3, -26 },
  { 5232, 21, 36, 28, 3, -36 },
  { 5327, 20, 26, 26, 3, -26 },
  { 5392, 15, 37, 13, 1, -37 },
  { 5462, 21, 38, 28, 3, -26 },
  { 5562, 19, 36, 28, 4, -36 },
  { 5648, 2, 35, 10, 4, -35 },
  { 5657, 8, 47, 10, -2, -35 },
  { 5704, 18, 36, 22, 4, -36 },
  { 5785, 2, 36, 10, 4, -36 },
  { 5794, 33, 26, 41, 4, -26 },
  { 5902, 19, 26, 28, 4, -26 },
  { 5964, 22, 26, 28, 3, -26 },
  { 6036, 21, 37, 28, 4, -26 },
  { 6134, 21, 37, 28, 3, -26 },
  { 6232, 13, 26, 18, 4, -26 },
  { 6275, 18, 26, 22, 2, -26 },
  { 6334, 14, 32, 15, 0, -32 },
  { 6390, 19, 25, 28, 4, -25 },
  { 6450, 21, 25, 21, 0, -25 },
  { 6516, 31, 25, 33, 1, -25 },
  { 6613, 21, 25, 23, 1, -25 },
  { 6679, 21, 37, 21, 0, -25 },
  { 6777, 18, 25, 22, 2, -25 },
  { 6834, 13, 42, 16, 1, -34 },
  { 6903, 1, 49, 26, 12, -37 },
  { 6910, 13, 42, 16, 2, -34 },
  { 6979, 22, 4, 27, 3, -19 },
};

const GFXfont NotoSans_Thin48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin48pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_THIN48PT7B_H_
