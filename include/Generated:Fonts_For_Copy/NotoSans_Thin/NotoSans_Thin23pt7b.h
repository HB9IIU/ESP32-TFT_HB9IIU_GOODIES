#ifndef _NOTOSANS_THIN23PT7B_H_
#define _NOTOSANS_THIN23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF1, 0x99, 0x99, 0x99, 0x04, 0x20, 0x21, 0x02, 0x10, 0x10,
  0x80, 0x84, 0x3F, 0xFC, 0x21, 0x02, 0x08, 0x10, 0x80, 0x84, 0x3F, 0xFC,
  0x21, 0x02, 0x08, 0x10, 0x80, 0x84, 0x04, 0x20, 0x04, 0x0F, 0xE4, 0x42,
  0x10, 0x84, 0x21, 0x04, 0x40, 0x90, 0x18, 0x01, 0xC0, 0x48, 0x11, 0x04,
  0x41, 0x10, 0x46, 0x16, 0x7E, 0x01, 0x00, 0x38, 0x00, 0x44, 0x08, 0x44,
  0x10, 0x82, 0x10, 0x82, 0x20, 0x82, 0x40, 0x82, 0x40, 0x82, 0x9E, 0x44,
  0xA2, 0x45, 0x21, 0x39, 0x41, 0x02, 0x41, 0x02, 0x41, 0x04, 0x41, 0x08,
  0x21, 0x08, 0x22, 0x10, 0x1E, 0x0F, 0x00, 0x42, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x82, 0x01, 0x10, 0x02, 0x80, 0x1C, 0x00, 0x88, 0x14, 0x10,
  0x60, 0x22, 0x80, 0x4A, 0x00, 0xC4, 0x03, 0x10, 0x12, 0x3F, 0x84, 0xFC,
  0x32, 0x44, 0x48, 0x88, 0x88, 0x88, 0x88, 0x84, 0x42, 0x21, 0x84, 0x22,
  0x21, 0x11, 0x11, 0x11, 0x11, 0x22, 0x24, 0x48, 0x04, 0x01, 0x00, 0x43,
  0xD7, 0x0E, 0x03, 0x01, 0x20, 0x44, 0x20, 0x80, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x0F, 0xFE, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x56, 0xA0,
  0xF8, 0x80, 0x02, 0x04, 0x10, 0x20, 0x81, 0x02, 0x08, 0x10, 0x20, 0x81,
  0x04, 0x08, 0x10, 0x40, 0x0F, 0x06, 0x10, 0x81, 0x20, 0x24, 0x05, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x14, 0x02, 0x80, 0x90,
  0x11, 0x04, 0x1F, 0x00, 0x19, 0x72, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x1E, 0x18, 0x40, 0x08, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0xC0,
  0x1E, 0x18, 0x68, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x04, 0x1F, 0x00,
  0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0xFF, 0x00, 0x00, 0x80,
  0x18, 0x02, 0x80, 0x28, 0x04, 0x80, 0x88, 0x08, 0x81, 0x08, 0x20, 0x84,
  0x08, 0x40, 0x88, 0x08, 0xFF, 0xF0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x7F, 0x90, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0F, 0xE0, 0x04, 0x00, 0x80,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x13, 0xF8, 0x0F, 0x8C, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x08, 0x02, 0xFC, 0xC0, 0xA0, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x09, 0x02, 0x3F, 0x00, 0xFF, 0xE0, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x80, 0x0F, 0x06, 0x11, 0x01, 0x20, 0x24, 0x04, 0x80,
  0x88, 0x20, 0x88, 0x0E, 0x06, 0x31, 0x01, 0x20, 0x18, 0x03, 0x00, 0x50,
  0x12, 0x02, 0x3F, 0x80, 0x1E, 0x04, 0x21, 0x02, 0x40, 0x28, 0x05, 0x00,
  0x60, 0x0C, 0x01, 0x40, 0x44, 0x34, 0x79, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x20, 0x08, 0x7E, 0x00, 0x80, 0x10, 0x40, 0x00, 0x15, 0xA8, 0x00, 0xE0,
  0x60, 0x30, 0x18, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x04,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0xE0, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x10, 0x00, 0x78,
  0x86, 0x02, 0x01, 0x01, 0x01, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x20,
  0x00, 0x00, 0x00, 0x20, 0x07, 0xFC, 0x02, 0x00, 0x81, 0x00, 0x10, 0x80,
  0x02, 0x40, 0xF0, 0x50, 0x42, 0x18, 0x20, 0x86, 0x10, 0x21, 0x84, 0x08,
  0x61, 0x02, 0x18, 0x40, 0x86, 0x10, 0x61, 0x82, 0x28, 0x90, 0x71, 0xC4,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0xFE, 0x00, 0x02, 0x00, 0x18,
  0x01, 0x40, 0x09, 0x00, 0x88, 0x04, 0x40, 0x21, 0x02, 0x08, 0x10, 0x20,
  0xFF, 0x08, 0x08, 0x40, 0x24, 0x01, 0x20, 0x0A, 0x00, 0x30, 0x01, 0xFF,
  0x90, 0x0A, 0x01, 0x40, 0x18, 0x05, 0x00, 0xA0, 0x27, 0xFC, 0x80, 0x50,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x17, 0xFC, 0x03, 0xE0, 0xC1,
  0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xF0, 0xFF,
  0x88, 0x04, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0xCF, 0xF0, 0xFF,
  0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFF, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0xFF, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x03,
  0xF0, 0x30, 0x31, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x07, 0xF8, 0x00, 0x50, 0x01, 0x40, 0x05, 0x00, 0x12,
  0x00, 0x44, 0x01, 0x0F, 0xF8, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x1F, 0xFF, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0xF2, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22,
  0x2F, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x43, 0xE0, 0x80, 0x70, 0x12, 0x04, 0x41, 0x08, 0x41, 0x10, 0x24, 0x05,
  0x40, 0xC8, 0x10, 0x82, 0x08, 0x40, 0x88, 0x11, 0x01, 0x20, 0x14, 0x01,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0xFF, 0xC0, 0x03, 0x80, 0x0E, 0x80, 0x1D,
  0x00, 0x5A, 0x00, 0xB2, 0x02, 0x64, 0x04, 0xC4, 0x11, 0x88, 0x23, 0x08,
  0x46, 0x11, 0x0C, 0x22, 0x18, 0x28, 0x30, 0x50, 0x60, 0x40, 0xC0, 0x81,
  0x80, 0x1C, 0x01, 0xA0, 0x19, 0x01, 0x90, 0x18, 0x81, 0x84, 0x18, 0x41,
  0x82, 0x18, 0x11, 0x81, 0x18, 0x09, 0x80, 0x58, 0x05, 0x80, 0x38, 0x01,
  0x07, 0xC0, 0x30, 0x60, 0x80, 0x21, 0x00, 0x24, 0x00, 0x48, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0A, 0x00, 0x14, 0x00,
  0x48, 0x00, 0x88, 0x02, 0x08, 0x0C, 0x0F, 0xE0, 0xFF, 0x20, 0x28, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x02, 0xFF, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x07, 0xC0, 0x30, 0x60, 0x80, 0x21, 0x00, 0x24,
  0x00, 0x48, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0A, 0x00, 0x14, 0x00, 0x48, 0x00, 0x88, 0x02, 0x08, 0x0C, 0x0F, 0xE0,
  0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0x10, 0x12, 0x01,
  0x40, 0x28, 0x05, 0x00, 0xA0, 0x24, 0x08, 0xFE, 0x10, 0x42, 0x08, 0x40,
  0x88, 0x09, 0x01, 0x20, 0x14, 0x03, 0x1F, 0x08, 0x34, 0x02, 0x00, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x02, 0xFF, 0x00, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14,
  0x01, 0x20, 0x21, 0xFC, 0x80, 0x0A, 0x00, 0x90, 0x04, 0x80, 0x22, 0x02,
  0x10, 0x10, 0x80, 0x82, 0x08, 0x10, 0x40, 0x44, 0x02, 0x20, 0x11, 0x00,
  0x50, 0x02, 0x80, 0x14, 0x00, 0x40, 0x80, 0x80, 0x60, 0x30, 0x18, 0x0C,
  0x05, 0x04, 0x82, 0x41, 0x20, 0x90, 0x48, 0x24, 0x12, 0x08, 0x88, 0x44,
  0x22, 0x11, 0x08, 0x84, 0x41, 0x41, 0x20, 0x50, 0x28, 0x14, 0x0A, 0x05,
  0x02, 0x80, 0x80, 0x40, 0x20, 0x10, 0xC0, 0x22, 0x04, 0x20, 0x41, 0x08,
  0x11, 0x00, 0x90, 0x06, 0x00, 0x40, 0x06, 0x00, 0x90, 0x11, 0x01, 0x08,
  0x20, 0x44, 0x04, 0x40, 0x28, 0x01, 0x80, 0x34, 0x02, 0x40, 0x42, 0x04,
  0x10, 0x81, 0x08, 0x09, 0x00, 0xA0, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFF, 0xE0, 0x08, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x80, 0x20, 0x07, 0xFF, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0xF0, 0x80, 0x81, 0x01, 0x02, 0x04, 0x04, 0x08,
  0x10, 0x10, 0x20, 0x20, 0x40, 0x80, 0x81, 0xF1, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x1F, 0x04, 0x00, 0xC0, 0x28, 0x04, 0x81, 0x10,
  0x21, 0x08, 0x21, 0x02, 0x40, 0x50, 0x06, 0x00, 0x80, 0xFF, 0x80, 0x84,
  0x21, 0x7F, 0x00, 0x40, 0x20, 0x10, 0x08, 0xFD, 0x83, 0x01, 0x80, 0xC0,
  0x60, 0x6F, 0xD0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x8C, 0x2C, 0xCC, 0x0A,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0B, 0x02, 0xBF,
  0x00, 0x1F, 0x90, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20,
  0x08, 0x03, 0xF0, 0x00, 0x40, 0x10, 0x04, 0x01, 0x06, 0x4E, 0x54, 0x0D,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x05, 0x03, 0x3F,
  0x40, 0x1F, 0x08, 0x24, 0x05, 0x01, 0x80, 0x7F, 0xF8, 0x02, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x7F, 0x0F, 0x10, 0x10, 0x20, 0x20, 0x20, 0xFC, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x3F, 0xD0,
  0x14, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x14, 0x0C,
  0xFD, 0x00, 0x40, 0x10, 0x04, 0x01, 0x61, 0x87, 0x80, 0x80, 0x40, 0x20,
  0x10, 0x08, 0xC5, 0x9B, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0x80, 0xC7, 0xFF, 0x80, 0x11, 0x00, 0x01, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x12, 0xC0, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x0A, 0x09, 0x08, 0x88, 0x48, 0x2C, 0x19, 0x08, 0x84, 0x22,
  0x09, 0x02, 0x81, 0x80, 0xFF, 0xFF, 0x80, 0xBE, 0x7E, 0xC1, 0x82, 0x81,
  0x01, 0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0x81,
  0x01, 0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0xBF, 0x60, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x1F, 0x84, 0x09,
  0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x40, 0x28, 0x08, 0x81,
  0x0F, 0xC0, 0xBF, 0x30, 0x28, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x1C, 0x0A, 0xFC, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00,
  0x3F, 0x50, 0x34, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50,
  0x14, 0x0C, 0xFD, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0xBF, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x7F, 0x80, 0x80, 0x80, 0x40,
  0x38, 0x06, 0x01, 0x01, 0x01, 0x01, 0xFE, 0x20, 0x40, 0x87, 0xF2, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x07, 0x80, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x6F, 0xD0, 0x80,
  0x60, 0x24, 0x09, 0x02, 0x21, 0x08, 0x42, 0x10, 0x48, 0x12, 0x03, 0x00,
  0xC0, 0x20, 0x80, 0x82, 0x83, 0x05, 0x06, 0x0A, 0x12, 0x12, 0x24, 0x44,
  0x48, 0x89, 0x09, 0x12, 0x12, 0x14, 0x28, 0x30, 0x30, 0x60, 0x60, 0x40,
  0x80, 0x80, 0xA0, 0x88, 0x84, 0x41, 0x40, 0x40, 0x50, 0x28, 0x22, 0x20,
  0x90, 0x50, 0x10, 0x80, 0x60, 0x24, 0x09, 0x02, 0x21, 0x08, 0x42, 0x10,
  0x48, 0x12, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20,
  0x30, 0x00, 0x7F, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20,
  0x20, 0x10, 0x1F, 0xE0, 0x1C, 0x82, 0x08, 0x20, 0x82, 0x08, 0x23, 0x04,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x81, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x31, 0x04, 0x10, 0x41, 0x04, 0x10, 0x42,
  0x30, 0x7C, 0x30, 0x78,
};

const GFXglyph NotoSans_Thin23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 1, 16, 5, 2, -16 },
  { 3, 4, 6, 7, 2, -16 },
  { 6, 13, 16, 15, 1, -16 },
  { 32, 10, 18, 13, 1, -17 },
  { 55, 16, 17, 18, 1, -17 },
  { 89, 14, 17, 16, 1, -17 },
  { 119, 1, 6, 4, 2, -16 },
  { 120, 4, 20, 6, 1, -16 },
  { 130, 4, 20, 6, 1, -16 },
  { 140, 10, 9, 13, 1, -17 },
  { 152, 11, 10, 13, 1, -13 },
  { 166, 2, 6, 4, 1, -3 },
  { 168, 5, 1, 7, 1, -7 },
  { 169, 1, 1, 5, 2, -1 },
  { 170, 7, 16, 7, 0, -16 },
  { 184, 11, 17, 13, 1, -17 },
  { 208, 5, 16, 13, 2, -16 },
  { 218, 10, 17, 13, 1, -17 },
  { 240, 10, 17, 13, 1, -17 },
  { 262, 12, 17, 13, 1, -17 },
  { 288, 10, 16, 13, 2, -16 },
  { 308, 10, 17, 13, 2, -17 },
  { 330, 11, 16, 13, 1, -16 },
  { 352, 11, 17, 13, 1, -17 },
  { 376, 11, 17, 13, 1, -17 },
  { 400, 1, 12, 5, 2, -12 },
  { 402, 2, 15, 5, 1, -12 },
  { 406, 11, 10, 13, 1, -13 },
  { 420, 11, 6, 13, 1, -11 },
  { 429, 11, 10, 13, 1, -13 },
  { 443, 8, 17, 10, 1, -17 },
  { 460, 18, 18, 20, 1, -16 },
  { 501, 13, 16, 13, 0, -16 },
  { 527, 11, 16, 14, 2, -16 },
  { 549, 12, 17, 14, 1, -17 },
  { 575, 12, 16, 16, 2, -16 },
  { 599, 9, 16, 13, 2, -16 },
  { 617, 9, 16, 11, 2, -16 },
  { 635, 14, 17, 17, 1, -17 },
  { 665, 12, 16, 16, 2, -16 },
  { 689, 4, 16, 7, 1, -16 },
  { 697, 5, 20, 5, -2, -16 },
  { 710, 11, 16, 13, 2, -16 },
  { 732, 9, 16, 12, 2, -16 },
  { 750, 15, 16, 19, 2, -16 },
  { 780, 12, 16, 16, 2, -16 },
  { 804, 15, 17, 17, 1, -17 },
  { 836, 10, 16, 13, 2, -16 },
  { 856, 15, 21, 17, 1, -17 },
  { 896, 11, 16, 13, 2, -16 },
  { 918, 10, 17, 12, 1, -17 },
  { 940, 12, 16, 12, 0, -16 },
  { 964, 12, 16, 16, 2, -16 },
  { 988, 13, 16, 13, 0, -16 },
  { 1014, 18, 16, 20, 1, -16 },
  { 1050, 12, 16, 12, 0, -16 },
  { 1074, 12, 16, 12, 0, -16 },
  { 1098, 11, 16, 13, 1, -16 },
  { 1120, 5, 20, 7, 2, -16 },
  { 1133, 7, 16, 7, 0, -16 },
  { 1147, 4, 20, 7, 1, -16 },
  { 1157, 11, 11, 13, 1, -17 },
  { 1173, 9, 1, 9, 0, 2 },
  { 1175, 4, 4, 6, 1, -18 },
  { 1177, 9, 12, 12, 1, -12 },
  { 1191, 10, 17, 13, 2, -17 },
  { 1213, 9, 12, 11, 1, -12 },
  { 1227, 10, 17, 13, 1, -17 },
  { 1249, 10, 12, 12, 1, -12 },
  { 1264, 8, 18, 6, 0, -18 },
  { 1282, 10, 18, 13, 1, -12 },
  { 1305, 9, 17, 13, 2, -17 },
  { 1325, 1, 17, 5, 2, -17 },
  { 1328, 4, 23, 5, -1, -17 },
  { 1340, 9, 17, 10, 2, -17 },
  { 1360, 1, 17, 5, 2, -17 },
  { 1363, 16, 12, 20, 2, -12 },
  { 1387, 9, 12, 13, 2, -12 },
  { 1401, 11, 12, 13, 1, -12 },
  { 1418, 10, 17, 13, 2, -12 },
  { 1440, 10, 17, 13, 1, -12 },
  { 1462, 6, 12, 9, 2, -12 },
  { 1471, 8, 12, 11, 1, -12 },
  { 1483, 7, 15, 7, 0, -15 },
  { 1497, 9, 12, 13, 2, -12 },
  { 1511, 10, 12, 10, 0, -12 },
  { 1526, 15, 12, 16, 0, -12 },
  { 1549, 9, 12, 11, 1, -12 },
  { 1563, 10, 18, 10, 0, -12 },
  { 1586, 9, 12, 10, 1, -12 },
  { 1600, 6, 20, 8, 1, -16 },
  { 1615, 1, 24, 12, 6, -18 },
  { 1618, 6, 20, 8, 1, -16 },
  { 1633, 11, 2, 13, 1, -9 },
};

const GFXfont NotoSans_Thin23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin23pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_THIN23PT7B_H_
