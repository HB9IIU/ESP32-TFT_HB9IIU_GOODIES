#ifndef _NOTOSANS_THIN28PT7B_H_
#define _NOTOSANS_THIN28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin28pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x54, 0x07, 0x8C, 0x63, 0x18, 0xC6, 0x20, 0x02,
  0x08, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x04, 0x08, 0x04, 0x08, 0x7F,
  0xFF, 0x04, 0x10, 0x04, 0x10, 0x08, 0x10, 0x08, 0x10, 0x08, 0x20, 0x08,
  0x20, 0xFF, 0xFE, 0x08, 0x20, 0x10, 0x20, 0x10, 0x40, 0x10, 0x40, 0x10,
  0x40, 0x10, 0x40, 0x04, 0x03, 0xE1, 0x93, 0x42, 0x08, 0x41, 0x08, 0x21,
  0x04, 0x20, 0x44, 0x04, 0x80, 0x70, 0x03, 0x80, 0x4C, 0x08, 0x41, 0x08,
  0x21, 0x04, 0x20, 0x84, 0x11, 0x62, 0x41, 0xF0, 0x08, 0x01, 0x00, 0x7C,
  0x02, 0x10, 0x40, 0x82, 0x08, 0x10, 0x41, 0x04, 0x08, 0x20, 0x81, 0x04,
  0x20, 0x20, 0x84, 0x04, 0x11, 0x00, 0x82, 0x47, 0x90, 0x49, 0x0A, 0x12,
  0x41, 0x3E, 0x48, 0x20, 0x11, 0x02, 0x02, 0x20, 0x40, 0x84, 0x08, 0x10,
  0x81, 0x04, 0x10, 0x41, 0x02, 0x08, 0x20, 0x21, 0x08, 0x03, 0xC0, 0x0F,
  0x80, 0x08, 0x20, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00,
  0x41, 0x00, 0x21, 0x00, 0x0B, 0x00, 0x06, 0x00, 0x0C, 0x80, 0x08, 0x20,
  0x28, 0x08, 0x14, 0x02, 0x12, 0x00, 0x89, 0x00, 0x28, 0x80, 0x08, 0x40,
  0x0A, 0x10, 0x08, 0x87, 0xF8, 0x30, 0xFE, 0x08, 0x88, 0x44, 0x21, 0x08,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x82, 0x10, 0x82, 0x10, 0x43, 0x82, 0x08,
  0x41, 0x08, 0x41, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x84, 0x22, 0x11,
  0x18, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0xE4, 0xF1, 0xF0, 0x04, 0x00,
  0xA0, 0x11, 0x01, 0x08, 0x20, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x69, 0x25, 0x20, 0xFE, 0x70, 0x00, 0x80, 0x80, 0x40, 0x40,
  0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x80,
  0x40, 0x20, 0x20, 0x10, 0x10, 0x00, 0x1F, 0x82, 0x04, 0x40, 0x24, 0x02,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x24, 0x02, 0x20, 0x41, 0xF8,
  0x04, 0x72, 0x51, 0x84, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x3F, 0x8C, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x0F, 0xFF, 0x1F, 0xC3, 0x01,
  0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40,
  0xFC, 0x00, 0x18, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0xA0, 0x08, 0xFF, 0x80, 0x00, 0x20, 0x00, 0xC0, 0x02, 0x80,
  0x09, 0x00, 0x12, 0x00, 0x44, 0x01, 0x08, 0x04, 0x10, 0x08, 0x20, 0x20,
  0x40, 0x80, 0x81, 0x01, 0x04, 0x02, 0x10, 0x04, 0x3F, 0xFF, 0x80, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x3F, 0xE4, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x7F, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x80,
  0x47, 0xF8, 0x0F, 0xE1, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x00, 0x9F, 0xCA, 0x02, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x40, 0x14, 0x01, 0x20, 0x21, 0xFC, 0xFF, 0xF0, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x1F, 0x86, 0x04, 0x40, 0x28, 0x02, 0x80, 0x18, 0x02, 0x40,
  0x22, 0x04, 0x19, 0x00, 0xF0, 0x30, 0xC4, 0x02, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x63, 0xF8, 0x3F, 0x84, 0x04, 0x80,
  0x28, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x40,
  0x53, 0xF9, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x87, 0xF0, 0xF0, 0x00, 0x00, 0x1C, 0x6C, 0x00, 0x00, 0x00, 0x06, 0x92,
  0x52, 0x00, 0x00, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x40, 0x03, 0x00, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x08, 0x00, 0xFF,
  0x00, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x03, 0x02, 0x01,
  0x01, 0x00, 0x80, 0x40, 0x00, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x7E,
  0x00, 0x0E, 0x07, 0x00, 0x40, 0x02, 0x06, 0x00, 0x04, 0x10, 0x00, 0x08,
  0x80, 0x00, 0x24, 0x07, 0xF0, 0x50, 0x20, 0x41, 0x41, 0x01, 0x05, 0x04,
  0x04, 0x18, 0x20, 0x10, 0x60, 0x80, 0x41, 0x82, 0x01, 0x06, 0x08, 0x08,
  0x14, 0x10, 0x30, 0x90, 0x41, 0x42, 0x40, 0xF8, 0xF1, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x80, 0x01, 0x80, 0x01, 0x40, 0x02, 0x40, 0x02, 0x40,
  0x02, 0x20, 0x04, 0x20, 0x04, 0x10, 0x08, 0x10, 0x08, 0x10, 0x08, 0x08,
  0x10, 0x08, 0x1F, 0xF8, 0x20, 0x04, 0x20, 0x04, 0x20, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x80, 0x01, 0x80, 0x01, 0xFF, 0x84, 0x03, 0x20, 0x05, 0x00,
  0x28, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x04, 0x80, 0x47, 0xFC, 0x20, 0x19,
  0x00, 0x28, 0x01, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x14, 0x00, 0xA0,
  0x19, 0xFF, 0x00, 0x07, 0xFC, 0x20, 0x03, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80,
  0x01, 0xFF, 0xFF, 0x81, 0x00, 0xC2, 0x00, 0x44, 0x00, 0x48, 0x00, 0x50,
  0x00, 0xA0, 0x01, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x04, 0x80, 0x09, 0x00, 0x22,
  0x01, 0x87, 0xFC, 0x00, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x1F, 0xFA, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0xFF, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x00,
  0x07, 0xFE, 0x08, 0x01, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xFF, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x01, 0x40, 0x01, 0x20, 0x01,
  0x18, 0x01, 0x07, 0xFE, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0xF4, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44,
  0x4F, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0xF8, 0x80,
  0x14, 0x01, 0x20, 0x11, 0x01, 0x08, 0x10, 0x41, 0x02, 0x10, 0x11, 0x00,
  0x90, 0x05, 0x40, 0x31, 0x01, 0x08, 0x08, 0x20, 0x40, 0x82, 0x02, 0x10,
  0x10, 0x80, 0x44, 0x01, 0x20, 0x05, 0x00, 0x30, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x7F, 0xF0,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x16, 0x80, 0x05, 0xA0, 0x02, 0x68,
  0x00, 0x99, 0x00, 0x26, 0x40, 0x11, 0x88, 0x04, 0x62, 0x02, 0x18, 0x80,
  0x86, 0x10, 0x21, 0x84, 0x10, 0x60, 0x84, 0x18, 0x22, 0x06, 0x08, 0x81,
  0x81, 0x20, 0x60, 0x50, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x68, 0x01, 0x90, 0x06, 0x40, 0x18, 0x80, 0x61, 0x01, 0x84,
  0x06, 0x08, 0x18, 0x10, 0x60, 0x41, 0x80, 0x86, 0x01, 0x18, 0x04, 0x60,
  0x09, 0x80, 0x16, 0x00, 0x58, 0x00, 0xE0, 0x01, 0x07, 0xF8, 0x0C, 0x02,
  0x08, 0x00, 0x88, 0x00, 0x24, 0x00, 0x14, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x80, 0x02, 0x40, 0x01, 0x10, 0x01, 0x04, 0x01,
  0x01, 0xFF, 0x00, 0xFF, 0x10, 0x1A, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x0A, 0x0E, 0x7E, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x00, 0x07, 0xF8, 0x0C, 0x02, 0x08,
  0x00, 0x88, 0x00, 0x24, 0x00, 0x14, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x80, 0x02, 0x40, 0x01, 0x10, 0x01, 0x04, 0x01, 0x01,
  0xFF, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0xFF, 0x88, 0x04, 0x80, 0x28, 0x02, 0x80, 0x18, 0x01, 0x80, 0x28,
  0x02, 0x80, 0x28, 0x0C, 0xFF, 0x08, 0x20, 0x81, 0x08, 0x08, 0x80, 0x88,
  0x04, 0x80, 0x48, 0x02, 0x80, 0x18, 0x01, 0x3F, 0xE4, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0xC0, 0x03, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x4F,
  0xF8, 0xFF, 0xFC, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x05, 0x00, 0x22, 0x01, 0x07, 0xF8, 0x80,
  0x01, 0x80, 0x02, 0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x20, 0x04, 0x20,
  0x08, 0x10, 0x08, 0x10, 0x08, 0x10, 0x10, 0x08, 0x10, 0x08, 0x10, 0x04,
  0x20, 0x04, 0x20, 0x04, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x50,
  0x0A, 0x01, 0x40, 0x48, 0x09, 0x01, 0x20, 0x22, 0x04, 0x80, 0x88, 0x11,
  0x02, 0x20, 0x84, 0x10, 0x82, 0x10, 0x41, 0x08, 0x21, 0x04, 0x40, 0x88,
  0x11, 0x02, 0x20, 0x44, 0x08, 0x80, 0x90, 0x12, 0x02, 0x80, 0x50, 0x0A,
  0x01, 0x40, 0x18, 0x05, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x40, 0x05,
  0x00, 0x22, 0x01, 0x04, 0x04, 0x10, 0x20, 0x21, 0x00, 0x44, 0x01, 0x20,
  0x03, 0x00, 0x04, 0x00, 0x30, 0x01, 0x20, 0x04, 0x40, 0x21, 0x01, 0x02,
  0x04, 0x04, 0x20, 0x11, 0x00, 0x24, 0x00, 0xA0, 0x01, 0x80, 0x05, 0x00,
  0x24, 0x00, 0x88, 0x04, 0x20, 0x10, 0x40, 0x81, 0x02, 0x02, 0x10, 0x04,
  0x40, 0x12, 0x00, 0x28, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x7F, 0xFC, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xFE, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x3F, 0x80, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10,
  0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x3F, 0x01, 0x00, 0x0C, 0x00, 0x48, 0x01, 0x20, 0x08, 0x40,
  0x21, 0x01, 0x02, 0x04, 0x08, 0x20, 0x10, 0x80, 0x44, 0x00, 0xB0, 0x03,
  0xFF, 0xE0, 0xC1, 0x04, 0x10, 0x1F, 0x84, 0x08, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x18, 0xFD, 0x20, 0x28, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x81,
  0x4F, 0xC8, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x3F, 0x16, 0x04, 0xA0, 0x16, 0x00, 0xB0, 0x05, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x16, 0x00, 0xB0, 0x05, 0x40, 0x49, 0xFC,
  0x00, 0x0F, 0xCC, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0xFC, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x1F, 0x92, 0x05, 0x40, 0x38, 0x03, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x40,
  0x34, 0x05, 0x3F, 0x90, 0x1F, 0x84, 0x09, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0F, 0xFF, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x07,
  0xF8, 0x0F, 0x84, 0x04, 0x02, 0x01, 0x00, 0x83, 0xF8, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x1F, 0x92, 0x05, 0x40, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x40, 0x34, 0x05, 0x3F, 0x90,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0xE0, 0xC1, 0xF0, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x27, 0xC7, 0x06, 0x80, 0x50, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x02, 0xE0, 0x2A, 0xAA, 0xAA, 0xAA, 0x18, 0x80, 0x00, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0xB8, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x0A, 0x04, 0x82,
  0x21, 0x08, 0x82, 0x20, 0x90, 0x2C, 0x0C, 0x82, 0x10, 0x82, 0x20, 0x88,
  0x12, 0x02, 0x80, 0x40, 0xFF, 0xFF, 0xF8, 0xBE, 0x1F, 0x98, 0x24, 0x0A,
  0x03, 0x01, 0x40, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C,
  0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18,
  0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x08, 0x9F, 0x1C, 0x1A, 0x01, 0x40,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x08, 0x1F, 0x82, 0x04, 0x40, 0x28, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x22,
  0x04, 0x1F, 0x80, 0x9F, 0x8A, 0x04, 0xC0, 0x28, 0x02, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x2C, 0x04,
  0xBF, 0x88, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x1F, 0x92, 0x05, 0x40, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x34, 0x05, 0x3F, 0x90, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0xBF, 0x82, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x00, 0x3F,
  0xC8, 0x01, 0x00, 0x40, 0x04, 0x00, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80,
  0x08, 0x00, 0x80, 0x10, 0x05, 0x00, 0x9F, 0xE0, 0x20, 0x20, 0x20, 0xFF,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x10,
  0x10, 0x0F, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x14, 0x02, 0x80, 0xCF, 0xE8, 0x80,
  0x18, 0x01, 0x40, 0x24, 0x02, 0x20, 0x22, 0x04, 0x20, 0x41, 0x08, 0x10,
  0x81, 0x08, 0x09, 0x00, 0x90, 0x06, 0x00, 0x60, 0x02, 0x00, 0x80, 0x40,
  0x28, 0x0C, 0x05, 0x01, 0x81, 0x20, 0x50, 0x22, 0x09, 0x04, 0x41, 0x21,
  0x08, 0x44, 0x21, 0x08, 0x44, 0x11, 0x08, 0x82, 0x41, 0x20, 0x48, 0x14,
  0x05, 0x02, 0x80, 0xC0, 0x50, 0x18, 0x0C, 0x01, 0x00, 0x80, 0x80, 0x24,
  0x04, 0x20, 0x42, 0x08, 0x11, 0x00, 0x90, 0x0A, 0x00, 0x40, 0x0A, 0x00,
  0x90, 0x11, 0x02, 0x08, 0x40, 0x44, 0x02, 0x80, 0x30, 0x80, 0x18, 0x01,
  0x40, 0x24, 0x02, 0x20, 0x22, 0x04, 0x20, 0x41, 0x08, 0x10, 0x81, 0x08,
  0x09, 0x00, 0x90, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x10, 0x0E, 0x00, 0x7F, 0xE0, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00,
  0x80, 0x3F, 0xF8, 0x06, 0x30, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x81, 0x0C, 0x04, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x10, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x04, 0x07, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x10, 0xE0, 0x7C, 0x18, 0x3F,
};

const GFXglyph NotoSans_Thin28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 20, 6, 2, -20 },
  { 6, 5, 7, 9, 2, -20 },
  { 11, 16, 20, 18, 1, -20 },
  { 51, 11, 23, 16, 2, -21 },
  { 83, 19, 20, 22, 2, -20 },
  { 131, 17, 20, 20, 2, -20 },
  { 174, 1, 7, 5, 2, -20 },
  { 175, 5, 24, 7, 1, -20 },
  { 190, 5, 24, 7, 1, -20 },
  { 205, 12, 11, 15, 2, -21 },
  { 222, 12, 13, 16, 2, -16 },
  { 242, 3, 7, 5, 1, -3 },
  { 245, 7, 1, 9, 1, -8 },
  { 246, 2, 2, 6, 2, -2 },
  { 247, 9, 20, 9, 0, -20 },
  { 270, 12, 20, 16, 2, -20 },
  { 300, 6, 20, 16, 3, -20 },
  { 315, 12, 20, 16, 2, -20 },
  { 345, 13, 20, 16, 1, -20 },
  { 378, 15, 20, 16, 1, -20 },
  { 416, 12, 20, 16, 2, -20 },
  { 446, 12, 20, 16, 2, -20 },
  { 476, 12, 20, 16, 2, -20 },
  { 506, 12, 20, 16, 2, -20 },
  { 536, 12, 20, 16, 2, -20 },
  { 566, 2, 15, 6, 2, -15 },
  { 570, 3, 19, 6, 1, -15 },
  { 578, 12, 12, 16, 2, -16 },
  { 596, 12, 6, 16, 2, -13 },
  { 605, 12, 12, 16, 2, -16 },
  { 623, 9, 20, 12, 1, -20 },
  { 646, 22, 23, 25, 1, -20 },
  { 710, 16, 20, 16, 0, -20 },
  { 750, 13, 20, 17, 3, -20 },
  { 783, 14, 20, 17, 2, -20 },
  { 818, 15, 20, 19, 3, -20 },
  { 856, 11, 20, 15, 3, -20 },
  { 884, 11, 20, 14, 3, -20 },
  { 912, 16, 20, 20, 2, -20 },
  { 952, 14, 20, 20, 3, -20 },
  { 987, 4, 20, 8, 2, -20 },
  { 997, 7, 25, 6, -3, -20 },
  { 1019, 13, 20, 16, 3, -20 },
  { 1052, 11, 20, 14, 3, -20 },
  { 1080, 18, 20, 23, 3, -20 },
  { 1125, 14, 20, 20, 3, -20 },
  { 1160, 17, 20, 21, 2, -20 },
  { 1203, 11, 20, 16, 3, -20 },
  { 1231, 17, 25, 21, 2, -20 },
  { 1285, 12, 20, 16, 3, -20 },
  { 1315, 12, 20, 15, 2, -20 },
  { 1345, 14, 20, 14, 0, -20 },
  { 1380, 14, 20, 20, 3, -20 },
  { 1415, 16, 20, 16, 0, -20 },
  { 1455, 22, 20, 24, 1, -20 },
  { 1510, 14, 20, 14, 0, -20 },
  { 1545, 14, 20, 14, 0, -20 },
  { 1580, 14, 20, 16, 1, -20 },
  { 1615, 6, 24, 9, 2, -20 },
  { 1633, 9, 20, 9, 0, -20 },
  { 1656, 5, 24, 9, 1, -20 },
  { 1671, 14, 12, 16, 1, -20 },
  { 1692, 11, 1, 11, 0, 2 },
  { 1694, 5, 4, 7, 1, -21 },
  { 1697, 11, 15, 14, 1, -15 },
  { 1718, 13, 21, 16, 2, -21 },
  { 1753, 10, 15, 13, 2, -15 },
  { 1772, 12, 21, 16, 2, -21 },
  { 1804, 11, 15, 15, 2, -15 },
  { 1825, 9, 21, 8, 0, -21 },
  { 1849, 12, 22, 16, 2, -15 },
  { 1882, 11, 21, 16, 3, -21 },
  { 1911, 2, 20, 6, 2, -20 },
  { 1916, 5, 27, 6, -1, -20 },
  { 1933, 10, 21, 13, 3, -21 },
  { 1960, 1, 21, 6, 2, -21 },
  { 1963, 19, 15, 24, 3, -15 },
  { 1999, 11, 15, 16, 3, -15 },
  { 2020, 12, 15, 16, 2, -15 },
  { 2043, 12, 22, 16, 3, -15 },
  { 2076, 12, 22, 16, 2, -15 },
  { 2109, 7, 15, 11, 3, -15 },
  { 2123, 11, 15, 13, 1, -15 },
  { 2144, 8, 18, 9, 0, -18 },
  { 2162, 11, 15, 16, 2, -15 },
  { 2183, 12, 15, 12, 0, -15 },
  { 2206, 19, 15, 19, 0, -15 },
  { 2242, 12, 15, 13, 1, -15 },
  { 2265, 12, 22, 12, 0, -15 },
  { 2298, 11, 15, 13, 1, -15 },
  { 2319, 7, 24, 9, 1, -20 },
  { 2340, 1, 28, 15, 7, -21 },
  { 2344, 8, 24, 9, 1, -20 },
  { 2368, 12, 2, 16, 2, -11 },
};

const GFXfont NotoSans_Thin28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin28pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_THIN28PT7B_H_
