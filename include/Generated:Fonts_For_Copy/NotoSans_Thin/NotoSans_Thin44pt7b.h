#ifndef _NOTOSANS_THIN44PT7B_H_
#define _NOTOSANS_THIN44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Thin.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Thin44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3C, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x00, 0x10, 0x0C, 0x00,
  0x08, 0x02, 0x00, 0x02, 0x00, 0x80, 0x00, 0x80, 0x20, 0x00, 0x20, 0x08,
  0x00, 0x08, 0x06, 0x00, 0x04, 0x01, 0x00, 0x01, 0x00, 0x40, 0x00, 0x40,
  0x10, 0x00, 0x10, 0x04, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x80, 0x00,
  0x80, 0x20, 0x00, 0x20, 0x08, 0x00, 0x08, 0x02, 0x00, 0x02, 0x01, 0x80,
  0x01, 0x80, 0x40, 0x00, 0x40, 0x10, 0x00, 0x10, 0x04, 0x00, 0x04, 0x01,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x20, 0x00, 0x20, 0x08, 0x00, 0x08,
  0x02, 0x00, 0x02, 0x00, 0x80, 0x00, 0x80, 0x20, 0x00, 0x20, 0x18, 0x00,
  0x10, 0x04, 0x00, 0x04, 0x01, 0x00, 0x01, 0x00, 0x40, 0x00, 0x40, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x7F, 0x80, 0x72, 0x3C, 0x20, 0x81,
  0x10, 0x20, 0x0C, 0x08, 0x02, 0x02, 0x00, 0x80, 0x80, 0x20, 0x20, 0x08,
  0x08, 0x02, 0x02, 0x00, 0xC0, 0x80, 0x18, 0x20, 0x03, 0x08, 0x00, 0x32,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x09, 0x80, 0x02, 0x18, 0x00, 0x83,
  0x00, 0x20, 0x60, 0x08, 0x08, 0x02, 0x03, 0x00, 0x80, 0xC0, 0x20, 0x30,
  0x08, 0x0C, 0x02, 0x02, 0x00, 0x81, 0x80, 0x20, 0x4C, 0x08, 0x61, 0xFF,
  0xF0, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x0F, 0x00,
  0x01, 0x01, 0x8C, 0x00, 0x10, 0x18, 0x10, 0x01, 0x80, 0x80, 0xC0, 0x08,
  0x0C, 0x02, 0x00, 0xC0, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x60, 0x10,
  0x06, 0x02, 0x00, 0x80, 0x30, 0x20, 0x04, 0x01, 0x81, 0x00, 0x20, 0x0C,
  0x10, 0x01, 0x00, 0x61, 0x80, 0x08, 0x03, 0x08, 0x00, 0x40, 0x10, 0xC3,
  0xE2, 0x00, 0x84, 0x60, 0x98, 0x04, 0x62, 0x02, 0x40, 0x62, 0x20, 0x13,
  0x02, 0x21, 0x00, 0xCC, 0x61, 0x08, 0x02, 0x1C, 0x10, 0xC0, 0x10, 0x00,
  0x86, 0x00, 0x80, 0x08, 0x20, 0x04, 0x00, 0xC1, 0x00, 0x20, 0x04, 0x0C,
  0x01, 0x00, 0x60, 0x40, 0x08, 0x02, 0x03, 0x00, 0x40, 0x20, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x30, 0x10, 0x02, 0x01, 0x00, 0x80, 0x18, 0x08, 0x08,
  0x00, 0x60, 0x80, 0xC0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x40, 0x30, 0x00, 0x20, 0x06, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x80, 0x02,
  0x00, 0x60, 0x00, 0xC0, 0x10, 0x00, 0x10, 0x18, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x06, 0x04, 0x00, 0x12, 0x00, 0x80, 0x09, 0x00, 0x10, 0x02, 0xC0,
  0x02, 0x01, 0xA0, 0x00, 0x40, 0x48, 0x00, 0x08, 0x12, 0x00, 0x01, 0x08,
  0x80, 0x00, 0x26, 0x20, 0x00, 0x05, 0x08, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x50, 0x40, 0x00, 0x26, 0x08, 0x00, 0x30, 0xC1, 0x80, 0x38, 0x18, 0x3F,
  0xF8, 0x03, 0xFF, 0xE0, 0x07, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20,
  0x60, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x40, 0x20, 0x20, 0x30,
  0x10, 0x18, 0x08, 0x0C, 0x06, 0x03, 0xC0, 0x80, 0x81, 0x81, 0x03, 0x02,
  0x06, 0x04, 0x08, 0x10, 0x30, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x18, 0x20, 0x41, 0x82, 0x04, 0x18, 0x20,
  0x83, 0x04, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x0C, 0x04, 0x0C, 0xE1, 0x1C, 0x07, 0x78,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x04, 0x80, 0x02, 0x10, 0x01, 0x82, 0x00,
  0xC0, 0xC0, 0x20, 0x10, 0x10, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x32, 0x22, 0x64, 0x44, 0x88, 0x80, 0xFF, 0xFF, 0xF0,
  0xF0, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xE3, 0xC0, 0x20, 0x0C, 0x08,
  0x00, 0xC2, 0x00, 0x08, 0x40, 0x01, 0x90, 0x00, 0x12, 0x00, 0x02, 0x40,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x03, 0x40, 0x00, 0x48, 0x00, 0x09, 0x80, 0x01, 0x10, 0x00, 0x43, 0x00,
  0x08, 0x30, 0x02, 0x03, 0x01, 0x80, 0x3F, 0xE0, 0x00, 0xC0, 0xD0, 0x64,
  0x31, 0x30, 0x78, 0x14, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03,
  0xF0, 0x03, 0xC7, 0x81, 0xC0, 0x18, 0x20, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x07, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0xF0, 0xE0, 0x30, 0x01, 0x8C, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x0E, 0x00, 0x7F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x48, 0x00, 0x08, 0xE0, 0x03, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x02, 0x40, 0x00,
  0x06, 0x40, 0x00, 0x04, 0x40, 0x00, 0x08, 0x40, 0x00, 0x18, 0x40, 0x00,
  0x10, 0x40, 0x00, 0x20, 0x40, 0x00, 0x40, 0x40, 0x00, 0xC0, 0x40, 0x00,
  0x80, 0x40, 0x01, 0x00, 0x40, 0x02, 0x00, 0x40, 0x06, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x40, 0x10, 0x00, 0x40, 0x30, 0x00, 0x40, 0x20,
  0x00, 0x40, 0x40, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x1F,
  0xFF, 0x86, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x3F, 0x00, 0xFC, 0x3C, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x48, 0x00, 0x11, 0xC0, 0x0C, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x1C, 0x08, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x3F, 0xE0,
  0x8C, 0x03, 0x09, 0x80, 0x08, 0xA0, 0x00, 0x4E, 0x00, 0x06, 0xC0, 0x00,
  0x2C, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x40, 0x00, 0x24, 0x00, 0x02, 0x60, 0x00, 0x22, 0x00, 0x04, 0x10,
  0x00, 0x41, 0x80, 0x08, 0x0C, 0x03, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xE0,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xF8, 0x01, 0xE3, 0xC0, 0x60, 0x04, 0x10, 0x00, 0x46, 0x00, 0x0C, 0x80,
  0x00, 0x90, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x19, 0x80,
  0x02, 0x18, 0x00, 0xC1, 0x80, 0x30, 0x1C, 0x18, 0x00, 0xEC, 0x00, 0x0F,
  0x80, 0x07, 0x1C, 0x03, 0x00, 0xE0, 0xC0, 0x06, 0x30, 0x00, 0x64, 0x00,
  0x05, 0x80, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x24, 0x00, 0x04, 0x40, 0x03, 0x06, 0x00,
  0xC0, 0x3F, 0xE0, 0x01, 0xF8, 0x00, 0x70, 0xE0, 0x18, 0x03, 0x03, 0x00,
  0x08, 0x20, 0x00, 0xC6, 0x00, 0x04, 0x40, 0x00, 0x64, 0x00, 0x02, 0x40,
  0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x40, 0x00, 0x14,
  0x00, 0x03, 0x40, 0x00, 0x32, 0x00, 0x05, 0x30, 0x00, 0xD1, 0x80, 0x19,
  0x0E, 0x0E, 0x10, 0x3F, 0x83, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x03, 0xFF, 0x00, 0x06,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x33, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x32, 0x26, 0x64, 0x44, 0x88, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x1F, 0x83, 0xC3, 0xC8, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x04,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x02, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x00, 0x10, 0x60, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x00, 0x88, 0x00,
  0x7F, 0xC0, 0x22, 0x00, 0x60, 0x10, 0x0D, 0x80, 0x30, 0x04, 0x01, 0x40,
  0x18, 0x01, 0x00, 0x50, 0x04, 0x00, 0x40, 0x14, 0x02, 0x00, 0x10, 0x07,
  0x00, 0x80, 0x04, 0x01, 0xC0, 0x60, 0x01, 0x00, 0x60, 0x18, 0x00, 0x40,
  0x18, 0x06, 0x00, 0x10, 0x06, 0x01, 0x80, 0x04, 0x01, 0xC0, 0x60, 0x03,
  0x00, 0x70, 0x08, 0x00, 0xC0, 0x24, 0x02, 0x00, 0x50, 0x09, 0x00, 0xC0,
  0x14, 0x04, 0x40, 0x18, 0x18, 0x83, 0x18, 0x01, 0xF8, 0x1F, 0x82, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x40, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x01, 0x20, 0x00, 0x01, 0x90, 0x00, 0x00, 0x84, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x41, 0x80, 0x00, 0x20, 0x40, 0x00, 0x30, 0x20, 0x00,
  0x10, 0x18, 0x00, 0x08, 0x04, 0x00, 0x08, 0x02, 0x00, 0x04, 0x01, 0x80,
  0x06, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x01, 0x80, 0x04,
  0x00, 0xFF, 0xFF, 0x00, 0x40, 0x00, 0x80, 0x40, 0x00, 0x40, 0x20, 0x00,
  0x30, 0x30, 0x00, 0x08, 0x10, 0x00, 0x06, 0x08, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x84, 0x00, 0x00, 0x66, 0x00, 0x00, 0x12, 0x00, 0x00, 0x09, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x08, 0x00, 0x30, 0x80, 0x00,
  0x88, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x06, 0x80, 0x00, 0x68, 0x00,
  0x02, 0x80, 0x00, 0x68, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x08, 0x80,
  0x01, 0x88, 0x00, 0xE0, 0xFF, 0xF8, 0x08, 0x00, 0x70, 0x80, 0x00, 0x88,
  0x00, 0x04, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02,
  0x80, 0x00, 0x38, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00,
  0x68, 0x00, 0x0C, 0x80, 0x01, 0x88, 0x00, 0xE0, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x01, 0xE0, 0x7C, 0x0E, 0x00, 0x10, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x01, 0x00, 0x7F, 0xFC, 0xFF, 0xFC, 0x01, 0x00, 0x0E,
  0x02, 0x00, 0x07, 0x04, 0x00, 0x03, 0x08, 0x00, 0x03, 0x10, 0x00, 0x02,
  0x20, 0x00, 0x02, 0x40, 0x00, 0x04, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x28, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x28, 0x00, 0x00, 0x50, 0x00, 0x00, 0xA0, 0x00,
  0x02, 0x40, 0x00, 0x04, 0x80, 0x00, 0x11, 0x00, 0x00, 0x62, 0x00, 0x01,
  0x84, 0x00, 0x06, 0x08, 0x00, 0x38, 0x10, 0x03, 0xC0, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0xFF,
  0xFE, 0xFF, 0xFF, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x3C, 0x0F, 0x80, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x05, 0x00, 0x00, 0x02, 0x80, 0x00, 0x01,
  0x40, 0x00, 0x00, 0x90, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x23, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x08, 0x30, 0x00, 0x04, 0x07, 0x00, 0x0E, 0x00, 0xFF,
  0xF8, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x3F, 0x80, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x30, 0x08, 0x02, 0x01, 0x3F, 0x87, 0x00, 0x80, 0x00, 0x68, 0x00,
  0x08, 0x80, 0x01, 0x08, 0x00, 0x20, 0x80, 0x04, 0x08, 0x00, 0x80, 0x80,
  0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x08, 0x08, 0x00, 0x81, 0x00, 0x08,
  0x20, 0x00, 0x84, 0x00, 0x08, 0xE0, 0x00, 0x93, 0x00, 0x0A, 0x10, 0x00,
  0xC1, 0x80, 0x08, 0x0C, 0x00, 0x80, 0x40, 0x08, 0x02, 0x00, 0x80, 0x30,
  0x08, 0x01, 0x80, 0x80, 0x08, 0x08, 0x00, 0x40, 0x80, 0x06, 0x08, 0x00,
  0x30, 0x80, 0x01, 0x08, 0x00, 0x18, 0x80, 0x00, 0xC8, 0x00, 0x04, 0x80,
  0x00, 0x30, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xD0, 0x00, 0x00, 0x5A, 0x00, 0x00, 0x1B, 0x20, 0x00, 0x02,
  0x64, 0x00, 0x00, 0x4C, 0xC0, 0x00, 0x11, 0x88, 0x00, 0x02, 0x31, 0x00,
  0x00, 0xC6, 0x10, 0x00, 0x10, 0xC2, 0x00, 0x02, 0x18, 0x60, 0x00, 0x83,
  0x04, 0x00, 0x10, 0x60, 0x80, 0x06, 0x0C, 0x08, 0x00, 0x81, 0x81, 0x00,
  0x10, 0x30, 0x30, 0x04, 0x06, 0x02, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x04, 0x04, 0x03, 0x00, 0x81, 0x80, 0x60, 0x18, 0x20, 0x0C, 0x01, 0x04,
  0x01, 0x80, 0x31, 0x80, 0x30, 0x02, 0x20, 0x06, 0x00, 0x4C, 0x00, 0xC0,
  0x05, 0x00, 0x18, 0x00, 0xA0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00,
  0x08, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x40, 0x00, 0x1B,
  0x00, 0x00, 0xC8, 0x00, 0x06, 0x20, 0x00, 0x31, 0x80, 0x01, 0x84, 0x00,
  0x0C, 0x10, 0x00, 0x60, 0xC0, 0x03, 0x03, 0x00, 0x18, 0x08, 0x00, 0xC0,
  0x60, 0x06, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x0C, 0x00, 0xC0,
  0x60, 0x02, 0x03, 0x00, 0x18, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x06, 0x00,
  0x04, 0x30, 0x00, 0x31, 0x80, 0x00, 0x8C, 0x00, 0x02, 0x60, 0x00, 0x1B,
  0x00, 0x00, 0x58, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00,
  0x3F, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x30, 0x20, 0x00, 0x03, 0x08, 0x00, 0x00, 0x21, 0x00,
  0x00, 0x06, 0x40, 0x00, 0x00, 0x48, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x50, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x44,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x02, 0x08, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x20, 0x0C, 0x00, 0x08, 0x00, 0xE0, 0x06, 0x00, 0x07, 0xFF, 0x00, 0xFF,
  0xF8, 0x20, 0x03, 0x88, 0x00, 0x32, 0x00, 0x06, 0x80, 0x00, 0xA0, 0x00,
  0x28, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x48, 0x00, 0x32, 0x00, 0x38, 0xFF,
  0xF8, 0x3F, 0xC0, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3C, 0x0E, 0x00, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x30, 0x20, 0x00, 0x03, 0x08, 0x00, 0x00, 0x21, 0x00, 0x00, 0x06,
  0x40, 0x00, 0x00, 0x48, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x50,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x44, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x02, 0x08, 0x00, 0x00, 0x80, 0x80, 0x00, 0x20, 0x0C,
  0x00, 0x08, 0x00, 0xE0, 0x06, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0xFF, 0xF8, 0x10,
  0x01, 0xC2, 0x00, 0x0C, 0x40, 0x00, 0xC8, 0x00, 0x09, 0x00, 0x01, 0x20,
  0x00, 0x34, 0x00, 0x06, 0x80, 0x00, 0xD0, 0x00, 0x1A, 0x00, 0x02, 0x40,
  0x00, 0x48, 0x00, 0x19, 0x00, 0x06, 0x20, 0x01, 0x84, 0x01, 0xC0, 0xFF,
  0xE0, 0x10, 0x04, 0x02, 0x00, 0xC0, 0x40, 0x08, 0x08, 0x00, 0x81, 0x00,
  0x18, 0x20, 0x01, 0x04, 0x00, 0x30, 0x80, 0x02, 0x10, 0x00, 0x22, 0x00,
  0x06, 0x40, 0x00, 0x48, 0x00, 0x0D, 0x00, 0x00, 0xA0, 0x00, 0x18, 0x00,
  0xFE, 0x00, 0x70, 0x7E, 0x18, 0x00, 0x43, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x08, 0xE0, 0x03, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x40, 0x00, 0x06, 0x80, 0x00, 0x08,
  0x80, 0x00, 0x31, 0x80, 0x00, 0x41, 0x80, 0x03, 0x01, 0xC0, 0x1C, 0x00,
  0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x90, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x42, 0x00, 0x00, 0x21, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x10, 0x20, 0x00, 0x08, 0x18, 0x00, 0x08, 0x04, 0x00, 0x04, 0x02, 0x00,
  0x06, 0x01, 0x80, 0x02, 0x00, 0x40, 0x01, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x03, 0x00, 0x40, 0x00, 0x80, 0x20, 0x00,
  0x40, 0x30, 0x00, 0x10, 0x10, 0x00, 0x08, 0x08, 0x00, 0x06, 0x0C, 0x00,
  0x01, 0x04, 0x00, 0x00, 0x82, 0x00, 0x00, 0x62, 0x00, 0x00, 0x11, 0x00,
  0x00, 0x09, 0x80, 0x00, 0x02, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x34, 0x00, 0x06, 0x00,
  0x02, 0x40, 0x00, 0x60, 0x00, 0x22, 0x00, 0x0D, 0x00, 0x02, 0x20, 0x00,
  0x90, 0x00, 0x62, 0x00, 0x09, 0x00, 0x04, 0x30, 0x00, 0x98, 0x00, 0x41,
  0x00, 0x10, 0x80, 0x0C, 0x10, 0x01, 0x08, 0x00, 0x81, 0x00, 0x10, 0x80,
  0x08, 0x18, 0x03, 0x0C, 0x00, 0x80, 0x80, 0x20, 0x40, 0x18, 0x08, 0x02,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x40, 0x10, 0x04, 0x06, 0x02, 0x01, 0x00,
  0x40, 0x40, 0x20, 0x30, 0x04, 0x04, 0x02, 0x02, 0x00, 0x60, 0x40, 0x30,
  0x20, 0x02, 0x08, 0x01, 0x06, 0x00, 0x20, 0x80, 0x10, 0x40, 0x02, 0x08,
  0x01, 0x04, 0x00, 0x31, 0x80, 0x08, 0x40, 0x01, 0x10, 0x00, 0x8C, 0x00,
  0x11, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0xC8, 0x00, 0x0B, 0x00, 0x05,
  0x80, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x0C, 0x60, 0x00, 0x30, 0x40, 0x00, 0x40, 0xC0, 0x01, 0x00,
  0x80, 0x06, 0x00, 0x80, 0x08, 0x01, 0x80, 0x20, 0x01, 0x00, 0xC0, 0x01,
  0x01, 0x00, 0x03, 0x04, 0x00, 0x02, 0x18, 0x00, 0x06, 0x20, 0x00, 0x04,
  0x80, 0x00, 0x05, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x68,
  0x00, 0x00, 0x98, 0x00, 0x02, 0x10, 0x00, 0x0C, 0x10, 0x00, 0x10, 0x30,
  0x00, 0x40, 0x20, 0x01, 0x80, 0x20, 0x02, 0x00, 0x60, 0x08, 0x00, 0x40,
  0x30, 0x00, 0x40, 0x40, 0x00, 0xC1, 0x80, 0x00, 0x86, 0x00, 0x00, 0x88,
  0x00, 0x01, 0xB0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x22,
  0x00, 0x01, 0x88, 0x00, 0x04, 0x10, 0x00, 0x30, 0x60, 0x00, 0x80, 0x80,
  0x04, 0x03, 0x00, 0x10, 0x04, 0x00, 0x80, 0x18, 0x02, 0x00, 0x20, 0x10,
  0x00, 0xC0, 0xC0, 0x01, 0x02, 0x00, 0x02, 0x18, 0x00, 0x08, 0x40, 0x00,
  0x13, 0x00, 0x00, 0x48, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x07, 0xFC, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0xFF, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x0F, 0xFC, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x14, 0x00, 0x00,
  0x90, 0x00, 0x08, 0x80, 0x00, 0x42, 0x00, 0x04, 0x10, 0x00, 0x20, 0x40,
  0x02, 0x02, 0x00, 0x10, 0x08, 0x01, 0x00, 0x40, 0x18, 0x01, 0x00, 0x80,
  0x08, 0x0C, 0x00, 0x20, 0x40, 0x01, 0x06, 0x00, 0x04, 0x20, 0x00, 0x23,
  0x00, 0x00, 0x90, 0x00, 0x05, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0x80, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x80, 0x00, 0x40, 0x07, 0xDE, 0x0C, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x1F, 0xF0, 0xF0, 0x09, 0xC0, 0x05,
  0x80, 0x02, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x7C, 0x00, 0x2A, 0x00, 0x24, 0xC0, 0x62, 0x3F, 0xE1, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x1E, 0x02, 0x1E, 0x78, 0x4C,
  0x01, 0x8B, 0x00, 0x19, 0x40, 0x01, 0x30, 0x00, 0x16, 0x00, 0x02, 0xC0,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00,
  0x01, 0x60, 0x00, 0x2C, 0x00, 0x0D, 0x40, 0x01, 0x2C, 0x00, 0x44, 0xC0,
  0x30, 0x87, 0xFC, 0x00, 0x00, 0x38, 0x03, 0xCF, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x0C, 0x01, 0x07, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x1E, 0x04, 0x1E, 0x70, 0x8C, 0x01, 0x93, 0x00, 0x12, 0x40,
  0x01, 0x50, 0x00, 0x2A, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x34, 0x00,
  0x0A, 0xC0, 0x01, 0x4C, 0x00, 0x48, 0xC0, 0x31, 0x07, 0xFC, 0x20, 0x00,
  0xF0, 0x01, 0xEF, 0x01, 0x80, 0x60, 0xC0, 0x04, 0x20, 0x01, 0x90, 0x00,
  0x24, 0x00, 0x0B, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x18, 0x1F, 0xFC, 0x00, 0x38, 0x03, 0xDC, 0x0C, 0x00, 0x10,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x07, 0xFF, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x00, 0xE0, 0x00,
  0xF7, 0xC4, 0x60, 0x0C, 0x98, 0x00, 0xD2, 0x00, 0x0E, 0x80, 0x00, 0xD0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xA0, 0x00, 0x56, 0x00, 0x0A, 0x60,
  0x02, 0xC6, 0x01, 0x98, 0x3F, 0xE3, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x60, 0x03, 0x07, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x78, 0x08, 0x7B, 0xC2, 0x60, 0x0C,
  0xB0, 0x01, 0x28, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x02, 0x80, 0x00, 0xA0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x5D, 0x80, 0x00, 0x09, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92,
  0x02, 0x07, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x04, 0xF8, 0x20, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x06, 0x80, 0x0C, 0x80, 0x18, 0x80, 0x30, 0x80,
  0x20, 0x80, 0x40, 0x80, 0x80, 0x81, 0x00, 0x82, 0x00, 0x86, 0x00, 0x8E,
  0x00, 0x9B, 0x00, 0xB1, 0x00, 0xA0, 0x80, 0xC0, 0xC0, 0x80, 0x60, 0x80,
  0x20, 0x80, 0x10, 0x80, 0x18, 0x80, 0x0C, 0x80, 0x04, 0x80, 0x02, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x03, 0x02, 0x3D, 0xE0,
  0xFF, 0x89, 0x00, 0xC6, 0x03, 0x28, 0x01, 0x20, 0x06, 0xC0, 0x03, 0x80,
  0x0B, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x18, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x80, 0x02, 0x00, 0x06, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x80, 0x01, 0x80, 0x02, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x60, 0x00, 0x80, 0x01, 0x80, 0x02, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x18, 0x00, 0x20, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x00, 0xF0, 0x21, 0xEF, 0x09, 0x80, 0x32, 0xC0, 0x04, 0xA0, 0x00, 0xB0,
  0x00, 0x2C, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x7B, 0xE0, 0x18,
  0x03, 0x03, 0x00, 0x08, 0x20, 0x00, 0xC4, 0x00, 0x04, 0x40, 0x00, 0x68,
  0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x02, 0x80, 0x00,
  0x2C, 0x00, 0x02, 0x40, 0x00, 0x64, 0x00, 0x04, 0x20, 0x00, 0xC3, 0x00,
  0x18, 0x0C, 0x03, 0x00, 0x7F, 0xC0, 0x00, 0xF0, 0x10, 0xF3, 0xC2, 0x20,
  0x0C, 0x48, 0x00, 0xCA, 0x00, 0x0D, 0xC0, 0x00, 0xB0, 0x00, 0x16, 0x00,
  0x03, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0B, 0x00, 0x01, 0x70, 0x00, 0x6A, 0x00, 0x09, 0x60, 0x02, 0x27, 0x01,
  0x84, 0x3F, 0xE0, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x78, 0x00, 0x3D, 0xE1, 0x0C, 0x01, 0x11, 0x80,
  0x09, 0x30, 0x00, 0x72, 0x00, 0x07, 0x60, 0x00, 0x34, 0x00, 0x03, 0x40,
  0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x40, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x34, 0x00, 0x03,
  0x60, 0x00, 0x72, 0x00, 0x07, 0x30, 0x00, 0xF1, 0x00, 0x1B, 0x0C, 0x03,
  0x30, 0x7F, 0xC3, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x01, 0x88, 0xFF, 0x98, 0x0A, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x01, 0xC0, 0x1F, 0x7F, 0x30, 0x02, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02,
  0xC0, 0x0C, 0x7F, 0xF8, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x03, 0xFF, 0xE1, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x3F, 0x80, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x54, 0x00,
  0x69, 0x80, 0x64, 0x7F, 0xC2, 0x80, 0x00, 0x68, 0x00, 0x09, 0x00, 0x01,
  0x30, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x04, 0x00, 0x40, 0x80, 0x08,
  0x18, 0x03, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x02, 0x00, 0x40, 0x40,
  0x08, 0x18, 0x00, 0x82, 0x00, 0x10, 0x40, 0x03, 0x10, 0x00, 0x22, 0x00,
  0x04, 0x40, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0xC0, 0x00, 0x10, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x05, 0x00, 0x14, 0x00,
  0x50, 0x02, 0x40, 0x0D, 0x00, 0x26, 0x00, 0x88, 0x02, 0x20, 0x08, 0x80,
  0x62, 0x01, 0x88, 0x04, 0x20, 0x10, 0x40, 0x41, 0x01, 0x04, 0x04, 0x10,
  0x30, 0x40, 0xC1, 0x02, 0x02, 0x08, 0x18, 0x20, 0x20, 0x80, 0x86, 0x02,
  0x08, 0x08, 0x40, 0x11, 0x80, 0x84, 0x01, 0x10, 0x04, 0xC0, 0x11, 0x00,
  0x48, 0x01, 0x90, 0x04, 0x80, 0x0A, 0x00, 0x78, 0x00, 0xA0, 0x03, 0x00,
  0x0A, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x04, 0x00, 0xC0, 0x00, 0xC4,
  0x00, 0x10, 0xC0, 0x04, 0x0C, 0x01, 0x80, 0x80, 0x60, 0x08, 0x08, 0x01,
  0x82, 0x00, 0x10, 0xC0, 0x01, 0x10, 0x00, 0x14, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0A, 0x00, 0x02, 0x20, 0x00, 0xC6, 0x00, 0x30, 0x40, 0x04,
  0x04, 0x01, 0x00, 0xC0, 0x60, 0x0C, 0x08, 0x00, 0x82, 0x00, 0x08, 0xC0,
  0x01, 0xB0, 0x00, 0x18, 0x80, 0x00, 0x68, 0x00, 0x09, 0x00, 0x01, 0x30,
  0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x04, 0x00, 0x40, 0x80, 0x08, 0x18,
  0x03, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x02, 0x00, 0x40, 0x40, 0x08,
  0x18, 0x00, 0x82, 0x00, 0x10, 0x40, 0x03, 0x10, 0x00, 0x22, 0x00, 0x04,
  0x40, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0xC0, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x98, 0x00, 0x1E, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0xF0, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C,
  0x01, 0x80, 0xE0, 0x03, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xF0, 0x00, 0x80, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0xF0, 0x1C, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x38, 0x0E, 0x00, 0x3F,
  0xC0, 0x0A, 0x03, 0x80, 0xA0, 0x03, 0xF8,
};

const GFXglyph NotoSans_Thin44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 2, 31, 10, 4, -31 },
  { 9, 8, 11, 14, 3, -31 },
  { 20, 26, 31, 28, 1, -31 },
  { 121, 18, 36, 25, 3, -33 },
  { 202, 29, 32, 35, 3, -32 },
  { 318, 26, 32, 31, 3, -32 },
  { 422, 1, 11, 8, 3, -31 },
  { 424, 8, 38, 11, 2, -31 },
  { 462, 7, 38, 11, 2, -31 },
  { 496, 18, 17, 24, 3, -33 },
  { 535, 21, 21, 25, 2, -26 },
  { 591, 4, 11, 8, 2, -5 },
  { 597, 10, 2, 14, 2, -13 },
  { 600, 2, 2, 10, 4, -2 },
  { 601, 13, 31, 14, 1, -31 },
  { 652, 19, 32, 25, 3, -32 },
  { 728, 10, 31, 25, 4, -31 },
  { 767, 19, 32, 25, 3, -32 },
  { 843, 20, 32, 25, 2, -32 },
  { 923, 24, 32, 25, 1, -32 },
  { 1019, 19, 31, 25, 3, -31 },
  { 1093, 20, 32, 25, 3, -32 },
  { 1173, 19, 31, 25, 3, -31 },
  { 1247, 19, 32, 25, 3, -32 },
  { 1323, 20, 33, 25, 2, -32 },
  { 1406, 2, 23, 10, 4, -23 },
  { 1412, 4, 29, 10, 2, -23 },
  { 1427, 21, 20, 25, 2, -26 },
  { 1480, 21, 10, 25, 2, -21 },
  { 1507, 21, 20, 25, 2, -26 },
  { 1560, 14, 32, 18, 2, -32 },
  { 1616, 34, 35, 39, 2, -31 },
  { 1765, 25, 32, 25, 0, -32 },
  { 1865, 20, 31, 27, 5, -31 },
  { 1943, 23, 32, 27, 3, -32 },
  { 2035, 23, 31, 30, 5, -31 },
  { 2125, 16, 31, 24, 5, -31 },
  { 2187, 17, 31, 22, 5, -31 },
  { 2253, 25, 32, 32, 3, -32 },
  { 2353, 22, 31, 31, 5, -31 },
  { 2439, 7, 31, 12, 3, -31 },
  { 2467, 10, 39, 10, -4, -31 },
  { 2516, 20, 31, 25, 5, -31 },
  { 2594, 16, 31, 22, 5, -31 },
  { 2656, 27, 31, 37, 5, -31 },
  { 2761, 21, 31, 31, 5, -31 },
  { 2843, 27, 32, 33, 3, -32 },
  { 2951, 18, 31, 25, 5, -31 },
  { 3021, 27, 39, 33, 3, -32 },
  { 3153, 19, 31, 25, 5, -31 },
  { 3227, 20, 32, 24, 2, -32 },
  { 3307, 22, 31, 22, 0, -31 },
  { 3393, 23, 31, 31, 4, -31 },
  { 3483, 25, 31, 25, 0, -31 },
  { 3580, 36, 31, 38, 1, -31 },
  { 3720, 23, 31, 22, 0, -31 },
  { 3810, 22, 31, 22, 0, -31 },
  { 3896, 22, 31, 25, 2, -31 },
  { 3982, 9, 38, 14, 4, -31 },
  { 4025, 13, 31, 14, 1, -31 },
  { 4076, 9, 38, 14, 1, -31 },
  { 4119, 21, 20, 25, 2, -32 },
  { 4172, 17, 1, 17, 0, 4 },
  { 4175, 7, 7, 11, 2, -34 },
  { 4182, 17, 24, 22, 2, -24 },
  { 4233, 19, 33, 26, 4, -33 },
  { 4312, 16, 24, 21, 3, -24 },
  { 4360, 19, 33, 26, 3, -33 },
  { 4439, 18, 24, 24, 3, -24 },
  { 4493, 15, 34, 12, 0, -34 },
  { 4557, 19, 35, 26, 3, -24 },
  { 4641, 18, 33, 25, 4, -33 },
  { 4716, 3, 32, 9, 3, -32 },
  { 4728, 8, 43, 9, -2, -32 },
  { 4771, 16, 33, 20, 4, -33 },
  { 4837, 1, 33, 9, 4, -33 },
  { 4842, 30, 24, 37, 4, -24 },
  { 4932, 18, 24, 25, 4, -24 },
  { 4986, 20, 24, 25, 3, -24 },
  { 5046, 19, 34, 26, 4, -24 },
  { 5127, 20, 34, 26, 2, -24 },
  { 5212, 12, 24, 17, 4, -24 },
  { 5248, 16, 24, 20, 2, -24 },
  { 5296, 13, 29, 14, 0, -29 },
  { 5344, 17, 23, 25, 4, -23 },
  { 5393, 19, 23, 19, 0, -23 },
  { 5448, 28, 23, 30, 1, -23 },
  { 5529, 19, 23, 21, 1, -23 },
  { 5584, 19, 34, 19, 0, -23 },
  { 5665, 16, 23, 20, 2, -23 },
  { 5711, 12, 38, 15, 1, -31 },
  { 5768, 1, 45, 24, 11, -34 },
  { 5774, 12, 38, 15, 2, -31 },
  { 5831, 21, 3, 25, 2, -17 },
};

const GFXfont NotoSans_Thin44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Thin44pt7bBitmaps,
  (GFXglyph *)NotoSans_Thin44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_THIN44PT7B_H_
