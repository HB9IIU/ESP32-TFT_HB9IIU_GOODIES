#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC68PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x07,
  0x80, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x1E, 0x0F, 0x1E,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0E, 0x3C, 0x1E, 0x38, 0x1E, 0x38,
  0x1E, 0x78, 0x1C, 0x78, 0x1C, 0x70, 0x1C, 0x70, 0x3C, 0x70, 0x38, 0x70,
  0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x30, 0xE0, 0x70, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x78, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x80, 0x70, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x03,
  0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0x80, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xE6, 0x3E,
  0x00, 0xF8, 0x60, 0x60, 0x1E, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x3C,
  0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x38, 0x18, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xE3, 0x00, 0x00, 0x1F, 0x30,
  0x00, 0x00, 0xFB, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E,
  0xF8, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0C, 0x3C, 0x00, 0x00, 0xC3, 0xC0,
  0x00, 0x1C, 0x1E, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x18, 0x0E, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x18, 0x0E, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x38, 0x1E,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0x30, 0x3C, 0x08, 0x03, 0x07, 0x80, 0xC0,
  0x70, 0xF0, 0x0F, 0xC7, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x1F, 0xE0,
  0x00, 0x38, 0x03, 0xFF, 0x00, 0x07, 0x00, 0x78, 0x70, 0x00, 0x70, 0x0F,
  0x07, 0x80, 0x0E, 0x00, 0xE0, 0x38, 0x01, 0xE0, 0x1E, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x70, 0x07, 0x80, 0x38, 0x0E, 0x00, 0x70,
  0x07, 0x81, 0xE0, 0x07, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x07, 0x03, 0xC0,
  0x07, 0x00, 0x70, 0x38, 0x00, 0xF0, 0x07, 0x07, 0x00, 0x0E, 0x00, 0xF0,
  0xF0, 0x00, 0xE0, 0x0E, 0x0E, 0x00, 0x0E, 0x00, 0xE1, 0xE0, 0x70, 0xE0,
  0x0E, 0x1C, 0x1F, 0xCE, 0x01, 0xC3, 0xC7, 0xFE, 0xE0, 0x1C, 0x38, 0xF9,
  0xEE, 0x03, 0xC7, 0x0E, 0x0F, 0xE0, 0x38, 0xF1, 0xE0, 0x7E, 0x07, 0x0E,
  0x1C, 0x07, 0x70, 0xF1, 0xE3, 0x80, 0x77, 0xFE, 0x1C, 0x38, 0x07, 0x3F,
  0xC3, 0x87, 0x80, 0x71, 0xF8, 0x38, 0x70, 0x07, 0x00, 0x07, 0x07, 0x00,
  0x70, 0x00, 0xF0, 0xF0, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0xF0, 0x01, 0xE0,
  0xE0, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x0E, 0x00,
  0x38, 0x1C, 0x00, 0xE0, 0x07, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x1C, 0x01,
  0xC0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x1C, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x78, 0x01, 0xC0, 0x70, 0x07,
  0x00, 0x1C, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0xE0, 0x0E, 0x00, 0x0F, 0x3C,
  0x01, 0xE0, 0x00, 0xFF, 0xC0, 0x3C, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x0F,
  0x00, 0x03, 0xC0, 0x1C, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x38, 0x03, 0xC0,
  0x00, 0xE0, 0x0F, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x38, 0x07, 0x80, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x0F, 0x07,
  0x83, 0xC0, 0x3C, 0x3C, 0x07, 0x80, 0xE1, 0xE0, 0x1E, 0x07, 0x87, 0x80,
  0x3C, 0x1E, 0x3C, 0x00, 0xF0, 0x70, 0xE0, 0x03, 0xC3, 0xC7, 0x80, 0x07,
  0x8E, 0x1E, 0x00, 0x1E, 0x78, 0x70, 0x00, 0x3F, 0xC1, 0xC0, 0x00, 0xFF,
  0x0F, 0x00, 0x03, 0xF8, 0x3C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1F, 0x03,
  0xC0, 0x00, 0xFC, 0x07, 0x00, 0x03, 0xF0, 0x1E, 0x00, 0x1F, 0xE0, 0x7C,
  0x01, 0xF7, 0x80, 0xF8, 0x0F, 0x8E, 0x03, 0xFF, 0xFC, 0x3C, 0x07, 0xFF,
  0xC0, 0xF0, 0x0F, 0xFE, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x3C,
  0x79, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0xF1, 0xC3, 0x87, 0x0E, 0x18, 0x70,
  0xE1, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x00, 0xE0, 0x1E, 0x06, 0x00, 0xFC,
  0x30, 0x03, 0xFB, 0x80, 0xC3, 0xFD, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xF3, 0x00, 0x0F, 0x1C, 0x00, 0xF0,
  0xE0, 0x0F, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x00, 0xF0, 0x10, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E,
  0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x39, 0xFF, 0xFE, 0xF9, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0xFC,
  0x7E, 0x00, 0x7C, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x07,
  0x80, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x1C,
  0x1E, 0x00, 0x07, 0x07, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xF0, 0xF0, 0x00,
  0x3C, 0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF1, 0xE0,
  0x00, 0x3C, 0x70, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x9E, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1C, 0x78, 0x00, 0x0F, 0x1C, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x3C,
  0x00, 0x07, 0x8F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C,
  0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xC0, 0xF0, 0x00,
  0xF0, 0x1C, 0x00, 0x78, 0x07, 0x00, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x07, 0x80, 0x0F, 0x03, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xDE, 0x1F, 0x1C, 0x3E,
  0x3C, 0xFC, 0x3C, 0x70, 0x3C, 0x20, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x1E, 0x00, 0xF8, 0x00, 0x60, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xE0, 0x7E, 0x00, 0xF0, 0x01, 0xE0, 0x06, 0x00, 0x1F, 0x00, 0x40,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x80,
  0x01, 0xF0, 0x0E, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01,
  0xDE, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x78, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x38,
  0x1E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xC0, 0x78,
  0x00, 0x1C, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0xE0, 0x07, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x70, 0x03, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x38, 0x00, 0x78,
  0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x70, 0x1F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x08, 0x00, 0x1F,
  0x00, 0x70, 0x03, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7E, 0x02, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0xFE, 0x00, 0x1E, 0x3F, 0xF0, 0x01, 0xCF, 0xFF,
  0x80, 0x3D, 0xF0, 0x7C, 0x03, 0xFC, 0x03, 0xE0, 0x3B, 0x00, 0x1E, 0x03,
  0xE0, 0x01, 0xE0, 0x7E, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF0, 0x7C, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0,
  0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0E, 0x0F, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1C,
  0x07, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0x78,
  0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xE0, 0x3E,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7E, 0x07, 0xC0, 0x03, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x03,
  0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x78, 0x07, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x38, 0x03, 0x80, 0x03, 0xC0, 0x1C, 0x00, 0x1C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78,
  0x1E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7E, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x78, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x78, 0x38, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x1F, 0x80, 0x7C, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0x80, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x78, 0x00, 0xF0, 0x1E, 0x00, 0x0E, 0x03, 0xC0, 0x01, 0xE0, 0x70, 0x00,
  0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0E, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x83, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x7E,
  0x0F, 0x00, 0x1F, 0xC1, 0xF0, 0x07, 0x70, 0x1F, 0x01, 0xEE, 0x01, 0xFF,
  0xFB, 0xC0, 0x3F, 0xFC, 0x78, 0x01, 0xFF, 0x0E, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x01, 0x00,
  0x7E, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xE0, 0x7C, 0x06, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x03, 0x80, 0x07, 0xF8, 0x07, 0x07, 0x00, 0x1F, 0xFC, 0x07, 0x07, 0x00,
  0x3F, 0xFC, 0x07, 0x0E, 0x00, 0x78, 0x3C, 0x07, 0x0E, 0x00, 0xE0, 0x38,
  0x07, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x1C,
  0x03, 0x80, 0x78, 0x07, 0x3C, 0x07, 0x00, 0x70, 0x07, 0x38, 0x07, 0x00,
  0x70, 0x0E, 0x38, 0x0F, 0x00, 0x70, 0x0E, 0x38, 0x0E, 0x00, 0xF0, 0x0E,
  0x78, 0x0E, 0x00, 0xE0, 0x0E, 0x70, 0x1E, 0x00, 0xE0, 0x1E, 0x70, 0x1C,
  0x00, 0xE0, 0x1C, 0x70, 0x1C, 0x01, 0xE0, 0x1C, 0x70, 0x1C, 0x01, 0xC0,
  0x1C, 0x70, 0x1C, 0x01, 0xC0, 0x38, 0xF0, 0x3C, 0x03, 0xC0, 0x38, 0xF0,
  0x3C, 0x03, 0xC0, 0x70, 0xE0, 0x3C, 0x07, 0xC0, 0x70, 0xE0, 0x3C, 0x07,
  0xC0, 0xE0, 0xE0, 0x1C, 0x0F, 0xC0, 0xE0, 0xE0, 0x1C, 0x1D, 0xC1, 0xC0,
  0xE0, 0x1F, 0x38, 0xF7, 0x80, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0xF0, 0x07,
  0xE0, 0x7E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x07, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x78, 0x0E, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x01, 0xE0,
  0x0E, 0x00, 0x1E, 0x00, 0xE0, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x0F, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x07, 0x3C,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x07, 0x78, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x78, 0x01, 0xF8,
  0x01, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x07, 0xC0, 0x1E, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xF0, 0x1E, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x07, 0xC0,
  0x0F, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x1E, 0x01, 0xFC, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xC0,
  0x01, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x3C, 0x03, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xF0, 0x1E, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0xFC, 0x01, 0xC0, 0x3F, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0x83,
  0xE0, 0x01, 0xF8, 0x00, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x07, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x78, 0x03, 0xF8, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x1E, 0x07,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1C,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x07, 0x80, 0x38, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x78, 0x03, 0xF8, 0x00, 0x70,
  0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x08, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x0F, 0xC0, 0x00,
  0x20, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xFC, 0x1E, 0x00, 0x0F,
  0xFF, 0x07, 0x80, 0x03, 0xFF, 0xC1, 0xC0, 0x00, 0xFF, 0xF0, 0x70, 0x00,
  0x00, 0x38, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1C, 0x0F,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0,
  0x1C, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x40, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x03, 0xE0,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x01, 0xC0, 0x07,
  0xC0, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0xE0, 0x1F, 0x00, 0x00, 0x78,
  0x0F, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x00, 0x70, 0x7C, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00,
  0x0F, 0x1F, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x00, 0x39, 0xF0, 0x00, 0x00, 0x1E, 0xFC, 0x00, 0x00, 0x07, 0xBF, 0x80,
  0x00, 0x01, 0xFD, 0xE0, 0x00, 0x00, 0x7E, 0x78, 0x00, 0x00, 0x1F, 0x0F,
  0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0,
  0x1C, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x07, 0x70, 0x00, 0x00, 0x7F, 0x80, 0x1D, 0xC0,
  0x00, 0x01, 0xDE, 0x00, 0x77, 0x00, 0x00, 0x0F, 0x70, 0x03, 0xDC, 0x00,
  0x00, 0x3B, 0xC0, 0x0F, 0x70, 0x00, 0x01, 0xEF, 0x00, 0x39, 0xC0, 0x00,
  0x07, 0x3C, 0x00, 0xE7, 0x00, 0x00, 0x3C, 0xE0, 0x07, 0x9E, 0x00, 0x00,
  0xE3, 0x80, 0x1E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x00, 0x1C,
  0x78, 0x01, 0xC7, 0x80, 0x00, 0xF1, 0xE0, 0x07, 0x1E, 0x00, 0x03, 0x87,
  0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0xE0, 0x00, 0x70, 0xF0,
  0x03, 0xC3, 0x80, 0x03, 0xC3, 0xC0, 0x0E, 0x0E, 0x00, 0x0E, 0x0F, 0x00,
  0x38, 0x38, 0x00, 0x78, 0x38, 0x01, 0xE0, 0xE0, 0x01, 0xC1, 0xE0, 0x07,
  0x83, 0x80, 0x0F, 0x07, 0x80, 0x1E, 0x0E, 0x00, 0x38, 0x1E, 0x00, 0x70,
  0x3C, 0x01, 0xE0, 0x70, 0x01, 0xC0, 0xF0, 0x07, 0x01, 0xC0, 0x0F, 0x03,
  0xC0, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0xE0, 0x3C, 0x00, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x1E, 0x01, 0xC0,
  0xF0, 0x0E, 0x00, 0x78, 0x07, 0x03, 0x80, 0x78, 0x01, 0xE0, 0x1C, 0x1E,
  0x01, 0xE0, 0x07, 0x00, 0x70, 0x70, 0x07, 0x80, 0x1C, 0x01, 0xC3, 0xC0,
  0x1C, 0x00, 0xF0, 0x07, 0x0E, 0x00, 0xF0, 0x03, 0xC0, 0x1C, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0x71, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xEF, 0x00, 0x3C,
  0x00, 0xE0, 0x07, 0xB8, 0x00, 0xE0, 0x07, 0x80, 0x1F, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x78, 0x01,
  0xC0, 0x03, 0xE0, 0x01, 0xC0, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x3F,
  0x80, 0x00, 0x78, 0x01, 0xFC, 0x00, 0x03, 0xC0, 0x0E, 0xE0, 0x00, 0x1E,
  0x00, 0x77, 0x00, 0x00, 0xE0, 0x07, 0xBC, 0x00, 0x07, 0x00, 0x3D, 0xE0,
  0x00, 0x78, 0x01, 0xC7, 0x00, 0x03, 0xC0, 0x0E, 0x38, 0x00, 0x1E, 0x00,
  0xF1, 0xE0, 0x00, 0xE0, 0x07, 0x8F, 0x00, 0x07, 0x00, 0x3C, 0x38, 0x00,
  0x78, 0x01, 0xC1, 0xC0, 0x03, 0xC0, 0x0E, 0x0F, 0x00, 0x1E, 0x00, 0xF0,
  0x78, 0x00, 0xE0, 0x07, 0x81, 0xC0, 0x0F, 0x00, 0x3C, 0x0E, 0x00, 0x78,
  0x01, 0xC0, 0x78, 0x03, 0xC0, 0x0E, 0x03, 0xC0, 0x1C, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x78, 0x01,
  0xC0, 0x1E, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0xF0, 0x03, 0x80,
  0xE0, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x38, 0x00, 0xF0, 0x78, 0x01, 0xC0,
  0x07, 0x83, 0xC0, 0x1E, 0x00, 0x1C, 0x1C, 0x00, 0xF0, 0x00, 0xF1, 0xE0,
  0x07, 0x80, 0x07, 0x8F, 0x00, 0x38, 0x00, 0x3C, 0x78, 0x01, 0xC0, 0x00,
  0xE3, 0x80, 0x1E, 0x00, 0x07, 0x9C, 0x00, 0xF0, 0x00, 0x3C, 0xE0, 0x07,
  0x80, 0x01, 0xEF, 0x00, 0x38, 0x00, 0x07, 0x78, 0x01, 0xC0, 0x00, 0x3F,
  0x80, 0x1E, 0x00, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x07, 0x80,
  0x00, 0x3F, 0x00, 0x38, 0x00, 0x01, 0xF8, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x0F, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x70, 0x7C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x03,
  0x87, 0x80, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x81, 0xC0,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x03, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0x80, 0x7E, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x78, 0x07, 0x80,
  0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x07,
  0x80, 0x70, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0x80,
  0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xF0, 0x0E, 0x00, 0x0F,
  0x00, 0xF0, 0x01, 0xF0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x0F, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x0F,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0x70, 0x7C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00,
  0x03, 0x87, 0x80, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x81,
  0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0x80, 0x7E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0,
  0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x78, 0x0E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0,
  0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x1F, 0x00, 0xF0,
  0x03, 0xF0, 0x07, 0x80, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x3C, 0x07, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0xF0,
  0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x7E,
  0x00, 0x3E, 0x00, 0x38, 0x01, 0xF0, 0x00, 0x20, 0x0F, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0xC0, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x3C, 0x07, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x78, 0x07, 0x00, 0x07, 0x80, 0x70, 0x00, 0xF0,
  0x07, 0x00, 0x0F, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x00, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x70, 0x03, 0x80, 0x07, 0x80, 0x78,
  0x00, 0x78, 0x07, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF3, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3B, 0x80,
  0x01, 0xE3, 0xC0, 0x00, 0xEE, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0xB8, 0x00,
  0x3C, 0x3C, 0x00, 0x1C, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF3, 0x80, 0x07,
  0x83, 0xC0, 0x03, 0x8E, 0x00, 0x1E, 0x0F, 0x00, 0x0E, 0x38, 0x00, 0xF0,
  0x3C, 0x00, 0x78, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xC3, 0x80, 0x0E, 0x03,
  0xC0, 0x0F, 0x0E, 0x00, 0x78, 0x0F, 0x00, 0x38, 0x38, 0x01, 0xE0, 0x3C,
  0x00, 0xE0, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x83, 0x80, 0x3C, 0x03, 0xC0,
  0x1C, 0x0E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x38, 0x07, 0x80, 0x3C, 0x03,
  0x80, 0xE0, 0x1C, 0x00, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x03, 0xC0, 0x70,
  0x0E, 0x03, 0xC0, 0x0F, 0x01, 0xC0, 0x38, 0x1E, 0x00, 0x3C, 0x0F, 0x00,
  0xE0, 0x78, 0x00, 0xF0, 0x38, 0x03, 0x81, 0xC0, 0x03, 0xC1, 0xE0, 0x0E,
  0x0F, 0x00, 0x0F, 0x07, 0x00, 0x38, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0xE1,
  0xE0, 0x00, 0xF0, 0xF0, 0x03, 0x87, 0x80, 0x03, 0xC3, 0x80, 0x0E, 0x1C,
  0x00, 0x0F, 0x1E, 0x00, 0x38, 0xF0, 0x00, 0x3C, 0x70, 0x00, 0xE3, 0x80,
  0x00, 0xF1, 0xC0, 0x03, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x0E, 0x78, 0x00,
  0x0F, 0x38, 0x00, 0x39, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0xEF, 0x00, 0x00,
  0xF7, 0x00, 0x03, 0xB8, 0x00, 0x03, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x70, 0x07, 0x80,
  0x00, 0x0E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x0E,
  0x1E, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x1C, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xDE, 0x00, 0x01, 0xE7, 0x00, 0x01, 0xE3, 0x80, 0x01, 0xF1, 0xC0, 0x00,
  0xF0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x1E, 0x00,
  0x3C, 0x07, 0x00, 0x3C, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xF0,
  0x1E, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x0E, 0x07, 0x80, 0x07,
  0x07, 0x80, 0x03, 0x83, 0x80, 0x01, 0xC3, 0xC0, 0x00, 0xF3, 0xC0, 0x00,
  0x79, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1E, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x0F, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x81,
  0xE0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xF0, 0x1C,
  0x07, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x02, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x3C, 0x70, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x78, 0x1C, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0x70,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0xF0, 0x01, 0xE0,
  0x3C, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x78, 0x38, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0x80, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1C, 0x0E,
  0x0E, 0x07, 0x03, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0x0F, 0x00, 0x7F,
  0xF8, 0xE0, 0x0F, 0xF7, 0xCE, 0x01, 0xF8, 0x1C, 0xE0, 0x1E, 0x00, 0xFE,
  0x03, 0xC0, 0x07, 0xC0, 0x78, 0x00, 0x7C, 0x07, 0x80, 0x07, 0xC0, 0xF0,
  0x00, 0x7C, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x38,
  0x00, 0x07, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x0F,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x3C, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0xC0,
  0x70, 0x01, 0xF8, 0x07, 0x80, 0x1B, 0x80, 0x78, 0x03, 0xB8, 0x03, 0xC0,
  0xF3, 0x80, 0x3F, 0xFE, 0x78, 0x01, 0xFF, 0xC7, 0x00, 0x0F, 0xF0, 0x70,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x03, 0xE0, 0x01, 0xE1,
  0xFF, 0x00, 0x3C, 0xFF, 0xF0, 0x07, 0x3F, 0x7F, 0x00, 0xEF, 0x03, 0xE0,
  0x3D, 0xC0, 0x3C, 0x07, 0xF0, 0x03, 0xC0, 0xFC, 0x00, 0x78, 0x1F, 0x00,
  0x0F, 0x03, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x1C, 0x1F, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x3C, 0x78,
  0x00, 0x07, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x07,
  0x87, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80,
  0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xE0,
  0xF8, 0x00, 0x78, 0x1F, 0x80, 0x1F, 0x03, 0xB0, 0x07, 0xC0, 0xF7, 0x01,
  0xF0, 0x1C, 0x7F, 0xFC, 0x03, 0x8F, 0xFF, 0x00, 0x70, 0xFF, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0xF3, 0xE0, 0x1F, 0x80, 0x40, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x03, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1F, 0xF0, 0xF0, 0x00,
  0xFF, 0xF1, 0xC0, 0x03, 0xFD, 0xF3, 0x80, 0x0F, 0xC0, 0xE7, 0x00, 0x1E,
  0x00, 0xFE, 0x00, 0x78, 0x00, 0xFC, 0x01, 0xE0, 0x01, 0xF0, 0x03, 0xC0,
  0x03, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00,
  0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x78, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78,
  0x07, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x78, 0x03,
  0xC0, 0x01, 0xF0, 0x07, 0x80, 0x03, 0xE0, 0x0F, 0x00, 0x0F, 0xC0, 0x0E,
  0x00, 0x3F, 0x80, 0x1E, 0x00, 0x6E, 0x00, 0x3C, 0x01, 0xDC, 0x00, 0x7C,
  0x0F, 0x38, 0x00, 0x7F, 0xFC, 0x70, 0x00, 0x7F, 0xF1, 0xC0, 0x00, 0x7F,
  0xC3, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0xFE, 0x7E, 0x01, 0xF0, 0x1E, 0x01, 0xE0,
  0x0E, 0x03, 0xC0, 0x0E, 0x07, 0x80, 0x0F, 0x07, 0x00, 0x0E, 0x0F, 0x00,
  0x0E, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0xF8, 0x38, 0x01, 0xF0, 0x78, 0x0F, 0xE0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x20, 0x3E, 0x00,
  0xC0, 0x1F, 0xCF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x20, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x70, 0x01, 0xFF, 0xE3, 0x80, 0x0F, 0xF7, 0xCE, 0x00, 0x7E, 0x07,
  0x38, 0x01, 0xE0, 0x0E, 0xE0, 0x0F, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x7C,
  0x01, 0xE0, 0x01, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xE0, 0x1C, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0xF0, 0x0F,
  0x00, 0x07, 0xC0, 0x3C, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0xFC, 0x01, 0xC0,
  0x07, 0xF0, 0x07, 0x80, 0x3B, 0x80, 0x1E, 0x00, 0xEE, 0x00, 0x7C, 0x0F,
  0x78, 0x00, 0xFF, 0xF9, 0xE0, 0x01, 0xFF, 0xC7, 0x80, 0x03, 0xFE, 0x1C,
  0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x7E,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x81, 0xF0, 0x01, 0xE1, 0xFF, 0x00, 0x79, 0xFF, 0xE0,
  0x1C, 0xFF, 0xF8, 0x07, 0x78, 0x1F, 0x03, 0xF8, 0x03, 0xC0, 0xFC, 0x00,
  0xF0, 0x3E, 0x00, 0x1C, 0x0F, 0x80, 0x07, 0x03, 0xC0, 0x03, 0xC1, 0xF0,
  0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0x81,
  0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07,
  0x83, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x3C, 0x1E, 0x00,
  0x0F, 0x07, 0x80, 0x03, 0xC1, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x78, 0x3C,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70,
  0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xC0, 0x00,
  0xE0, 0xF0, 0x00, 0x38, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0,
  0x01, 0xE0, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0xF0, 0x07, 0x00, 0x3E, 0x00,
  0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x1E,
  0x00, 0x1C, 0x07, 0x80, 0x03, 0x81, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x0E, 0x3C, 0x00,
  0x03, 0xCF, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x0E, 0x7E, 0x00, 0x01, 0xDF,
  0xC0, 0x00, 0x7F, 0x38, 0x00, 0x0F, 0xE7, 0x80, 0x01, 0xF8, 0xF0, 0x00,
  0x3E, 0x1E, 0x00, 0x07, 0x81, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07,
  0x80, 0x07, 0x80, 0x70, 0x00, 0xE0, 0x0F, 0x00, 0x1C, 0x01, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x03, 0x80, 0x0F,
  0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x1C, 0x03, 0xC0, 0x03, 0xC0, 0x70,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0x70, 0xFF, 0x80, 0xFF, 0x80, 0x1C, 0x7F, 0xF0,
  0x7F, 0xF0, 0x07, 0x3E, 0xFE, 0x7E, 0xFE, 0x01, 0xDC, 0x07, 0x9C, 0x07,
  0x80, 0xFE, 0x01, 0xEE, 0x01, 0xE0, 0x3B, 0x00, 0x3F, 0x00, 0x38, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0x80, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x7C, 0x00, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x07, 0x80, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0xF0, 0x00, 0x70, 0x00, 0x70, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x78, 0x00, 0x38, 0x00, 0x38, 0x1E, 0x00, 0x1E, 0x00, 0x0E,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x70,
  0x00, 0x70, 0x00, 0x78, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x38, 0x00, 0x38, 0x00, 0x38, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x70, 0x00,
  0x78, 0x00, 0x78, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x70, 0xFF, 0xC0, 0x1C, 0x7F, 0xF8, 0x07,
  0x3F, 0xFF, 0x01, 0xDE, 0x07, 0xC0, 0xFE, 0x00, 0xF0, 0x3B, 0x00, 0x3C,
  0x0F, 0xC0, 0x07, 0x03, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x7C, 0x00,
  0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xE0, 0xF0,
  0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0,
  0xE0, 0x00, 0x70, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03,
  0xC1, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x1E, 0x0F, 0x00,
  0x07, 0x83, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x1C, 0x1E,
  0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x38,
  0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xCF, 0xC0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x78, 0x0F, 0x00, 0x1E,
  0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x87, 0x80, 0x01, 0xC3, 0xC0, 0x00,
  0xE3, 0xC0, 0x00, 0x71, 0xE0, 0x00, 0x39, 0xE0, 0x00, 0x1C, 0xF0, 0x00,
  0x0E, 0x78, 0x00, 0x0F, 0x38, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x73, 0x80, 0x00, 0x7B, 0xC0,
  0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0x78, 0x00, 0x0F, 0x3C,
  0x00, 0x07, 0x9E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC3, 0x80, 0x03, 0xC1,
  0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x7C, 0x01, 0xE0, 0x1F, 0x03, 0xE0,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x3F, 0xE0, 0x00, 0x71, 0xFF,
  0xE0, 0x00, 0xE7, 0xEF, 0xE0, 0x01, 0xCE, 0x03, 0xC0, 0x07, 0xB8, 0x07,
  0x80, 0x0F, 0xE0, 0x07, 0x80, 0x1F, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0x1C, 0x01, 0xF0, 0x00, 0x38, 0x03, 0xE0, 0x00, 0x70,
  0x07, 0x80, 0x00, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x03,
  0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0xC0,
  0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x3C, 0x01, 0xF0, 0x00,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0x60, 0x0F, 0x80, 0x0E, 0xE0, 0x3E,
  0x00, 0x3C, 0xFF, 0xF8, 0x00, 0x79, 0xFF, 0xE0, 0x00, 0xF0, 0xFF, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0x07, 0x00, 0x7F,
  0xF8, 0xE0, 0x0F, 0xEF, 0xCE, 0x01, 0xF0, 0x1C, 0xE0, 0x1E, 0x00, 0xEE,
  0x03, 0xC0, 0x07, 0xE0, 0x78, 0x00, 0x7C, 0x07, 0x80, 0x07, 0xC0, 0xF0,
  0x00, 0x7C, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x38,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x70, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x1E, 0x0F,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x3C, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0xC0,
  0x70, 0x01, 0xFC, 0x07, 0x80, 0x1B, 0x80, 0x78, 0x03, 0xB8, 0x07, 0xC0,
  0xF7, 0x80, 0x3F, 0xFE, 0x78, 0x01, 0xFF, 0xC7, 0x00, 0x0F, 0xF0, 0x70,
  0x00, 0x1C, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x07, 0x0F, 0xE0, 0x1C, 0x7F, 0x80, 0x73, 0xFE, 0x01, 0xDE, 0x00, 0x0F,
  0xF0, 0x00, 0x3B, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x1F, 0xC7, 0xE0, 0x3C, 0x00, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x80,
  0x07, 0x81, 0x80, 0x1F, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x1F,
  0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x0E,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x03,
  0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0xE0, 0x38, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C,
  0x00, 0x1E, 0x07, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x1E,
  0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1C, 0x00, 0x0E, 0x07, 0x80,
  0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xE0,
  0x70, 0x00, 0x38, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0x3C, 0x0E, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x7C, 0x0F,
  0x00, 0x0F, 0x81, 0xE0, 0x03, 0xF0, 0x3C, 0x00, 0xFC, 0x07, 0xC0, 0x3B,
  0x80, 0x78, 0x0E, 0x70, 0x0F, 0xFF, 0x8E, 0x00, 0xFF, 0xE1, 0xC0, 0x0F,
  0xF8, 0x70, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7B,
  0x80, 0x00, 0xF7, 0x00, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x1E, 0x3C,
  0x00, 0x3C, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0x83, 0xC0,
  0x0F, 0x07, 0x80, 0x1C, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0xE0, 0x3C, 0x03,
  0xC0, 0x78, 0x07, 0x00, 0x70, 0x1E, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0xF0,
  0x03, 0x81, 0xC0, 0x07, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x1C, 0x3C, 0x00,
  0x38, 0x78, 0x00, 0x71, 0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xC7, 0x00, 0x03,
  0x9E, 0x00, 0x07, 0x38, 0x00, 0x0E, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0x80, 0x07, 0xBC,
  0x00, 0x7E, 0x00, 0x3D, 0xE0, 0x03, 0xF0, 0x01, 0xCF, 0x00, 0x1F, 0x80,
  0x1E, 0x78, 0x01, 0xDC, 0x00, 0xE3, 0xC0, 0x0E, 0xE0, 0x0F, 0x1E, 0x00,
  0xEF, 0x00, 0x78, 0xF0, 0x07, 0x78, 0x03, 0x87, 0x80, 0x7B, 0xC0, 0x3C,
  0x3C, 0x03, 0x9E, 0x01, 0xC1, 0xE0, 0x1C, 0xF0, 0x1E, 0x0F, 0x01, 0xC7,
  0x80, 0xF0, 0x78, 0x0E, 0x3C, 0x0F, 0x03, 0xC0, 0xF1, 0xE0, 0x78, 0x1E,
  0x07, 0x0F, 0x03, 0x80, 0xF0, 0x78, 0x38, 0x3C, 0x07, 0x83, 0x81, 0xC1,
  0xC0, 0x3C, 0x1C, 0x0E, 0x1E, 0x01, 0xE1, 0xC0, 0x70, 0xF0, 0x0F, 0x0E,
  0x03, 0x87, 0x00, 0x78, 0xF0, 0x1C, 0x78, 0x03, 0xC7, 0x00, 0xE3, 0x80,
  0x1E, 0x78, 0x07, 0x3C, 0x00, 0xF3, 0x80, 0x39, 0xC0, 0x07, 0x9C, 0x01,
  0xCE, 0x00, 0x3D, 0xC0, 0x0E, 0xF0, 0x01, 0xEE, 0x00, 0x77, 0x00, 0x0F,
  0xF0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x1F, 0x80, 0x03, 0xB8, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x7C, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x38, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x0E,
  0x78, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07,
  0x83, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x80,
  0x70, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x0E,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0,
  0x3E, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0xF0, 0x03, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x70, 0x3C,
  0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x07,
  0x1E, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x05, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0xFD, 0x80, 0x0F, 0xFF,
  0x20, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x80,
};

const GFXglyph NotoSans_Condensed_LightItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 15, 49, 15, 1, -49 },
  { 93, 16, 18, 21, 7, -49 },
  { 129, 32, 49, 32, 1, -49 },
  { 325, 28, 56, 29, 1, -52 },
  { 521, 36, 50, 43, 4, -49 },
  { 746, 30, 50, 32, 0, -49 },
  { 934, 7, 18, 12, 7, -49 },
  { 950, 20, 60, 17, 2, -49 },
  { 1100, 20, 60, 17, -5, -49 },
  { 1250, 21, 24, 27, 8, -52 },
  { 1313, 26, 32, 31, 3, -40 },
  { 1417, 10, 16, 13, -3, -7 },
  { 1437, 15, 3, 19, 2, -20 },
  { 1443, 6, 6, 13, 1, -6 },
  { 1448, 30, 49, 22, -3, -49 },
  { 1632, 26, 50, 29, 2, -49 },
  { 1795, 16, 49, 29, 8, -49 },
  { 1893, 30, 49, 29, -2, -49 },
  { 2077, 28, 50, 29, 0, -49 },
  { 2252, 29, 49, 29, -1, -49 },
  { 2430, 29, 50, 29, 0, -49 },
  { 2612, 28, 50, 29, 2, -49 },
  { 2787, 27, 49, 29, 4, -49 },
  { 2953, 29, 50, 29, 0, -49 },
  { 3135, 27, 50, 29, 1, -49 },
  { 3304, 11, 36, 13, 1, -36 },
  { 3354, 16, 45, 13, -3, -36 },
  { 3444, 27, 30, 31, 3, -39 },
  { 3546, 26, 18, 31, 3, -33 },
  { 3605, 27, 30, 31, 3, -39 },
  { 3707, 22, 49, 21, 2, -49 },
  { 3842, 40, 55, 43, 2, -49 },
  { 4117, 28, 49, 29, -4, -49 },
  { 4289, 30, 49, 31, 1, -49 },
  { 4473, 31, 50, 29, 3, -49 },
  { 4667, 32, 49, 35, 1, -49 },
  { 4863, 29, 49, 27, 1, -49 },
  { 5041, 29, 49, 26, 1, -49 },
  { 5219, 34, 50, 36, 3, -49 },
  { 5432, 36, 49, 36, 1, -49 },
  { 5653, 24, 49, 16, -3, -49 },
  { 5800, 25, 61, 14, -10, -49 },
  { 5991, 34, 49, 29, 1, -49 },
  { 6200, 19, 49, 25, 1, -49 },
  { 6317, 46, 49, 46, 1, -49 },
  { 6599, 37, 49, 37, 1, -49 },
  { 6826, 33, 50, 37, 3, -49 },
  { 7033, 29, 49, 29, 1, -49 },
  { 7211, 33, 61, 37, 3, -49 },
  { 7463, 29, 49, 30, 1, -49 },
  { 7641, 30, 50, 27, -1, -49 },
  { 7829, 25, 49, 25, 6, -49 },
  { 7983, 33, 50, 35, 3, -49 },
  { 8190, 28, 49, 29, 6, -49 },
  { 8362, 46, 49, 47, 6, -49 },
  { 8644, 35, 49, 26, -4, -49 },
  { 8859, 25, 49, 26, 6, -49 },
  { 9013, 32, 49, 26, -2, -49 },
  { 9209, 25, 60, 19, -1, -49 },
  { 9397, 10, 49, 22, 7, -49 },
  { 9459, 25, 60, 19, -4, -49 },
  { 9647, 27, 27, 30, 2, -49 },
  { 9739, 22, 3, 21, -6, 6 },
  { 9748, 8, 11, 16, 10, -52 },
  { 9759, 28, 38, 30, 2, -37 },
  { 9892, 27, 53, 30, 1, -52 },
  { 10071, 23, 38, 23, 2, -37 },
  { 10181, 31, 53, 31, 2, -52 },
  { 10387, 24, 38, 27, 2, -37 },
  { 10501, 33, 68, 16, -9, -52 },
  { 10782, 30, 53, 31, 0, -37 },
  { 10981, 26, 52, 30, 1, -52 },
  { 11150, 14, 49, 13, 1, -49 },
  { 11236, 24, 65, 13, -9, -49 },
  { 11431, 27, 52, 25, 1, -52 },
  { 11607, 14, 52, 13, 1, -52 },
  { 11698, 42, 37, 45, 1, -37 },
  { 11893, 26, 37, 30, 1, -37 },
  { 12014, 25, 38, 30, 2, -37 },
  { 12133, 31, 53, 31, -3, -37 },
  { 12339, 28, 53, 31, 2, -37 },
  { 12525, 22, 37, 20, 1, -37 },
  { 12627, 23, 38, 23, 0, -37 },
  { 12737, 16, 46, 17, 2, -45 },
  { 12829, 27, 37, 30, 2, -36 },
  { 12954, 23, 36, 23, 4, -36 },
  { 13058, 37, 36, 38, 4, -36 },
  { 13225, 30, 36, 24, -3, -36 },
  { 13360, 34, 52, 24, -7, -36 },
  { 13581, 25, 36, 21, -2, -36 },
  { 13694, 24, 60, 22, 2, -49 },
  { 13874, 3, 68, 28, 13, -52 },
  { 13900, 24, 60, 22, -4, -49 },
  { 14080, 27, 8, 31, 3, -28 },
};

const GFXfont NotoSans_Condensed_LightItalic68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic68pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC68PT7B_H_
