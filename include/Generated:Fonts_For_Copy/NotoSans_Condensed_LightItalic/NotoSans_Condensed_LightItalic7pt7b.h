#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC7PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x5A, 0x80, 0xC0, 0x6D, 0x7C, 0x79, 0x2C, 0xDE, 0xF3, 0x70, 0x69,
  0x5E, 0xC0, 0x5A, 0xA0, 0x24, 0x95, 0x80, 0xB0, 0x5D, 0x00, 0xC0, 0xC0,
  0x80, 0x29, 0x48, 0x76, 0xDC, 0xF8, 0x64, 0xAC, 0x65, 0x1C, 0x2E, 0xF4,
  0x71, 0x9C, 0x73, 0xDC, 0x65, 0x28, 0x75, 0x5E, 0x77, 0x9C, 0x90, 0x98,
  0x71, 0x80, 0xE0, 0xC7, 0x00, 0xD6, 0x80, 0x7B, 0xFF, 0x86, 0x4A, 0xFA,
  0x6D, 0x5E, 0x72, 0x4C, 0x6E, 0xDC, 0x69, 0xCC, 0x69, 0xC8, 0x78, 0xA9,
  0xE0, 0x55, 0x6A, 0xA0, 0x5A, 0x80, 0x25, 0x25, 0x80, 0x74, 0x4C, 0xA0,
  0x5A, 0xC0, 0x4A, 0x75, 0xEB, 0x00, 0x55, 0xAA, 0xA0, 0x79, 0x99, 0xE0,
  0x6F, 0xC8, 0x79, 0x99, 0xE2, 0x6F, 0xEA, 0x71, 0x1C, 0xEA, 0x80, 0x59,
  0x9A, 0xE0, 0xBA, 0x48, 0xDD, 0xAE, 0xA0, 0x69, 0x6C, 0xEA, 0x80, 0x65,
  0x4C, 0x5A, 0xA0, 0xF8, 0x55, 0xA0, 0x4E, 0x80, 0xE0, 0x80, 0x76, 0xE0,
  0x4E, 0xDE, 0x72, 0x60, 0x2E, 0xDC, 0x77, 0x60, 0x2D, 0x24, 0xA0, 0x76,
  0xE5, 0x80, 0x4E, 0xDA, 0x5A, 0x80, 0x25, 0x24, 0xA0, 0x55, 0x6C, 0x6A,
  0x80, 0x7B, 0xBB, 0x76, 0xD0, 0x76, 0xE0, 0x76, 0xF9, 0x00, 0x76, 0xE4,
  0x80, 0x6A, 0x67, 0x7A, 0x80, 0xB6, 0xE0, 0xBB, 0x40, 0xBB, 0xEA, 0xA9,
  0x60, 0x55, 0x24, 0x48, 0x5B, 0x69, 0x49, 0x00, 0xFE, 0x55, 0xA0, 0xE0,
};

const GFXglyph NotoSans_Condensed_LightItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 1, 2, 2, 1, -5 },
  { 4, 3, 5, 3, 0, -5 },
  { 6, 3, 5, 3, 0, -5 },
  { 8, 4, 5, 4, 0, -5 },
  { 11, 3, 5, 3, 0, -5 },
  { 13, 1, 2, 1, 1, -5 },
  { 14, 2, 6, 2, 0, -5 },
  { 16, 3, 6, 2, -1, -5 },
  { 19, 2, 2, 3, 1, -5 },
  { 20, 3, 3, 3, 0, -4 },
  { 22, 1, 2, 1, 0, -1 },
  { 23, 2, 1, 2, 0, -2 },
  { 24, 1, 1, 1, 0, -1 },
  { 25, 3, 5, 2, 0, -5 },
  { 27, 3, 5, 3, 0, -5 },
  { 29, 1, 5, 3, 1, -5 },
  { 30, 3, 5, 3, 0, -5 },
  { 32, 3, 5, 3, 0, -5 },
  { 34, 3, 5, 3, 0, -5 },
  { 36, 3, 5, 3, 0, -5 },
  { 38, 3, 5, 3, 0, -5 },
  { 40, 3, 5, 3, 0, -5 },
  { 42, 3, 5, 3, 0, -5 },
  { 44, 3, 5, 3, 0, -5 },
  { 46, 1, 4, 1, 0, -4 },
  { 47, 1, 5, 1, 0, -4 },
  { 48, 3, 3, 3, 0, -4 },
  { 50, 3, 1, 3, 0, -3 },
  { 51, 3, 3, 3, 0, -4 },
  { 53, 2, 5, 2, 0, -5 },
  { 55, 4, 6, 4, 0, -5 },
  { 58, 3, 5, 3, 0, -5 },
  { 60, 3, 5, 3, 0, -5 },
  { 62, 3, 5, 3, 0, -5 },
  { 64, 3, 5, 4, 0, -5 },
  { 66, 3, 5, 3, 0, -5 },
  { 68, 3, 5, 3, 0, -5 },
  { 70, 4, 5, 4, 0, -5 },
  { 73, 4, 5, 4, 0, -5 },
  { 76, 2, 5, 2, 0, -5 },
  { 78, 3, 6, 1, -1, -5 },
  { 81, 4, 5, 3, 0, -5 },
  { 84, 2, 5, 3, 0, -5 },
  { 86, 5, 5, 5, 0, -5 },
  { 90, 4, 5, 4, 0, -5 },
  { 93, 4, 5, 4, 0, -5 },
  { 96, 3, 5, 3, 0, -5 },
  { 98, 4, 6, 4, 0, -5 },
  { 101, 3, 5, 3, 0, -5 },
  { 103, 3, 5, 3, 0, -5 },
  { 105, 2, 5, 3, 1, -5 },
  { 107, 4, 5, 4, 0, -5 },
  { 110, 3, 5, 3, 1, -5 },
  { 112, 4, 5, 5, 1, -5 },
  { 115, 3, 5, 3, 0, -5 },
  { 117, 2, 5, 3, 1, -5 },
  { 119, 3, 5, 3, 0, -5 },
  { 121, 2, 6, 2, 0, -5 },
  { 123, 1, 5, 2, 1, -5 },
  { 124, 2, 6, 2, 0, -5 },
  { 126, 3, 3, 3, 0, -5 },
  { 128, 3, 1, 2, -1, 0 },
  { 129, 1, 1, 2, 1, -5 },
  { 130, 3, 4, 3, 0, -4 },
  { 132, 3, 5, 3, 0, -5 },
  { 134, 3, 4, 2, 0, -4 },
  { 136, 3, 5, 3, 0, -5 },
  { 138, 3, 4, 3, 0, -4 },
  { 140, 3, 7, 2, -1, -5 },
  { 143, 3, 6, 3, 0, -4 },
  { 146, 3, 5, 3, 0, -5 },
  { 148, 2, 5, 1, 0, -5 },
  { 150, 3, 7, 1, -1, -5 },
  { 153, 3, 5, 3, 0, -5 },
  { 155, 2, 5, 1, 0, -5 },
  { 157, 4, 4, 5, 0, -4 },
  { 159, 3, 4, 3, 0, -4 },
  { 161, 3, 4, 3, 0, -4 },
  { 163, 3, 6, 3, 0, -4 },
  { 166, 3, 6, 3, 0, -4 },
  { 169, 2, 4, 2, 0, -4 },
  { 170, 2, 4, 2, 0, -4 },
  { 171, 2, 5, 2, 0, -5 },
  { 173, 3, 4, 3, 0, -4 },
  { 175, 3, 4, 2, 0, -4 },
  { 177, 4, 4, 4, 0, -4 },
  { 179, 3, 4, 3, 0, -4 },
  { 181, 4, 6, 2, -1, -4 },
  { 184, 2, 4, 2, 0, -4 },
  { 185, 3, 6, 2, 0, -5 },
  { 188, 1, 7, 3, 1, -5 },
  { 189, 2, 6, 2, 0, -5 },
  { 191, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_Condensed_LightItalic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic7pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC7PT7B_H_
