#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC48PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x07,
  0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01,
  0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x03, 0xC0, 0xE0, 0x38, 0x00, 0x38, 0x73, 0x0E, 0x70,
  0xE7, 0x0E, 0x70, 0xC6, 0x0C, 0x61, 0xC6, 0x1C, 0xE1, 0x8C, 0x18, 0xC1,
  0x8C, 0x18, 0x00, 0x18, 0x18, 0x00, 0xE0, 0xC0, 0x03, 0x03, 0x00, 0x0C,
  0x0C, 0x00, 0x70, 0x60, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x38,
  0x00, 0xC0, 0xC0, 0x03, 0x03, 0x01, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x01,
  0x81, 0x80, 0x06, 0x06, 0x00, 0x38, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03,
  0x00, 0x0C, 0x1C, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x06, 0x0E, 0x03,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x03, 0x03, 0x00, 0x1C, 0x18, 0x00, 0x60,
  0x60, 0x01, 0x81, 0x80, 0x06, 0x0E, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0,
  0x03, 0x07, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01, 0x83, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x7F,
  0xE0, 0x1F, 0xFF, 0x03, 0xCC, 0x30, 0x38, 0xC0, 0x07, 0x0C, 0x00, 0x60,
  0xC0, 0x06, 0x08, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x61, 0x80, 0x07,
  0x10, 0x00, 0x39, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x7E, 0x00, 0x06, 0xF0, 0x00, 0x67, 0x00, 0x06, 0x38,
  0x00, 0x43, 0x80, 0x0C, 0x18, 0x00, 0xC3, 0x80, 0x0C, 0x38, 0x00, 0x83,
  0x00, 0x08, 0x70, 0x41, 0x8E, 0x0F, 0xDF, 0xC0, 0x7F, 0xF8, 0x00, 0xFC,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x80, 0x01, 0x03, 0xF0, 0x03, 0x03, 0xB8, 0x03, 0x83,
  0x0E, 0x01, 0x83, 0x83, 0x01, 0x81, 0x81, 0x81, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xE0, 0xE0, 0x60, 0x70, 0x60, 0x30, 0x30, 0x70, 0x38, 0x18, 0x30,
  0x18, 0x0C, 0x30, 0x0C, 0x06, 0x38, 0x06, 0x07, 0x18, 0x03, 0x03, 0x1C,
  0x79, 0x81, 0x8C, 0x7E, 0xC1, 0xCC, 0x73, 0xE0, 0xC6, 0x70, 0xF0, 0xE6,
  0x30, 0x7C, 0xE7, 0x38, 0x37, 0xE3, 0x18, 0x19, 0xC3, 0x8C, 0x0C, 0x01,
  0x8C, 0x06, 0x01, 0x86, 0x03, 0x00, 0xC3, 0x03, 0x80, 0xC1, 0x81, 0xC0,
  0xE1, 0xC0, 0xC0, 0x60, 0xE0, 0x60, 0x70, 0x60, 0x70, 0x30, 0x30, 0x30,
  0x30, 0x18, 0x18, 0x38, 0x0E, 0x18, 0x18, 0x03, 0x1C, 0x1C, 0x01, 0xFC,
  0x1C, 0x00, 0x7C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xFC,
  0x00, 0x1E, 0xF0, 0x01, 0xC3, 0x80, 0x0C, 0x0C, 0x00, 0xE0, 0x60, 0x06,
  0x03, 0x00, 0x30, 0x18, 0x01, 0x81, 0xC0, 0x0C, 0x0E, 0x00, 0x60, 0xE0,
  0x03, 0x07, 0x00, 0x1C, 0x70, 0x00, 0xE7, 0x00, 0x03, 0x70, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x1C, 0x60, 0x31,
  0xC3, 0x83, 0x8C, 0x0C, 0x1C, 0xE0, 0x70, 0xCE, 0x03, 0x8E, 0x70, 0x0E,
  0x63, 0x00, 0x77, 0x38, 0x01, 0xB1, 0xC0, 0x0F, 0x8E, 0x00, 0x78, 0x70,
  0x03, 0xC3, 0x80, 0x3E, 0x0E, 0x03, 0xB8, 0x78, 0x39, 0xC1, 0xFF, 0x86,
  0x07, 0xF8, 0x38, 0x39, 0x8C, 0xE7, 0x31, 0x8C, 0x66, 0x31, 0x80, 0x00,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0,
  0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x40, 0xC0, 0x61,
  0x80, 0xF9, 0x80, 0x1F, 0x9F, 0x07, 0xFF, 0x03, 0x80, 0x06, 0xC0, 0x0E,
  0xC0, 0x1C, 0x60, 0x38, 0x60, 0x70, 0x70, 0x20, 0x38, 0x00, 0x20, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x1C, 0x30, 0xE1, 0xC7, 0x0E, 0x18, 0x70,
  0xC3, 0x00, 0xFF, 0xFF, 0xFC, 0x6F, 0xEE, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x0E, 0x0E, 0x07, 0x01,
  0x81, 0xC0, 0x70, 0xE0, 0x1C, 0x30, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x73,
  0x80, 0x1C, 0xE0, 0x07, 0x30, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x19, 0xC0,
  0x06, 0x60, 0x01, 0x98, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03,
  0x38, 0x01, 0xCC, 0x00, 0x73, 0x00, 0x1C, 0xC0, 0x06, 0x30, 0x03, 0x8C,
  0x00, 0xE3, 0x00, 0x70, 0xC0, 0x1C, 0x30, 0x0E, 0x0E, 0x03, 0x83, 0x81,
  0xC0, 0x70, 0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x01, 0xE0, 0x78, 0x1F,
  0x07, 0xE3, 0xDC, 0xF3, 0xB8, 0x62, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80,
  0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0xF8, 0x03, 0x80, 0xE0, 0x08, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x78,
  0x0E, 0x02, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x08, 0x01, 0xE0, 0xC0,
  0x3C, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x60, 0x00, 0x7E, 0x00, 0x06,
  0xE0, 0x00, 0xCC, 0x00, 0x1C, 0xC0, 0x01, 0x8C, 0x00, 0x31, 0xC0, 0x07,
  0x1C, 0x00, 0xE1, 0x80, 0x0C, 0x18, 0x01, 0xC3, 0x80, 0x38, 0x38, 0x03,
  0x03, 0x80, 0x70, 0x30, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x07, 0x03,
  0x80, 0x70, 0x30, 0x06, 0x06, 0x00, 0x60, 0xE0, 0x0E, 0x0F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xEF, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x80, 0x1E, 0x0C, 0x07, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x7E, 0x03,
  0xBF, 0xF0, 0x7E, 0x0E, 0x0D, 0x80, 0xE1, 0xE0, 0x1C, 0x78, 0x03, 0x8E,
  0x00, 0x31, 0xC0, 0x06, 0x38, 0x00, 0xC7, 0x00, 0x38, 0xC0, 0x07, 0x18,
  0x00, 0xE3, 0x00, 0x1C, 0x60, 0x03, 0x0C, 0x00, 0xE1, 0xC0, 0x18, 0x38,
  0x07, 0x03, 0x01, 0xC0, 0x70, 0x78, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1C, 0x0F, 0x03, 0x80, 0x70, 0x30, 0x03,
  0x07, 0x00, 0x30, 0x70, 0x03, 0x07, 0x00, 0x30, 0x70, 0x07, 0x07, 0x00,
  0x70, 0x30, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x01, 0xC7, 0x80, 0x0E,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xDC, 0x00, 0xF0, 0xE0, 0x1E,
  0x07, 0x03, 0xC0, 0x70, 0x38, 0x03, 0x87, 0x00, 0x38, 0x60, 0x01, 0x86,
  0x00, 0x18, 0xE0, 0x01, 0x8E, 0x00, 0x18, 0xE0, 0x03, 0x8E, 0x00, 0x38,
  0x70, 0x03, 0x07, 0x00, 0x70, 0x38, 0x1E, 0x01, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x01, 0xC1, 0xE0, 0x70,
  0x1C, 0x1C, 0x01, 0x83, 0x80, 0x30, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x00,
  0x1C, 0x60, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0x8E, 0x00,
  0x71, 0xC0, 0x0E, 0x38, 0x03, 0xC3, 0x00, 0x78, 0x70, 0x3F, 0x0F, 0x9E,
  0xC0, 0xFF, 0x98, 0x07, 0xC7, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x81, 0xE0, 0x1F, 0xF8, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0x03, 0xC1, 0xE0, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0xE0, 0xF0, 0x38, 0x00, 0x00, 0x40, 0x3C, 0x07, 0x80,
  0xF0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xE0, 0x1F, 0xF0, 0xFF, 0xF0, 0xC0, 0xE0, 0x00, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x78, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xC0,
  0x38, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x60, 0xC0, 0x3E, 0x07, 0x18, 0x07, 0xF8, 0x71, 0x81, 0xC3, 0x07,
  0x30, 0x38, 0x30, 0x73, 0x03, 0x03, 0x07, 0x70, 0x70, 0x70, 0x66, 0x06,
  0x06, 0x06, 0x60, 0xC0, 0x60, 0x66, 0x0C, 0x06, 0x06, 0xE0, 0xC0, 0xE0,
  0x6C, 0x18, 0x0C, 0x0C, 0xC1, 0x80, 0xC0, 0xCC, 0x18, 0x1C, 0x0C, 0xC1,
  0x81, 0xC1, 0x8C, 0x18, 0x1C, 0x18, 0xC1, 0x83, 0xC3, 0x0C, 0x18, 0x6C,
  0x70, 0xC1, 0xCC, 0xEE, 0x0C, 0x0F, 0xC7, 0xC0, 0xC0, 0x30, 0x30, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x18, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x66, 0x00, 0x06,
  0x60, 0x00, 0xE6, 0x00, 0x0C, 0x60, 0x01, 0xC6, 0x00, 0x18, 0x60, 0x03,
  0x86, 0x00, 0x30, 0x60, 0x07, 0x06, 0x00, 0x70, 0x60, 0x0E, 0x07, 0x00,
  0xE0, 0x70, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1F, 0xFF, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0x07, 0x00, 0x70, 0x70, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07,
  0x1C, 0x00, 0x71, 0xC0, 0x07, 0x38, 0x00, 0x73, 0x80, 0x07, 0x30, 0x00,
  0x37, 0x00, 0x03, 0x70, 0x00, 0x3E, 0x00, 0x03, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xF0, 0x38, 0x03, 0x81, 0x80, 0x1C,
  0x0C, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC1, 0x80,
  0x0C, 0x1C, 0x00, 0xE0, 0xE0, 0x0E, 0x07, 0x00, 0xF0, 0x30, 0x1F, 0x01,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xE0, 0x7C, 0x07, 0x00, 0xE0, 0x30, 0x03,
  0x81, 0x80, 0x1C, 0x1C, 0x00, 0x60, 0xE0, 0x03, 0x07, 0x00, 0x18, 0x30,
  0x00, 0xC1, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x38,
  0x30, 0x03, 0xC3, 0x80, 0x3C, 0x1C, 0x1F, 0xC0, 0xFF, 0xF8, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3C,
  0x02, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x06, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x38, 0x1F, 0x00,
  0xE0, 0x1E, 0x03, 0x80, 0x38, 0x0C, 0x00, 0xF0, 0x30, 0x01, 0xC1, 0xC0,
  0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x60, 0x00, 0xC3, 0x80, 0x03,
  0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xC0, 0x01, 0xC3, 0x00, 0x07, 0x1C,
  0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0x86, 0x00, 0x0E, 0x18, 0x00,
  0x38, 0xE0, 0x00, 0xE3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x30, 0x00, 0xE0,
  0xC0, 0x03, 0x87, 0x00, 0x1C, 0x1C, 0x00, 0xF0, 0x60, 0x07, 0x81, 0x80,
  0x3C, 0x0E, 0x01, 0xE0, 0x38, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x40, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0xF0, 0x06, 0x01, 0xE0, 0x02, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x04, 0x60, 0x07, 0xF8,
  0x60, 0x07, 0xF8, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x30,
  0xE0, 0x00, 0x30, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70,
  0x60, 0x00, 0x60, 0x70, 0x00, 0x60, 0x70, 0x00, 0xE0, 0x38, 0x00, 0xE0,
  0x3C, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x01, 0xC0, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xC0, 0x70, 0x00,
  0xE0, 0x38, 0x00, 0x70, 0x18, 0x00, 0x38, 0x0C, 0x00, 0x1C, 0x0E, 0x00,
  0x0C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x01, 0x80, 0x03, 0x81, 0xC0,
  0x01, 0x80, 0xE0, 0x00, 0xC0, 0x70, 0x00, 0xE0, 0x30, 0x00, 0x70, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03,
  0x00, 0x07, 0x01, 0x80, 0x03, 0x81, 0xC0, 0x01, 0x80, 0xE0, 0x01, 0xC0,
  0x70, 0x00, 0xE0, 0x30, 0x00, 0x70, 0x38, 0x00, 0x30, 0x1C, 0x00, 0x18,
  0x0E, 0x00, 0x1C, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x07, 0x03, 0x80, 0x03,
  0x01, 0xC0, 0x01, 0x80, 0xE0, 0x01, 0xC0, 0x60, 0x00, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x7F, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x1E, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x0E, 0x03, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x38, 0x0F, 0x00, 0x60, 0x1C, 0x00, 0xC0, 0x70, 0x03, 0x81, 0xC0,
  0x07, 0x07, 0x00, 0x0E, 0x1C, 0x00, 0x18, 0x78, 0x00, 0x70, 0xE0, 0x00,
  0xE3, 0x80, 0x01, 0xCE, 0x00, 0x03, 0x38, 0x00, 0x06, 0xF0, 0x00, 0x1D,
  0xE0, 0x00, 0x3E, 0xE0, 0x00, 0x79, 0xC0, 0x00, 0xE1, 0x80, 0x01, 0x83,
  0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x30, 0x1C,
  0x00, 0xE0, 0x38, 0x01, 0xC0, 0x30, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0,
  0x0C, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x01,
  0x80, 0x07, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x3E, 0x03, 0x60, 0x00, 0x36, 0x03, 0x60, 0x00, 0x7E, 0x03,
  0x60, 0x00, 0x6E, 0x07, 0x60, 0x00, 0xEE, 0x07, 0x60, 0x00, 0xCC, 0x06,
  0x60, 0x01, 0xCC, 0x06, 0x60, 0x01, 0x9C, 0x0E, 0x70, 0x03, 0x9C, 0x0E,
  0x70, 0x03, 0x18, 0x0E, 0x70, 0x07, 0x18, 0x0C, 0x70, 0x06, 0x38, 0x0C,
  0x70, 0x0E, 0x38, 0x1C, 0x30, 0x0C, 0x38, 0x1C, 0x30, 0x1C, 0x30, 0x1C,
  0x30, 0x18, 0x30, 0x18, 0x30, 0x38, 0x70, 0x18, 0x30, 0x30, 0x70, 0x38,
  0x30, 0x70, 0x70, 0x38, 0x30, 0x60, 0x60, 0x30, 0x30, 0xE0, 0x60, 0x30,
  0x38, 0xC0, 0xE0, 0x70, 0x39, 0xC0, 0xE0, 0x70, 0x39, 0x80, 0xE0, 0x70,
  0x3B, 0x80, 0xC0, 0x60, 0x3B, 0x01, 0xC0, 0x60, 0x1F, 0x01, 0xC0, 0xE0,
  0x1E, 0x01, 0xC0, 0xE0, 0x1E, 0x01, 0x80, 0xE0, 0x1C, 0x01, 0x80, 0xC0,
  0x1C, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x3E, 0x00,
  0x18, 0x0F, 0x80, 0x06, 0x03, 0x60, 0x03, 0x80, 0xD8, 0x00, 0xE0, 0x37,
  0x00, 0x38, 0x1D, 0xC0, 0x0C, 0x07, 0x30, 0x03, 0x01, 0x8C, 0x01, 0xC0,
  0x63, 0x80, 0x70, 0x38, 0xE0, 0x18, 0x0E, 0x18, 0x06, 0x03, 0x86, 0x03,
  0x80, 0xC1, 0xC0, 0xE0, 0x30, 0x70, 0x38, 0x1C, 0x1C, 0x0C, 0x07, 0x03,
  0x03, 0x01, 0xC0, 0xC1, 0xC0, 0x60, 0x38, 0x70, 0x18, 0x0E, 0x1C, 0x0E,
  0x01, 0x86, 0x03, 0x80, 0x61, 0x80, 0xC0, 0x1C, 0xE0, 0x30, 0x07, 0x38,
  0x1C, 0x00, 0xCC, 0x07, 0x00, 0x33, 0x01, 0xC0, 0x0E, 0xC0, 0x60, 0x03,
  0xF0, 0x18, 0x00, 0x7C, 0x0E, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x80, 0xE0,
  0x01, 0xE0, 0x30, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0xE0, 0x0F, 0x01, 0xC0, 0x3C, 0x01, 0xC0, 0x70, 0x03, 0x81,
  0xC0, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70,
  0x00, 0x38, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCC, 0x00,
  0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x19, 0xC0, 0x00,
  0x73, 0x00, 0x00, 0xE6, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x0E,
  0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7,
  0x00, 0x07, 0x06, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x1C,
  0x03, 0xC0, 0x3C, 0x0F, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x1F, 0xFC, 0x03, 0x83, 0xE0, 0x38, 0x0F, 0x03, 0x80, 0x70,
  0x30, 0x07, 0x03, 0x00, 0x30, 0x70, 0x03, 0x07, 0x00, 0x30, 0x70, 0x07,
  0x06, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x0E, 0x0C, 0x00,
  0xE0, 0xC0, 0x1C, 0x1C, 0x07, 0x81, 0xC3, 0xF0, 0x1F, 0xFE, 0x01, 0xFF,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0x01, 0xC0,
  0x3C, 0x01, 0xC0, 0x70, 0x03, 0x81, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x0E,
  0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xC0, 0x00, 0x73, 0x80,
  0x00, 0xE7, 0x00, 0x01, 0xCC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00,
  0x0E, 0xE0, 0x00, 0x19, 0xC0, 0x00, 0x73, 0x00, 0x00, 0xE6, 0x00, 0x01,
  0xDC, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39,
  0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x06, 0x00, 0x0E, 0x0E,
  0x00, 0x38, 0x1C, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0x81, 0xE0,
  0x38, 0x0F, 0x03, 0x80, 0x70, 0x30, 0x07, 0x03, 0x00, 0x30, 0x70, 0x03,
  0x07, 0x00, 0x30, 0x70, 0x07, 0x06, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00,
  0x60, 0xE0, 0x0E, 0x0C, 0x01, 0xC0, 0xC0, 0x3C, 0x1C, 0x0F, 0x81, 0xFF,
  0xE0, 0x1F, 0xF8, 0x01, 0x83, 0x80, 0x18, 0x38, 0x03, 0x81, 0x80, 0x38,
  0x18, 0x03, 0x81, 0xC0, 0x30, 0x1C, 0x03, 0x01, 0xC0, 0x70, 0x0C, 0x07,
  0x00, 0xE0, 0x70, 0x0E, 0x06, 0x00, 0xE0, 0xE0, 0x06, 0x0E, 0x00, 0x70,
  0xE0, 0x07, 0x0C, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x78, 0x06, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x20, 0x03, 0xC0, 0xE0, 0x3E, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x07, 0x07, 0x00, 0x06, 0x07, 0x00, 0x06, 0x07, 0x00, 0x0E, 0x06,
  0x00, 0x0E, 0x0E, 0x00, 0x0C, 0x0E, 0x00, 0x0C, 0x0E, 0x00, 0x1C, 0x0C,
  0x00, 0x1C, 0x0C, 0x00, 0x1C, 0x1C, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x1C,
  0x00, 0x38, 0x18, 0x00, 0x38, 0x18, 0x00, 0x38, 0x38, 0x00, 0x30, 0x38,
  0x00, 0x70, 0x38, 0x00, 0x70, 0x30, 0x00, 0x70, 0x70, 0x00, 0x60, 0x70,
  0x00, 0x60, 0x70, 0x00, 0xE0, 0x60, 0x00, 0xE0, 0x60, 0x00, 0xE0, 0xE0,
  0x00, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0x80, 0xE0,
  0x03, 0x80, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x1E, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x06, 0xE0, 0x00,
  0xEE, 0x00, 0x0E, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0x60, 0x03, 0x86, 0x00,
  0x38, 0x60, 0x07, 0x06, 0x00, 0x70, 0x60, 0x06, 0x06, 0x00, 0xE0, 0x60,
  0x0C, 0x06, 0x01, 0xC0, 0x60, 0x1C, 0x06, 0x03, 0x80, 0x60, 0x38, 0x06,
  0x07, 0x00, 0x60, 0x70, 0x06, 0x06, 0x00, 0x70, 0xE0, 0x07, 0x0C, 0x00,
  0x71, 0xC0, 0x07, 0x18, 0x00, 0x73, 0x80, 0x07, 0x30, 0x00, 0x77, 0x00,
  0x07, 0x70, 0x00, 0x76, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x03,
  0x80, 0x0E, 0xC0, 0x07, 0x80, 0x0E, 0xC0, 0x07, 0x80, 0x1C, 0xC0, 0x0F,
  0x80, 0x1C, 0xC0, 0x0D, 0x80, 0x18, 0xC0, 0x0D, 0x80, 0x38, 0xC0, 0x1D,
  0x80, 0x38, 0xC0, 0x19, 0x80, 0x70, 0xC0, 0x39, 0x80, 0x70, 0xC0, 0x31,
  0x80, 0x60, 0xC0, 0x31, 0x80, 0xE0, 0xC0, 0x71, 0x80, 0xC0, 0xC0, 0x61,
  0x81, 0xC0, 0xC0, 0xE1, 0x81, 0xC0, 0xC0, 0xC1, 0x81, 0x80, 0xC1, 0xC1,
  0x83, 0x80, 0xC1, 0x81, 0x83, 0x00, 0xC1, 0x81, 0x87, 0x00, 0xC3, 0x81,
  0x87, 0x00, 0xC3, 0x01, 0x8E, 0x00, 0xC7, 0x01, 0x8E, 0x00, 0xC6, 0x01,
  0x8C, 0x00, 0xC6, 0x03, 0x9C, 0x00, 0xCE, 0x03, 0x98, 0x00, 0xCC, 0x03,
  0xB8, 0x00, 0xDC, 0x03, 0xB8, 0x00, 0xD8, 0x03, 0xB0, 0x00, 0xD8, 0x03,
  0xF0, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0xF0, 0x03,
  0xE0, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x30, 0x03, 0x80, 0x1C, 0x01, 0x80, 0x0E, 0x01, 0xC0, 0x07,
  0x01, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0xC0, 0xE0, 0x00, 0x70, 0x60, 0x00,
  0x38, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x06, 0x30, 0x00, 0x03, 0x38, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0xC0,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x86,
  0x00, 0x03, 0x83, 0x00, 0x01, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xC0,
  0x70, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x70, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xF8,
  0x00, 0xE6, 0x00, 0x39, 0x80, 0x1C, 0x60, 0x06, 0x1C, 0x03, 0x87, 0x01,
  0xC1, 0xC0, 0x70, 0x30, 0x38, 0x0C, 0x0E, 0x03, 0x07, 0x00, 0xC1, 0x80,
  0x38, 0xE0, 0x0E, 0x30, 0x03, 0x9C, 0x00, 0x6E, 0x00, 0x1B, 0x80, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x40, 0x7F, 0xFF,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0xC1, 0xC3, 0x87, 0x06, 0x0C, 0x18, 0x30, 0x70, 0xE1,
  0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x38, 0x70, 0x60, 0xC1, 0x83, 0x07, 0x0E,
  0x1C, 0x18, 0x30, 0x60, 0xC1, 0xC3, 0x87, 0x06, 0x0C, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x7C, 0x00, 0x06, 0xC0, 0x00, 0xEC, 0x00, 0x1C, 0xE0, 0x01,
  0x86, 0x00, 0x38, 0x70, 0x03, 0x07, 0x00, 0x70, 0x30, 0x06, 0x03, 0x80,
  0xE0, 0x18, 0x0C, 0x01, 0x81, 0x80, 0x1C, 0x38, 0x00, 0xC3, 0x00, 0x0E,
  0x70, 0x00, 0xEE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xE3, 0x87, 0x1C,
  0x30, 0x61, 0x83, 0x00, 0xF8, 0x00, 0x7F, 0x8C, 0x1F, 0x3B, 0x87, 0x83,
  0x61, 0xE0, 0x3C, 0x38, 0x07, 0x8E, 0x00, 0xF1, 0xC0, 0x1C, 0x70, 0x03,
  0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x30, 0x01, 0xCE, 0x00, 0x31, 0xC0, 0x06,
  0x38, 0x01, 0xC6, 0x00, 0x38, 0xC0, 0x07, 0x18, 0x01, 0xC3, 0x00, 0x38,
  0x60, 0x0F, 0x0C, 0x01, 0xE1, 0xC0, 0x78, 0x38, 0x1B, 0x07, 0x87, 0x60,
  0x7F, 0xCC, 0x07, 0xE3, 0x80, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x7C, 0x03, 0x3F, 0xC0, 0xEE, 0x3C,
  0x1F, 0x83, 0x83, 0x60, 0x38, 0x78, 0x07, 0x0E, 0x00, 0xE3, 0xC0, 0x1C,
  0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x30, 0x01, 0xCE, 0x00, 0x39,
  0xC0, 0x06, 0x30, 0x01, 0xC6, 0x00, 0x38, 0xC0, 0x07, 0x38, 0x01, 0xC7,
  0x00, 0x38, 0xE0, 0x06, 0x1C, 0x01, 0xC7, 0x80, 0x70, 0xF8, 0x0E, 0x1B,
  0x87, 0x83, 0x3F, 0xE0, 0x63, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xFC, 0x1F,
  0x18, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x38, 0x10, 0x7F, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x3E,
  0x38, 0x07, 0xF9, 0xC0, 0x78, 0xEE, 0x07, 0x81, 0x60, 0x38, 0x0F, 0x03,
  0x80, 0x78, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0C, 0x00, 0x60, 0xE0, 0x07,
  0x07, 0x00, 0x38, 0x30, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x60, 0xE0,
  0x07, 0x06, 0x00, 0x38, 0x30, 0x01, 0xC1, 0x80, 0x1C, 0x0C, 0x00, 0xE0,
  0x60, 0x0F, 0x03, 0x00, 0x78, 0x1C, 0x07, 0xC0, 0xE0, 0x6C, 0x07, 0x87,
  0x60, 0x1F, 0xF3, 0x00, 0x7E, 0x18, 0x00, 0x00, 0xF8, 0x03, 0xFE, 0x07,
  0x8E, 0x0E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x70,
  0x06, 0x70, 0x0E, 0x60, 0x3C, 0xE0, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xE0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x10, 0x3F, 0xF0, 0x1F, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07,
  0xF8, 0xC0, 0x7C, 0xEE, 0x07, 0x81, 0x60, 0x38, 0x0F, 0x03, 0x80, 0x78,
  0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0C, 0x00, 0x60, 0xE0, 0x07, 0x07, 0x00,
  0x38, 0x30, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x60, 0xE0, 0x07, 0x06,
  0x00, 0x38, 0x30, 0x01, 0xC1, 0x80, 0x1C, 0x0C, 0x00, 0xE0, 0x60, 0x0F,
  0x03, 0x00, 0x78, 0x1C, 0x07, 0xC0, 0xE0, 0x6C, 0x07, 0x87, 0x60, 0x1F,
  0xF7, 0x00, 0x7F, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x30, 0x1C, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x61,
  0xF0, 0x19, 0xFE, 0x0E, 0xF3, 0xC3, 0xE0, 0x70, 0xD0, 0x0C, 0x3C, 0x03,
  0x0E, 0x00, 0xC7, 0x80, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x18, 0x01, 0x86,
  0x00, 0x63, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8C, 0x00, 0xC3, 0x00,
  0x31, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC6, 0x00, 0x63, 0x80, 0x18,
  0xE0, 0x0E, 0x38, 0x03, 0x8C, 0x00, 0xC3, 0x00, 0x30, 0x01, 0x80, 0xF0,
  0x38, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x60, 0x18,
  0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E,
  0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03,
  0x80, 0xE0, 0x30, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x83,
  0x00, 0xE0, 0xE0, 0x38, 0x1C, 0x0E, 0x03, 0x83, 0x80, 0x60, 0x60, 0x0C,
  0x1C, 0x03, 0x87, 0x00, 0x71, 0xC0, 0x0E, 0x70, 0x01, 0x9C, 0x00, 0x37,
  0x80, 0x0E, 0xF0, 0x01, 0xF7, 0x00, 0x3C, 0xE0, 0x07, 0x1C, 0x00, 0xC1,
  0x80, 0x38, 0x38, 0x07, 0x07, 0x00, 0xC0, 0xE0, 0x18, 0x0C, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x00, 0x60, 0x60, 0x0E, 0x00, 0x01,
  0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0,
  0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70,
  0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18,
  0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x33, 0xFC, 0x7F, 0x83, 0xB9, 0xE7, 0x3E, 0x1F, 0x03, 0x60, 0x70, 0xD0,
  0x1E, 0x03, 0x87, 0x00, 0xF0, 0x1C, 0x38, 0x07, 0x00, 0xE3, 0x80, 0x38,
  0x07, 0x1C, 0x01, 0x80, 0x38, 0xE0, 0x1C, 0x01, 0x86, 0x00, 0xE0, 0x0C,
  0x30, 0x07, 0x00, 0xE3, 0x80, 0x30, 0x07, 0x1C, 0x01, 0x80, 0x38, 0xE0,
  0x1C, 0x01, 0x86, 0x00, 0xE0, 0x0C, 0x30, 0x07, 0x00, 0xE3, 0x80, 0x30,
  0x07, 0x1C, 0x01, 0x80, 0x30, 0xC0, 0x1C, 0x01, 0x86, 0x00, 0xE0, 0x1C,
  0x70, 0x06, 0x00, 0xE3, 0x80, 0x30, 0x07, 0x1C, 0x03, 0x80, 0x30, 0xC0,
  0x1C, 0x01, 0x86, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x0F, 0x80, 0x67, 0xF8,
  0x1D, 0xEF, 0x83, 0xE0, 0x70, 0x68, 0x06, 0x0F, 0x00, 0xC1, 0xC0, 0x38,
  0x78, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x30, 0x03, 0x06, 0x00, 0x61,
  0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x70, 0xC0, 0x0C, 0x38, 0x01, 0x87,
  0x00, 0x70, 0xE0, 0x0E, 0x18, 0x01, 0xC3, 0x00, 0x30, 0xE0, 0x0E, 0x1C,
  0x01, 0xC3, 0x80, 0x38, 0x60, 0x06, 0x1C, 0x00, 0xC0, 0x00, 0xF8, 0x01,
  0xFF, 0x01, 0xE3, 0xC1, 0xC0, 0xE1, 0xC0, 0x38, 0xE0, 0x1C, 0xE0, 0x06,
  0x70, 0x03, 0x70, 0x01, 0xB8, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x06, 0xC0, 0x07, 0x60, 0x03, 0xB0,
  0x01, 0x98, 0x01, 0xCC, 0x00, 0xE7, 0x00, 0xE3, 0x80, 0xE0, 0xE0, 0xE0,
  0x7F, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x03, 0x3F, 0xC0, 0x0D,
  0xC7, 0x80, 0x7E, 0x0E, 0x01, 0xB0, 0x1C, 0x07, 0x80, 0x70, 0x1C, 0x01,
  0xC0, 0xF0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0,
  0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x60, 0x70, 0x03, 0x81, 0x80,
  0x0E, 0x06, 0x00, 0x38, 0x38, 0x00, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x18,
  0x0E, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xF0, 0x1C, 0x07, 0xE1, 0xE0, 0x19,
  0xFF, 0x00, 0x63, 0xF8, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x7F, 0x8C, 0x1E, 0x3B, 0x87, 0x83, 0x61, 0xE0, 0x3C, 0x38,
  0x07, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x30, 0x01, 0x8E, 0x00, 0x71, 0xC0,
  0x0E, 0x30, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x06, 0x38, 0x01, 0xC7, 0x00,
  0x38, 0xC0, 0x07, 0x18, 0x01, 0xC3, 0x00, 0x38, 0x60, 0x0F, 0x0C, 0x01,
  0xE1, 0xC0, 0x7C, 0x38, 0x1B, 0x07, 0x87, 0x60, 0x7F, 0xDC, 0x07, 0xE3,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x00, 0x1E, 0x0C, 0xFC, 0x3B, 0xF0, 0x6E, 0x00, 0xD8,
  0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xC0, 0x01, 0x80, 0x00, 0x01, 0xFC, 0x07, 0xFF, 0x0F, 0x0F, 0x0E, 0x02,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x70, 0xC0, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x03, 0xFF, 0x3F, 0xE0, 0xE0, 0x0E,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x06, 0x00, 0x7E, 0x07, 0xE0, 0x0C, 0x00, 0xC7, 0x00,
  0x71, 0xC0, 0x1C, 0x70, 0x07, 0x18, 0x01, 0x8E, 0x00, 0x63, 0x80, 0x38,
  0xE0, 0x0E, 0x30, 0x03, 0x0C, 0x00, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70,
  0x07, 0x18, 0x01, 0x86, 0x00, 0x63, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03,
  0x8C, 0x01, 0xC3, 0x00, 0x70, 0xC0, 0x3C, 0x30, 0x1F, 0x0E, 0x0D, 0xC3,
  0xFE, 0x60, 0x7F, 0x18, 0x00, 0xC0, 0x07, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0,
  0x1C, 0xC0, 0x1C, 0xC0, 0x38, 0xC0, 0x38, 0xC0, 0x70, 0xE0, 0x70, 0xE0,
  0x60, 0xE0, 0xE0, 0xE0, 0xC0, 0xE1, 0xC0, 0xE1, 0x80, 0xE3, 0x80, 0xE3,
  0x00, 0xE7, 0x00, 0x66, 0x00, 0x6E, 0x00, 0x6C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xC0, 0x1C, 0x01, 0xF0, 0x07,
  0x00, 0xEC, 0x03, 0xC0, 0x3B, 0x00, 0xF0, 0x0C, 0xC0, 0x7C, 0x07, 0x30,
  0x1B, 0x01, 0x8C, 0x06, 0xC0, 0xE3, 0x03, 0x30, 0x30, 0xC0, 0xCC, 0x1C,
  0x30, 0x73, 0x07, 0x0C, 0x18, 0xC1, 0x83, 0x0E, 0x30, 0xE0, 0xC3, 0x0C,
  0x30, 0x30, 0xC3, 0x1C, 0x0C, 0x60, 0xC7, 0x03, 0x18, 0x31, 0x80, 0xCE,
  0x0C, 0xE0, 0x33, 0x03, 0x30, 0x0D, 0xC0, 0xDC, 0x03, 0x60, 0x36, 0x00,
  0xD8, 0x0D, 0x80, 0x3C, 0x03, 0xE0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x3C,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x78, 0x1C, 0x03, 0x00, 0x60,
  0x38, 0x03, 0x03, 0x80, 0x1C, 0x18, 0x00, 0xE1, 0xC0, 0x03, 0x1C, 0x00,
  0x18, 0xC0, 0x00, 0xEE, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x33, 0x00, 0x03,
  0x98, 0x00, 0x38, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x18, 0x01, 0xC0, 0xC0,
  0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x00, 0xC0, 0xE0, 0x07, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0x60, 0x38, 0x00, 0x60, 0x38, 0x00,
  0x60, 0x70, 0x00, 0x60, 0x70, 0x00, 0x60, 0x60, 0x00, 0x60, 0xE0, 0x00,
  0x60, 0xC0, 0x00, 0x61, 0xC0, 0x00, 0x61, 0x80, 0x00, 0x63, 0x80, 0x00,
  0x73, 0x00, 0x00, 0x77, 0x00, 0x00, 0x76, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x0F,
  0xC0, 0x0F, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00,
  0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0xFC, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x3C, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x3F, 0x80, 0x2F,
  0xFC, 0x0F, 0x83, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x20,
};

const GFXglyph NotoSans_Condensed_LightItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 10, 34, 11, 1, -34 },
  { 44, 12, 12, 15, 5, -34 },
  { 62, 22, 34, 22, 1, -34 },
  { 156, 20, 39, 20, 0, -36 },
  { 254, 25, 36, 30, 3, -35 },
  { 367, 21, 35, 22, 0, -35 },
  { 459, 5, 12, 8, 5, -34 },
  { 467, 14, 42, 12, 1, -34 },
  { 541, 14, 42, 12, -3, -34 },
  { 615, 16, 16, 19, 5, -36 },
  { 647, 19, 22, 22, 2, -28 },
  { 700, 7, 11, 9, -2, -5 },
  { 710, 11, 2, 13, 1, -14 },
  { 713, 4, 4, 9, 1, -4 },
  { 715, 21, 34, 15, -2, -34 },
  { 805, 18, 35, 20, 2, -35 },
  { 884, 11, 34, 20, 6, -34 },
  { 931, 21, 35, 20, -1, -35 },
  { 1023, 20, 35, 20, 0, -35 },
  { 1111, 20, 35, 20, 0, -35 },
  { 1199, 20, 34, 20, 0, -34 },
  { 1284, 19, 35, 20, 2, -35 },
  { 1368, 19, 34, 20, 3, -34 },
  { 1449, 20, 35, 20, 0, -35 },
  { 1537, 19, 35, 20, 1, -35 },
  { 1621, 9, 26, 9, 0, -26 },
  { 1651, 11, 32, 9, -2, -26 },
  { 1695, 19, 21, 22, 2, -28 },
  { 1745, 19, 12, 22, 2, -23 },
  { 1774, 19, 21, 22, 2, -28 },
  { 1824, 15, 35, 15, 2, -35 },
  { 1890, 28, 38, 31, 2, -34 },
  { 2023, 20, 34, 20, -3, -34 },
  { 2108, 21, 34, 22, 1, -34 },
  { 2198, 22, 35, 21, 2, -35 },
  { 2295, 22, 34, 24, 1, -34 },
  { 2389, 20, 34, 19, 1, -34 },
  { 2474, 20, 34, 18, 1, -34 },
  { 2559, 24, 35, 26, 2, -35 },
  { 2664, 25, 34, 25, 1, -34 },
  { 2771, 17, 34, 11, -2, -34 },
  { 2844, 18, 43, 10, -7, -34 },
  { 2941, 23, 34, 21, 1, -34 },
  { 3039, 13, 34, 18, 1, -34 },
  { 3095, 32, 34, 33, 1, -34 },
  { 3231, 26, 34, 26, 1, -34 },
  { 3342, 23, 35, 26, 2, -35 },
  { 3443, 20, 34, 21, 1, -34 },
  { 3528, 23, 43, 26, 2, -35 },
  { 3652, 20, 34, 21, 1, -34 },
  { 3737, 22, 35, 19, -1, -35 },
  { 3834, 18, 34, 18, 4, -34 },
  { 3911, 24, 34, 25, 2, -34 },
  { 4013, 20, 34, 20, 4, -34 },
  { 4098, 32, 34, 33, 5, -34 },
  { 4234, 25, 34, 19, -3, -34 },
  { 4341, 18, 34, 18, 4, -34 },
  { 4418, 23, 34, 18, -2, -34 },
  { 4516, 18, 42, 14, -1, -34 },
  { 4611, 7, 34, 16, 5, -34 },
  { 4641, 18, 42, 14, -3, -34 },
  { 4736, 20, 18, 21, 1, -34 },
  { 4781, 15, 2, 15, -4, 4 },
  { 4785, 6, 8, 11, 7, -37 },
  { 4791, 19, 26, 22, 2, -26 },
  { 4853, 19, 36, 22, 1, -36 },
  { 4939, 15, 26, 16, 2, -26 },
  { 4988, 21, 36, 22, 2, -36 },
  { 5083, 16, 26, 19, 2, -26 },
  { 5135, 23, 49, 11, -6, -37 },
  { 5276, 21, 38, 22, 0, -26 },
  { 5376, 18, 36, 21, 1, -36 },
  { 5457, 10, 35, 9, 1, -35 },
  { 5501, 17, 47, 9, -6, -35 },
  { 5601, 19, 36, 18, 1, -36 },
  { 5687, 10, 36, 9, 1, -36 },
  { 5732, 29, 26, 32, 1, -26 },
  { 5827, 19, 26, 21, 0, -26 },
  { 5889, 17, 26, 21, 2, -26 },
  { 5945, 22, 37, 22, -2, -26 },
  { 6047, 19, 37, 22, 2, -26 },
  { 6135, 15, 26, 14, 1, -26 },
  { 6184, 16, 26, 16, 0, -26 },
  { 6236, 12, 32, 12, 1, -32 },
  { 6284, 18, 25, 21, 2, -25 },
  { 6341, 16, 25, 17, 3, -25 },
  { 6391, 26, 25, 27, 3, -25 },
  { 6473, 21, 25, 17, -2, -25 },
  { 6539, 24, 37, 17, -5, -25 },
  { 6650, 17, 25, 15, -1, -25 },
  { 6704, 17, 42, 16, 1, -34 },
  { 6794, 2, 49, 20, 9, -37 },
  { 6807, 17, 42, 16, -3, -34 },
  { 6897, 19, 5, 22, 2, -19 },
};

const GFXfont NotoSans_Condensed_LightItalic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic48pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC48PT7B_H_
