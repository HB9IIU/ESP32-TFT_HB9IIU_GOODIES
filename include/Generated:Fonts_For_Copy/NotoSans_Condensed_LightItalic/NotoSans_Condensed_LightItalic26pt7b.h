#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC26PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0xC2, 0x08, 0x61, 0x84, 0x10, 0x43, 0x08, 0x20, 0x80,
  0x00, 0x01, 0x8C, 0x00, 0x4D, 0x3C, 0xB2, 0x8A, 0x29, 0x00, 0x03, 0x10,
  0x11, 0x80, 0x88, 0x04, 0x40, 0x46, 0x02, 0x20, 0xFF, 0xE1, 0x88, 0x08,
  0x80, 0x44, 0x06, 0x20, 0x23, 0x0F, 0xFE, 0x18, 0x80, 0x8C, 0x04, 0x40,
  0x22, 0x02, 0x30, 0x11, 0x00, 0x01, 0x00, 0x20, 0x0C, 0x07, 0xF1, 0x90,
  0x24, 0x04, 0x80, 0x90, 0x12, 0x01, 0x40, 0x18, 0x03, 0x80, 0x58, 0x09,
  0x02, 0x20, 0x44, 0x09, 0x9D, 0xE1, 0xF0, 0x08, 0x01, 0x00, 0x20, 0x00,
  0x18, 0x11, 0x61, 0x91, 0x09, 0x88, 0xC8, 0x44, 0x42, 0x42, 0x32, 0x11,
  0x20, 0x8B, 0x7C, 0xD6, 0x6D, 0xA2, 0xC9, 0x10, 0x98, 0x84, 0x84, 0x44,
  0x26, 0x22, 0x21, 0x13, 0x09, 0xB0, 0x78, 0x03, 0x80, 0x6C, 0x0C, 0x40,
  0x84, 0x08, 0xC0, 0x88, 0x09, 0x80, 0xB0, 0x0E, 0x00, 0xC0, 0x36, 0x12,
  0x22, 0x43, 0x6C, 0x34, 0xC1, 0xCC, 0x18, 0xC1, 0x8C, 0x2C, 0x7C, 0x40,
  0x5F, 0xA8, 0x02, 0x08, 0x30, 0x41, 0x06, 0x08, 0x30, 0x40, 0x83, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0C, 0x08, 0x10, 0x00, 0x04,
  0x06, 0x02, 0x02, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x02,
  0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x60, 0xC0, 0x08, 0x08,
  0x88, 0xE8, 0x3F, 0x18, 0x68, 0xC4, 0x04, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x3F, 0xF0, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x32, 0x26,
  0x48, 0xFF, 0xC0, 0x78, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x02,
  0x00, 0x40, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C,
  0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0x00, 0x07, 0x03, 0x61, 0x8C, 0xC3,
  0x20, 0xD8, 0x36, 0x0D, 0x03, 0x40, 0xB0, 0x2C, 0x0A, 0x06, 0x81, 0xA0,
  0x48, 0x32, 0x08, 0x86, 0x33, 0x07, 0x80, 0x04, 0x73, 0xDA, 0xC8, 0x21,
  0x86, 0x10, 0x41, 0x0C, 0x30, 0x82, 0x18, 0x61, 0x84, 0x00, 0x03, 0x80,
  0xFE, 0x08, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x06,
  0x00, 0xFF, 0x80, 0x07, 0x83, 0xF8, 0x41, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x10, 0x06, 0x03, 0x83, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20,
  0x0C, 0x01, 0x10, 0xE3, 0xF0, 0x00, 0x00, 0x60, 0x1C, 0x03, 0x00, 0xA0,
  0x24, 0x0D, 0x81, 0x30, 0x44, 0x18, 0x82, 0x30, 0x86, 0x30, 0x84, 0x11,
  0xFF, 0xBF, 0xF0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x00, 0x0F, 0xE1, 0xFC,
  0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x3F, 0x00, 0x30, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x10, 0xE3, 0xF0, 0x00,
  0x01, 0xC1, 0xD0, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x10, 0x5F, 0x18,
  0x6C, 0x1B, 0x06, 0xC1, 0xA0, 0x68, 0x12, 0x04, 0xC3, 0x11, 0x87, 0xC0,
  0x3F, 0xE7, 0xFC, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C,
  0x03, 0x00, 0x00, 0x03, 0x81, 0xD8, 0x61, 0x88, 0x11, 0x02, 0x20, 0xC4,
  0x10, 0x46, 0x0F, 0x01, 0xC0, 0x6C, 0x30, 0xC4, 0x09, 0x81, 0x30, 0x26,
  0x04, 0xC1, 0x8C, 0x60, 0xF8, 0x00, 0x07, 0x81, 0xF8, 0x61, 0x08, 0x33,
  0x06, 0x40, 0xC8, 0x19, 0x02, 0x20, 0x46, 0x18, 0xCD, 0x0F, 0x60, 0x08,
  0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0x83, 0xE0, 0x00, 0x18, 0xC4, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x0C, 0x30, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x21, 0x84, 0x10, 0x80, 0x00, 0x40, 0x70, 0x70, 0x70,
  0x30, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x30, 0x1C, 0x1C, 0x1C, 0x1C, 0x0C, 0x00, 0x1C, 0x76, 0x03, 0x01,
  0x03, 0x03, 0x02, 0x04, 0x0C, 0x18, 0x30, 0x20, 0x60, 0x40, 0x00, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0xE0, 0x07, 0x70, 0x30, 0x10, 0xC0, 0x31, 0x00,
  0x24, 0x00, 0x48, 0x78, 0xA1, 0x11, 0x44, 0x62, 0x88, 0x86, 0x21, 0x1C,
  0x42, 0x28, 0x8C, 0x51, 0x19, 0x22, 0x52, 0x47, 0x38, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x02, 0x01, 0xF8, 0x00, 0x00, 0x60, 0x1C, 0x03, 0x80,
  0xF0, 0x16, 0x02, 0x40, 0x88, 0x11, 0x06, 0x20, 0x84, 0x30, 0x87, 0xF1,
  0x82, 0x20, 0x4C, 0x09, 0x81, 0x60, 0x2C, 0x07, 0x00, 0x80, 0x0F, 0x00,
  0xFE, 0x08, 0x30, 0x83, 0x18, 0x31, 0x83, 0x10, 0x21, 0x06, 0x10, 0xC3,
  0xF8, 0x30, 0xC2, 0x04, 0x20, 0x62, 0x06, 0x60, 0x46, 0x0C, 0x40, 0xC4,
  0x38, 0xFE, 0x00, 0x01, 0xE0, 0x77, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x07, 0x10, 0x3F, 0x00, 0x0F, 0x00, 0x7F, 0x02,
  0x0C, 0x10, 0x21, 0x81, 0x0C, 0x0C, 0x40, 0x62, 0x03, 0x10, 0x19, 0x80,
  0x8C, 0x04, 0x40, 0x62, 0x03, 0x10, 0x11, 0x81, 0x8C, 0x18, 0x41, 0x82,
  0x38, 0x3F, 0x00, 0x0F, 0xF0, 0xFE, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x01, 0x00, 0x10, 0x03, 0xF8, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0xFE, 0x08,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0xF8, 0x3F,
  0x82, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x00, 0x01, 0xE0, 0x3F, 0xC3, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x7D, 0x80, 0x4C, 0x02, 0x60, 0x33,
  0x01, 0x88, 0x08, 0x60, 0x41, 0x82, 0x07, 0xF0, 0x0C, 0x04, 0x30, 0x30,
  0x80, 0xC2, 0x02, 0x18, 0x08, 0x60, 0x21, 0x01, 0x84, 0x06, 0x10, 0x10,
  0xFF, 0xC3, 0x03, 0x08, 0x0C, 0x20, 0x20, 0x80, 0x86, 0x02, 0x18, 0x18,
  0x40, 0x61, 0x01, 0x0C, 0x04, 0x00, 0x0F, 0x83, 0x01, 0x80, 0x80, 0x40,
  0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60,
  0x30, 0x10, 0x3E, 0x00, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60,
  0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18,
  0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x0F, 0x03, 0x80, 0x0C, 0x18,
  0x60, 0x82, 0x0C, 0x10, 0xC1, 0x8C, 0x0C, 0xC0, 0x44, 0x02, 0x40, 0x16,
  0x01, 0xF0, 0x0E, 0x80, 0x64, 0x02, 0x30, 0x11, 0x81, 0x84, 0x0C, 0x20,
  0x41, 0x82, 0x04, 0x30, 0x30, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x10,
  0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0xFF,
  0x0C, 0x00, 0xC3, 0x00, 0x70, 0xC0, 0x1C, 0x38, 0x0E, 0x1E, 0x02, 0x87,
  0x81, 0xE1, 0x60, 0x58, 0x48, 0x34, 0x12, 0x09, 0x0C, 0x86, 0x43, 0x21,
  0x30, 0x88, 0xCC, 0x22, 0x22, 0x08, 0x98, 0x86, 0x24, 0x21, 0x0B, 0x18,
  0x43, 0x86, 0x10, 0xE1, 0x0C, 0x30, 0x40, 0x0C, 0x06, 0x18, 0x08, 0x30,
  0x10, 0x70, 0x21, 0xA0, 0xC3, 0x41, 0x84, 0x82, 0x09, 0x84, 0x11, 0x18,
  0x62, 0x30, 0xC4, 0x41, 0x0C, 0x82, 0x19, 0x04, 0x16, 0x18, 0x2C, 0x20,
  0x70, 0x40, 0xE0, 0x80, 0xC3, 0x01, 0x80, 0x03, 0xC0, 0x3F, 0x02, 0x0C,
  0x20, 0x23, 0x01, 0x90, 0x0D, 0x80, 0x6C, 0x02, 0x40, 0x12, 0x00, 0xB0,
  0x05, 0x80, 0x6C, 0x03, 0x60, 0x13, 0x01, 0x98, 0x08, 0x40, 0xC3, 0x0C,
  0x0F, 0xC0, 0x0F, 0x00, 0xFC, 0x08, 0x60, 0x82, 0x18, 0x31, 0x83, 0x10,
  0x21, 0x02, 0x10, 0x63, 0x0C, 0x3F, 0x82, 0x00, 0x20, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x3F, 0x02, 0x0C,
  0x20, 0x23, 0x01, 0x90, 0x0D, 0x80, 0x6C, 0x02, 0x40, 0x12, 0x00, 0xB0,
  0x05, 0x80, 0x6C, 0x03, 0x60, 0x13, 0x01, 0x98, 0x08, 0x40, 0xC3, 0x0C,
  0x0F, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x0F, 0x00, 0xFC,
  0x08, 0x60, 0x82, 0x18, 0x31, 0x82, 0x10, 0x21, 0x06, 0x10, 0x43, 0x1C,
  0x3F, 0x02, 0x30, 0x23, 0x02, 0x10, 0x61, 0x06, 0x10, 0x41, 0x84, 0x18,
  0xC0, 0x80, 0x07, 0xC1, 0xFC, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x10, 0xE3, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x80, 0x20, 0x08, 0x06,
  0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01,
  0x80, 0x40, 0x10, 0x0C, 0x00, 0x18, 0x08, 0x80, 0xC4, 0x06, 0x60, 0x23,
  0x01, 0x18, 0x18, 0x80, 0xC4, 0x04, 0x60, 0x23, 0x01, 0x10, 0x18, 0x80,
  0xC4, 0x04, 0x60, 0x23, 0x03, 0x18, 0x10, 0xC1, 0x83, 0x18, 0x0F, 0x80,
  0xC0, 0x38, 0x0F, 0x01, 0x60, 0x6C, 0x08, 0x83, 0x10, 0x42, 0x18, 0x42,
  0x08, 0x41, 0x18, 0x22, 0x04, 0xC0, 0x90, 0x16, 0x02, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x00, 0xC0, 0xC0, 0xF0, 0x30, 0x2C, 0x0C, 0x0B, 0x05, 0x06,
  0xC1, 0x41, 0x30, 0xD0, 0xCC, 0x24, 0x23, 0x09, 0x18, 0xC4, 0x46, 0x31,
  0x11, 0x0C, 0xC4, 0xC3, 0x21, 0x20, 0xD8, 0x58, 0x34, 0x14, 0x0D, 0x05,
  0x03, 0xC1, 0xC0, 0xE0, 0x60, 0x38, 0x18, 0x0C, 0x04, 0x00, 0x04, 0x0C,
  0x18, 0x20, 0x61, 0x80, 0x84, 0x02, 0x20, 0x09, 0x80, 0x34, 0x00, 0xF0,
  0x01, 0x80, 0x04, 0x00, 0x38, 0x01, 0xE0, 0x04, 0x80, 0x32, 0x01, 0x88,
  0x04, 0x30, 0x30, 0xC1, 0x83, 0x0C, 0x04, 0x00, 0xC0, 0xF0, 0x24, 0x19,
  0x04, 0x43, 0x10, 0x86, 0x61, 0xB0, 0x68, 0x0E, 0x03, 0x00, 0xC0, 0x20,
  0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x30, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06,
  0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xFF,
  0x80, 0x0F, 0x87, 0xC2, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18,
  0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x18, 0x08,
  0x04, 0x03, 0xE0, 0x88, 0x88, 0xCC, 0x44, 0x44, 0x46, 0x62, 0x22, 0x22,
  0x30, 0x07, 0xC1, 0xF0, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01,
  0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00,
  0x40, 0x30, 0x0C, 0x02, 0x0F, 0x80, 0x04, 0x01, 0x80, 0xE0, 0x2C, 0x11,
  0x0C, 0x42, 0x19, 0x82, 0x40, 0xB0, 0x30, 0xFF, 0xFF, 0x99, 0x10, 0x0E,
  0x46, 0x53, 0x0D, 0x83, 0x40, 0x90, 0x2C, 0x0B, 0x06, 0x81, 0xA0, 0x48,
  0x32, 0x0C, 0xC7, 0x1E, 0xC0, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x30, 0x06, 0xF0, 0xA6, 0x18, 0x66, 0x0C, 0xC1, 0x98, 0x32, 0x06, 0x40,
  0x98, 0x13, 0x06, 0x60, 0x8C, 0x31, 0x8C, 0x6F, 0x00, 0x0F, 0x19, 0x30,
  0x60, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x80, 0xC0, 0xC4, 0x7C, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x0F, 0x41, 0x94, 0x30,
  0xC6, 0x0C, 0x40, 0x84, 0x08, 0xC0, 0x8C, 0x18, 0x81, 0x88, 0x10, 0x83,
  0x08, 0x30, 0xC5, 0x07, 0xB0, 0x0F, 0x0C, 0xC8, 0x6C, 0x34, 0x16, 0x1B,
  0xF9, 0xC0, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x23, 0xF0, 0x00, 0x70, 0x0D,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x07, 0xC0, 0xB0, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x0E, 0x00,
  0x07, 0xA1, 0x94, 0x61, 0x98, 0x32, 0x04, 0x40, 0x98, 0x13, 0x06, 0x40,
  0xC8, 0x11, 0x06, 0x20, 0xC6, 0x38, 0x7B, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x42, 0x18, 0x7E, 0x00, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01,
  0xBC, 0x53, 0x18, 0x4C, 0x13, 0x04, 0xC1, 0x20, 0xC8, 0x36, 0x09, 0x82,
  0x40, 0x90, 0x64, 0x1B, 0x04, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x04, 0x10,
  0xC2, 0x08, 0x21, 0x86, 0x10, 0x41, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60,
  0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x40, 0xE0,
  0x00, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x18, 0x86,
  0x11, 0x86, 0x60, 0xD8, 0x12, 0x02, 0xC0, 0x68, 0x19, 0x83, 0x30, 0x42,
  0x08, 0x41, 0x0C, 0x61, 0x80, 0x0C, 0x30, 0x82, 0x08, 0x61, 0x84, 0x10,
  0xC3, 0x08, 0x20, 0x86, 0x18, 0x41, 0x04, 0x30, 0x13, 0x8E, 0x14, 0xD3,
  0x18, 0x61, 0x30, 0x41, 0x30, 0xC1, 0x30, 0xC3, 0x20, 0x83, 0x20, 0x82,
  0x60, 0x82, 0x61, 0x82, 0x41, 0x86, 0x41, 0x06, 0x41, 0x04, 0xC3, 0x04,
  0x13, 0xC5, 0x31, 0x84, 0xC1, 0x30, 0x4C, 0x12, 0x0C, 0x83, 0x60, 0x98,
  0x24, 0x09, 0x06, 0x41, 0xB0, 0x40, 0x0F, 0x0C, 0xC8, 0x2C, 0x14, 0x0A,
  0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x50, 0x6C, 0x63, 0xE0, 0x09, 0xE0,
  0xA2, 0x0C, 0x30, 0xC3, 0x18, 0x31, 0x83, 0x10, 0x31, 0x02, 0x30, 0x23,
  0x06, 0x30, 0x43, 0x0C, 0x31, 0x86, 0xF0, 0x60, 0x04, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0x0F, 0x46, 0x53, 0x0D, 0x83, 0x40, 0x90, 0x2C,
  0x0B, 0x06, 0x81, 0xA0, 0x48, 0x32, 0x0C, 0xC7, 0x1E, 0xC0, 0x20, 0x08,
  0x02, 0x01, 0x80, 0x60, 0x10, 0x13, 0x8A, 0x06, 0x06, 0x03, 0x01, 0x80,
  0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x00, 0x1F, 0x98, 0x88,
  0x04, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0x80, 0xC8, 0x47,
  0xE0, 0x10, 0x43, 0x1F, 0xA0, 0x86, 0x18, 0x41, 0x04, 0x30, 0xC2, 0x08,
  0x20, 0xF0, 0x30, 0x48, 0x32, 0x0D, 0x82, 0x60, 0x90, 0x64, 0x19, 0x06,
  0xC1, 0x30, 0x48, 0x32, 0x0C, 0xCE, 0x1E, 0x80, 0xC0, 0xE0, 0xD0, 0x48,
  0x64, 0x22, 0x31, 0x10, 0x98, 0x48, 0x2C, 0x14, 0x0A, 0x06, 0x03, 0x00,
  0x82, 0x0E, 0x18, 0x28, 0x61, 0xA3, 0x84, 0x8A, 0x32, 0x28, 0x89, 0x22,
  0x24, 0x98, 0xB2, 0x42, 0x8B, 0x0E, 0x28, 0x30, 0xA0, 0xC3, 0x02, 0x0C,
  0x00, 0x18, 0x63, 0x08, 0x23, 0x04, 0xC0, 0xD0, 0x0C, 0x01, 0x80, 0x70,
  0x0A, 0x03, 0x40, 0xC8, 0x11, 0x84, 0x11, 0x82, 0x00, 0x04, 0x0C, 0x10,
  0x60, 0x41, 0x01, 0x0C, 0x04, 0x20, 0x10, 0x80, 0x46, 0x01, 0x10, 0x04,
  0xC0, 0x1A, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x3C, 0x00, 0x1F, 0xC0, 0x20, 0x18,
  0x0C, 0x02, 0x01, 0x80, 0x40, 0x20, 0x18, 0x04, 0x03, 0x01, 0x80, 0x40,
  0x3F, 0x80, 0x00, 0x83, 0xC1, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18,
  0x08, 0x0C, 0x1C, 0x0E, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08,
  0x04, 0x03, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x08, 0x07, 0x00, 0xC0,
  0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x80, 0x70, 0x70, 0x60,
  0x20, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x83, 0x80, 0x20, 0x3F,
  0x18, 0x7C,
};

const GFXglyph NotoSans_Condensed_LightItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 19, 6, 0, -19 },
  { 16, 6, 7, 8, 3, -19 },
  { 22, 13, 19, 12, 0, -19 },
  { 53, 11, 22, 11, 0, -20 },
  { 84, 13, 19, 16, 2, -19 },
  { 115, 12, 19, 12, 0, -19 },
  { 144, 2, 7, 5, 3, -19 },
  { 146, 7, 23, 7, 1, -19 },
  { 167, 8, 23, 7, -2, -19 },
  { 190, 8, 9, 10, 3, -20 },
  { 199, 10, 12, 12, 1, -15 },
  { 214, 4, 6, 5, -1, -3 },
  { 217, 5, 2, 7, 1, -8 },
  { 219, 3, 2, 5, 0, -2 },
  { 220, 11, 19, 8, -1, -19 },
  { 247, 10, 19, 11, 1, -19 },
  { 271, 6, 19, 11, 3, -19 },
  { 286, 12, 19, 11, -1, -19 },
  { 315, 11, 19, 11, 0, -19 },
  { 342, 11, 19, 11, 0, -19 },
  { 369, 11, 19, 11, 0, -19 },
  { 396, 10, 19, 11, 1, -19 },
  { 420, 11, 19, 11, 1, -19 },
  { 447, 11, 19, 11, 0, -19 },
  { 474, 11, 19, 11, 0, -19 },
  { 501, 5, 14, 5, 0, -14 },
  { 510, 6, 17, 5, -1, -14 },
  { 523, 10, 11, 12, 1, -15 },
  { 537, 10, 7, 12, 1, -13 },
  { 546, 10, 11, 12, 1, -15 },
  { 560, 8, 19, 8, 1, -19 },
  { 579, 15, 21, 17, 1, -19 },
  { 619, 11, 19, 11, -2, -19 },
  { 646, 12, 19, 12, 0, -19 },
  { 675, 12, 19, 11, 1, -19 },
  { 704, 13, 19, 13, 0, -19 },
  { 735, 12, 19, 11, 0, -19 },
  { 764, 12, 19, 10, 0, -19 },
  { 793, 13, 19, 14, 1, -19 },
  { 824, 14, 19, 14, 0, -19 },
  { 858, 9, 19, 6, -1, -19 },
  { 880, 10, 24, 5, -4, -19 },
  { 910, 13, 19, 11, 0, -19 },
  { 941, 8, 19, 10, 0, -19 },
  { 960, 18, 19, 18, 0, -19 },
  { 1003, 15, 19, 14, 0, -19 },
  { 1039, 13, 19, 14, 1, -19 },
  { 1070, 12, 19, 11, 0, -19 },
  { 1099, 13, 23, 14, 1, -19 },
  { 1137, 12, 19, 11, 0, -19 },
  { 1166, 11, 19, 10, 0, -19 },
  { 1193, 10, 19, 10, 2, -19 },
  { 1217, 13, 19, 14, 1, -19 },
  { 1248, 11, 19, 11, 2, -19 },
  { 1275, 18, 19, 18, 2, -19 },
  { 1318, 14, 19, 10, -2, -19 },
  { 1352, 10, 19, 10, 2, -19 },
  { 1376, 12, 19, 10, -1, -19 },
  { 1405, 9, 23, 7, 0, -19 },
  { 1431, 4, 19, 9, 3, -19 },
  { 1441, 10, 23, 7, -2, -19 },
  { 1470, 10, 10, 12, 1, -19 },
  { 1483, 8, 2, 8, -2, 2 },
  { 1485, 3, 4, 6, 4, -20 },
  { 1487, 10, 14, 12, 1, -14 },
  { 1505, 11, 20, 12, 0, -20 },
  { 1533, 8, 14, 9, 1, -14 },
  { 1547, 12, 20, 12, 1, -20 },
  { 1577, 9, 14, 10, 1, -14 },
  { 1593, 12, 26, 6, -3, -20 },
  { 1632, 11, 20, 12, 0, -14 },
  { 1660, 10, 20, 11, 0, -20 },
  { 1685, 6, 19, 5, 0, -19 },
  { 1700, 9, 25, 5, -3, -19 },
  { 1729, 11, 20, 10, 0, -20 },
  { 1757, 6, 20, 5, 0, -20 },
  { 1772, 16, 14, 17, 0, -14 },
  { 1800, 10, 14, 11, 0, -14 },
  { 1818, 9, 14, 11, 1, -14 },
  { 1834, 12, 20, 12, -1, -14 },
  { 1864, 10, 20, 12, 1, -14 },
  { 1889, 9, 14, 8, 0, -14 },
  { 1905, 9, 14, 9, 0, -14 },
  { 1921, 6, 17, 6, 1, -17 },
  { 1934, 10, 14, 11, 1, -14 },
  { 1952, 9, 14, 9, 1, -14 },
  { 1968, 14, 14, 14, 2, -14 },
  { 1993, 11, 14, 9, -1, -14 },
  { 2013, 14, 20, 9, -3, -14 },
  { 2048, 10, 14, 8, -1, -14 },
  { 2066, 9, 23, 8, 1, -19 },
  { 2092, 1, 26, 11, 5, -20 },
  { 2096, 9, 23, 8, -1, -19 },
  { 2122, 10, 3, 12, 1, -11 },
};

const GFXfont NotoSans_Condensed_LightItalic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic26pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC26PT7B_H_
