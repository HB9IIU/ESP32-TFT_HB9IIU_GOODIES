#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC37PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18,
  0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x20, 0x60, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0xE0, 0xC0, 0x73, 0xB1, 0x98, 0xCC, 0x64, 0x36, 0x33, 0x19, 0x8C,
  0x84, 0x00, 0x00, 0x61, 0x80, 0x10, 0x40, 0x0C, 0x30, 0x03, 0x0C, 0x00,
  0x82, 0x00, 0x61, 0x80, 0x18, 0x60, 0x7F, 0xFF, 0x1F, 0xFF, 0xC0, 0xC3,
  0x00, 0x30, 0xC0, 0x08, 0x20, 0x06, 0x18, 0x01, 0x86, 0x00, 0x41, 0x00,
  0x30, 0xC0, 0x7F, 0xFE, 0x3F, 0xFF, 0x81, 0x86, 0x00, 0x61, 0x80, 0x18,
  0x60, 0x04, 0x10, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x20, 0x80, 0x18, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x01, 0xFC, 0x03, 0xFF, 0x06,
  0x22, 0x0C, 0x60, 0x0C, 0x40, 0x08, 0x40, 0x08, 0x40, 0x0C, 0xC0, 0x0C,
  0xC0, 0x06, 0x80, 0x07, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x01,
  0x38, 0x01, 0x18, 0x01, 0x18, 0x03, 0x18, 0x02, 0x18, 0x02, 0x18, 0x82,
  0x30, 0xFF, 0xE0, 0x7F, 0xC0, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x00, 0xF8, 0x0C, 0x19, 0x80, 0x83, 0x08, 0x18, 0x20,
  0x83, 0x06, 0x08, 0x30, 0x60, 0x86, 0x04, 0x18, 0x40, 0x41, 0x8C, 0x0C,
  0x18, 0x80, 0xC1, 0x98, 0x0C, 0x33, 0x1E, 0xC3, 0x33, 0x6C, 0x26, 0x63,
  0xC6, 0x4C, 0x37, 0xCC, 0xC3, 0x39, 0x88, 0x30, 0x19, 0x83, 0x03, 0x18,
  0x20, 0x31, 0x86, 0x06, 0x10, 0x60, 0x41, 0x06, 0x0C, 0x30, 0x41, 0x83,
  0x0C, 0x18, 0x10, 0xC3, 0x01, 0x98, 0x70, 0x1F, 0x00, 0x00, 0x70, 0x01,
  0xF8, 0x03, 0x8C, 0x03, 0x0C, 0x02, 0x0C, 0x06, 0x0C, 0x06, 0x0C, 0x06,
  0x0C, 0x06, 0x18, 0x06, 0x30, 0x03, 0x70, 0x03, 0xE0, 0x03, 0x80, 0x07,
  0x80, 0x0D, 0x80, 0x18, 0xC3, 0x30, 0xC3, 0x70, 0xE3, 0x60, 0x66, 0x60,
  0x66, 0xC0, 0x3C, 0xC0, 0x38, 0xC0, 0x38, 0xC0, 0x78, 0x60, 0xFC, 0x7B,
  0xCC, 0x3F, 0x0E, 0x76, 0x66, 0x4C, 0xCC, 0x80, 0x00, 0xE0, 0x30, 0x0C,
  0x01, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x01, 0x80, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x07, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00,
  0x03, 0x00, 0x30, 0x02, 0x0C, 0x20, 0xF2, 0x01, 0xFF, 0x07, 0xF0, 0xE0,
  0x1B, 0x03, 0x10, 0x61, 0x84, 0x1C, 0x01, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x0C, 0x71, 0x86, 0x30, 0xC6, 0x18, 0xC0, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xF0, 0x0F, 0xE0, 0x71, 0xC1, 0x83, 0x0C, 0x0C, 0x30, 0x31, 0x80, 0xC6,
  0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xD8, 0x03, 0x60, 0x0D, 0x80, 0x36,
  0x01, 0xD8, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x03, 0x30, 0x0C, 0xC0, 0x33,
  0x01, 0x8C, 0x06, 0x18, 0x30, 0x61, 0xC1, 0xFE, 0x03, 0xF0, 0x00, 0x07,
  0x0F, 0x3E, 0x76, 0xE6, 0x86, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60,
  0xC0, 0x00, 0x78, 0x01, 0xFE, 0x07, 0x87, 0x02, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x70, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0xF0, 0x0F, 0xF8, 0x38,
  0x38, 0x20, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x7E, 0x00, 0xF8, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x38, 0x80, 0xE1, 0xE7, 0x83, 0xFE, 0x00, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0x60, 0x0D, 0x80, 0x1B, 0x00,
  0x66, 0x01, 0x8C, 0x03, 0x10, 0x0C, 0x60, 0x30, 0xC0, 0x41, 0x81, 0x83,
  0x06, 0x0C, 0x18, 0x18, 0x30, 0x30, 0xC0, 0x63, 0x00, 0xC7, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x03, 0xFF, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x1F, 0xC0, 0x1F,
  0xF0, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x80,
  0xE0, 0xF7, 0xC0, 0xFF, 0x80, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0xBF, 0x06, 0xE7, 0x0F, 0x07, 0x1C, 0x06, 0x30, 0x0C, 0x60,
  0x19, 0xC0, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x03, 0x98, 0x06, 0x30, 0x0C,
  0x30, 0x30, 0x60, 0xE0, 0x77, 0x80, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0xF0, 0x03,
  0xFC, 0x07, 0x0E, 0x06, 0x06, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x0C,
  0x06, 0x0C, 0x06, 0x0E, 0x0C, 0x06, 0x1C, 0x03, 0x38, 0x03, 0xE0, 0x03,
  0xC0, 0x0E, 0x60, 0x1C, 0x30, 0x30, 0x38, 0x60, 0x18, 0x60, 0x18, 0xC0,
  0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0x60, 0x38, 0x60, 0x30, 0x3D,
  0xE0, 0x1F, 0xC0, 0x00, 0xF0, 0x07, 0xF0, 0x1C, 0x30, 0x30, 0x30, 0xC0,
  0x61, 0x80, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x0C, 0xC0, 0x19,
  0x80, 0x71, 0x80, 0xE3, 0x03, 0x87, 0x0F, 0x07, 0xF6, 0x07, 0x8C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0xC1, 0xDF, 0x03, 0xF8, 0x00, 0x04, 0x1C, 0x38, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x87, 0x00,
  0x01, 0x81, 0xC0, 0xE0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0E, 0x06, 0x03, 0x03, 0x01,
  0x81, 0x80, 0xC0, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x0C, 0x00, 0x20, 0x00, 0x07, 0x83, 0xFE, 0x18, 0x60,
  0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0xC0,
  0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x03, 0x81, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x06, 0x06,
  0x00, 0x08, 0x30, 0x00, 0x30, 0x80, 0x00, 0xC6, 0x07, 0xE3, 0x10, 0x73,
  0x0C, 0xC1, 0x8C, 0x32, 0x0C, 0x30, 0xD8, 0x60, 0xC3, 0x61, 0x82, 0x09,
  0x8C, 0x18, 0x24, 0x30, 0x61, 0x90, 0xC1, 0x86, 0xC3, 0x0C, 0x13, 0x08,
  0x30, 0xCC, 0x31, 0xC2, 0x30, 0xC5, 0x18, 0xC3, 0xE7, 0xC3, 0x07, 0x0E,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x8E, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xD0, 0x01, 0xA0, 0x02, 0x40, 0x0C, 0x80, 0x19, 0x80, 0x63, 0x00,
  0xC6, 0x03, 0x0C, 0x06, 0x18, 0x18, 0x30, 0x30, 0x60, 0xC0, 0xC1, 0x81,
  0x87, 0xFF, 0x0F, 0xFE, 0x18, 0x0C, 0x60, 0x18, 0xC0, 0x33, 0x00, 0x66,
  0x00, 0xD8, 0x01, 0xB0, 0x03, 0xE0, 0x07, 0x80, 0x0C, 0x07, 0xFC, 0x06,
  0x1E, 0x06, 0x07, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x1C,
  0x07, 0x18, 0x06, 0x18, 0x0E, 0x18, 0x1C, 0x1F, 0xF0, 0x3F, 0xE0, 0x30,
  0x38, 0x30, 0x18, 0x30, 0x0C, 0x30, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60,
  0x0C, 0x60, 0x1C, 0x60, 0x18, 0xC0, 0x38, 0xC0, 0x70, 0xFF, 0xE0, 0xFF,
  0x80, 0x00, 0x3C, 0x01, 0xFF, 0x03, 0x83, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0x3F, 0x01,
  0x81, 0xC1, 0x80, 0x60, 0xC0, 0x38, 0x60, 0x0C, 0x30, 0x06, 0x30, 0x03,
  0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x33, 0x00, 0x39, 0x80,
  0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x07, 0x30, 0x03, 0x18, 0x03, 0x8C,
  0x01, 0x86, 0x01, 0xC3, 0x01, 0xC3, 0x01, 0xC1, 0x83, 0xC0, 0xFF, 0xC0,
  0x7F, 0x00, 0x00, 0x07, 0xFE, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xFF, 0x83, 0xFF, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFE, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0x3C, 0x1C,
  0x1C, 0x01, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x0C, 0x03, 0xF3, 0x01, 0x0C, 0xC0, 0x07, 0x30, 0x01, 0x8C, 0x00, 0x63,
  0x00, 0x18, 0xC0, 0x06, 0x30, 0x03, 0x0E, 0x00, 0xC1, 0x80, 0x30, 0x70,
  0x0C, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x18,
  0x03, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x70, 0xE0,
  0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x06, 0x0F, 0xFF, 0x83, 0xFF,
  0xF0, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x06, 0x0C, 0x00,
  0xC1, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x61, 0xC0, 0x18, 0x30, 0x03,
  0x06, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x03, 0x00, 0x07, 0xF0, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x0F, 0xE0, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x1C, 0x08, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x06, 0x01, 0xC1,
  0x80, 0xC0, 0x60, 0x60, 0x30, 0x38, 0x0C, 0x1C, 0x03, 0x06, 0x00, 0xC3,
  0x00, 0x61, 0x80, 0x18, 0xE0, 0x06, 0x70, 0x01, 0xB8, 0x00, 0x6C, 0x00,
  0x37, 0x80, 0x0F, 0x60, 0x03, 0x98, 0x00, 0xC6, 0x00, 0x30, 0xC0, 0x18,
  0x30, 0x06, 0x0C, 0x01, 0x81, 0x80, 0x60, 0x60, 0x38, 0x18, 0x0C, 0x07,
  0x03, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x0E, 0x00, 0x06, 0x01, 0x80, 0x60,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C,
  0x03, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x07, 0x83, 0x80, 0x03, 0x81,
  0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xB0, 0x68, 0x00, 0xF0,
  0x36, 0x00, 0xD8, 0x33, 0x00, 0x6C, 0x19, 0x80, 0x66, 0x0C, 0xC0, 0x36,
  0x06, 0x60, 0x33, 0x03, 0x30, 0x19, 0x83, 0x18, 0x18, 0xC1, 0x8C, 0x0C,
  0x60, 0xC6, 0x0C, 0x60, 0x63, 0x06, 0x30, 0x31, 0x86, 0x18, 0x30, 0x43,
  0x0C, 0x18, 0x23, 0x06, 0x0C, 0x19, 0x86, 0x06, 0x0D, 0x83, 0x06, 0x06,
  0xC1, 0x83, 0x03, 0xC0, 0xC1, 0x81, 0xE0, 0x60, 0xC0, 0xE0, 0x60, 0x60,
  0x70, 0x30, 0x00, 0x07, 0x00, 0x30, 0x70, 0x06, 0x07, 0x00, 0x60, 0xF0,
  0x06, 0x0D, 0x80, 0x60, 0xD8, 0x06, 0x0D, 0x80, 0xC1, 0x98, 0x0C, 0x18,
  0xC0, 0xC1, 0x8C, 0x0C, 0x18, 0xC1, 0x81, 0x8C, 0x18, 0x30, 0x61, 0x83,
  0x06, 0x18, 0x30, 0x61, 0x83, 0x06, 0x30, 0x30, 0x33, 0x06, 0x03, 0x30,
  0x60, 0x33, 0x06, 0x03, 0x30, 0x60, 0x1E, 0x0C, 0x01, 0xE0, 0xC0, 0x1E,
  0x0C, 0x01, 0xE0, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0x00, 0x70, 0x00, 0xFF,
  0x01, 0xE1, 0xC0, 0xC0, 0x60, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x60,
  0x03, 0x30, 0x01, 0xB8, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x01,
  0xD8, 0x00, 0xCC, 0x00, 0xE6, 0x00, 0x63, 0x00, 0x71, 0xC0, 0x30, 0x70,
  0x70, 0x1E, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x0C, 0x78, 0x18, 0x38,
  0x60, 0x30, 0xC0, 0x61, 0x80, 0xC3, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30,
  0x0C, 0x60, 0x30, 0xC0, 0xE3, 0x03, 0x87, 0xFE, 0x0F, 0xF0, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0xFF, 0x01,
  0xE1, 0xC0, 0xC0, 0x60, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x60, 0x03,
  0x30, 0x01, 0xB8, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x01, 0xD8,
  0x00, 0xCC, 0x00, 0xE6, 0x00, 0x63, 0x00, 0x71, 0xC0, 0x30, 0x70, 0x70,
  0x1E, 0xF0, 0x07, 0xF0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x07, 0xF8, 0x0C, 0x78, 0x18, 0x38,
  0x60, 0x30, 0xC0, 0x61, 0x80, 0xC3, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30,
  0x1C, 0x60, 0x30, 0xC0, 0xE3, 0x07, 0x87, 0xFC, 0x0F, 0xF0, 0x18, 0x60,
  0x30, 0xC0, 0xC1, 0x81, 0x83, 0x03, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0x30,
  0x18, 0x60, 0x18, 0xC0, 0x31, 0x80, 0x60, 0x00, 0x78, 0x03, 0xFF, 0x07,
  0x06, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x80, 0xE0, 0xFF, 0xC0, 0xFF,
  0x80, 0xFF, 0xFC, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0xC3, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00,
  0x63, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x61,
  0x80, 0x18, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x30, 0xC0,
  0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x06,
  0x0C, 0x03, 0x03, 0x81, 0xC0, 0x7F, 0xE0, 0x0F, 0xE0, 0x00, 0xC0, 0x07,
  0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0x60, 0x18, 0x60, 0x38,
  0x60, 0x30, 0x60, 0x70, 0x60, 0x60, 0x60, 0x60, 0x60, 0xC0, 0x60, 0xC0,
  0x61, 0x80, 0x61, 0x80, 0x63, 0x00, 0x63, 0x00, 0x67, 0x00, 0x66, 0x00,
  0x66, 0x00, 0x6C, 0x00, 0x6C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x80, 0x18, 0x03, 0x80, 0x38, 0x07, 0x80, 0x38, 0x06, 0x80,
  0x78, 0x06, 0x80, 0x78, 0x0C, 0x80, 0x58, 0x0C, 0x80, 0xD8, 0x18, 0x80,
  0xD8, 0x18, 0x81, 0x98, 0x18, 0x81, 0x98, 0x30, 0x83, 0x18, 0x30, 0x83,
  0x18, 0x60, 0x82, 0x18, 0x60, 0x86, 0x18, 0xE0, 0x86, 0x18, 0xC0, 0x8C,
  0x18, 0xC0, 0x8C, 0x19, 0x80, 0x88, 0x19, 0x80, 0x98, 0x1B, 0x00, 0x98,
  0x1B, 0x00, 0xB0, 0x1B, 0x00, 0xB0, 0x1E, 0x00, 0xA0, 0x1E, 0x00, 0xE0,
  0x1C, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x00, 0xE0, 0x30,
  0x18, 0x06, 0x06, 0x00, 0xC1, 0xC0, 0x18, 0x30, 0x03, 0x0C, 0x00, 0x31,
  0x80, 0x06, 0x60, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x68, 0x00, 0x0D, 0x80, 0x03, 0x30,
  0x00, 0xC6, 0x00, 0x18, 0xC0, 0x06, 0x18, 0x01, 0xC1, 0x80, 0x30, 0x30,
  0x0C, 0x06, 0x03, 0x80, 0xC0, 0x60, 0x18, 0x18, 0x01, 0x80, 0xC0, 0x1D,
  0x80, 0x66, 0x03, 0x18, 0x0C, 0x60, 0x61, 0x81, 0x86, 0x0C, 0x18, 0x70,
  0x21, 0x80, 0xCC, 0x03, 0x30, 0x0D, 0x80, 0x36, 0x00, 0xF0, 0x03, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x00, 0x03, 0xFF, 0x82, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xFF,
  0xF0, 0x7F, 0xF8, 0x00, 0x01, 0xFC, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0xE0, 0x3F, 0x80,
  0xC6, 0x31, 0x8C, 0x21, 0x8C, 0x63, 0x18, 0xC2, 0x18, 0xC6, 0x31, 0x8C,
  0x21, 0x8C, 0x63, 0x18, 0xC0, 0x03, 0xF8, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0xC0, 0x03,
  0x80, 0x0D, 0x80, 0x1B, 0x00, 0x66, 0x00, 0xC6, 0x03, 0x0C, 0x06, 0x0C,
  0x18, 0x18, 0x60, 0x30, 0xC0, 0x33, 0x00, 0x66, 0x00, 0xD8, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xE3, 0x0C, 0x61, 0x84, 0x03, 0xE6, 0x0F, 0xEC, 0x38,
  0x58, 0xE0, 0xE1, 0x80, 0xC6, 0x01, 0x8C, 0x03, 0x30, 0x06, 0x60, 0x18,
  0xC0, 0x31, 0x80, 0x67, 0x00, 0xCC, 0x03, 0x98, 0x06, 0x30, 0x0C, 0x60,
  0x38, 0xE0, 0xF0, 0xC1, 0x41, 0xCC, 0x81, 0xF3, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x04, 0x78, 0x1B, 0xF8, 0x34, 0x38, 0x70, 0x30, 0xE0, 0x63, 0x80, 0xC7,
  0x01, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00,
  0xC6, 0x01, 0x8C, 0x07, 0x38, 0x0C, 0x70, 0x38, 0xF0, 0xE1, 0x33, 0x86,
  0x7E, 0x00, 0x01, 0xF0, 0x7F, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x79, 0x83, 0xF8, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x03, 0xE6, 0x03, 0xFB, 0x03, 0x85, 0x83, 0x81, 0xC1, 0x80, 0xC1,
  0x80, 0x60, 0xC0, 0x30, 0xC0, 0x18, 0x60, 0x1C, 0x30, 0x0C, 0x18, 0x06,
  0x18, 0x03, 0x0C, 0x03, 0x86, 0x01, 0x83, 0x00, 0xC1, 0x80, 0xE0, 0xC0,
  0xF0, 0x30, 0x58, 0x1C, 0xC8, 0x07, 0xCC, 0x00, 0x01, 0xE0, 0x3F, 0x83,
  0x86, 0x30, 0x31, 0x81, 0x98, 0x0C, 0xC0, 0xCC, 0x0E, 0x60, 0xE3, 0xFC,
  0x1F, 0x81, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x1E, 0x70, 0x7F, 0x80, 0x00, 0x07, 0xC0, 0x03, 0xB0, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x7E, 0x00, 0x7F, 0x80, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF1, 0x03, 0xFB, 0x07, 0x0B, 0x0E,
  0x0F, 0x0C, 0x06, 0x18, 0x06, 0x18, 0x06, 0x30, 0x06, 0x30, 0x0E, 0x30,
  0x0C, 0x30, 0x0C, 0x60, 0x0C, 0x60, 0x1C, 0x60, 0x18, 0x60, 0x18, 0x60,
  0x38, 0x70, 0x78, 0x30, 0xD8, 0x39, 0xB0, 0x1F, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x81, 0xC0, 0xFF,
  0x80, 0x3E, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x78, 0x1B, 0xF8, 0x3C, 0x38,
  0x70, 0x30, 0xC0, 0x63, 0x80, 0xC6, 0x01, 0x8C, 0x06, 0x18, 0x0C, 0x30,
  0x18, 0xC0, 0x31, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x0C, 0x06, 0x30, 0x0C,
  0x60, 0x30, 0xC0, 0x61, 0x80, 0xC7, 0x01, 0x80, 0x03, 0x07, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0xC0, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x3E, 0x01, 0xE0, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x06, 0x18, 0x18, 0x30, 0x60, 0x61, 0x80, 0xC7, 0x03, 0x0C,
  0x06, 0x30, 0x0C, 0xC0, 0x1B, 0x00, 0x3F, 0x00, 0xF6, 0x01, 0xCC, 0x03,
  0x18, 0x06, 0x18, 0x0C, 0x30, 0x30, 0x60, 0x60, 0xE0, 0xC0, 0xC1, 0x81,
  0x86, 0x03, 0x00, 0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0xC0, 0x04, 0x78, 0x7C, 0x1B, 0xF9,
  0xFC, 0x3C, 0x36, 0x18, 0x70, 0x78, 0x30, 0xC0, 0xE0, 0x63, 0x81, 0xC0,
  0xC6, 0x03, 0x01, 0x8C, 0x06, 0x03, 0x18, 0x0C, 0x0C, 0x30, 0x30, 0x18,
  0xC0, 0x60, 0x31, 0x80, 0xC0, 0x63, 0x01, 0x80, 0xC6, 0x03, 0x03, 0x0C,
  0x0C, 0x06, 0x30, 0x18, 0x0C, 0x60, 0x30, 0x18, 0xC0, 0x60, 0x21, 0x80,
  0xC0, 0xC6, 0x03, 0x01, 0x80, 0x0C, 0x78, 0x1B, 0xF8, 0x3C, 0x38, 0x70,
  0x30, 0xC0, 0x63, 0x80, 0xC6, 0x03, 0x8C, 0x06, 0x18, 0x0C, 0x30, 0x18,
  0xC0, 0x31, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x0C, 0x06, 0x30, 0x0C, 0x60,
  0x30, 0xC0, 0x61, 0x80, 0xC7, 0x01, 0x80, 0x03, 0xE0, 0x1F, 0xC0, 0xC1,
  0x86, 0x07, 0x18, 0x0C, 0xC0, 0x33, 0x00, 0xD8, 0x03, 0x60, 0x0D, 0x80,
  0x36, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x03, 0x30, 0x0C, 0xE0,
  0x61, 0x83, 0x87, 0xBC, 0x0F, 0xC0, 0x02, 0x3C, 0x06, 0x7E, 0x06, 0x87,
  0x07, 0x03, 0x07, 0x03, 0x0E, 0x03, 0x0E, 0x03, 0x0C, 0x03, 0x0C, 0x03,
  0x0C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x06, 0x18, 0x06, 0x18, 0x06,
  0x38, 0x0C, 0x38, 0x1C, 0x3C, 0x38, 0x36, 0x70, 0x37, 0xE0, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x03, 0xE2, 0x0F, 0xEC, 0x38, 0x58, 0xE0, 0xF1,
  0x80, 0xC6, 0x01, 0x8C, 0x03, 0x30, 0x06, 0x60, 0x1C, 0xC0, 0x31, 0x80,
  0x66, 0x00, 0xCC, 0x03, 0x98, 0x06, 0x30, 0x0C, 0x60, 0x38, 0xC0, 0xF0,
  0xC1, 0x61, 0xCD, 0x81, 0xF3, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x04,
  0x70, 0xDF, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0C, 0x00, 0x07, 0xE0, 0xFF, 0x18, 0x13, 0x80, 0x30,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC8, 0x18, 0xE7, 0x8F, 0xF0, 0x04,
  0x06, 0x03, 0x01, 0x81, 0xFB, 0xFC, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x90, 0xF0, 0x18, 0x06, 0x30, 0x18, 0x60, 0x30, 0xC0, 0x61, 0x80, 0xC6,
  0x01, 0x8C, 0x06, 0x18, 0x0C, 0x30, 0x18, 0xC0, 0x31, 0x80, 0x63, 0x01,
  0x86, 0x03, 0x0C, 0x06, 0x30, 0x1C, 0x60, 0x38, 0xC0, 0xE1, 0xC3, 0xC1,
  0xDD, 0x83, 0xF3, 0x00, 0xC0, 0x3E, 0x01, 0xB0, 0x1D, 0x80, 0xCC, 0x06,
  0x60, 0x63, 0x03, 0x18, 0x30, 0xC1, 0x86, 0x18, 0x10, 0xC0, 0x8C, 0x04,
  0x60, 0x36, 0x01, 0xB0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x00, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0xE0, 0x6C, 0x0E, 0x06, 0xC1,
  0xA0, 0xCC, 0x1A, 0x0C, 0xC1, 0x20, 0xCC, 0x32, 0x18, 0xC2, 0x21, 0x8C,
  0x62, 0x30, 0xC6, 0x23, 0x0C, 0xC2, 0x30, 0xCC, 0x26, 0x0C, 0x82, 0x60,
  0xD8, 0x2C, 0x0D, 0x82, 0xC0, 0xF0, 0x28, 0x0F, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x00, 0x06, 0x03, 0x06, 0x07, 0x03, 0x06, 0x03, 0x0C, 0x03,
  0x1C, 0x03, 0x18, 0x01, 0xB0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0x40, 0x06, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x18,
  0x30, 0x30, 0x30, 0x70, 0x30, 0xE0, 0x38, 0x03, 0x00, 0x60, 0x60, 0x18,
  0x04, 0x03, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x07, 0x00, 0x60, 0xC0,
  0x0C, 0x18, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x30, 0x00, 0xC6, 0x00,
  0x19, 0x80, 0x03, 0x30, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x7E,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x0E, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x3F, 0xF1, 0xFF,
  0x80, 0x00, 0x78, 0x07, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00,
  0xE0, 0x1E, 0x00, 0xF0, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x03, 0x00,
  0x18, 0x00, 0xF8, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x80, 0x07, 0x00, 0xF8, 0x0E, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C,
  0x00, 0xC0, 0x0E, 0x03, 0xE0, 0x1C, 0x00, 0x7C, 0x07, 0xFC, 0x38, 0x3F,
  0xE0, 0x3C,
};

const GFXglyph NotoSans_Condensed_LightItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 26, 8, 1, -26 },
  { 27, 9, 9, 12, 4, -26 },
  { 38, 18, 26, 17, 0, -26 },
  { 97, 16, 30, 16, 0, -28 },
  { 157, 20, 27, 23, 2, -27 },
  { 225, 16, 27, 17, 0, -27 },
  { 279, 4, 9, 6, 4, -26 },
  { 284, 11, 32, 9, 1, -26 },
  { 328, 11, 32, 9, -3, -26 },
  { 372, 12, 13, 15, 4, -28 },
  { 392, 14, 18, 17, 2, -22 },
  { 424, 6, 9, 7, -2, -4 },
  { 431, 8, 2, 10, 1, -11 },
  { 433, 3, 3, 7, 1, -3 },
  { 435, 17, 26, 12, -2, -26 },
  { 491, 14, 27, 16, 1, -27 },
  { 539, 8, 26, 16, 5, -26 },
  { 565, 16, 27, 16, -1, -27 },
  { 619, 15, 27, 16, 0, -27 },
  { 670, 15, 27, 16, 0, -27 },
  { 721, 16, 26, 16, 0, -26 },
  { 773, 15, 27, 16, 1, -27 },
  { 824, 15, 26, 16, 2, -26 },
  { 873, 16, 27, 16, 0, -27 },
  { 927, 15, 27, 16, 0, -27 },
  { 978, 7, 20, 7, 0, -20 },
  { 996, 9, 25, 7, -2, -20 },
  { 1025, 14, 16, 17, 2, -21 },
  { 1053, 14, 10, 17, 2, -18 },
  { 1071, 14, 16, 17, 2, -21 },
  { 1099, 12, 27, 11, 1, -27 },
  { 1140, 22, 29, 24, 1, -26 },
  { 1220, 15, 26, 16, -2, -26 },
  { 1269, 16, 26, 17, 1, -26 },
  { 1321, 16, 27, 16, 2, -27 },
  { 1375, 17, 26, 19, 1, -26 },
  { 1431, 15, 26, 15, 1, -26 },
  { 1480, 15, 26, 14, 1, -26 },
  { 1529, 18, 27, 20, 2, -27 },
  { 1590, 19, 26, 20, 1, -26 },
  { 1652, 12, 26, 9, -1, -26 },
  { 1691, 14, 33, 7, -6, -26 },
  { 1749, 18, 26, 16, 1, -26 },
  { 1808, 10, 26, 14, 1, -26 },
  { 1841, 25, 26, 25, 1, -26 },
  { 1923, 20, 26, 20, 1, -26 },
  { 1988, 17, 27, 20, 2, -27 },
  { 2046, 15, 26, 16, 1, -26 },
  { 2095, 17, 33, 20, 2, -27 },
  { 2166, 15, 26, 16, 1, -26 },
  { 2215, 16, 27, 15, 0, -27 },
  { 2269, 14, 26, 14, 3, -26 },
  { 2315, 18, 26, 19, 2, -26 },
  { 2374, 16, 26, 16, 3, -26 },
  { 2426, 24, 26, 26, 4, -26 },
  { 2504, 19, 26, 14, -2, -26 },
  { 2566, 14, 26, 14, 3, -26 },
  { 2612, 17, 26, 14, -1, -26 },
  { 2668, 14, 32, 11, -1, -26 },
  { 2724, 5, 26, 12, 4, -26 },
  { 2741, 13, 32, 11, -2, -26 },
  { 2793, 15, 14, 16, 1, -26 },
  { 2820, 12, 2, 12, -3, 3 },
  { 2823, 5, 6, 9, 5, -28 },
  { 2827, 15, 20, 17, 1, -20 },
  { 2865, 15, 28, 17, 0, -28 },
  { 2918, 12, 20, 13, 1, -20 },
  { 2948, 17, 28, 17, 1, -28 },
  { 3008, 13, 20, 15, 1, -20 },
  { 3041, 18, 37, 9, -5, -28 },
  { 3125, 16, 29, 17, 0, -20 },
  { 3183, 15, 28, 16, 0, -28 },
  { 3236, 8, 27, 7, 0, -27 },
  { 3263, 13, 36, 7, -5, -27 },
  { 3322, 15, 28, 14, 0, -28 },
  { 3375, 8, 28, 7, 0, -28 },
  { 3403, 23, 20, 25, 0, -20 },
  { 3461, 15, 20, 16, 0, -20 },
  { 3499, 14, 20, 16, 1, -20 },
  { 3534, 16, 29, 17, -1, -20 },
  { 3592, 15, 29, 17, 1, -20 },
  { 3647, 12, 20, 11, 0, -20 },
  { 3677, 12, 20, 12, 0, -20 },
  { 3707, 9, 24, 9, 1, -24 },
  { 3734, 15, 20, 16, 1, -20 },
  { 3772, 13, 20, 13, 2, -20 },
  { 3805, 20, 20, 21, 2, -20 },
  { 3855, 16, 20, 13, -2, -20 },
  { 3895, 19, 29, 13, -4, -20 },
  { 3964, 13, 20, 12, -1, -20 },
  { 3997, 13, 32, 12, 1, -26 },
  { 4049, 2, 37, 15, 7, -28 },
  { 4059, 13, 32, 12, -2, -26 },
  { 4111, 14, 4, 17, 2, -15 },
};

const GFXfont NotoSans_Condensed_LightItalic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic37pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC37PT7B_H_
