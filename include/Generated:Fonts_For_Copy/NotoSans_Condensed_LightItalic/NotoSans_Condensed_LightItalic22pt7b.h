#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC22PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x46, 0x21, 0x08, 0x44, 0x21, 0x08, 0xC0, 0x01, 0x18, 0x4D,
  0x24, 0x92, 0x8A, 0x40, 0x04, 0x40, 0x88, 0x12, 0x04, 0x40, 0x88, 0x7F,
  0xC2, 0x40, 0x88, 0x11, 0x02, 0x43, 0xFE, 0x11, 0x02, 0x40, 0x88, 0x11,
  0x02, 0x40, 0x02, 0x01, 0x03, 0xE3, 0x53, 0x41, 0x20, 0x90, 0x28, 0x18,
  0x06, 0x02, 0x81, 0x20, 0x90, 0x9A, 0x58, 0xF8, 0x10, 0x08, 0x00, 0x18,
  0x22, 0x44, 0x44, 0x44, 0x48, 0x44, 0x88, 0x90, 0x89, 0x68, 0xA9, 0x94,
  0x96, 0x51, 0x09, 0x10, 0x91, 0x12, 0x23, 0x22, 0x23, 0x24, 0x1C, 0x07,
  0x02, 0x41, 0x10, 0x44, 0x11, 0x04, 0x81, 0xE0, 0x20, 0x3C, 0x19, 0x34,
  0x4B, 0x0A, 0x83, 0x20, 0xCC, 0x51, 0xE6, 0x69, 0x29, 0x00, 0x04, 0x21,
  0x0C, 0x21, 0x84, 0x10, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0C,
  0x00, 0x04, 0x08, 0x10, 0x30, 0x20, 0x40, 0x81, 0x02, 0x0C, 0x10, 0x20,
  0x41, 0x02, 0x08, 0x10, 0x43, 0x00, 0x08, 0x08, 0xC8, 0x36, 0x19, 0x28,
  0x44, 0x04, 0x08, 0x04, 0x02, 0x01, 0x00, 0x87, 0xFC, 0x20, 0x10, 0x08,
  0x04, 0x00, 0x25, 0x28, 0x7F, 0xC0, 0x70, 0x00, 0xC0, 0x20, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x10,
  0x04, 0x02, 0x00, 0x0E, 0x13, 0x21, 0x21, 0x41, 0x41, 0x41, 0x81, 0x83,
  0x82, 0x82, 0x82, 0x84, 0x84, 0x88, 0x70, 0x19, 0x95, 0x21, 0x18, 0x84,
  0x21, 0x18, 0x84, 0x21, 0x10, 0x0F, 0x08, 0xC0, 0x20, 0x10, 0x08, 0x0C,
  0x04, 0x06, 0x06, 0x02, 0x02, 0x02, 0x02, 0x02, 0x03, 0x01, 0xFC, 0x0F,
  0x08, 0xC0, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x3C, 0x06, 0x01, 0x00, 0xC0,
  0x20, 0x30, 0x12, 0x19, 0xF8, 0x01, 0x80, 0xC0, 0xA0, 0xE0, 0x50, 0x48,
  0x44, 0x26, 0x22, 0x21, 0x10, 0x9F, 0xF0, 0x60, 0x20, 0x10, 0x08, 0x0F,
  0x88, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x7C, 0x03, 0x00, 0x80, 0x40,
  0x20, 0x30, 0x12, 0x19, 0xF0, 0x07, 0x8C, 0x04, 0x04, 0x06, 0x02, 0x01,
  0x71, 0xCC, 0xC2, 0x41, 0x20, 0x90, 0x48, 0x24, 0x33, 0x10, 0xF0, 0x7F,
  0x80, 0x40, 0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06,
  0x02, 0x03, 0x01, 0x01, 0x80, 0x0F, 0x0C, 0xC4, 0x26, 0x13, 0x08, 0x8C,
  0x4C, 0x18, 0x16, 0x31, 0x10, 0x50, 0x28, 0x14, 0x19, 0x08, 0xF8, 0x0F,
  0x0C, 0x8C, 0x24, 0x12, 0x09, 0x05, 0x86, 0x43, 0x23, 0x0E, 0x80, 0x40,
  0x60, 0x20, 0x20, 0x31, 0xF0, 0x13, 0x00, 0x00, 0x00, 0x00, 0xCC, 0x08,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x08, 0xC4, 0x22, 0x00, 0x00, 0x81, 0x83,
  0x87, 0x0E, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x1C, 0x18,
  0x30, 0x60, 0x40, 0x00, 0x38, 0x88, 0x18, 0x30, 0x40, 0x82, 0x08, 0x20,
  0x81, 0x02, 0x00, 0x00, 0x20, 0x40, 0x03, 0xC0, 0x61, 0x04, 0x04, 0x40,
  0x22, 0x00, 0xA3, 0xC5, 0x32, 0x31, 0x12, 0x98, 0x94, 0x88, 0xA4, 0x45,
  0x26, 0x49, 0xF6, 0x44, 0x42, 0x00, 0x18, 0x00, 0x61, 0x01, 0xF0, 0x00,
  0x01, 0x01, 0x80, 0xC0, 0xA0, 0x50, 0x68, 0x26, 0x13, 0x11, 0x8F, 0xC8,
  0x24, 0x16, 0x0A, 0x07, 0x03, 0x01, 0x0F, 0x06, 0x71, 0x04, 0x41, 0x10,
  0x44, 0x33, 0x08, 0xFC, 0x23, 0x08, 0x66, 0x09, 0x02, 0x41, 0x90, 0x44,
  0x33, 0xF0, 0x07, 0x83, 0x11, 0x00, 0x80, 0x20, 0x10, 0x04, 0x03, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x30, 0x04, 0x00, 0xF8, 0x0F, 0x03,
  0x30, 0x41, 0x08, 0x21, 0x06, 0x20, 0xCC, 0x19, 0x03, 0x20, 0x44, 0x09,
  0x83, 0x20, 0x44, 0x18, 0x82, 0x11, 0x87, 0xE0, 0x0F, 0xC6, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x03, 0x00, 0xFC, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x03, 0xF8, 0x0F, 0xC6, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03,
  0x00, 0x80, 0x3F, 0x08, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00,
  0x07, 0xC1, 0x8C, 0x40, 0x10, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0x83,
  0xD0, 0x12, 0x02, 0x40, 0x48, 0x09, 0x83, 0x18, 0x41, 0xF8, 0x08, 0x11,
  0x83, 0x10, 0x21, 0x02, 0x10, 0x21, 0x02, 0x30, 0x63, 0xFC, 0x20, 0x42,
  0x04, 0x60, 0xC4, 0x08, 0x40, 0x84, 0x08, 0x40, 0x8C, 0x18, 0x1F, 0x04,
  0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20,
  0x20, 0xF0, 0x01, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04,
  0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x30, 0xE0, 0x08, 0x23,
  0x08, 0x42, 0x08, 0xC1, 0x30, 0x2C, 0x0D, 0x01, 0x60, 0x34, 0x04, 0x81,
  0x90, 0x23, 0x04, 0x20, 0x84, 0x10, 0xC6, 0x08, 0x08, 0x30, 0x40, 0x81,
  0x02, 0x0C, 0x10, 0x20, 0x41, 0x82, 0x04, 0x08, 0x10, 0xFE, 0x08, 0x06,
  0x30, 0x0C, 0x70, 0x28, 0xE0, 0x71, 0x41, 0x42, 0x82, 0x89, 0x09, 0x12,
  0x16, 0x24, 0x48, 0x48, 0x91, 0x92, 0x22, 0x24, 0x44, 0x51, 0x88, 0xA2,
  0x11, 0x84, 0x63, 0x08, 0x08, 0x11, 0x81, 0x1C, 0x11, 0x43, 0x14, 0x21,
  0x42, 0x26, 0x22, 0x22, 0x22, 0x62, 0x24, 0x62, 0x44, 0x14, 0x41, 0x44,
  0x1C, 0x41, 0x8C, 0x08, 0x07, 0x86, 0x31, 0x04, 0x81, 0x60, 0x50, 0x14,
  0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x02, 0x81, 0xB0, 0x44, 0x20, 0xF0,
  0x0F, 0x06, 0x61, 0x0C, 0x41, 0x10, 0x44, 0x33, 0x08, 0x86, 0x3F, 0x0E,
  0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x07, 0x86, 0x31, 0x04,
  0x81, 0x60, 0x50, 0x14, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x02, 0x81,
  0xB0, 0x44, 0x20, 0xF0, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x0F, 0x06, 0x61,
  0x0C, 0x41, 0x10, 0xC4, 0x33, 0x08, 0x86, 0x3E, 0x09, 0x06, 0x61, 0x08,
  0x42, 0x10, 0x84, 0x33, 0x0C, 0x0F, 0x8C, 0x4C, 0x04, 0x02, 0x01, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x20, 0x12, 0x19, 0xF8, 0xFF,
  0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40,
  0x40, 0xC0, 0x80, 0x30, 0x24, 0x0C, 0x81, 0x10, 0x22, 0x04, 0xC1, 0x90,
  0x22, 0x04, 0x40, 0x88, 0x13, 0x06, 0x40, 0x88, 0x11, 0x06, 0x30, 0x83,
  0xE0, 0x80, 0xC0, 0xE0, 0x50, 0x68, 0x24, 0x32, 0x11, 0x08, 0x88, 0x44,
  0x24, 0x12, 0x0F, 0x07, 0x03, 0x80, 0x80, 0x81, 0x07, 0x06, 0x0A, 0x0C,
  0x14, 0x18, 0x68, 0x50, 0x90, 0xA3, 0x22, 0x44, 0x44, 0x88, 0x99, 0x21,
  0x22, 0x42, 0x45, 0x85, 0x0A, 0x0A, 0x14, 0x1C, 0x30, 0x30, 0x60, 0x60,
  0xC0, 0x18, 0x21, 0x08, 0x23, 0x04, 0x40, 0xD8, 0x0A, 0x01, 0x80, 0x30,
  0x06, 0x01, 0x40, 0x48, 0x09, 0x02, 0x20, 0xC4, 0x10, 0xC4, 0x08, 0x81,
  0x82, 0x82, 0xC4, 0x4C, 0x48, 0x58, 0x50, 0x60, 0x60, 0x40, 0x40, 0x40,
  0x40, 0xC0, 0x80, 0x0F, 0xE0, 0x08, 0x03, 0x00, 0x40, 0x10, 0x06, 0x00,
  0x80, 0x30, 0x04, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x07,
  0xF8, 0x0F, 0x18, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x40, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0xF0, 0xF0, 0x8C, 0x44, 0x44,
  0x44, 0x62, 0x22, 0x22, 0x23, 0x0F, 0x12, 0x02, 0x02, 0x02, 0x06, 0x04,
  0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0xF0,
  0xF0, 0x08, 0x0C, 0x14, 0x14, 0x22, 0x62, 0x43, 0x81, 0x81, 0xFE, 0xC9,
  0x10, 0x1C, 0x99, 0x98, 0xC8, 0x2C, 0x34, 0x12, 0x09, 0x04, 0x86, 0x43,
  0x23, 0x0E, 0x80, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0xB8, 0xE6, 0x61,
  0x30, 0x90, 0x48, 0x2C, 0x14, 0x1A, 0x09, 0x0C, 0xC4, 0xBC, 0x00, 0x1E,
  0x65, 0x82, 0x0C, 0x10, 0x20, 0x40, 0x81, 0x03, 0x03, 0xC0, 0x00, 0xC0,
  0x20, 0x08, 0x02, 0x00, 0x87, 0x63, 0x31, 0x84, 0x41, 0x30, 0x48, 0x32,
  0x08, 0x82, 0x21, 0x88, 0x62, 0x30, 0x74, 0x00, 0x1C, 0x65, 0x8A, 0x1C,
  0x73, 0xB8, 0x40, 0x81, 0x03, 0x03, 0xE0, 0x00, 0xE0, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x1F, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x03, 0x01,
  0xC0, 0x00, 0x0E, 0x46, 0x63, 0x08, 0x82, 0x60, 0x90, 0x64, 0x11, 0x04,
  0x43, 0x10, 0xC4, 0x60, 0xE8, 0x02, 0x00, 0x80, 0x62, 0x10, 0xF8, 0x00,
  0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0xB8, 0xE6, 0x61, 0x20, 0x90, 0xC8,
  0x4C, 0x24, 0x12, 0x09, 0x08, 0x84, 0xC2, 0x00, 0x18, 0xC0, 0x01, 0x18,
  0x84, 0x21, 0x18, 0x84, 0x21, 0x18, 0x03, 0x03, 0x00, 0x00, 0x02, 0x02,
  0x04, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10,
  0x10, 0x30, 0xE0, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x8C, 0xC4, 0x44,
  0x24, 0x14, 0x0E, 0x0F, 0x06, 0xC2, 0x21, 0x10, 0x88, 0xC6, 0x00, 0x08,
  0x44, 0x21, 0x08, 0xC4, 0x21, 0x08, 0xC4, 0x21, 0x08, 0xC0, 0x17, 0x38,
  0xA5, 0x33, 0x18, 0x48, 0x63, 0x21, 0x08, 0x84, 0x26, 0x10, 0x90, 0xC2,
  0x42, 0x19, 0x08, 0x44, 0x21, 0x31, 0x84, 0x17, 0x14, 0xCC, 0x24, 0x12,
  0x19, 0x09, 0x84, 0x82, 0x43, 0x21, 0x10, 0x98, 0x40, 0x1C, 0x32, 0x61,
  0x41, 0xC1, 0x81, 0x83, 0x82, 0x82, 0x86, 0x8C, 0x78, 0x0B, 0x87, 0x31,
  0x84, 0x61, 0x10, 0x44, 0x13, 0x04, 0x83, 0x20, 0x88, 0x63, 0x11, 0xF8,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x00, 0x1C, 0x99, 0x98, 0x48, 0x2C,
  0x14, 0x1A, 0x09, 0x04, 0x86, 0x43, 0x23, 0x0E, 0x80, 0x40, 0x20, 0x30,
  0x10, 0x08, 0x00, 0x16, 0x50, 0xC1, 0x82, 0x04, 0x18, 0x20, 0x40, 0x81,
  0x06, 0x00, 0x1E, 0x45, 0x83, 0x02, 0x06, 0x06, 0x06, 0x04, 0x0A, 0x37,
  0xC0, 0x21, 0x3E, 0xC4, 0x21, 0x08, 0xC4, 0x21, 0x08, 0x70, 0x21, 0x61,
  0x41, 0x43, 0x42, 0x42, 0xC2, 0x82, 0x86, 0x84, 0x8C, 0xF4, 0x83, 0x82,
  0x86, 0x84, 0xCC, 0xC8, 0x48, 0x50, 0x50, 0x60, 0x60, 0x40, 0x82, 0x18,
  0x61, 0x86, 0x28, 0xA2, 0x8A, 0x49, 0x24, 0x92, 0xC9, 0x28, 0xA2, 0x8A,
  0x30, 0xC3, 0x0C, 0x30, 0x10, 0xC4, 0x61, 0x90, 0x28, 0x0E, 0x03, 0x00,
  0xC0, 0x50, 0x34, 0x09, 0x84, 0x23, 0x08, 0x18, 0x21, 0x08, 0x21, 0x04,
  0x40, 0x88, 0x12, 0x02, 0x40, 0x50, 0x0A, 0x01, 0xC0, 0x30, 0x06, 0x00,
  0x80, 0x30, 0x04, 0x01, 0x80, 0xE0, 0x00, 0x1F, 0x01, 0x02, 0x06, 0x04,
  0x08, 0x18, 0x10, 0x20, 0x20, 0x40, 0xFC, 0x02, 0x18, 0x20, 0x81, 0x02,
  0x04, 0x18, 0x21, 0x81, 0x03, 0x06, 0x08, 0x10, 0x20, 0x41, 0x81, 0xC0,
  0xFF, 0xFF, 0xFC, 0x08, 0x04, 0x06, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C,
  0x07, 0x0E, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x20, 0xE0, 0x70, 0xC7,
  0x80,
};

const GFXglyph NotoSans_Condensed_LightItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 16, 5, 0, -16 },
  { 11, 6, 6, 7, 2, -16 },
  { 16, 11, 16, 10, 0, -16 },
  { 38, 9, 18, 9, 0, -17 },
  { 59, 12, 16, 14, 1, -16 },
  { 83, 10, 16, 10, 0, -16 },
  { 103, 3, 6, 4, 2, -16 },
  { 106, 6, 19, 6, 1, -16 },
  { 121, 7, 19, 6, -2, -16 },
  { 138, 8, 8, 9, 2, -17 },
  { 146, 9, 10, 10, 1, -13 },
  { 158, 3, 5, 4, -1, -2 },
  { 160, 5, 2, 6, 0, -7 },
  { 162, 2, 2, 4, 0, -2 },
  { 163, 10, 16, 7, -1, -16 },
  { 183, 8, 16, 9, 1, -16 },
  { 199, 5, 16, 9, 3, -16 },
  { 209, 9, 16, 9, 0, -16 },
  { 227, 9, 16, 9, 0, -16 },
  { 245, 9, 16, 9, 0, -16 },
  { 263, 9, 16, 9, 0, -16 },
  { 281, 9, 16, 9, 1, -16 },
  { 299, 9, 16, 9, 1, -16 },
  { 317, 9, 16, 9, 0, -16 },
  { 335, 9, 16, 9, 0, -16 },
  { 353, 4, 12, 4, 0, -12 },
  { 359, 5, 15, 4, -1, -12 },
  { 369, 9, 10, 10, 1, -13 },
  { 381, 9, 6, 10, 1, -11 },
  { 388, 9, 10, 10, 1, -13 },
  { 400, 7, 16, 7, 1, -16 },
  { 414, 13, 18, 14, 1, -16 },
  { 444, 9, 16, 9, -1, -16 },
  { 462, 10, 16, 10, 0, -16 },
  { 482, 10, 16, 9, 1, -16 },
  { 502, 11, 16, 11, 0, -16 },
  { 524, 10, 16, 9, 0, -16 },
  { 544, 10, 16, 8, 0, -16 },
  { 564, 11, 16, 12, 1, -16 },
  { 586, 12, 16, 12, 0, -16 },
  { 610, 8, 16, 5, -1, -16 },
  { 626, 8, 20, 4, -3, -16 },
  { 646, 11, 16, 9, 0, -16 },
  { 668, 7, 16, 8, 0, -16 },
  { 682, 15, 16, 15, 0, -16 },
  { 712, 12, 16, 12, 0, -16 },
  { 736, 10, 16, 12, 1, -16 },
  { 756, 10, 16, 10, 0, -16 },
  { 776, 10, 20, 12, 1, -16 },
  { 801, 10, 16, 10, 0, -16 },
  { 821, 9, 16, 9, 0, -16 },
  { 839, 8, 16, 8, 2, -16 },
  { 855, 11, 16, 11, 1, -16 },
  { 877, 9, 16, 9, 2, -16 },
  { 895, 15, 16, 15, 2, -16 },
  { 925, 11, 16, 9, -1, -16 },
  { 947, 8, 16, 8, 2, -16 },
  { 963, 11, 16, 8, -1, -16 },
  { 985, 8, 20, 6, 0, -16 },
  { 1005, 4, 16, 7, 2, -16 },
  { 1013, 8, 20, 6, -1, -16 },
  { 1033, 8, 9, 10, 1, -16 },
  { 1042, 7, 1, 7, -2, 2 },
  { 1043, 3, 4, 5, 3, -17 },
  { 1045, 9, 12, 10, 1, -12 },
  { 1059, 9, 17, 10, 0, -17 },
  { 1079, 7, 12, 8, 1, -12 },
  { 1090, 10, 17, 10, 1, -17 },
  { 1112, 7, 12, 9, 1, -12 },
  { 1123, 11, 22, 5, -3, -17 },
  { 1154, 10, 17, 10, 0, -12 },
  { 1176, 9, 17, 10, 0, -17 },
  { 1196, 5, 16, 4, 0, -16 },
  { 1206, 8, 21, 4, -3, -16 },
  { 1227, 9, 17, 8, 0, -17 },
  { 1247, 5, 17, 4, 0, -17 },
  { 1258, 14, 12, 15, 0, -12 },
  { 1279, 9, 12, 10, 0, -12 },
  { 1293, 8, 12, 10, 1, -12 },
  { 1305, 10, 17, 10, -1, -12 },
  { 1327, 9, 17, 10, 1, -12 },
  { 1347, 7, 12, 6, 0, -12 },
  { 1358, 7, 12, 7, 0, -12 },
  { 1369, 5, 14, 5, 1, -14 },
  { 1378, 8, 12, 10, 1, -12 },
  { 1390, 8, 12, 8, 1, -12 },
  { 1402, 12, 12, 12, 1, -12 },
  { 1420, 10, 12, 8, -1, -12 },
  { 1435, 11, 17, 8, -2, -12 },
  { 1459, 8, 12, 7, -1, -12 },
  { 1471, 7, 19, 7, 1, -16 },
  { 1488, 1, 22, 9, 4, -17 },
  { 1491, 8, 19, 7, -1, -16 },
  { 1510, 9, 2, 10, 1, -9 },
};

const GFXfont NotoSans_Condensed_LightItalic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic22pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC22PT7B_H_
