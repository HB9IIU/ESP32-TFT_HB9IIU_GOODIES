#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC31PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0xC2, 0x18, 0x61, 0x84, 0x10, 0xC3, 0x0C, 0x20, 0x86,
  0x18, 0x00, 0x00, 0x30, 0xC3, 0x00, 0x63, 0x62, 0x66, 0x46, 0x46, 0x44,
  0xC4, 0x8C, 0x00, 0x84, 0x03, 0x18, 0x04, 0x20, 0x08, 0x40, 0x31, 0x80,
  0x42, 0x07, 0xFF, 0x9F, 0xFF, 0x04, 0x30, 0x08, 0x40, 0x30, 0x80, 0x63,
  0x00, 0x84, 0x01, 0x08, 0x3F, 0xFE, 0x08, 0x40, 0x10, 0x80, 0x63, 0x00,
  0x86, 0x01, 0x08, 0x06, 0x30, 0x0C, 0x60, 0x00, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x07, 0xE0, 0x7F, 0x86, 0x44, 0x62, 0x03, 0x30, 0x19, 0x00, 0xC8,
  0x06, 0x40, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0B, 0x00, 0x4C, 0x02, 0x60,
  0x23, 0x01, 0x18, 0x08, 0x88, 0x4C, 0x7F, 0xC0, 0x70, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x00, 0x1E, 0x06, 0x32, 0x04, 0x63, 0x0C, 0x43, 0x08, 0x42,
  0x10, 0xC2, 0x30, 0xC2, 0x20, 0x82, 0x60, 0x86, 0x44, 0x84, 0xDF, 0x8D,
  0x91, 0xC9, 0x31, 0xFB, 0x21, 0x02, 0x61, 0x06, 0x41, 0x04, 0x43, 0x0C,
  0x43, 0x18, 0x42, 0x10, 0xC2, 0x30, 0x46, 0x20, 0x4C, 0x60, 0x78, 0x03,
  0xE0, 0x18, 0xC0, 0x63, 0x01, 0x0C, 0x0C, 0x30, 0x30, 0x80, 0xC6, 0x01,
  0x30, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0xC0, 0x33, 0x0D, 0x86, 0x26,
  0x19, 0x90, 0x34, 0xC0, 0xF3, 0x01, 0x8C, 0x0E, 0x30, 0x38, 0x63, 0x30,
  0xF8, 0xC0, 0x6D, 0xA4, 0xB4, 0x01, 0x81, 0x01, 0x81, 0x80, 0x80, 0xC0,
  0x40, 0x60, 0x20, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x30, 0x18, 0x00,
  0x02, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0,
  0x40, 0x60, 0x60, 0x20, 0x30, 0x30, 0x00, 0x04, 0x01, 0x80, 0x61, 0x10,
  0xF4, 0x47, 0xF0, 0xC0, 0x58, 0x32, 0x18, 0xC0, 0x10, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x33, 0x26, 0x4C, 0x80, 0xFE, 0xFC,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x00,
  0x07, 0xE0, 0xE6, 0x0C, 0x31, 0x83, 0x10, 0x33, 0x03, 0x20, 0x36, 0x03,
  0x60, 0x36, 0x02, 0x40, 0x2C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x4C, 0x0C,
  0xC0, 0xCC, 0x18, 0xC1, 0x8C, 0x30, 0x66, 0x03, 0xC0, 0x0E, 0x3C, 0xD3,
  0x6C, 0xC1, 0x82, 0x04, 0x18, 0x30, 0x60, 0x81, 0x06, 0x0C, 0x18, 0x20,
  0xC1, 0x83, 0x04, 0x18, 0x00, 0x03, 0xF0, 0x18, 0x60, 0x40, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x08, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x07, 0xE0, 0x61, 0x82,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x0E,
  0x03, 0xC0, 0x07, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x8C, 0x38, 0x7F, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x14, 0x01, 0xA0, 0x0B, 0x00, 0x98, 0x0C, 0x80, 0xC4, 0x04, 0x60, 0x63,
  0x06, 0x18, 0x20, 0x83, 0x04, 0x30, 0x61, 0x03, 0x1F, 0xFE, 0xFF, 0xF0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x07, 0xF8, 0x20, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0xFC,
  0x04, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x03, 0x8C, 0x38, 0x7F, 0x00, 0x01, 0xF8, 0x38, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x63, 0x03, 0x7E,
  0x14, 0x30, 0xC0, 0xCE, 0x06, 0x60, 0x33, 0x01, 0x98, 0x0C, 0xC0, 0x46,
  0x06, 0x30, 0x30, 0x83, 0x06, 0x30, 0x1F, 0x00, 0x7F, 0xF0, 0x03, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0xF0, 0x31, 0xC3, 0x06, 0x10, 0x31,
  0x81, 0x8C, 0x0C, 0x60, 0x61, 0x86, 0x0C, 0x60, 0x3E, 0x01, 0xC0, 0x1B,
  0x03, 0x8C, 0x30, 0x31, 0x81, 0x98, 0x04, 0xC0, 0x26, 0x03, 0x30, 0x18,
  0xC1, 0x87, 0x1C, 0x1F, 0x80, 0x03, 0xE0, 0x71, 0x83, 0x04, 0x30, 0x31,
  0x81, 0x98, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x11, 0x81, 0x8C, 0x0C, 0x31,
  0xE1, 0xFB, 0x03, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60,
  0x06, 0x08, 0x60, 0x7E, 0x00, 0x08, 0x71, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x38, 0xC0, 0x04, 0x1C, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x60, 0xC1, 0x06, 0x08,
  0x00, 0x00, 0x10, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x07,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x07, 0x01, 0xC0,
  0x78, 0x0E, 0x03, 0x80, 0xE0, 0x08, 0x00, 0x3F, 0x8C, 0x60, 0x0C, 0x03,
  0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x0C,
  0x02, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0x00, 0xE0, 0x30, 0x00, 0x00,
  0xFE, 0x00, 0x60, 0xC0, 0x60, 0x18, 0x30, 0x02, 0x08, 0x00, 0xC6, 0x00,
  0x13, 0x07, 0xC4, 0x83, 0x21, 0x21, 0x08, 0x58, 0xC6, 0x14, 0x21, 0x8D,
  0x18, 0x43, 0xC4, 0x10, 0xB1, 0x0C, 0x2C, 0x43, 0x1A, 0x10, 0xC4, 0x84,
  0x53, 0x21, 0xE7, 0x8C, 0x10, 0x83, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x7F, 0x80, 0x07, 0x80, 0x00, 0x00, 0x30, 0x03, 0x80,
  0x1C, 0x00, 0xA0, 0x0D, 0x00, 0x48, 0x06, 0x60, 0x23, 0x03, 0x18, 0x10,
  0xC1, 0x86, 0x0C, 0x30, 0xC1, 0x87, 0xFC, 0x60, 0x63, 0x03, 0x10, 0x19,
  0x80, 0xC8, 0x06, 0xC0, 0x36, 0x01, 0xE0, 0x0C, 0x07, 0xF0, 0x18, 0xE0,
  0x40, 0xC3, 0x03, 0x0C, 0x0C, 0x30, 0x30, 0x80, 0xC2, 0x03, 0x18, 0x18,
  0x61, 0xC1, 0xFC, 0x04, 0x18, 0x30, 0x30, 0xC0, 0x43, 0x01, 0x8C, 0x06,
  0x20, 0x11, 0x80, 0xC6, 0x03, 0x18, 0x18, 0x7F, 0xC3, 0xFC, 0x00, 0x03,
  0xF8, 0x38, 0x43, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x18, 0x1F, 0xC0, 0x07,
  0xF0, 0x0C, 0xF0, 0x10, 0x30, 0x60, 0x30, 0xC0, 0x61, 0x80, 0xC2, 0x01,
  0x84, 0x03, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x18, 0x80, 0x33, 0x00, 0x46,
  0x01, 0x8C, 0x03, 0x18, 0x0C, 0x20, 0x18, 0xC0, 0x61, 0x81, 0x83, 0x07,
  0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0xFE,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x07, 0xF8, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x00, 0x03,
  0xFC, 0x0E, 0x1C, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x07, 0xC8, 0x01, 0x90,
  0x03, 0x20, 0x04, 0x40, 0x18, 0x80, 0x31, 0x80, 0x63, 0x00, 0xC7, 0x01,
  0x07, 0x0E, 0x07, 0xFC, 0x00, 0x06, 0x01, 0x82, 0x00, 0x81, 0x00, 0xC1,
  0x80, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x20, 0x08, 0x10, 0x0C, 0x18, 0x06,
  0x0C, 0x03, 0x07, 0xFF, 0x02, 0x00, 0x83, 0x00, 0xC1, 0x80, 0x60, 0xC0,
  0x30, 0x60, 0x10, 0x20, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x0C, 0x03, 0x04,
  0x01, 0x06, 0x01, 0x80, 0x0F, 0xC0, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80,
  0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x3F, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0xF8,
  0x07, 0x00, 0x06, 0x07, 0x04, 0x0C, 0x04, 0x0C, 0x0C, 0x18, 0x0C, 0x30,
  0x0C, 0x60, 0x08, 0xC0, 0x09, 0xC0, 0x19, 0x80, 0x1B, 0x00, 0x1F, 0x00,
  0x1D, 0x00, 0x39, 0x80, 0x31, 0x80, 0x31, 0x80, 0x30, 0x80, 0x20, 0xC0,
  0x60, 0xC0, 0x60, 0x40, 0x60, 0x60, 0x40, 0x60, 0xC0, 0x60, 0x06, 0x02,
  0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x07, 0xFF, 0xFC, 0x07,
  0x00, 0x18, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x1E, 0x00, 0xF0, 0xF0, 0x05,
  0x07, 0x80, 0x68, 0x2C, 0x02, 0xC1, 0x20, 0x36, 0x19, 0x01, 0x30, 0xC8,
  0x19, 0x06, 0x40, 0x98, 0x22, 0x0C, 0xC3, 0x10, 0x46, 0x18, 0xC6, 0x30,
  0xC6, 0x21, 0x04, 0x33, 0x18, 0x21, 0x90, 0xC3, 0x0D, 0x86, 0x18, 0x68,
  0x20, 0xC1, 0xC1, 0x04, 0x0C, 0x18, 0x60, 0x60, 0xC0, 0x06, 0x00, 0x83,
  0x00, 0xC1, 0xC0, 0x61, 0xE0, 0x30, 0xD0, 0x10, 0x68, 0x08, 0x26, 0x0C,
  0x13, 0x06, 0x18, 0x83, 0x0C, 0x41, 0x06, 0x31, 0x82, 0x18, 0xC3, 0x04,
  0x61, 0x82, 0x20, 0xC1, 0x90, 0x40, 0xD8, 0x20, 0x6C, 0x30, 0x16, 0x18,
  0x0E, 0x0C, 0x07, 0x04, 0x03, 0x86, 0x00, 0xC0, 0x01, 0xF8, 0x0E, 0x38,
  0x30, 0x18, 0x60, 0x31, 0x80, 0x62, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x60,
  0x06, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x34, 0x00, 0x48, 0x01, 0xB0, 0x03,
  0x60, 0x04, 0x40, 0x18, 0x80, 0x31, 0x80, 0xC3, 0x03, 0x03, 0x9C, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x19, 0xE0, 0x41, 0x83, 0x03, 0x0C, 0x0C, 0x30,
  0x30, 0x80, 0xC2, 0x02, 0x18, 0x18, 0x60, 0x61, 0x83, 0x07, 0xF8, 0x3F,
  0x80, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x00, 0x01, 0xF8, 0x0E, 0x38, 0x30, 0x18, 0x60,
  0x31, 0x80, 0x62, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x60, 0x06, 0xC0, 0x0D,
  0x80, 0x1B, 0x00, 0x34, 0x00, 0x48, 0x01, 0xB0, 0x03, 0x60, 0x04, 0x40,
  0x18, 0x80, 0x31, 0x80, 0xC3, 0x03, 0x03, 0x9C, 0x03, 0xF0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x07, 0xF0, 0x19, 0xE0,
  0x41, 0x83, 0x03, 0x0C, 0x0C, 0x30, 0x30, 0x80, 0xC2, 0x02, 0x18, 0x18,
  0x60, 0xC1, 0x87, 0x07, 0xF0, 0x31, 0x80, 0xC6, 0x03, 0x08, 0x0C, 0x30,
  0x20, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x18, 0x40, 0x63, 0x01, 0x80, 0x07,
  0xF8, 0x70, 0xC6, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x60, 0x03, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x8C, 0x78, 0x7F, 0x80, 0xFF,
  0xE1, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x08, 0x02, 0x18, 0x06,
  0x18, 0x06, 0x18, 0x06, 0x10, 0x04, 0x10, 0x04, 0x30, 0x0C, 0x30, 0x0C,
  0x30, 0x0C, 0x20, 0x08, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x10,
  0x40, 0x10, 0xC0, 0x30, 0xC0, 0x30, 0x40, 0x60, 0x60, 0x60, 0x71, 0xC0,
  0x3F, 0x80, 0x80, 0x1E, 0x01, 0xB0, 0x09, 0x80, 0xCC, 0x06, 0x60, 0x63,
  0x03, 0x18, 0x30, 0xC1, 0x86, 0x18, 0x30, 0xC1, 0x84, 0x0C, 0x60, 0x62,
  0x03, 0x30, 0x19, 0x80, 0xD8, 0x06, 0xC0, 0x3C, 0x01, 0xE0, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x60, 0x1E, 0x03, 0x01, 0xB0, 0x38, 0x0D, 0x81, 0x40,
  0xCC, 0x0A, 0x06, 0x60, 0xD0, 0x23, 0x04, 0x83, 0x18, 0x64, 0x18, 0xC2,
  0x21, 0x86, 0x11, 0x0C, 0x31, 0x88, 0x41, 0x88, 0x46, 0x0C, 0xC2, 0x20,
  0x64, 0x13, 0x03, 0x60, 0x98, 0x1B, 0x04, 0x80, 0xD0, 0x2C, 0x07, 0x81,
  0x40, 0x28, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x00, 0x60, 0x18, 0x00,
  0x06, 0x03, 0x03, 0x06, 0x03, 0x06, 0x03, 0x0C, 0x03, 0x08, 0x01, 0x18,
  0x01, 0x30, 0x01, 0xB0, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x02, 0x40, 0x06, 0x40, 0x0C, 0x60, 0x0C, 0x60, 0x18, 0x60,
  0x30, 0x60, 0x30, 0x20, 0x60, 0x30, 0xC0, 0x30, 0xC0, 0x78, 0x0B, 0x03,
  0x60, 0xCC, 0x18, 0x86, 0x10, 0xC2, 0x30, 0x64, 0x0D, 0x81, 0xE0, 0x3C,
  0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x03, 0xF0, 0x20,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0xC0,
  0xFC, 0x00, 0xC6, 0x10, 0x84, 0x31, 0x8C, 0x61, 0x08, 0x43, 0x18, 0xC6,
  0x10, 0x84, 0x31, 0x8C, 0x03, 0xE0, 0x8C, 0x01, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x20, 0x04, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0x00, 0x30, 0x07, 0x80, 0x48,
  0x0C, 0xC1, 0x8C, 0x10, 0x43, 0x06, 0x20, 0x66, 0x02, 0x40, 0x3C, 0x01,
  0xFF, 0xC0, 0x9B, 0x32, 0x03, 0x88, 0x7E, 0x86, 0x14, 0x60, 0xE3, 0x03,
  0x30, 0x11, 0x81, 0x88, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x11, 0x81, 0x8C,
  0x0C, 0x60, 0xE3, 0x07, 0x0C, 0xD0, 0x7C, 0x80, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x1C, 0x0B, 0xF0, 0xF0,
  0x87, 0x06, 0x30, 0x31, 0x81, 0x88, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x11,
  0x01, 0x98, 0x0C, 0xC0, 0x46, 0x06, 0x28, 0x61, 0x47, 0x19, 0xE0, 0x03,
  0x83, 0xF1, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x8C, 0x3F, 0x00, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0xE6, 0x0F,
  0xD0, 0x61, 0x43, 0x03, 0x0C, 0x0C, 0x60, 0x31, 0x80, 0x84, 0x06, 0x30,
  0x18, 0xC0, 0x63, 0x01, 0x0C, 0x0C, 0x30, 0x30, 0xC1, 0xC3, 0x07, 0x06,
  0x68, 0x1F, 0x20, 0x03, 0x81, 0xF8, 0x61, 0x98, 0x32, 0x06, 0xC1, 0x98,
  0x32, 0x1C, 0xFE, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x03,
  0x08, 0x3F, 0x00, 0x00, 0x1C, 0x00, 0x7C, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x03, 0xF0, 0x01, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0x84, 0x1F, 0xA0, 0xC2, 0x86, 0x06, 0x18, 0x18, 0xC0,
  0x63, 0x01, 0x08, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x02, 0x18, 0x18, 0x60,
  0x61, 0x83, 0x86, 0x1E, 0x0C, 0xD0, 0x3E, 0x40, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x08, 0x30, 0x3F, 0x80, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x8E, 0x0B, 0xF1, 0xE3, 0x1C,
  0x11, 0x81, 0x18, 0x11, 0x03, 0x30, 0x33, 0x03, 0x30, 0x22, 0x06, 0x60,
  0x66, 0x06, 0x60, 0x66, 0x04, 0x40, 0xCC, 0x0C, 0x04, 0x0C, 0x18, 0x00,
  0x00, 0x00, 0x04, 0x18, 0x30, 0x60, 0x81, 0x06, 0x0C, 0x18, 0x20, 0x41,
  0x83, 0x06, 0x08, 0x30, 0x00, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x81, 0xE0, 0x00, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x01,
  0x08, 0x30, 0xC3, 0x06, 0x30, 0x33, 0x01, 0x10, 0x09, 0x80, 0xD8, 0x07,
  0xC0, 0x3B, 0x01, 0x98, 0x18, 0xC0, 0xC2, 0x06, 0x18, 0x30, 0xC1, 0x06,
  0x18, 0x18, 0x06, 0x0C, 0x18, 0x20, 0xC1, 0x83, 0x06, 0x08, 0x30, 0x60,
  0xC1, 0x02, 0x0C, 0x18, 0x30, 0x41, 0x83, 0x06, 0x0C, 0x10, 0x60, 0x00,
  0xC1, 0xC1, 0x7E, 0xFC, 0x70, 0xF1, 0x8E, 0x1C, 0x11, 0x83, 0x02, 0x30,
  0x60, 0xC4, 0x0C, 0x19, 0x81, 0x03, 0x30, 0x20, 0x66, 0x0C, 0x08, 0x81,
  0x83, 0x30, 0x30, 0x66, 0x04, 0x0C, 0xC1, 0x81, 0x18, 0x30, 0x22, 0x06,
  0x0C, 0xC0, 0x81, 0x80, 0x00, 0xE0, 0xBF, 0x1E, 0x31, 0xC1, 0x18, 0x11,
  0x83, 0x10, 0x33, 0x03, 0x30, 0x33, 0x02, 0x20, 0x66, 0x06, 0x60, 0x66,
  0x06, 0x60, 0x44, 0x0C, 0xC0, 0xC0, 0x03, 0x80, 0xFC, 0x18, 0x63, 0x02,
  0x30, 0x26, 0x03, 0x60, 0x24, 0x02, 0xC0, 0x2C, 0x06, 0xC0, 0x6C, 0x04,
  0xC0, 0xCC, 0x0C, 0xC1, 0x86, 0x30, 0x3E, 0x00, 0x00, 0x70, 0x17, 0xE0,
  0xF0, 0x83, 0x83, 0x0C, 0x0C, 0x30, 0x30, 0x80, 0xC6, 0x03, 0x18, 0x0C,
  0x60, 0x21, 0x01, 0x84, 0x06, 0x30, 0x10, 0xC0, 0xC3, 0x86, 0x0A, 0x38,
  0x67, 0x81, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x03, 0x88, 0x7E, 0x86, 0x14, 0x60, 0x63, 0x03, 0x30, 0x19,
  0x80, 0x88, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x11, 0x81, 0x8C, 0x0C, 0x60,
  0xE3, 0x07, 0x0C, 0xD0, 0x7C, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0xC2, 0xF1, 0xE0, 0x70, 0x18, 0x06,
  0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x00, 0xC0, 0x00, 0x07, 0x87, 0xF3, 0x04, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x40, 0x32, 0x1C, 0xFC,
  0x00, 0x08, 0x30, 0x60, 0x87, 0xE6, 0x0C, 0x18, 0x20, 0xC1, 0x83, 0x06,
  0x08, 0x30, 0x60, 0xC1, 0x83, 0x07, 0x80, 0x30, 0x33, 0x03, 0x30, 0x33,
  0x02, 0x20, 0x66, 0x06, 0x60, 0x66, 0x04, 0x40, 0x44, 0x0C, 0xC0, 0xCC,
  0x0C, 0xC1, 0x8C, 0x38, 0xE6, 0x87, 0xD8, 0x80, 0xE0, 0x28, 0x1B, 0x04,
  0xC3, 0x30, 0x8C, 0x63, 0x10, 0xCC, 0x32, 0x0D, 0x83, 0x60, 0xF0, 0x3C,
  0x0E, 0x03, 0x80, 0x81, 0x83, 0xC0, 0xC1, 0xA0, 0xE0, 0x90, 0x50, 0xC8,
  0x68, 0x64, 0x24, 0x62, 0x32, 0x31, 0x11, 0x10, 0x88, 0x98, 0x4C, 0x48,
  0x24, 0x2C, 0x16, 0x16, 0x0A, 0x0A, 0x07, 0x07, 0x03, 0x83, 0x01, 0x81,
  0x80, 0x18, 0x18, 0x61, 0x83, 0x18, 0x08, 0x80, 0x4C, 0x03, 0xC0, 0x1C,
  0x00, 0x60, 0x07, 0x00, 0x78, 0x06, 0x40, 0x33, 0x03, 0x18, 0x30, 0x41,
  0x82, 0x18, 0x18, 0x06, 0x07, 0x06, 0x06, 0x06, 0x0C, 0x06, 0x0C, 0x06,
  0x18, 0x06, 0x18, 0x06, 0x10, 0x02, 0x30, 0x02, 0x20, 0x02, 0x60, 0x02,
  0x40, 0x02, 0xC0, 0x02, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xF0,
  0x00, 0x40, 0x00, 0x0F, 0xE0, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00,
  0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x10, 0x07,
  0xF8, 0x01, 0xE0, 0x70, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x20, 0x0C, 0x07, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x07,
  0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0x78, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x1C, 0x00, 0xC0, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x60, 0x18, 0x1F, 0x03, 0x80, 0x00, 0x10, 0x07, 0xE1,
  0xC3, 0xF8, 0x0E,
};

const GFXglyph NotoSans_Condensed_LightItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 22, 7, 1, -22 },
  { 18, 8, 8, 10, 3, -22 },
  { 26, 15, 22, 14, 0, -22 },
  { 68, 13, 26, 13, 0, -24 },
  { 111, 16, 22, 20, 2, -22 },
  { 155, 14, 22, 14, 0, -22 },
  { 194, 3, 8, 5, 3, -22 },
  { 197, 9, 27, 8, 1, -22 },
  { 228, 9, 27, 8, -2, -22 },
  { 259, 10, 11, 12, 3, -24 },
  { 273, 12, 14, 14, 1, -18 },
  { 294, 4, 7, 6, -1, -3 },
  { 298, 7, 1, 9, 1, -9 },
  { 299, 2, 3, 6, 1, -3 },
  { 300, 13, 22, 10, -1, -22 },
  { 336, 12, 22, 13, 1, -22 },
  { 369, 7, 22, 13, 4, -22 },
  { 389, 14, 22, 13, -1, -22 },
  { 428, 13, 22, 13, 0, -22 },
  { 464, 13, 22, 13, 0, -22 },
  { 500, 13, 22, 13, 0, -22 },
  { 536, 13, 22, 13, 1, -22 },
  { 572, 12, 22, 13, 2, -22 },
  { 605, 13, 22, 13, 0, -22 },
  { 641, 13, 22, 13, 0, -22 },
  { 677, 6, 17, 6, 0, -17 },
  { 690, 7, 21, 6, -1, -17 },
  { 709, 12, 14, 14, 1, -18 },
  { 730, 12, 8, 14, 1, -15 },
  { 742, 12, 14, 14, 1, -18 },
  { 763, 10, 22, 10, 1, -22 },
  { 791, 18, 25, 20, 1, -22 },
  { 848, 13, 22, 13, -2, -22 },
  { 884, 14, 22, 14, 0, -22 },
  { 923, 13, 22, 13, 2, -22 },
  { 959, 15, 22, 16, 0, -22 },
  { 1001, 14, 22, 13, 0, -22 },
  { 1040, 14, 22, 12, 0, -22 },
  { 1079, 15, 22, 17, 2, -22 },
  { 1121, 17, 22, 16, 0, -22 },
  { 1168, 10, 22, 7, -1, -22 },
  { 1196, 12, 28, 6, -5, -22 },
  { 1238, 16, 22, 13, 0, -22 },
  { 1282, 9, 22, 11, 0, -22 },
  { 1307, 21, 22, 21, 0, -22 },
  { 1365, 17, 22, 17, 0, -22 },
  { 1412, 15, 22, 17, 1, -22 },
  { 1454, 14, 22, 13, 0, -22 },
  { 1493, 15, 27, 17, 1, -22 },
  { 1544, 14, 22, 14, 0, -22 },
  { 1583, 13, 22, 12, 0, -22 },
  { 1619, 11, 22, 12, 3, -22 },
  { 1650, 16, 22, 16, 1, -22 },
  { 1694, 13, 22, 13, 3, -22 },
  { 1730, 21, 22, 21, 3, -22 },
  { 1788, 16, 22, 12, -2, -22 },
  { 1832, 11, 22, 12, 3, -22 },
  { 1863, 15, 22, 12, -1, -22 },
  { 1905, 12, 27, 9, -1, -22 },
  { 1946, 5, 22, 10, 3, -22 },
  { 1960, 11, 27, 9, -2, -22 },
  { 1998, 12, 12, 14, 1, -22 },
  { 2016, 10, 1, 10, -3, 3 },
  { 2018, 3, 5, 7, 5, -24 },
  { 2020, 13, 17, 14, 1, -17 },
  { 2048, 13, 24, 14, 0, -24 },
  { 2087, 10, 17, 11, 1, -17 },
  { 2109, 14, 24, 14, 1, -24 },
  { 2151, 11, 17, 12, 1, -17 },
  { 2175, 15, 31, 7, -4, -24 },
  { 2234, 14, 24, 14, 0, -17 },
  { 2276, 12, 24, 14, 0, -24 },
  { 2312, 7, 23, 6, 0, -23 },
  { 2333, 11, 30, 6, -4, -23 },
  { 2375, 13, 24, 11, 0, -24 },
  { 2414, 7, 24, 6, 0, -24 },
  { 2435, 19, 17, 21, 0, -17 },
  { 2476, 12, 17, 14, 0, -17 },
  { 2502, 12, 17, 14, 1, -17 },
  { 2528, 14, 24, 14, -1, -17 },
  { 2570, 13, 24, 14, 1, -17 },
  { 2609, 10, 17, 9, 0, -17 },
  { 2631, 10, 17, 10, 0, -17 },
  { 2653, 7, 20, 8, 1, -20 },
  { 2671, 12, 16, 14, 1, -16 },
  { 2695, 10, 16, 11, 2, -16 },
  { 2715, 17, 16, 17, 2, -16 },
  { 2749, 13, 16, 11, -1, -16 },
  { 2775, 16, 24, 11, -3, -16 },
  { 2823, 11, 16, 10, -1, -16 },
  { 2845, 11, 27, 10, 1, -22 },
  { 2883, 1, 31, 13, 6, -24 },
  { 2887, 11, 27, 10, -2, -22 },
  { 2925, 12, 4, 14, 1, -13 },
};

const GFXfont NotoSans_Condensed_LightItalic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic31pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC31PT7B_H_
