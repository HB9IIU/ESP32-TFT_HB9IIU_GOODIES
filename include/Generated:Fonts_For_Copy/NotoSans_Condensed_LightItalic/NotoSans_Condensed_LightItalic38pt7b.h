#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC38PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x18,
  0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x60, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0xE0, 0xC0, 0x71, 0xB0, 0xD8, 0xCC, 0x66, 0x32, 0x1B, 0x09,
  0x8C, 0xC6, 0x43, 0x00, 0x00, 0x61, 0x80, 0x18, 0x60, 0x04, 0x18, 0x03,
  0x04, 0x00, 0xC3, 0x00, 0x20, 0xC0, 0x18, 0x20, 0x06, 0x18, 0x1F, 0xFF,
  0xC0, 0x41, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x02, 0x0C, 0x01, 0x82, 0x00,
  0x61, 0x80, 0x10, 0x60, 0x0C, 0x10, 0x1F, 0xFF, 0xC8, 0xC3, 0x00, 0x60,
  0x80, 0x18, 0x60, 0x06, 0x18, 0x01, 0x06, 0x00, 0xC3, 0x00, 0x30, 0xC0,
  0x08, 0x30, 0x06, 0x18, 0x00, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x78, 0x03, 0xFF, 0x07, 0x23, 0x0E, 0x20, 0x0C, 0x60, 0x0C, 0x60, 0x0C,
  0x40, 0x0C, 0x40, 0x0C, 0x40, 0x0E, 0xC0, 0x07, 0xC0, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x01, 0xB0, 0x01, 0x18, 0x01, 0x18, 0x01, 0x18, 0x03,
  0x18, 0x03, 0x18, 0x02, 0x18, 0x82, 0x30, 0xFF, 0xE0, 0x7F, 0xC0, 0x06,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0xF8, 0x06,
  0x19, 0x80, 0xC3, 0x0C, 0x0C, 0x30, 0xC1, 0x82, 0x0C, 0x30, 0x60, 0xC3,
  0x06, 0x08, 0x60, 0x40, 0x86, 0x04, 0x18, 0xC0, 0xC1, 0x88, 0x0C, 0x19,
  0x84, 0xC1, 0x31, 0xFC, 0x33, 0x33, 0xC2, 0x66, 0x16, 0x66, 0x41, 0x7C,
  0xCC, 0x11, 0x08, 0xC3, 0x01, 0x88, 0x30, 0x31, 0x83, 0x03, 0x18, 0x30,
  0x61, 0x83, 0x06, 0x18, 0x60, 0xC1, 0x86, 0x08, 0x18, 0x41, 0x81, 0x8C,
  0x30, 0x19, 0x83, 0x00, 0xF0, 0x00, 0x20, 0x00, 0x7C, 0x00, 0x63, 0x00,
  0x61, 0xC0, 0x30, 0x60, 0x38, 0x30, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x0C,
  0x03, 0x0C, 0x00, 0xCC, 0x00, 0x6C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x19, 0x80, 0x18, 0xC1, 0x98, 0x71, 0x98, 0x18, 0xCC, 0x0C, 0xC6,
  0x03, 0x66, 0x01, 0xE3, 0x00, 0xF1, 0x80, 0x30, 0xE0, 0x3C, 0x30, 0x36,
  0x1E, 0xF3, 0x07, 0xF0, 0xC0, 0x76, 0x66, 0x64, 0xCC, 0xC8, 0x00, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x00, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x00, 0xC0,
  0x30, 0x0C, 0x01, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x30, 0x03, 0x04, 0x30,
  0xE2, 0x03, 0xA3, 0x0F, 0xF0, 0xE0, 0x1B, 0x03, 0x10, 0x71, 0x82, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x71, 0x86, 0x30,
  0xC6, 0x18, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x00, 0x00, 0x20, 0x03, 0xF0, 0x0E, 0x70, 0x38,
  0x60, 0xE0, 0xE1, 0x80, 0xC7, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x60, 0x0C,
  0xC0, 0x39, 0x80, 0x66, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x06, 0x60,
  0x1D, 0xC0, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x03, 0x18, 0x06, 0x30, 0x1C,
  0x60, 0x30, 0x60, 0xE0, 0xC3, 0x81, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0x0F,
  0x1F, 0x3B, 0xE6, 0xC6, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60,
  0x60, 0x00, 0x10, 0x00, 0xFF, 0x00, 0xF3, 0xC0, 0x60, 0x60, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x3F, 0xFE, 0x1F, 0xFF,
  0x00, 0x00, 0x20, 0x03, 0xFC, 0x0F, 0x9E, 0x04, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x30, 0x80, 0x60, 0xF3, 0xC0, 0xFF, 0x80, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x16, 0x00, 0x36, 0x00, 0x66, 0x00, 0x4C, 0x00,
  0xCC, 0x01, 0x8C, 0x01, 0x0C, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x18, 0x0C,
  0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x60, 0x30, 0xC0, 0x30, 0xFF,
  0xFE, 0xFF, 0xFE, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x1F, 0xE0, 0x1C, 0xF0, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x30, 0x80, 0xE0, 0xF7, 0xC0, 0xFF, 0x80, 0x00, 0x08, 0x00,
  0x7F, 0x01, 0xE2, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x31, 0xC0, 0x37, 0xF0, 0x6C,
  0x38, 0x78, 0x18, 0x70, 0x18, 0x60, 0x18, 0x60, 0x18, 0xE0, 0x18, 0xE0,
  0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x38, 0x60, 0x30, 0x60, 0x70, 0x60,
  0xE0, 0x3B, 0xC0, 0x1F, 0x80, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x20, 0x01, 0xFC,
  0x03, 0x8E, 0x07, 0x07, 0x06, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03,
  0x0C, 0x03, 0x0C, 0x06, 0x06, 0x0E, 0x07, 0x1C, 0x03, 0xF0, 0x01, 0xE0,
  0x07, 0xE0, 0x0E, 0x70, 0x18, 0x30, 0x30, 0x18, 0x60, 0x18, 0x60, 0x0C,
  0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0x60, 0x18, 0x70, 0x30,
  0x3D, 0xE0, 0x1F, 0xC0, 0x00, 0x20, 0x01, 0xF8, 0x03, 0x9C, 0x06, 0x06,
  0x0E, 0x06, 0x0C, 0x06, 0x1C, 0x03, 0x18, 0x03, 0x18, 0x07, 0x18, 0x07,
  0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x18, 0x0E, 0x18, 0x1E, 0x1C, 0x76,
  0x0F, 0xEC, 0x03, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0xEF, 0x80, 0xFE, 0x00,
  0x0E, 0x1C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC3, 0x87, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x0E, 0x06, 0x03, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x00, 0x00,
  0x04, 0x00, 0x30, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0C, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x30, 0x00, 0x80, 0x00, 0x01, 0x03, 0xFE, 0x1C, 0xE1, 0x07, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x1C, 0x03,
  0x80, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0x00,
  0x1F, 0xC0, 0x01, 0xE3, 0xC0, 0x1C, 0x03, 0x80, 0xE0, 0x06, 0x07, 0x00,
  0x0C, 0x18, 0x00, 0x30, 0xC0, 0x00, 0x46, 0x01, 0x81, 0x18, 0x3F, 0x84,
  0xC1, 0x86, 0x13, 0x0C, 0x10, 0x48, 0x30, 0xC1, 0x61, 0x83, 0x0D, 0x86,
  0x0C, 0x36, 0x10, 0x20, 0xD0, 0xC1, 0x83, 0x43, 0x06, 0x1B, 0x0C, 0x18,
  0x6C, 0x30, 0xE1, 0x30, 0xC3, 0x0C, 0xC3, 0x16, 0x63, 0x07, 0xDF, 0x0C,
  0x0C, 0x38, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x36, 0x00, 0x36, 0x00, 0x66, 0x00, 0x66,
  0x00, 0x66, 0x00, 0xC6, 0x00, 0xC6, 0x01, 0x86, 0x01, 0x86, 0x03, 0x06,
  0x03, 0x06, 0x06, 0x06, 0x07, 0xFE, 0x0F, 0xFE, 0x0C, 0x06, 0x0C, 0x06,
  0x18, 0x06, 0x18, 0x06, 0x30, 0x06, 0x30, 0x07, 0x60, 0x07, 0x60, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0x81, 0xC0, 0xC0,
  0x60, 0xC0, 0x30, 0x60, 0x1C, 0x30, 0x0C, 0x18, 0x06, 0x1C, 0x03, 0x0C,
  0x03, 0x06, 0x03, 0x83, 0x07, 0x81, 0xFF, 0x01, 0xFF, 0x80, 0xC0, 0x60,
  0x60, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x86, 0x00,
  0xC3, 0x00, 0x61, 0x80, 0x61, 0x80, 0x70, 0xC0, 0x70, 0x7F, 0xF0, 0x3F,
  0xE0, 0x00, 0x00, 0x08, 0x00, 0x7F, 0xC0, 0x79, 0xC0, 0xF0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0xC0,
  0x38, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x1C, 0x01, 0x8C, 0x00, 0xC6,
  0x00, 0x63, 0x00, 0x31, 0x80, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x07,
  0x30, 0x03, 0x18, 0x01, 0x98, 0x01, 0xCC, 0x00, 0xC6, 0x00, 0xE3, 0x00,
  0xE1, 0x80, 0xE1, 0x80, 0xE0, 0xC1, 0xE0, 0x7F, 0xE0, 0x3F, 0x80, 0x00,
  0x07, 0xFF, 0x07, 0xFF, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x1F, 0xF8, 0x3F, 0xF0, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x3F, 0xF8, 0x3F, 0xF0,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x1F, 0xF8, 0x07, 0xCF, 0x83, 0xC0, 0x20, 0x60, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x0F, 0xE6,
  0x01, 0xF8, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x03, 0x0C,
  0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x87, 0x00, 0x30, 0x60, 0x0C, 0x0E,
  0x01, 0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x06, 0x00, 0x70, 0x60, 0x06,
  0x06, 0x00, 0x60, 0x60, 0x06, 0x0C, 0x00, 0xE0, 0xC0, 0x0C, 0x0C, 0x00,
  0xC0, 0xC0, 0x0C, 0x1C, 0x00, 0xC1, 0x80, 0x18, 0x18, 0x01, 0x81, 0x80,
  0x18, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x30, 0x03, 0x03, 0x00, 0x30, 0x30,
  0x03, 0x03, 0x00, 0x30, 0x60, 0x07, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06,
  0x00, 0x60, 0xE0, 0x06, 0x0C, 0x00, 0xE0, 0xC0, 0x0C, 0x0C, 0x00, 0xC0,
  0xC0, 0x0C, 0x00, 0x03, 0xFC, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0xF0,
  0x0F, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0xFC,
  0x03, 0xE0, 0x00, 0x06, 0x01, 0xC1, 0x80, 0x60, 0x60, 0x30, 0x18, 0x18,
  0x0C, 0x0E, 0x03, 0x07, 0x00, 0xC3, 0x80, 0x30, 0xC0, 0x1C, 0x60, 0x06,
  0x30, 0x01, 0x9C, 0x00, 0x6E, 0x00, 0x1B, 0x80, 0x0D, 0xE0, 0x03, 0xD8,
  0x00, 0xE7, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x06, 0x0C, 0x01, 0x81, 0x80,
  0x60, 0x60, 0x18, 0x18, 0x0E, 0x07, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x30,
  0x0C, 0x0C, 0x01, 0x80, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x3F,
  0xFF, 0xFC, 0x07, 0x00, 0x03, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xE0,
  0xB0, 0x01, 0xB0, 0xD8, 0x00, 0xF0, 0x6C, 0x00, 0xD8, 0x36, 0x00, 0x6C,
  0x1B, 0x00, 0x66, 0x19, 0x80, 0x36, 0x0C, 0xC0, 0x33, 0x06, 0x60, 0x19,
  0x83, 0x30, 0x18, 0xC1, 0x98, 0x0C, 0x61, 0x8C, 0x0C, 0x60, 0xC6, 0x06,
  0x30, 0x61, 0x06, 0x18, 0x30, 0xC3, 0x0C, 0x18, 0x63, 0x0E, 0x18, 0x31,
  0x86, 0x0C, 0x19, 0x83, 0x06, 0x0C, 0xC1, 0x83, 0x06, 0xC0, 0xC3, 0x83,
  0x60, 0xC1, 0x81, 0xE0, 0x60, 0xC0, 0xF0, 0x30, 0x60, 0x70, 0x18, 0x30,
  0x38, 0x1C, 0x00, 0x07, 0x00, 0x30, 0x70, 0x03, 0x07, 0x00, 0x30, 0x58,
  0x03, 0x0D, 0x80, 0x60, 0xD8, 0x06, 0x0D, 0x80, 0x60, 0xC8, 0x06, 0x18,
  0xC0, 0xC1, 0x8C, 0x0C, 0x18, 0xC0, 0xC1, 0x84, 0x0C, 0x18, 0x60, 0xC3,
  0x06, 0x18, 0x30, 0x61, 0x83, 0x06, 0x18, 0x30, 0x31, 0x83, 0x03, 0x18,
  0x60, 0x33, 0x06, 0x03, 0x30, 0x60, 0x1B, 0x06, 0x01, 0xB0, 0xE0, 0x1B,
  0x0C, 0x01, 0xE0, 0xC0, 0x0E, 0x0C, 0x00, 0xE0, 0xC0, 0x0E, 0x00, 0x00,
  0x10, 0x00, 0x7F, 0x80, 0x3C, 0xF0, 0x1C, 0x0E, 0x0E, 0x01, 0x83, 0x00,
  0x71, 0x80, 0x1C, 0xE0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x37, 0x00, 0x0D,
  0x80, 0x03, 0x60, 0x01, 0xF8, 0x00, 0x6E, 0x00, 0x1B, 0x00, 0x06, 0xC0,
  0x01, 0xB0, 0x00, 0xEC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x07, 0x30, 0x01,
  0x8C, 0x00, 0xE3, 0x00, 0x30, 0x60, 0x18, 0x1C, 0x0E, 0x03, 0xFF, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x06, 0x0E, 0x06, 0x07, 0x0C, 0x03,
  0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x1C, 0x07, 0x18, 0x06, 0x18, 0x06,
  0x18, 0x0E, 0x18, 0x1C, 0x30, 0x38, 0x3F, 0xF0, 0x3F, 0xC0, 0x30, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x7F,
  0x80, 0x3C, 0xF0, 0x1C, 0x0E, 0x0E, 0x01, 0x83, 0x00, 0x71, 0x80, 0x1C,
  0xE0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x37, 0x00, 0x0D, 0x80, 0x03, 0x60,
  0x01, 0xF8, 0x00, 0x6E, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00,
  0xEC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x07, 0x30, 0x01, 0x8C, 0x00, 0xE3,
  0x00, 0x30, 0x60, 0x18, 0x1C, 0x0E, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x07, 0xF8, 0x07, 0xFC, 0x06, 0x0E, 0x06, 0x07, 0x0C, 0x03, 0x0C,
  0x03, 0x0C, 0x03, 0x0C, 0x03, 0x1C, 0x07, 0x18, 0x06, 0x18, 0x06, 0x18,
  0x0C, 0x18, 0x1C, 0x3F, 0xF8, 0x3F, 0xE0, 0x30, 0xC0, 0x30, 0xC0, 0x30,
  0xC0, 0x60, 0xE0, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x70, 0xC0,
  0x30, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x38, 0x00, 0x18, 0x00, 0x7F, 0xC0,
  0xFB, 0xE0, 0x60, 0x10, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18,
  0x20, 0x38, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xC3, 0x00, 0x30,
  0xC0, 0x0C, 0x60, 0x03, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x18, 0xE0,
  0x06, 0x30, 0x03, 0x8C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x60, 0x03,
  0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x30, 0x01, 0x8C,
  0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00,
  0xE0, 0xE0, 0x70, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0xC0, 0x03, 0xE0, 0x07,
  0xE0, 0x06, 0x60, 0x0E, 0x60, 0x0C, 0x60, 0x1C, 0x60, 0x18, 0x60, 0x18,
  0x60, 0x30, 0x60, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0xC0, 0x60, 0xC0,
  0x61, 0xC0, 0x61, 0x80, 0x63, 0x80, 0x63, 0x00, 0x63, 0x00, 0x66, 0x00,
  0x66, 0x00, 0x6C, 0x00, 0x6C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xC0, 0x18, 0x01, 0xE0, 0x0C, 0x01, 0xB0, 0x0E, 0x00, 0xD8,
  0x07, 0x00, 0xEC, 0x06, 0x80, 0x66, 0x03, 0x40, 0x33, 0x01, 0xA0, 0x31,
  0x81, 0x90, 0x18, 0xC0, 0xC8, 0x1C, 0x60, 0xC4, 0x0C, 0x30, 0x62, 0x06,
  0x18, 0x23, 0x06, 0x0C, 0x31, 0x83, 0x06, 0x18, 0xC3, 0x03, 0x18, 0x61,
  0x81, 0x8C, 0x31, 0xC0, 0xCC, 0x18, 0xC0, 0x66, 0x0C, 0x60, 0x33, 0x06,
  0x60, 0x1B, 0x03, 0x30, 0x0D, 0x81, 0xB8, 0x07, 0x80, 0xD8, 0x02, 0xC0,
  0x6C, 0x01, 0x40, 0x3C, 0x00, 0xE0, 0x1E, 0x00, 0x70, 0x0E, 0x00, 0x30,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x70, 0x18, 0x0E, 0x01, 0x80, 0xC0, 0x18,
  0x18, 0x01, 0x83, 0x80, 0x18, 0x30, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00,
  0xCC, 0x00, 0x0D, 0xC0, 0x00, 0x58, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x1B, 0x00, 0x03, 0xB0, 0x00, 0x33, 0x00,
  0x06, 0x30, 0x00, 0x61, 0x80, 0x0C, 0x18, 0x01, 0xC1, 0x80, 0x18, 0x18,
  0x03, 0x01, 0x80, 0x70, 0x1C, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x00, 0xC0,
  0x0E, 0xC0, 0x39, 0x80, 0x63, 0x01, 0x86, 0x03, 0x0C, 0x0C, 0x18, 0x18,
  0x30, 0x60, 0x31, 0xC0, 0x63, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x60, 0x06,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x3F, 0xFE,
  0x0F, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0xC3, 0x0C, 0x30, 0x41, 0x86, 0x18, 0x61, 0x86, 0x08, 0x30, 0xC3,
  0x0C, 0x30, 0xC1, 0x06, 0x18, 0x61, 0x86, 0x18, 0x20, 0xC0, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x1B, 0x00, 0x33, 0x00, 0xC6, 0x01, 0x8C, 0x06, 0x0C, 0x18,
  0x18, 0x30, 0x30, 0xC0, 0x31, 0x80, 0x66, 0x00, 0x6C, 0x00, 0xF0, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xCC, 0x66, 0x31, 0x00, 0x81, 0x03, 0xF2, 0x07,
  0x36, 0x0C, 0x1E, 0x18, 0x0E, 0x38, 0x0E, 0x30, 0x0C, 0x30, 0x0C, 0x60,
  0x0C, 0x60, 0x0C, 0x60, 0x1C, 0x60, 0x18, 0xE0, 0x18, 0xC0, 0x18, 0xC0,
  0x38, 0xC0, 0x30, 0xC0, 0x70, 0xE0, 0x70, 0x60, 0xB0, 0x7B, 0xB0, 0x3E,
  0x20, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x10, 0x06, 0xFC, 0x0D, 0xCE, 0x0F,
  0x06, 0x0E, 0x07, 0x0E, 0x03, 0x1C, 0x03, 0x1C, 0x03, 0x18, 0x03, 0x18,
  0x07, 0x18, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x0C, 0x30,
  0x0C, 0x70, 0x18, 0x70, 0x18, 0x78, 0x30, 0x4E, 0xE0, 0xCF, 0xC0, 0x00,
  0xC0, 0x1F, 0xC1, 0xC4, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xF3, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x83, 0x01, 0xFB, 0x81, 0xCF, 0x81, 0x81, 0xC1,
  0x80, 0xE1, 0xC0, 0x70, 0xC0, 0x30, 0x60, 0x18, 0x60, 0x0C, 0x30, 0x06,
  0x18, 0x03, 0x0C, 0x03, 0x0E, 0x01, 0x86, 0x00, 0xC3, 0x00, 0xE1, 0x80,
  0x70, 0xC0, 0x70, 0x70, 0x38, 0x18, 0x2C, 0x0F, 0x76, 0x03, 0xE3, 0x00,
  0x00, 0xC0, 0x1F, 0x81, 0xCE, 0x18, 0x31, 0x81, 0x9C, 0x0C, 0xC0, 0x66,
  0x06, 0x60, 0x73, 0x0F, 0x1F, 0xE1, 0xF8, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x08, 0x7B, 0x81, 0xFC, 0x00, 0x00,
  0x03, 0xC0, 0x03, 0xF0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x40, 0x00, 0xFC, 0xC0, 0xE6, 0x40, 0xC0, 0xE0, 0xC0, 0x70,
  0xE0, 0x38, 0x60, 0x18, 0x30, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x01,
  0x86, 0x01, 0x87, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x70, 0xC0, 0x38, 0x60,
  0x38, 0x38, 0x1C, 0x0C, 0x16, 0x07, 0xBB, 0x01, 0xF3, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x10, 0x38,
  0x0F, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x10, 0x0D, 0xF8,
  0x36, 0x38, 0x78, 0x30, 0xE0, 0x61, 0x80, 0xC7, 0x01, 0x8C, 0x03, 0x18,
  0x06, 0x30, 0x18, 0x60, 0x31, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x8C, 0x06,
  0x18, 0x0C, 0x60, 0x18, 0xC0, 0x31, 0x80, 0xE3, 0x01, 0x8E, 0x03, 0x00,
  0x01, 0x03, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00, 0x06, 0x0C, 0x0C, 0x0C,
  0x0C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60,
  0x60, 0x60, 0x60, 0xE0, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03,
  0x01, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x01, 0x06,
  0x06, 0x0C, 0x0C, 0x0C, 0x18, 0x0C, 0x30, 0x0C, 0x70, 0x18, 0xE0, 0x18,
  0xC0, 0x19, 0x80, 0x1B, 0x80, 0x1F, 0x80, 0x3D, 0x80, 0x39, 0xC0, 0x30,
  0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x60, 0xE0, 0x60, 0x60, 0x60, 0x60, 0x60,
  0x60, 0xE0, 0x70, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x06,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x00,
  0x00, 0x10, 0x10, 0x04, 0xFC, 0x7E, 0x0D, 0x8C, 0xCE, 0x0F, 0x0F, 0x87,
  0x0E, 0x07, 0x03, 0x0C, 0x06, 0x03, 0x1C, 0x06, 0x03, 0x18, 0x0C, 0x06,
  0x18, 0x0C, 0x06, 0x18, 0x0C, 0x06, 0x18, 0x0C, 0x06, 0x30, 0x1C, 0x0E,
  0x30, 0x18, 0x0C, 0x30, 0x18, 0x0C, 0x30, 0x18, 0x0C, 0x30, 0x18, 0x0C,
  0x60, 0x30, 0x18, 0x60, 0x30, 0x18, 0x60, 0x30, 0x18, 0x60, 0x30, 0x18,
  0xE0, 0x70, 0x38, 0x00, 0x30, 0x09, 0xF8, 0x37, 0x38, 0x78, 0x30, 0xE0,
  0x61, 0x80, 0xC7, 0x01, 0x8E, 0x03, 0x18, 0x06, 0x30, 0x18, 0x60, 0x31,
  0x80, 0x63, 0x00, 0xC6, 0x03, 0x8C, 0x06, 0x18, 0x0C, 0x60, 0x18, 0xC0,
  0x31, 0x80, 0xE3, 0x01, 0x8E, 0x03, 0x00, 0x00, 0x40, 0x0F, 0xC0, 0xF3,
  0x83, 0x07, 0x18, 0x0C, 0xE0, 0x33, 0x00, 0xCC, 0x03, 0x60, 0x0D, 0x80,
  0x36, 0x00, 0xD8, 0x03, 0xE0, 0x1F, 0x00, 0x6C, 0x01, 0xB0, 0x0E, 0xC0,
  0x31, 0x81, 0xC6, 0x0E, 0x1E, 0xF0, 0x3F, 0x80, 0x00, 0x08, 0x01, 0x3F,
  0x01, 0xB9, 0xC0, 0xF0, 0x60, 0x70, 0x18, 0x38, 0x0C, 0x18, 0x06, 0x1C,
  0x03, 0x0C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x30,
  0xC0, 0x18, 0x60, 0x18, 0x30, 0x0C, 0x38, 0x0C, 0x1C, 0x06, 0x0F, 0x06,
  0x06, 0xCE, 0x03, 0x3E, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x80, 0x03, 0xF3, 0x07, 0x32, 0x0C, 0x1E, 0x18, 0x0E, 0x38, 0x0E,
  0x30, 0x0C, 0x30, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x18,
  0xE0, 0x18, 0xC0, 0x18, 0xC0, 0x38, 0xC0, 0x38, 0xC0, 0x70, 0xE0, 0x70,
  0x60, 0xB0, 0x7B, 0xB0, 0x3E, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0,
  0x00, 0x18, 0x27, 0x83, 0x74, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x7F, 0xC7, 0x0C, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x20, 0x71, 0xDF, 0x0F, 0xF0, 0x00, 0x06, 0x02,
  0x03, 0x01, 0x80, 0xC3, 0xFD, 0xFE, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x01,
  0xC8, 0x7C, 0x00, 0x1C, 0x06, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x61, 0x80,
  0xC6, 0x01, 0x8C, 0x03, 0x18, 0x0E, 0x30, 0x18, 0xE0, 0x31, 0x80, 0x63,
  0x00, 0xC6, 0x03, 0x0C, 0x06, 0x38, 0x0C, 0x60, 0x38, 0xC0, 0xF1, 0xC3,
  0x41, 0xDD, 0x83, 0xF3, 0x00, 0xC0, 0x1E, 0x01, 0xB0, 0x0D, 0x80, 0xCC,
  0x06, 0x60, 0x63, 0x03, 0x18, 0x30, 0x41, 0x82, 0x18, 0x18, 0xC0, 0xCC,
  0x06, 0x60, 0x36, 0x01, 0xB0, 0x0D, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x00, 0xC0, 0x70, 0x3E, 0x03, 0x81, 0xB0, 0x3C, 0x0D, 0x81, 0xE0,
  0xCC, 0x1B, 0x06, 0x60, 0xD8, 0x63, 0x04, 0xC3, 0x18, 0x66, 0x18, 0xC3,
  0x31, 0x86, 0x31, 0x8C, 0x31, 0x8C, 0xC1, 0x98, 0x66, 0x0C, 0xC3, 0x20,
  0x64, 0x1B, 0x03, 0x60, 0xD8, 0x1B, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81,
  0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x00, 0x06, 0x03, 0x83, 0x83, 0x80,
  0xC1, 0x80, 0x61, 0x80, 0x31, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x68, 0x00, 0x36, 0x00, 0x33,
  0x00, 0x31, 0x80, 0x18, 0x60, 0x18, 0x30, 0x18, 0x18, 0x1C, 0x0C, 0x1C,
  0x03, 0x00, 0x03, 0x80, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x00, 0xC0, 0xE0,
  0x18, 0x18, 0x03, 0x03, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x86, 0x00,
  0x30, 0xC0, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00,
  0x6C, 0x00, 0x0D, 0x80, 0x01, 0xA0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x3C,
  0x03, 0xE0, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0,
  0x1E, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0F, 0x80, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x1F, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x07, 0x80,
  0x70, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x70, 0x1F, 0x00, 0xE0, 0x00,
  0x7E, 0x03, 0xDF, 0x1E, 0x07, 0xF0, 0x01, 0x00,
};

const GFXglyph NotoSans_Condensed_LightItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 27, 9, 1, -27 },
  { 28, 9, 10, 12, 4, -27 },
  { 40, 18, 27, 18, 0, -27 },
  { 101, 16, 31, 16, 0, -29 },
  { 163, 20, 28, 24, 2, -28 },
  { 233, 17, 28, 18, 0, -28 },
  { 293, 4, 10, 7, 4, -27 },
  { 298, 11, 33, 10, 1, -27 },
  { 344, 11, 33, 10, -3, -27 },
  { 390, 12, 13, 15, 4, -29 },
  { 410, 14, 17, 18, 2, -22 },
  { 440, 6, 9, 7, -2, -4 },
  { 447, 8, 2, 10, 1, -11 },
  { 449, 3, 3, 7, 1, -3 },
  { 451, 17, 27, 12, -2, -27 },
  { 509, 15, 28, 16, 1, -28 },
  { 562, 8, 27, 16, 5, -27 },
  { 589, 17, 28, 16, -1, -28 },
  { 649, 16, 28, 16, 0, -28 },
  { 705, 16, 27, 16, 0, -27 },
  { 759, 16, 27, 16, 0, -27 },
  { 813, 16, 28, 16, 1, -28 },
  { 869, 15, 27, 16, 2, -27 },
  { 920, 16, 28, 16, 0, -28 },
  { 976, 16, 28, 16, 0, -28 },
  { 1032, 7, 20, 7, 0, -20 },
  { 1050, 9, 25, 7, -2, -20 },
  { 1079, 14, 17, 18, 2, -22 },
  { 1109, 14, 10, 18, 2, -18 },
  { 1127, 14, 17, 18, 2, -22 },
  { 1157, 12, 28, 12, 1, -28 },
  { 1199, 22, 30, 24, 1, -27 },
  { 1282, 16, 27, 16, -2, -27 },
  { 1336, 17, 27, 18, 1, -27 },
  { 1394, 17, 28, 16, 2, -28 },
  { 1454, 17, 27, 19, 1, -27 },
  { 1512, 16, 27, 15, 1, -27 },
  { 1566, 16, 27, 14, 1, -27 },
  { 1620, 19, 28, 20, 2, -28 },
  { 1687, 20, 27, 20, 1, -27 },
  { 1755, 14, 27, 9, -2, -27 },
  { 1803, 14, 34, 8, -6, -27 },
  { 1863, 18, 27, 16, 1, -27 },
  { 1924, 10, 27, 14, 1, -27 },
  { 1958, 25, 27, 26, 1, -27 },
  { 2043, 20, 27, 21, 1, -27 },
  { 2111, 18, 28, 21, 2, -28 },
  { 2174, 16, 27, 16, 1, -27 },
  { 2228, 18, 34, 21, 2, -28 },
  { 2305, 16, 27, 17, 1, -27 },
  { 2359, 17, 28, 15, -1, -28 },
  { 2419, 14, 27, 14, 3, -27 },
  { 2467, 18, 27, 20, 2, -27 },
  { 2528, 16, 27, 16, 3, -27 },
  { 2582, 25, 27, 26, 4, -27 },
  { 2667, 20, 27, 15, -2, -27 },
  { 2735, 15, 27, 14, 3, -27 },
  { 2786, 18, 27, 15, -1, -27 },
  { 2847, 14, 33, 11, -1, -27 },
  { 2905, 6, 27, 13, 4, -27 },
  { 2926, 14, 33, 11, -3, -27 },
  { 2984, 15, 15, 17, 1, -27 },
  { 3013, 12, 2, 12, -3, 3 },
  { 3016, 4, 6, 9, 6, -29 },
  { 3019, 16, 21, 17, 1, -21 },
  { 3061, 16, 29, 17, 0, -29 },
  { 3119, 13, 21, 13, 1, -21 },
  { 3154, 17, 29, 17, 1, -29 },
  { 3216, 13, 21, 15, 1, -21 },
  { 3251, 18, 38, 9, -5, -29 },
  { 3337, 17, 30, 17, 0, -21 },
  { 3401, 15, 29, 17, 0, -29 },
  { 3456, 8, 28, 7, 0, -28 },
  { 3484, 13, 37, 7, -5, -28 },
  { 3545, 16, 29, 14, 0, -29 },
  { 3603, 9, 29, 7, 0, -29 },
  { 3636, 24, 21, 25, 0, -21 },
  { 3699, 15, 21, 17, 0, -21 },
  { 3739, 14, 21, 17, 1, -21 },
  { 3776, 17, 30, 17, -1, -21 },
  { 3840, 16, 30, 17, 1, -21 },
  { 3900, 13, 21, 11, 0, -21 },
  { 3935, 13, 21, 13, 0, -21 },
  { 3970, 9, 25, 9, 1, -25 },
  { 3999, 15, 20, 17, 1, -20 },
  { 4037, 13, 20, 13, 2, -20 },
  { 4070, 21, 20, 21, 2, -20 },
  { 4123, 17, 20, 14, -2, -20 },
  { 4166, 19, 29, 13, -4, -20 },
  { 4235, 14, 20, 12, -1, -20 },
  { 4270, 14, 33, 12, 1, -27 },
  { 4328, 2, 38, 16, 7, -29 },
  { 4338, 13, 33, 12, -2, -27 },
  { 4392, 15, 4, 18, 2, -15 },
};

const GFXfont NotoSans_Condensed_LightItalic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic38pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC38PT7B_H_
