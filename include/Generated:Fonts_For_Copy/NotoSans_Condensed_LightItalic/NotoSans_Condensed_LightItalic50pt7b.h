#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC50PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0xF0, 0x1E, 0x03,
  0xC0, 0x70, 0x00, 0x38, 0x73, 0x87, 0x38, 0x73, 0x06, 0x30, 0x67, 0x0E,
  0x70, 0xE6, 0x0C, 0x60, 0xC6, 0x0C, 0xE1, 0xCC, 0x18, 0xC1, 0x80, 0x00,
  0x1C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x01, 0xC0, 0xC0, 0x03,
  0x03, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x38, 0x00, 0x60,
  0x60, 0x00, 0xC0, 0xC0, 0x03, 0x81, 0x80, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xE0, 0x38, 0x18, 0x00, 0x60, 0x70, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80,
  0x06, 0x07, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x70, 0x70, 0x00,
  0xC0, 0xC0, 0x01, 0x81, 0x80, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x18,
  0x18, 0x00, 0x70, 0x30, 0x00, 0xC0, 0xE0, 0x01, 0x81, 0x80, 0x03, 0x03,
  0x00, 0x0E, 0x0E, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0xE0, 0xE0,
  0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0xE0, 0x78, 0xC3, 0x03, 0x84, 0x00, 0x38, 0x60, 0x01, 0xC3, 0x00,
  0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x04, 0x00, 0x1C, 0x60, 0x00, 0xE3,
  0x00, 0x03, 0x98, 0x00, 0x1E, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xDC, 0x00, 0x0C, 0x70, 0x00, 0x63,
  0x80, 0x03, 0x0E, 0x00, 0x18, 0x70, 0x00, 0x83, 0x80, 0x0C, 0x1C, 0x00,
  0x60, 0xC0, 0x03, 0x0E, 0x00, 0x18, 0xE0, 0x60, 0x8F, 0x07, 0xFF, 0xF0,
  0x1F, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x03, 0xE0, 0x03, 0x81, 0xFC,
  0x00, 0xC0, 0xE7, 0x00, 0x60, 0x70, 0xC0, 0x38, 0x38, 0x30, 0x0C, 0x0C,
  0x0C, 0x07, 0x03, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x30, 0x70,
  0x18, 0x0C, 0x18, 0x06, 0x03, 0x0E, 0x03, 0x81, 0xC3, 0x00, 0xE0, 0x61,
  0xC0, 0x30, 0x18, 0x60, 0x0C, 0x06, 0x30, 0xF3, 0x03, 0x9C, 0x7E, 0xC0,
  0xC6, 0x39, 0xF0, 0x73, 0x9C, 0x3C, 0x18, 0xC6, 0x0F, 0x8E, 0x73, 0x83,
  0x7F, 0x18, 0xC0, 0xCF, 0x8C, 0x70, 0x30, 0x07, 0x18, 0x0C, 0x01, 0x86,
  0x03, 0x00, 0xE1, 0x80, 0xC0, 0x30, 0xE0, 0x70, 0x1C, 0x38, 0x1C, 0x06,
  0x0C, 0x06, 0x03, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x30, 0x30,
  0x38, 0x0C, 0x1C, 0x0C, 0x03, 0x06, 0x07, 0x00, 0xE3, 0x83, 0x80, 0x1F,
  0xC0, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0x00, 0x07, 0x1E, 0x00, 0x38, 0x38, 0x00, 0xC0, 0x60, 0x07, 0x01,
  0x80, 0x1C, 0x06, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x00,
  0x1C, 0x1C, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0x1C, 0x00, 0x0E,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x3B, 0x00,
  0x01, 0xCE, 0x00, 0x0E, 0x38, 0x1C, 0x70, 0x70, 0x73, 0x81, 0xC1, 0x8E,
  0x03, 0x0E, 0x70, 0x0E, 0x31, 0xC0, 0x39, 0xC6, 0x00, 0x76, 0x38, 0x01,
  0xF8, 0xE0, 0x03, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x38, 0x38, 0x01, 0xF0,
  0x70, 0x0F, 0xC1, 0xE0, 0xF3, 0x83, 0xFF, 0x8E, 0x07, 0xF8, 0x1C, 0x02,
  0x00, 0x00, 0x39, 0xCE, 0x63, 0x39, 0xCC, 0x63, 0x19, 0x8C, 0x00, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0xC1, 0x80, 0xE1, 0x80, 0xF9, 0x81, 0x1F,
  0x3F, 0x07, 0xFF, 0x07, 0x80, 0x0F, 0x80, 0x1C, 0xC0, 0x38, 0xC0, 0x70,
  0x60, 0xE0, 0x60, 0x20, 0x70, 0x00, 0x20, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38,
  0x30, 0x70, 0x60, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x2F, 0xFF, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x07, 0x9F, 0x01, 0xC0,
  0xE0, 0x78, 0x1C, 0x0E, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x1C, 0x00,
  0xE3, 0x80, 0x1C, 0x60, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0x60, 0x01,
  0x9C, 0x00, 0x33, 0x80, 0x0E, 0x70, 0x01, 0xCC, 0x00, 0x3B, 0x80, 0x07,
  0x70, 0x00, 0xEE, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1C,
  0xC0, 0x07, 0x18, 0x00, 0xE3, 0x00, 0x1C, 0x60, 0x07, 0x0C, 0x00, 0xE1,
  0x80, 0x38, 0x38, 0x07, 0x07, 0x01, 0xC0, 0xE0, 0x70, 0x0E, 0x1E, 0x01,
  0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x70, 0x1E, 0x03, 0xE0,
  0x7E, 0x0E, 0xE3, 0xCC, 0x78, 0xCE, 0x1C, 0x41, 0xC0, 0x1C, 0x01, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0x0F, 0x00, 0x30, 0x0E,
  0x00, 0x80, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0xF8, 0x7C,
  0x07, 0x00, 0xE0, 0x20, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x01, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x80, 0x0E, 0x06, 0x01, 0xE0, 0x3F, 0xFE, 0x00,
  0xFF, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x36, 0x00, 0x01, 0xF8, 0x00, 0x06, 0xE0, 0x00,
  0x3B, 0x00, 0x01, 0xCC, 0x00, 0x06, 0x70, 0x00, 0x31, 0xC0, 0x01, 0xC7,
  0x00, 0x06, 0x18, 0x00, 0x30, 0x60, 0x01, 0xC3, 0x80, 0x06, 0x0E, 0x00,
  0x30, 0x38, 0x01, 0xC0, 0xC0, 0x0E, 0x07, 0x00, 0x30, 0x1C, 0x01, 0xC0,
  0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0xE0,
  0x30, 0x03, 0x81, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x39, 0x80,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x20, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x80, 0x1E, 0x07,
  0x01, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7C, 0x20, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0xFC,
  0x07, 0x3F, 0xE0, 0x77, 0x1F, 0x07, 0xC0, 0x70, 0x78, 0x03, 0x87, 0x00,
  0x38, 0xF0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0,
  0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E,
  0x00, 0x60, 0xE0, 0x0E, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x87, 0x80,
  0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x3C, 0x3C, 0x03, 0x80,
  0xF0, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x07,
  0x00, 0x38, 0x38, 0x01, 0xC0, 0xC0, 0x0E, 0x07, 0x00, 0xE0, 0x38, 0x06,
  0x00, 0xC0, 0x70, 0x07, 0x0F, 0x00, 0x1C, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0x80, 0x0F, 0x1C, 0x00, 0xF0, 0x70, 0x0E, 0x01, 0xC0,
  0xE0, 0x0E, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x00, 0x0E, 0x38, 0x00,
  0x71, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE1, 0x80, 0x06, 0x0E,
  0x00, 0x70, 0x78, 0x07, 0x01, 0xE0, 0x78, 0x07, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xE3, 0xC0,
  0x38, 0x1E, 0x07, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0x60, 0xC0, 0x06,
  0x1C, 0x00, 0x71, 0xC0, 0x06, 0x18, 0x00, 0x61, 0x80, 0x06, 0x38, 0x00,
  0x63, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x01, 0xE1, 0xC0,
  0x3E, 0x1C, 0x07, 0xC1, 0xE0, 0xEC, 0x0F, 0xFD, 0xC0, 0x7F, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x08, 0x1E, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x01, 0xC1, 0xE0, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0xE0, 0x70, 0x78, 0x1C, 0x00, 0x00, 0x40, 0x1C, 0x07,
  0x80, 0xF0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00,
  0xE0, 0x18, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xF8, 0x78, 0xF0, 0x80,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x01, 0xC3, 0x00, 0x7C, 0x06, 0x38, 0x0F, 0xF8, 0x31, 0x80, 0xE1, 0x81,
  0x9C, 0x0E, 0x0C, 0x0C, 0xC0, 0xE0, 0x60, 0x66, 0x06, 0x07, 0x07, 0x70,
  0x70, 0x30, 0x3B, 0x03, 0x01, 0x81, 0x98, 0x38, 0x1C, 0x0C, 0xC1, 0x80,
  0xE0, 0x6E, 0x0C, 0x06, 0x07, 0x60, 0x60, 0x30, 0x33, 0x07, 0x03, 0x81,
  0x98, 0x38, 0x1C, 0x1C, 0xC1, 0x80, 0xC0, 0xC6, 0x0C, 0x0E, 0x06, 0x30,
  0x70, 0xF0, 0x61, 0x83, 0x86, 0xC7, 0x0C, 0x0F, 0xE7, 0xF0, 0x60, 0x3E,
  0x3F, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xCE, 0x00,
  0x0E, 0x70, 0x00, 0x73, 0x80, 0x03, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0x83,
  0x00, 0x1C, 0x18, 0x00, 0xC0, 0xC0, 0x0E, 0x06, 0x00, 0x70, 0x30, 0x07,
  0x01, 0x80, 0x38, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x60, 0x06, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC3, 0x80,
  0x0E, 0x1C, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0xE0, 0x00, 0xE7,
  0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0F, 0xC0, 0x00,
  0x70, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x60, 0x1E,
  0x03, 0x80, 0x3C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03,
  0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x0E, 0x06, 0x00,
  0x38, 0x38, 0x01, 0xC0, 0xE0, 0x0F, 0x03, 0x80, 0xF8, 0x0F, 0xFF, 0x80,
  0x3F, 0xF8, 0x01, 0xC1, 0xF8, 0x07, 0x00, 0xF0, 0x1C, 0x01, 0xE0, 0x70,
  0x03, 0x81, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x03,
  0x83, 0x80, 0x0E, 0x0C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x07, 0x07,
  0x00, 0x1C, 0x18, 0x00, 0xE0, 0xE0, 0x0F, 0x03, 0x83, 0xF8, 0x0F, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFC, 0x01, 0xF8,
  0x70, 0x07, 0x80, 0x20, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x0C, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x04, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x0C, 0x07, 0xC0, 0x38, 0x03, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x81,
  0xC0, 0x07, 0x03, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38,
  0x00, 0x70, 0x60, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00,
  0x07, 0x0E, 0x00, 0x0E, 0x18, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00,
  0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x86, 0x00, 0x07, 0x1C, 0x00, 0x1C,
  0x38, 0x00, 0x38, 0x70, 0x00, 0xE0, 0xC0, 0x01, 0xC1, 0x80, 0x07, 0x07,
  0x00, 0x0E, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x30, 0x07, 0x80, 0xE0,
  0x1E, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF,
  0xE0, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0xE0,
  0x3F, 0xFE, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xC3, 0xE0, 0x1E, 0x00, 0x20, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x1C, 0x00, 0xFF, 0x0E, 0x00, 0x7F, 0x86,
  0x00, 0x41, 0xC3, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x30,
  0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x06,
  0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0xE0, 0x01, 0xC0, 0x70, 0x00,
  0xE0, 0x3C, 0x00, 0x60, 0x0F, 0x80, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70,
  0x1C, 0x00, 0x1C, 0x06, 0x00, 0x06, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00,
  0xE0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0C, 0x03, 0x00, 0x07, 0x01, 0xC0,
  0x01, 0xC0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x06, 0x00, 0x06, 0x03,
  0x80, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x70, 0x1C, 0x00,
  0x1C, 0x07, 0x00, 0x07, 0x01, 0x80, 0x01, 0x80, 0xE0, 0x00, 0xE0, 0x38,
  0x00, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x01, 0xC0, 0x01, 0xC0,
  0x70, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0x80, 0x01,
  0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x01, 0xBE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x0E,
  0x01, 0xC0, 0x1E, 0x01, 0x80, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70,
  0x03, 0x80, 0xE0, 0x03, 0x01, 0xE0, 0x03, 0x03, 0xC0, 0x07, 0x03, 0x80,
  0x07, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x06, 0x1C, 0x00, 0x0E, 0x3C, 0x00,
  0x0E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0D, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0x30, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x18, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00,
  0x30, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x80,
  0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF8, 0x07, 0x80,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xC0, 0x3F,
  0x00, 0x03, 0xB0, 0x0D, 0xC0, 0x00, 0xFC, 0x03, 0x70, 0x00, 0x77, 0x01,
  0xDC, 0x00, 0x1D, 0xC0, 0x77, 0x00, 0x0E, 0x60, 0x1C, 0xC0, 0x03, 0xB8,
  0x06, 0x30, 0x01, 0xCE, 0x03, 0x8C, 0x00, 0x73, 0x80, 0xE3, 0x00, 0x38,
  0xE0, 0x38, 0xC0, 0x0C, 0x30, 0x0C, 0x30, 0x07, 0x1C, 0x03, 0x0C, 0x01,
  0x87, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x30, 0x60, 0x1C, 0x38,
  0x1C, 0x18, 0x06, 0x0E, 0x06, 0x0E, 0x01, 0x83, 0x83, 0x83, 0x80, 0xE0,
  0xE0, 0xC0, 0xE0, 0x38, 0x18, 0x70, 0x30, 0x0E, 0x06, 0x18, 0x0C, 0x03,
  0x01, 0x8E, 0x07, 0x01, 0xC0, 0x63, 0x01, 0xC0, 0x70, 0x19, 0xC0, 0x70,
  0x1C, 0x06, 0x60, 0x18, 0x07, 0x01, 0xB8, 0x0E, 0x01, 0x80, 0x7C, 0x03,
  0x80, 0xE0, 0x1F, 0x00, 0xE0, 0x38, 0x07, 0x80, 0x38, 0x0E, 0x01, 0xE0,
  0x0C, 0x03, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x3C, 0x00,
  0x1C, 0x07, 0x80, 0x03, 0x80, 0xF0, 0x00, 0x60, 0x3E, 0x00, 0x1C, 0x07,
  0xE0, 0x03, 0x80, 0xDC, 0x00, 0x70, 0x19, 0x80, 0x0E, 0x03, 0x30, 0x01,
  0x80, 0xE7, 0x00, 0x70, 0x1C, 0xE0, 0x0E, 0x03, 0x8C, 0x01, 0xC0, 0x61,
  0x80, 0x30, 0x1C, 0x38, 0x06, 0x03, 0x87, 0x01, 0xC0, 0x70, 0xE0, 0x38,
  0x0E, 0x0C, 0x07, 0x01, 0x81, 0xC0, 0xC0, 0x70, 0x38, 0x38, 0x0E, 0x07,
  0x07, 0x01, 0xC0, 0x60, 0xE0, 0x30, 0x0E, 0x1C, 0x06, 0x01, 0xC3, 0x01,
  0xC0, 0x38, 0xE0, 0x38, 0x03, 0x1C, 0x07, 0x00, 0x73, 0x80, 0xC0, 0x0E,
  0x60, 0x38, 0x01, 0xCC, 0x07, 0x00, 0x1B, 0x80, 0xE0, 0x03, 0xF0, 0x1C,
  0x00, 0x7E, 0x03, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x1E,
  0x03, 0x80, 0x03, 0xC0, 0x60, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x78, 0x7C, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x0E, 0x03,
  0x80, 0x0E, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E,
  0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38,
  0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x06, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x60,
  0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x38, 0x60, 0x00, 0x78, 0x60, 0x00, 0x70, 0x70,
  0x00, 0xE0, 0x70, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x3E,
  0x0F, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0x01, 0xE0, 0x38, 0x07,
  0x81, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x03, 0x00, 0x38, 0x38,
  0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x60, 0x03, 0x87, 0x00, 0x38,
  0x38, 0x01, 0xC1, 0xC0, 0x1E, 0x0E, 0x00, 0xE0, 0x60, 0x1E, 0x07, 0x03,
  0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x78, 0x7C, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x0E, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x0E, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x38, 0x00,
  0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x70, 0x00,
  0x07, 0x70, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x60, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70, 0x60, 0x00,
  0x70, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x3E, 0x0F, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xB8,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0x01, 0xE0,
  0x38, 0x07, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x03, 0x00,
  0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x60, 0x03, 0x87,
  0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x1C, 0x0E, 0x01, 0xE0, 0x60, 0x3E,
  0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0E, 0x0C, 0x00, 0x60,
  0x70, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0x60, 0x0C, 0x03, 0x80,
  0x60, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x03, 0x01, 0xC0, 0x1C, 0x0C, 0x00,
  0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x00,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xF0, 0x0F, 0xCF, 0xC0, 0x78, 0x02, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x80, 0x0F, 0x03, 0xC0, 0xF8, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x03, 0x81,
  0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70,
  0x38, 0x00, 0x38, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x0C, 0x0E, 0x00, 0x0E,
  0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0x80, 0x01, 0x81, 0xC0, 0x01,
  0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0x18, 0x00,
  0x18, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x00,
  0x03, 0x01, 0x80, 0x01, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70,
  0x00, 0x70, 0x30, 0x00, 0x30, 0x18, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E,
  0x00, 0x0C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x3B, 0x00, 0x01, 0xD8, 0x00, 0x1C,
  0xC0, 0x00, 0xE6, 0x00, 0x0E, 0x30, 0x00, 0x71, 0x80, 0x03, 0x0C, 0x00,
  0x38, 0x60, 0x01, 0xC3, 0x00, 0x1C, 0x18, 0x00, 0xE0, 0xE0, 0x0E, 0x07,
  0x00, 0x70, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C,
  0x03, 0x80, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x60, 0x07, 0x07, 0x00, 0x38,
  0x38, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00,
  0x1C, 0x60, 0x00, 0xE7, 0x00, 0x03, 0x30, 0x00, 0x1B, 0x80, 0x00, 0xD8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x01, 0xD8, 0x00, 0x78, 0x00, 0xEC, 0x00, 0x7C, 0x00, 0x76,
  0x00, 0x36, 0x00, 0x73, 0x00, 0x1B, 0x00, 0x39, 0x80, 0x1F, 0x80, 0x38,
  0xC0, 0x0D, 0xC0, 0x1C, 0x60, 0x0E, 0xE0, 0x0C, 0x30, 0x06, 0x70, 0x0E,
  0x18, 0x03, 0x38, 0x07, 0x0C, 0x03, 0x9C, 0x07, 0x06, 0x01, 0x8E, 0x03,
  0x83, 0x01, 0xC7, 0x01, 0x81, 0x80, 0xC3, 0x81, 0xC0, 0xC0, 0xE1, 0xC0,
  0xE0, 0x60, 0x70, 0xE0, 0xE0, 0x30, 0x30, 0x70, 0x70, 0x18, 0x38, 0x38,
  0x30, 0x0C, 0x18, 0x1C, 0x38, 0x06, 0x1C, 0x0E, 0x18, 0x03, 0x0E, 0x07,
  0x1C, 0x01, 0x86, 0x03, 0x8E, 0x00, 0xC7, 0x01, 0xCE, 0x00, 0x63, 0x00,
  0xE7, 0x00, 0x33, 0x80, 0x73, 0x00, 0x19, 0x80, 0x3B, 0x80, 0x0C, 0xC0,
  0x1D, 0xC0, 0x06, 0xE0, 0x0E, 0xC0, 0x03, 0x60, 0x07, 0xE0, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x60, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x30, 0x06,
  0x00, 0x0C, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38,
  0x38, 0x00, 0x06, 0x1C, 0x00, 0x01, 0x87, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x1C, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x03,
  0x8C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x38, 0x00,
  0x0C, 0x0E, 0x00, 0x07, 0x01, 0x80, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x1C,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x07, 0x00,
  0x0E, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xEC, 0x00, 0x39, 0x80, 0x07,
  0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x70,
  0x30, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x87, 0x00,
  0x70, 0xE0, 0x06, 0x38, 0x00, 0xC6, 0x00, 0x19, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x60, 0x60, 0x70,
  0x70, 0x70, 0x30, 0x30, 0x30, 0x30, 0x38, 0x38, 0x38, 0x18, 0x18, 0x18,
  0x18, 0x1C, 0x1C, 0x1C, 0x0C, 0x0C, 0x0C, 0x0E, 0x0E, 0x0E, 0x0E, 0x06,
  0x06, 0x06, 0x07, 0x07, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x6E, 0x00, 0x0E, 0x60, 0x00, 0xC7,
  0x00, 0x1C, 0x70, 0x01, 0x83, 0x00, 0x38, 0x38, 0x07, 0x03, 0x80, 0x70,
  0x18, 0x0E, 0x01, 0xC0, 0xC0, 0x0C, 0x1C, 0x00, 0xE1, 0x80, 0x0E, 0x38,
  0x00, 0x67, 0x00, 0x07, 0x70, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFE, 0xE1, 0xC7, 0x0E, 0x18, 0x70, 0xC1, 0x00, 0xFC, 0x30, 0x1F, 0xE7,
  0x07, 0xCF, 0x60, 0x70, 0x36, 0x0E, 0x01, 0xE1, 0xC0, 0x1E, 0x1C, 0x01,
  0xE3, 0x80, 0x1C, 0x38, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00,
  0x18, 0xE0, 0x01, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0,
  0x03, 0x0E, 0x00, 0x70, 0xC0, 0x07, 0x0C, 0x00, 0xF0, 0xC0, 0x0F, 0x0E,
  0x01, 0xE0, 0xE0, 0x16, 0x0E, 0x03, 0x60, 0x70, 0xEE, 0x07, 0xFC, 0xC0,
  0x3F, 0x8C, 0x00, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x71, 0xF8, 0x07,
  0x3F, 0xC0, 0x67, 0x3E, 0x0E, 0xC0, 0xE0, 0xF8, 0x0E, 0x0F, 0x00, 0x70,
  0xF0, 0x07, 0x0E, 0x00, 0x71, 0xE0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07,
  0x1C, 0x00, 0x71, 0x80, 0x06, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00,
  0xE3, 0x00, 0x0E, 0x30, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0x87, 0x00,
  0x38, 0x70, 0x03, 0x8F, 0x80, 0x70, 0xF8, 0x0E, 0x0C, 0xC1, 0xE0, 0xCF,
  0xFC, 0x0C, 0x7F, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7E, 0x01, 0xFF, 0x07,
  0xE7, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x30, 0x3F, 0xF0, 0x1F,
  0xE0, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x3F, 0x1C,
  0x01, 0xFE, 0x70, 0x1F, 0x3D, 0x80, 0x70, 0x36, 0x03, 0x80, 0x78, 0x1C,
  0x01, 0xE0, 0x70, 0x07, 0x83, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x70, 0x01,
  0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x18, 0x00, 0x60, 0xE0, 0x03, 0x83,
  0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xC0, 0x07, 0x03, 0x00,
  0x1C, 0x0C, 0x00, 0xF0, 0x30, 0x03, 0xC0, 0xE0, 0x1E, 0x03, 0x80, 0x78,
  0x0E, 0x03, 0x60, 0x1C, 0x3B, 0x80, 0x7F, 0xCE, 0x00, 0xFE, 0x30, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0xF3, 0xC0, 0xE0, 0x70,
  0xE0, 0x38, 0xE0, 0x1C, 0x60, 0x0E, 0x70, 0x06, 0x30, 0x07, 0x38, 0x03,
  0x9C, 0x07, 0x8C, 0x07, 0x8F, 0xFF, 0x87, 0xFF, 0x03, 0xF8, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x18, 0x1F, 0xFC, 0x07, 0xFC,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xE2,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0xBE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x0C,
  0x01, 0xFE, 0x70, 0x1F, 0x3D, 0x80, 0x70, 0x36, 0x03, 0x80, 0x58, 0x1C,
  0x01, 0xE0, 0x70, 0x07, 0x83, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x70, 0x01,
  0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x18, 0x00, 0x60, 0xE0, 0x03, 0x83,
  0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x01, 0xE0, 0xC0, 0x07, 0x03, 0x00,
  0x1C, 0x0C, 0x00, 0xF0, 0x30, 0x03, 0xC0, 0xE0, 0x1E, 0x03, 0x80, 0xF8,
  0x0E, 0x03, 0xE0, 0x1C, 0x3B, 0x80, 0x7F, 0xCE, 0x00, 0xFE, 0x30, 0x00,
  0x40, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x20, 0x0E, 0x00,
  0xF1, 0xF0, 0x03, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x8F, 0xC0, 0x73, 0xFC, 0x0D, 0xE7, 0xC1, 0xB0, 0x38, 0x7C, 0x07, 0x0F,
  0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0C, 0x38,
  0x01, 0x87, 0x00, 0x70, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x30, 0xE0,
  0x06, 0x18, 0x01, 0xC3, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xC3, 0x80,
  0x38, 0x60, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x0E, 0x00,
  0xE1, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38,
  0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C,
  0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x37, 0xC0, 0x0F, 0xE0, 0x03, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x70, 0x0E, 0x0C, 0x03, 0x81, 0x80,
  0xE0, 0x70, 0x38, 0x0E, 0x0E, 0x01, 0xC3, 0x80, 0x30, 0xE0, 0x0E, 0x1C,
  0x01, 0xC7, 0x00, 0x39, 0xC0, 0x06, 0x70, 0x00, 0xDF, 0x00, 0x3F, 0xE0,
  0x07, 0xDC, 0x00, 0xF1, 0x80, 0x1C, 0x38, 0x03, 0x07, 0x00, 0xE0, 0xE0,
  0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x1C, 0x07, 0x03, 0x80, 0x70,
  0x70, 0x0E, 0x0E, 0x01, 0xC1, 0x80, 0x18, 0x00, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0,
  0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x00, 0x06, 0x1F, 0x01, 0xF0,
  0x19, 0xFE, 0x1F, 0xE0, 0x6F, 0x3C, 0xE7, 0xC1, 0xB0, 0x76, 0x07, 0x0F,
  0x80, 0xF0, 0x1C, 0x3C, 0x03, 0xC0, 0x30, 0xE0, 0x0E, 0x01, 0xC3, 0x80,
  0x38, 0x07, 0x1C, 0x01, 0xC0, 0x1C, 0x70, 0x07, 0x00, 0x71, 0xC0, 0x1C,
  0x01, 0x87, 0x00, 0x60, 0x06, 0x18, 0x01, 0x80, 0x38, 0xE0, 0x0E, 0x00,
  0xE3, 0x80, 0x38, 0x03, 0x8E, 0x00, 0xE0, 0x0C, 0x30, 0x03, 0x00, 0x30,
  0xC0, 0x1C, 0x01, 0xC7, 0x00, 0x70, 0x07, 0x1C, 0x01, 0xC0, 0x1C, 0x70,
  0x07, 0x00, 0x61, 0x80, 0x18, 0x03, 0x8E, 0x00, 0xE0, 0x0E, 0x38, 0x03,
  0x80, 0x38, 0xE0, 0x0E, 0x00, 0xC3, 0x80, 0x30, 0x03, 0x0C, 0x01, 0xC0,
  0x1C, 0x00, 0x03, 0x0F, 0xC0, 0x33, 0xFE, 0x03, 0x7D, 0xF0, 0x76, 0x07,
  0x07, 0xC0, 0x70, 0x78, 0x07, 0x07, 0x00, 0x70, 0x70, 0x07, 0x0F, 0x00,
  0x70, 0xE0, 0x06, 0x0E, 0x00, 0x60, 0xE0, 0x0E, 0x0C, 0x00, 0xE1, 0xC0,
  0x0E, 0x1C, 0x00, 0xC1, 0xC0, 0x1C, 0x18, 0x01, 0xC1, 0x80, 0x1C, 0x38,
  0x01, 0xC3, 0x80, 0x18, 0x38, 0x03, 0x83, 0x00, 0x38, 0x70, 0x03, 0x87,
  0x00, 0x38, 0x70, 0x03, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0xC0, 0x7C, 0x78, 0x3C, 0x0E, 0x0E, 0x01, 0xC7, 0x00, 0x71,
  0xC0, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x1D, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0E, 0xE0, 0x03,
  0xB0, 0x00, 0xEC, 0x00, 0x33, 0x00, 0x1C, 0xC0, 0x07, 0x38, 0x03, 0x8E,
  0x01, 0xE3, 0xC0, 0x70, 0x78, 0x78, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x08,
  0x00, 0x00, 0xC3, 0xF0, 0x01, 0x8F, 0xF0, 0x03, 0x39, 0xF0, 0x06, 0xC0,
  0xE0, 0x1F, 0x00, 0xC0, 0x3C, 0x01, 0xC0, 0x78, 0x03, 0x80, 0xE0, 0x07,
  0x03, 0xC0, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70,
  0x30, 0x00, 0xC0, 0xE0, 0x01, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x07,
  0x00, 0x1C, 0x0C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0,
  0x07, 0x01, 0xC0, 0x0E, 0x03, 0xC0, 0x38, 0x0F, 0x80, 0xE0, 0x1D, 0x83,
  0x80, 0x3B, 0xFF, 0x00, 0x63, 0xF8, 0x01, 0xC0, 0x80, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x30, 0x1F, 0xE7, 0x07,
  0xCF, 0x60, 0x70, 0x36, 0x0E, 0x01, 0x61, 0xC0, 0x1E, 0x1C, 0x01, 0xE3,
  0x80, 0x1C, 0x38, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C,
  0x60, 0x01, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03,
  0x8C, 0x00, 0x70, 0xC0, 0x07, 0x0C, 0x00, 0xF0, 0xC0, 0x0F, 0x0E, 0x01,
  0xE0, 0xE0, 0x1E, 0x0E, 0x03, 0xE0, 0x70, 0xEE, 0x07, 0xFC, 0xE0, 0x3F,
  0x8C, 0x00, 0x40, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x1F, 0x06, 0x7E,
  0x06, 0xFE, 0x06, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC1, 0xE3, 0xC1, 0xC0, 0x21, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xE1, 0x00, 0x70, 0xC0, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x0F,
  0xF3, 0xFF, 0x3F, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x70,
  0x07, 0xF0, 0x3F, 0x00, 0x80, 0x0E, 0x00, 0x61, 0x80, 0x1C, 0x30, 0x03,
  0x8E, 0x00, 0x71, 0xC0, 0x0C, 0x38, 0x03, 0x86, 0x00, 0x71, 0xC0, 0x0E,
  0x38, 0x01, 0xC7, 0x00, 0x30, 0xE0, 0x0E, 0x18, 0x01, 0xC7, 0x00, 0x38,
  0xE0, 0x06, 0x1C, 0x00, 0xC3, 0x00, 0x38, 0x60, 0x07, 0x1C, 0x00, 0xE3,
  0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0x80, 0x3C, 0x30, 0x0F, 0x87,
  0x03, 0x60, 0xF0, 0xEC, 0x0F, 0xF9, 0x81, 0xFC, 0x70, 0x04, 0x00, 0x00,
  0xC0, 0x03, 0xE0, 0x03, 0xB0, 0x01, 0xDC, 0x01, 0xCE, 0x00, 0xE7, 0x00,
  0x63, 0x80, 0x71, 0xC0, 0x30, 0xE0, 0x38, 0x70, 0x18, 0x38, 0x1C, 0x1C,
  0x0C, 0x0E, 0x0E, 0x07, 0x07, 0x03, 0x87, 0x01, 0xC3, 0x80, 0x63, 0x80,
  0x31, 0xC0, 0x19, 0xC0, 0x0C, 0xE0, 0x06, 0x60, 0x03, 0x70, 0x01, 0xB0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0xFC, 0x01, 0xC0, 0x1F, 0x80, 0x78, 0x07, 0x70, 0x0F, 0x00, 0xEE,
  0x03, 0xE0, 0x19, 0xC0, 0x6C, 0x07, 0x38, 0x0D, 0x80, 0xC7, 0x03, 0x30,
  0x38, 0xE0, 0x66, 0x07, 0x1C, 0x1C, 0xC0, 0xC3, 0x83, 0x18, 0x38, 0x70,
  0xE3, 0x06, 0x0E, 0x18, 0x61, 0xC1, 0xC3, 0x0C, 0x38, 0x38, 0xE1, 0x8E,
  0x07, 0x18, 0x31, 0xC0, 0xE7, 0x06, 0x30, 0x1C, 0xC0, 0xCE, 0x03, 0xB8,
  0x19, 0x80, 0x76, 0x03, 0x70, 0x0E, 0xC0, 0x6E, 0x01, 0xF8, 0x0D, 0x80,
  0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x3C, 0x0E, 0x00, 0xE0,
  0x18, 0x07, 0x00, 0x60, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x07, 0x00, 0x0C,
  0x38, 0x00, 0x38, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0xB8, 0x00, 0x06, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xD8, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x01, 0xC3,
  0x00, 0x0E, 0x0C, 0x00, 0x38, 0x38, 0x01, 0xC0, 0xE0, 0x0E, 0x01, 0x80,
  0x38, 0x07, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x70, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x70, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x38, 0x00, 0x60,
  0x18, 0x00, 0x30, 0x1C, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x0E, 0x00, 0x06,
  0x07, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE3, 0x80, 0x00,
  0x71, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x07, 0x70, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x09, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xC0,
  0x00, 0x3F, 0x80, 0x17, 0xFE, 0x03, 0xE0, 0xFD, 0xFC, 0x03, 0xFE, 0x80,
  0x0F, 0x80,
};

const GFXglyph NotoSans_Condensed_LightItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 11, 36, 11, 1, -36 },
  { 51, 12, 13, 16, 5, -36 },
  { 71, 23, 36, 23, 1, -36 },
  { 175, 21, 41, 21, 0, -38 },
  { 283, 26, 37, 31, 3, -36 },
  { 404, 22, 37, 23, 0, -36 },
  { 506, 5, 13, 9, 5, -36 },
  { 515, 15, 44, 13, 1, -36 },
  { 598, 15, 44, 13, -4, -36 },
  { 681, 16, 17, 20, 6, -38 },
  { 715, 20, 23, 23, 2, -29 },
  { 773, 8, 11, 10, -2, -5 },
  { 784, 11, 3, 14, 1, -15 },
  { 789, 4, 5, 10, 1, -5 },
  { 792, 22, 36, 16, -2, -36 },
  { 891, 19, 37, 21, 2, -36 },
  { 979, 12, 36, 21, 6, -36 },
  { 1033, 22, 36, 21, -1, -36 },
  { 1132, 21, 37, 21, 0, -36 },
  { 1230, 22, 36, 21, -1, -36 },
  { 1329, 21, 37, 21, 0, -36 },
  { 1427, 20, 37, 21, 2, -36 },
  { 1520, 20, 36, 21, 3, -36 },
  { 1610, 21, 37, 21, 0, -36 },
  { 1708, 20, 37, 21, 1, -36 },
  { 1801, 9, 27, 10, 0, -27 },
  { 1832, 11, 33, 10, -2, -27 },
  { 1878, 20, 22, 23, 2, -29 },
  { 1933, 20, 13, 23, 2, -24 },
  { 1966, 20, 22, 23, 2, -29 },
  { 2021, 15, 36, 16, 2, -36 },
  { 2089, 29, 40, 32, 2, -36 },
  { 2234, 21, 36, 21, -3, -36 },
  { 2329, 22, 36, 23, 1, -36 },
  { 2428, 23, 37, 22, 2, -36 },
  { 2535, 23, 36, 25, 1, -36 },
  { 2639, 21, 36, 20, 1, -36 },
  { 2734, 21, 36, 19, 1, -36 },
  { 2829, 25, 37, 27, 2, -36 },
  { 2945, 26, 36, 26, 1, -36 },
  { 3062, 17, 36, 12, -2, -36 },
  { 3139, 19, 45, 10, -8, -36 },
  { 3246, 24, 36, 21, 1, -36 },
  { 3354, 14, 36, 18, 1, -36 },
  { 3417, 34, 36, 34, 1, -36 },
  { 3570, 27, 36, 27, 1, -36 },
  { 3692, 24, 37, 27, 2, -36 },
  { 3803, 21, 36, 22, 1, -36 },
  { 3898, 24, 45, 27, 2, -36 },
  { 4033, 21, 36, 22, 1, -36 },
  { 4128, 22, 37, 20, -1, -36 },
  { 4230, 19, 36, 19, 4, -36 },
  { 4316, 25, 37, 26, 2, -36 },
  { 4432, 21, 36, 21, 4, -36 },
  { 4527, 33, 36, 35, 5, -36 },
  { 4676, 26, 36, 19, -3, -36 },
  { 4793, 19, 36, 19, 4, -36 },
  { 4879, 24, 36, 19, -2, -36 },
  { 4987, 19, 44, 14, -1, -36 },
  { 5092, 8, 36, 17, 5, -36 },
  { 5128, 18, 44, 14, -3, -36 },
  { 5227, 20, 20, 22, 1, -36 },
  { 5277, 16, 2, 16, -4, 5 },
  { 5281, 6, 8, 12, 7, -38 },
  { 5287, 20, 28, 22, 2, -27 },
  { 5357, 20, 39, 22, 1, -38 },
  { 5455, 16, 28, 17, 2, -27 },
  { 5511, 22, 39, 23, 2, -38 },
  { 5619, 17, 28, 20, 2, -27 },
  { 5679, 24, 50, 12, -6, -38 },
  { 5829, 22, 39, 23, 0, -27 },
  { 5937, 19, 38, 22, 1, -38 },
  { 6028, 10, 36, 10, 1, -36 },
  { 6073, 18, 48, 10, -7, -36 },
  { 6181, 19, 38, 19, 1, -38 },
  { 6272, 10, 38, 9, 1, -38 },
  { 6320, 30, 27, 33, 1, -27 },
  { 6422, 20, 27, 22, 0, -27 },
  { 6490, 18, 28, 22, 2, -27 },
  { 6553, 23, 39, 22, -2, -27 },
  { 6666, 20, 39, 23, 2, -27 },
  { 6764, 16, 27, 15, 1, -27 },
  { 6818, 17, 28, 17, 0, -27 },
  { 6878, 12, 34, 12, 1, -33 },
  { 6929, 19, 28, 22, 2, -27 },
  { 6996, 17, 27, 17, 3, -27 },
  { 7054, 27, 27, 28, 3, -27 },
  { 7146, 22, 27, 18, -2, -27 },
  { 7221, 25, 39, 18, -5, -27 },
  { 7343, 18, 27, 16, -1, -27 },
  { 7404, 18, 44, 16, 1, -36 },
  { 7503, 3, 50, 21, 9, -38 },
  { 7522, 18, 44, 16, -3, -36 },
  { 7621, 20, 5, 23, 2, -20 },
};

const GFXfont NotoSans_Condensed_LightItalic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic50pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC50PT7B_H_
