#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC29PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x10, 0x60, 0xC1, 0x82, 0x04, 0x18, 0x30, 0x40, 0x81,
  0x06, 0x08, 0x10, 0x00, 0x01, 0x03, 0x0C, 0x00, 0x66, 0xCD, 0x12, 0x2C,
  0x59, 0xA2, 0x44, 0x01, 0x88, 0x04, 0x20, 0x11, 0x80, 0xC4, 0x02, 0x10,
  0x08, 0xC3, 0xFF, 0xCF, 0xFF, 0x04, 0x60, 0x31, 0x00, 0x84, 0x02, 0x10,
  0x08, 0xC3, 0xFF, 0xCF, 0xFF, 0x04, 0x60, 0x31, 0x00, 0x84, 0x02, 0x30,
  0x18, 0x80, 0x42, 0x00, 0x00, 0x80, 0x08, 0x01, 0xC0, 0x7F, 0x0D, 0x11,
  0x90, 0x11, 0x01, 0x10, 0x19, 0x01, 0xA0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x2C, 0x04, 0x40, 0x44, 0x04, 0x40, 0x4C, 0x8C, 0x8F, 0xF0, 0x1C, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x1C, 0x04, 0x6C, 0x11, 0x88, 0x62, 0x10, 0x8C,
  0x23, 0x18, 0xC4, 0x21, 0x90, 0x42, 0x60, 0x84, 0x8D, 0x1B, 0x7E, 0x24,
  0x8E, 0xDA, 0x17, 0x24, 0x20, 0x98, 0x43, 0x31, 0x84, 0x43, 0x18, 0x84,
  0x21, 0x08, 0xC2, 0x31, 0x04, 0xC4, 0x0F, 0x00, 0x03, 0xC0, 0x33, 0x01,
  0x08, 0x18, 0x40, 0xC6, 0x06, 0x30, 0x31, 0x01, 0x98, 0x05, 0x80, 0x30,
  0x03, 0x80, 0x34, 0x03, 0x31, 0xB0, 0x89, 0x06, 0xD8, 0x34, 0xC0, 0xE6,
  0x06, 0x30, 0x70, 0xC6, 0xC7, 0xE3, 0x00, 0x6D, 0x25, 0xA4, 0x01, 0x02,
  0x04, 0x0C, 0x08, 0x10, 0x30, 0x20, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0xC0,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x40, 0x60,
  0x06, 0x02, 0x03, 0x03, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x30, 0x20,
  0x40, 0x80, 0x04, 0x01, 0x08, 0x43, 0xB0, 0x3F, 0xC3, 0x03, 0x41, 0x98,
  0x42, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x33, 0x26, 0x4C, 0x80, 0xFF, 0xF0, 0x4F, 0x80, 0x00, 0x10, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x0C, 0x00, 0x80, 0x00, 0x03, 0x81, 0xD8, 0x61, 0x8C, 0x33, 0x06, 0x60,
  0xC8, 0x1B, 0x03, 0x60, 0x68, 0x0D, 0x01, 0x60, 0x2C, 0x0D, 0x81, 0xB0,
  0x36, 0x0C, 0xC1, 0x98, 0x23, 0x0C, 0x33, 0x07, 0xC0, 0x0C, 0x73, 0xDA,
  0x88, 0x61, 0x86, 0x10, 0x43, 0x0C, 0x30, 0x82, 0x18, 0x61, 0x84, 0x10,
  0xC0, 0x03, 0xE0, 0x3B, 0x81, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x0F, 0xFC, 0x00,
  0x07, 0xC1, 0xEE, 0x08, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x40, 0x38, 0x0F, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x0C, 0x01, 0x88, 0x30, 0xFE, 0x00, 0x00, 0x30, 0x07, 0x00,
  0x70, 0x0A, 0x01, 0xA0, 0x36, 0x02, 0x60, 0x66, 0x0C, 0x40, 0x84, 0x10,
  0xC3, 0x0C, 0x20, 0x84, 0x08, 0xC1, 0x8F, 0xFE, 0x01, 0x80, 0x10, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x07, 0xF0, 0xFF, 0x0C, 0x00, 0x80, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x12, 0x03, 0xF8, 0x00, 0xC0, 0x04, 0x00, 0x40,
  0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x01, 0x88, 0x70, 0xFE, 0x00,
  0x01, 0xF0, 0x7A, 0x0C, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x67, 0x05, 0xF8, 0x70, 0xCE, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x0C,
  0xC0, 0x8C, 0x18, 0xC1, 0x06, 0x30, 0x3E, 0x00, 0x7F, 0xEF, 0xFC, 0x01,
  0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08,
  0x00, 0x03, 0xC0, 0x77, 0x0C, 0x31, 0x81, 0x18, 0x11, 0x81, 0x18, 0x30,
  0x86, 0x0C, 0xC0, 0x78, 0x0F, 0x01, 0x98, 0x30, 0xC6, 0x0C, 0x40, 0x4C,
  0x06, 0xC0, 0x4C, 0x04, 0xC0, 0xC6, 0x18, 0x3F, 0x00, 0x03, 0xC0, 0xEE,
  0x0C, 0x21, 0x83, 0x10, 0x33, 0x03, 0x30, 0x33, 0x03, 0x20, 0x33, 0x07,
  0x30, 0x61, 0x9A, 0x1F, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18,
  0x03, 0x08, 0x60, 0xFC, 0x00, 0x08, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x23, 0x98, 0x04, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC3, 0x18, 0x61, 0x0C, 0x20, 0x00, 0x10, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x30, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x30, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x80, 0x00, 0x1E, 0x1D,
  0x80, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x06, 0x06, 0x06, 0x02, 0x03,
  0x01, 0x01, 0x80, 0x80, 0x00, 0x00, 0x10, 0x18, 0x0C, 0x00, 0x00, 0x78,
  0x00, 0xE7, 0x01, 0x80, 0xC1, 0x80, 0x21, 0x80, 0x18, 0x80, 0x0C, 0xC3,
  0xE2, 0x43, 0x31, 0x63, 0x10, 0xA1, 0x08, 0xD1, 0x8C, 0x78, 0x86, 0x2C,
  0x42, 0x14, 0x61, 0x1A, 0x31, 0x89, 0x18, 0xCC, 0x87, 0xBC, 0x41, 0x8C,
  0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x01, 0x00, 0x7F, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xB0, 0x1B, 0x01, 0x30,
  0x33, 0x02, 0x30, 0x63, 0x06, 0x30, 0x41, 0x0F, 0xF0, 0xFF, 0x18, 0x11,
  0x01, 0x30, 0x13, 0x01, 0x60, 0x16, 0x01, 0xC0, 0x10, 0x07, 0xC0, 0x3F,
  0x83, 0x06, 0x18, 0x10, 0xC0, 0x84, 0x04, 0x60, 0x63, 0x03, 0x18, 0x30,
  0xFF, 0x07, 0xF0, 0x60, 0xC3, 0x03, 0x18, 0x18, 0x80, 0xC4, 0x06, 0x60,
  0x23, 0x03, 0x18, 0x38, 0x87, 0x8F, 0xF0, 0x00, 0x01, 0xF8, 0x1D, 0xC3,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x18, 0x00, 0x61, 0x01, 0xF8, 0x00, 0x07, 0x80, 0x1F, 0xC0, 0xC1,
  0x83, 0x03, 0x0C, 0x0C, 0x20, 0x31, 0x80, 0xC6, 0x03, 0x18, 0x0C, 0x40,
  0x31, 0x00, 0xCC, 0x03, 0x30, 0x08, 0xC0, 0x62, 0x01, 0x88, 0x0C, 0x60,
  0x31, 0x81, 0x86, 0x0C, 0x13, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC3,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xFF,
  0x07, 0xF0, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC3, 0x00,
  0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x07,
  0xF0, 0x7F, 0x83, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xBC, 0x18, 0x10,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x03, 0xE2, 0x07, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x04, 0x60, 0x08,
  0x40, 0x30, 0xC0, 0x61, 0x80, 0x81, 0xC3, 0x01, 0xFE, 0x00, 0x04, 0x03,
  0x04, 0x02, 0x0C, 0x02, 0x0C, 0x06, 0x0C, 0x06, 0x08, 0x06, 0x18, 0x04,
  0x18, 0x04, 0x18, 0x0C, 0x1F, 0xFC, 0x1F, 0xF8, 0x30, 0x08, 0x30, 0x18,
  0x30, 0x18, 0x20, 0x18, 0x20, 0x10, 0x60, 0x10, 0x60, 0x30, 0x60, 0x30,
  0x40, 0x30, 0xC0, 0x20, 0x0F, 0xC0, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80,
  0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60,
  0x10, 0x04, 0x03, 0x00, 0xC0, 0xFC, 0x00, 0x00, 0x40, 0x10, 0x0C, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00,
  0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0,
  0x20, 0x18, 0x3C, 0x00, 0x04, 0x06, 0x08, 0x18, 0x30, 0x60, 0x61, 0x80,
  0x86, 0x01, 0x08, 0x06, 0x30, 0x0C, 0xC0, 0x1B, 0x00, 0x2C, 0x00, 0x5C,
  0x01, 0xD8, 0x03, 0x30, 0x06, 0x20, 0x08, 0x60, 0x10, 0xC0, 0x60, 0x80,
  0xC1, 0x81, 0x83, 0x02, 0x06, 0x0C, 0x06, 0x00, 0x04, 0x02, 0x03, 0x01,
  0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80,
  0x80, 0x40, 0x60, 0x30, 0x18, 0x08, 0x1F, 0xF0, 0x06, 0x00, 0x30, 0x60,
  0x07, 0x0E, 0x00, 0x70, 0xE0, 0x0E, 0x0A, 0x00, 0xA0, 0xA0, 0x1E, 0x1B,
  0x01, 0x61, 0xB0, 0x36, 0x1B, 0x02, 0x41, 0x30, 0x64, 0x13, 0x04, 0xC3,
  0x30, 0xCC, 0x31, 0x08, 0x83, 0x11, 0x88, 0x21, 0x11, 0x82, 0x13, 0x18,
  0x61, 0x21, 0x86, 0x16, 0x10, 0x41, 0x41, 0x04, 0x1C, 0x30, 0xC1, 0x83,
  0x00, 0x06, 0x01, 0x06, 0x03, 0x0E, 0x03, 0x0E, 0x03, 0x0B, 0x02, 0x0B,
  0x02, 0x19, 0x06, 0x19, 0x06, 0x19, 0x86, 0x11, 0x84, 0x10, 0x84, 0x30,
  0x8C, 0x30, 0xCC, 0x30, 0xC8, 0x20, 0x48, 0x20, 0x48, 0x60, 0x78, 0x60,
  0x78, 0x40, 0x30, 0x40, 0x30, 0xC0, 0x30, 0x01, 0xE0, 0x1D, 0xE0, 0xC1,
  0x86, 0x03, 0x18, 0x0C, 0xC0, 0x33, 0x00, 0xC8, 0x03, 0x60, 0x0D, 0x80,
  0x34, 0x00, 0xD0, 0x03, 0xC0, 0x0B, 0x00, 0x6C, 0x01, 0xB0, 0x04, 0xC0,
  0x31, 0x01, 0x86, 0x06, 0x0C, 0x70, 0x1F, 0x00, 0x07, 0xC0, 0x3F, 0x83,
  0x0C, 0x18, 0x30, 0xC1, 0x84, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x30, 0x81,
  0x84, 0x38, 0x7F, 0x83, 0xE0, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x01, 0xE0, 0x1D, 0xE0, 0xC1,
  0x86, 0x03, 0x18, 0x0C, 0xC0, 0x33, 0x00, 0xC8, 0x03, 0x60, 0x0D, 0x80,
  0x34, 0x00, 0xD0, 0x03, 0xC0, 0x0B, 0x00, 0x6C, 0x01, 0xB0, 0x04, 0xC0,
  0x31, 0x01, 0x86, 0x06, 0x0C, 0x70, 0x1F, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x07, 0x00, 0x07, 0x80, 0x3F, 0x83, 0x0C, 0x18, 0x30,
  0xC1, 0x84, 0x0C, 0x60, 0x63, 0x02, 0x18, 0x30, 0x83, 0x84, 0x78, 0x7F,
  0x03, 0x10, 0x18, 0xC0, 0x86, 0x04, 0x30, 0x60, 0x83, 0x06, 0x18, 0x30,
  0x81, 0x8C, 0x04, 0x00, 0x03, 0xE0, 0xFF, 0x18, 0x01, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x8C, 0x30, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18,
  0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0x00, 0x08, 0x06, 0x30, 0x08, 0x60, 0x30, 0xC0,
  0x61, 0x00, 0xC2, 0x01, 0x0C, 0x02, 0x18, 0x0C, 0x30, 0x18, 0x40, 0x31,
  0x80, 0x43, 0x00, 0x86, 0x03, 0x08, 0x06, 0x10, 0x08, 0x60, 0x10, 0xC0,
  0x61, 0x80, 0xC1, 0x03, 0x03, 0x8C, 0x03, 0xF0, 0x00, 0x80, 0x38, 0x06,
  0x80, 0x68, 0x04, 0x80, 0xC8, 0x08, 0x81, 0x88, 0x10, 0x83, 0x08, 0x20,
  0x86, 0x08, 0x60, 0xCC, 0x0C, 0xC0, 0xC8, 0x0D, 0x80, 0xD0, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0xC0, 0x00, 0x80, 0x40, 0x70, 0x18, 0x0E, 0x03, 0x01,
  0x40, 0xE0, 0x68, 0x14, 0x09, 0x02, 0x83, 0x20, 0xD0, 0x64, 0x12, 0x08,
  0x86, 0x43, 0x10, 0x88, 0x42, 0x31, 0x18, 0x46, 0x23, 0x08, 0x84, 0x41,
  0x30, 0x98, 0x24, 0x12, 0x05, 0x82, 0xC0, 0xA0, 0x50, 0x14, 0x0A, 0x03,
  0x81, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x00, 0x06, 0x02, 0x04, 0x0C, 0x08,
  0x30, 0x18, 0x40, 0x31, 0x80, 0x66, 0x00, 0x4C, 0x00, 0xB0, 0x01, 0x40,
  0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x2C, 0x00, 0xD8, 0x03, 0x30, 0x06,
  0x20, 0x18, 0x40, 0x20, 0xC0, 0xC1, 0x83, 0x03, 0x0C, 0x06, 0x00, 0x80,
  0x60, 0x38, 0x1B, 0x06, 0xC3, 0x30, 0x8C, 0x61, 0x10, 0x4C, 0x16, 0x07,
  0x81, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00,
  0xC0, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x00, 0xFF, 0xC0, 0x03, 0xE0, 0x7C, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0x7C, 0x1F, 0x80, 0x8C, 0xCC, 0x44, 0x44, 0x66, 0x62, 0x22, 0x23, 0x33,
  0x11, 0x10, 0x07, 0xE0, 0xFC, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20,
  0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0xFC,
  0x1F, 0x00, 0x02, 0x00, 0xE0, 0x14, 0x06, 0x80, 0x98, 0x31, 0x04, 0x31,
  0x86, 0x60, 0x48, 0x0F, 0x00, 0x80, 0xFF, 0x80, 0xC6, 0x63, 0x06, 0x10,
  0xFA, 0x18, 0xA3, 0x06, 0x60, 0x66, 0x06, 0x40, 0x4C, 0x04, 0xC0, 0xCC,
  0x0C, 0xC0, 0xCC, 0x18, 0xC1, 0x8C, 0x38, 0xE7, 0x87, 0xD0, 0x06, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0xC1, 0xBE, 0x1C, 0x31,
  0x83, 0x18, 0x31, 0x03, 0x30, 0x33, 0x03, 0x20, 0x32, 0x02, 0x60, 0x66,
  0x06, 0x60, 0x46, 0x0C, 0x51, 0x8D, 0xF0, 0x03, 0xC3, 0xE1, 0x80, 0xC0,
  0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x06, 0x20, 0xF8, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00,
  0x18, 0x18, 0xC1, 0xF6, 0x18, 0xE1, 0x83, 0x08, 0x18, 0xC0, 0xC4, 0x04,
  0x60, 0x23, 0x03, 0x18, 0x18, 0xC0, 0xC6, 0x0C, 0x30, 0x61, 0x85, 0x0C,
  0x78, 0x3E, 0xC0, 0x07, 0x03, 0xE1, 0x8C, 0xC3, 0x60, 0xD8, 0x24, 0x1B,
  0x3C, 0xF8, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x10, 0xFC, 0x00,
  0x3C, 0x01, 0x90, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0xFC, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x2C, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x3E, 0xC3, 0x1C, 0x30, 0x61, 0x03, 0x18, 0x18,
  0x80, 0x8C, 0x04, 0x60, 0x63, 0x03, 0x18, 0x18, 0xC1, 0x86, 0x0C, 0x30,
  0xA1, 0x8F, 0x07, 0xD8, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x67, 0x01, 0xF0, 0x00, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x09, 0xC1, 0xBE, 0x1C, 0x31, 0x83, 0x18, 0x31, 0x02, 0x30, 0x23,
  0x06, 0x20, 0x62, 0x06, 0x60, 0x46, 0x04, 0x60, 0xC4, 0x0C, 0x40, 0x8C,
  0x08, 0x04, 0x30, 0x40, 0x00, 0x01, 0x86, 0x18, 0x41, 0x0C, 0x30, 0x82,
  0x18, 0x61, 0x84, 0x10, 0xC0, 0x00, 0x40, 0x30, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20,
  0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08,
  0x06, 0x0B, 0x03, 0x80, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x08, 0x11, 0x86, 0x18, 0xC1, 0x08, 0x11, 0x81, 0x30, 0x36, 0x03,
  0xE0, 0x3E, 0x03, 0x20, 0x63, 0x06, 0x30, 0x63, 0x04, 0x10, 0x41, 0x8C,
  0x18, 0x06, 0x08, 0x30, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0x30, 0x40, 0x83,
  0x06, 0x08, 0x10, 0x60, 0xC1, 0x82, 0x04, 0x18, 0x00, 0x00, 0xC3, 0x06,
  0xFB, 0xF1, 0xC7, 0x8C, 0x60, 0xC1, 0x18, 0x20, 0xC4, 0x18, 0x33, 0x06,
  0x0C, 0xC1, 0x82, 0x20, 0x40, 0x88, 0x10, 0x66, 0x0C, 0x19, 0x83, 0x06,
  0x60, 0xC1, 0x10, 0x20, 0x44, 0x08, 0x33, 0x06, 0x0C, 0x00, 0xC1, 0xBE,
  0x1C, 0x31, 0x83, 0x18, 0x31, 0x02, 0x30, 0x23, 0x06, 0x20, 0x62, 0x06,
  0x60, 0x46, 0x04, 0x60, 0xC4, 0x0C, 0x40, 0x8C, 0x08, 0x07, 0x01, 0xF8,
  0x63, 0x18, 0x36, 0x06, 0xC0, 0xD0, 0x1E, 0x03, 0xC0, 0x58, 0x0B, 0x03,
  0x60, 0x6C, 0x19, 0x82, 0x19, 0xC3, 0xF0, 0x00, 0x60, 0x6F, 0x83, 0x86,
  0x1C, 0x30, 0xC1, 0x84, 0x0C, 0x60, 0x63, 0x03, 0x10, 0x18, 0x80, 0x8C,
  0x04, 0x60, 0x63, 0x02, 0x18, 0x30, 0xA3, 0x0D, 0xF0, 0x60, 0x03, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x06, 0x00, 0xFB,
  0x18, 0xE3, 0x06, 0x60, 0x66, 0x06, 0x40, 0x4C, 0x04, 0xC0, 0xCC, 0x0C,
  0xC0, 0xCC, 0x18, 0xC1, 0x8C, 0x28, 0xC7, 0x87, 0xD8, 0x01, 0x00, 0x10,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x00, 0xC6, 0xE1, 0xC0,
  0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60,
  0x10, 0x04, 0x03, 0x00, 0x07, 0x07, 0xF3, 0x04, 0xC0, 0x20, 0x0C, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC8, 0x63, 0xF0,
  0x08, 0x30, 0x40, 0x87, 0xE6, 0x08, 0x10, 0x60, 0xC1, 0x82, 0x04, 0x18,
  0x30, 0x60, 0x81, 0x83, 0xC0, 0x30, 0x26, 0x0C, 0x81, 0x90, 0x26, 0x04,
  0xC1, 0x98, 0x32, 0x06, 0x40, 0x98, 0x13, 0x06, 0x60, 0xCC, 0x39, 0x8A,
  0x1E, 0x40, 0x81, 0xC0, 0xE0, 0xD0, 0x68, 0x64, 0x32, 0x11, 0x18, 0x88,
  0x6C, 0x34, 0x1E, 0x0E, 0x07, 0x03, 0x00, 0x83, 0x07, 0x06, 0x0E, 0x0C,
  0x14, 0x28, 0x68, 0x50, 0x91, 0xB3, 0x22, 0x66, 0x4C, 0xC8, 0x91, 0xB1,
  0x23, 0x42, 0xC7, 0x85, 0x0E, 0x0E, 0x14, 0x18, 0x38, 0x30, 0x60, 0x00,
  0x18, 0x30, 0x86, 0x0C, 0x40, 0xCC, 0x05, 0x80, 0x50, 0x07, 0x00, 0x60,
  0x0E, 0x00, 0xB0, 0x1B, 0x03, 0x10, 0x61, 0x86, 0x18, 0xC0, 0x80, 0x06,
  0x06, 0x0C, 0x18, 0x18, 0x20, 0x30, 0xC0, 0x61, 0x00, 0xC6, 0x01, 0x88,
  0x03, 0x30, 0x06, 0x40, 0x0D, 0x80, 0x0B, 0x00, 0x14, 0x00, 0x38, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0,
  0x0B, 0x80, 0x1C, 0x00, 0x00, 0x0F, 0xE0, 0x18, 0x02, 0x00, 0xC0, 0x30,
  0x04, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80,
  0x3F, 0xC0, 0x00, 0x40, 0xF0, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30,
  0x08, 0x02, 0x01, 0x80, 0x40, 0xE0, 0x38, 0x03, 0x00, 0xC0, 0x30, 0x08,
  0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x38, 0x06, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x02, 0x00, 0xF0, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x1E, 0x03, 0x80, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0xC0, 0xF0, 0x10, 0x00, 0x38, 0x1F, 0xE3, 0x83, 0xE0,
};

const GFXglyph NotoSans_Condensed_LightItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 21, 7, 0, -21 },
  { 20, 7, 8, 9, 3, -21 },
  { 27, 14, 21, 13, 0, -21 },
  { 64, 12, 24, 12, 0, -22 },
  { 100, 15, 21, 18, 2, -21 },
  { 140, 13, 21, 14, 0, -21 },
  { 175, 3, 8, 5, 3, -21 },
  { 178, 8, 26, 7, 1, -21 },
  { 204, 8, 26, 7, -2, -21 },
  { 230, 10, 10, 12, 3, -22 },
  { 243, 12, 14, 13, 1, -17 },
  { 264, 4, 7, 6, -1, -3 },
  { 268, 6, 2, 8, 1, -9 },
  { 270, 3, 3, 6, 0, -3 },
  { 272, 12, 21, 9, -1, -21 },
  { 304, 11, 21, 12, 1, -21 },
  { 333, 6, 21, 12, 4, -21 },
  { 349, 13, 21, 12, -1, -21 },
  { 384, 12, 21, 12, 0, -21 },
  { 416, 12, 21, 12, 0, -21 },
  { 448, 12, 21, 12, 0, -21 },
  { 480, 12, 21, 12, 1, -21 },
  { 512, 11, 21, 12, 2, -21 },
  { 541, 12, 21, 12, 0, -21 },
  { 573, 12, 21, 12, 0, -21 },
  { 605, 5, 16, 6, 0, -16 },
  { 615, 6, 20, 6, -1, -16 },
  { 630, 12, 13, 13, 1, -17 },
  { 650, 12, 8, 13, 1, -14 },
  { 662, 12, 13, 13, 1, -17 },
  { 682, 9, 21, 9, 1, -21 },
  { 706, 17, 24, 18, 1, -21 },
  { 757, 12, 21, 12, -2, -21 },
  { 789, 13, 21, 13, 0, -21 },
  { 824, 13, 21, 12, 1, -21 },
  { 859, 14, 21, 15, 0, -21 },
  { 896, 13, 21, 12, 0, -21 },
  { 931, 13, 21, 11, 0, -21 },
  { 966, 15, 21, 16, 1, -21 },
  { 1006, 16, 21, 15, 0, -21 },
  { 1048, 10, 21, 7, -1, -21 },
  { 1075, 10, 26, 6, -4, -21 },
  { 1108, 15, 21, 12, 0, -21 },
  { 1148, 9, 21, 11, 0, -21 },
  { 1172, 20, 21, 20, 0, -21 },
  { 1225, 16, 21, 16, 0, -21 },
  { 1267, 14, 21, 16, 1, -21 },
  { 1304, 13, 21, 13, 0, -21 },
  { 1339, 14, 26, 16, 1, -21 },
  { 1385, 13, 21, 13, 0, -21 },
  { 1420, 12, 21, 12, 0, -21 },
  { 1452, 11, 21, 11, 2, -21 },
  { 1481, 15, 21, 15, 1, -21 },
  { 1521, 12, 21, 12, 3, -21 },
  { 1553, 19, 21, 20, 3, -21 },
  { 1603, 15, 21, 11, -2, -21 },
  { 1643, 10, 21, 11, 3, -21 },
  { 1670, 14, 21, 11, -1, -21 },
  { 1707, 11, 26, 8, -1, -21 },
  { 1743, 4, 21, 10, 3, -21 },
  { 1754, 11, 26, 8, -2, -21 },
  { 1790, 11, 11, 13, 1, -21 },
  { 1806, 9, 1, 9, -2, 3 },
  { 1808, 4, 4, 7, 4, -22 },
  { 1810, 12, 16, 13, 1, -16 },
  { 1834, 12, 22, 13, 0, -22 },
  { 1867, 10, 16, 10, 1, -16 },
  { 1887, 13, 22, 13, 1, -22 },
  { 1923, 10, 16, 11, 1, -16 },
  { 1943, 14, 29, 7, -4, -22 },
  { 1994, 13, 23, 13, 0, -16 },
  { 2032, 12, 22, 13, 0, -22 },
  { 2065, 6, 21, 6, 0, -21 },
  { 2081, 10, 28, 6, -4, -21 },
  { 2116, 12, 22, 11, 0, -22 },
  { 2149, 7, 22, 5, 0, -22 },
  { 2169, 18, 16, 19, 0, -16 },
  { 2205, 12, 16, 13, 0, -16 },
  { 2229, 11, 16, 13, 1, -16 },
  { 2251, 13, 23, 13, -1, -16 },
  { 2289, 12, 23, 13, 1, -16 },
  { 2324, 10, 16, 9, 0, -16 },
  { 2344, 10, 16, 10, 0, -16 },
  { 2364, 7, 19, 7, 1, -19 },
  { 2381, 11, 15, 13, 1, -15 },
  { 2402, 9, 15, 10, 2, -15 },
  { 2419, 15, 15, 16, 2, -15 },
  { 2448, 12, 15, 10, -1, -15 },
  { 2471, 15, 22, 10, -3, -15 },
  { 2513, 11, 15, 9, -1, -15 },
  { 2534, 10, 26, 9, 1, -21 },
  { 2567, 2, 29, 12, 5, -22 },
  { 2575, 11, 26, 9, -2, -21 },
  { 2611, 12, 3, 13, 1, -12 },
};

const GFXfont NotoSans_Condensed_LightItalic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic29pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC29PT7B_H_
