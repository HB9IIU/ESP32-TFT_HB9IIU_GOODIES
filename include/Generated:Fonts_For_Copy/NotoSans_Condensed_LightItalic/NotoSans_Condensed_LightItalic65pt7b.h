#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC65PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x3C, 0x1E,
  0x78, 0x3C, 0xF0, 0x79, 0xC0, 0xE3, 0x81, 0xCF, 0x07, 0x9E, 0x0F, 0x38,
  0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE7, 0x03, 0x8E, 0x07, 0x1C, 0x0E,
  0x38, 0x1C, 0x60, 0x30, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x1C, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x01,
  0x80, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x1C,
  0x00, 0x03, 0x80, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC,
  0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x38,
  0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x30, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0xFC, 0xC7, 0xC0, 0x3E, 0x18, 0x18, 0x07, 0x03, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x38, 0x18, 0x00, 0x07, 0x03, 0x00, 0x01, 0xE0, 0x60, 0x00,
  0x3C, 0x1C, 0x00, 0x07, 0x83, 0x80, 0x00, 0xF0, 0x60, 0x00, 0x0E, 0x0C,
  0x00, 0x01, 0xE1, 0x80, 0x00, 0x3C, 0x70, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x3D, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xDF, 0x00, 0x00,
  0x39, 0xF0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x18, 0x3C,
  0x00, 0x03, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x60, 0x78, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x60, 0x70, 0x10, 0x0C, 0x3E, 0x03, 0xE1, 0x9F, 0x80, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0x00, 0xFF, 0x00, 0x03, 0x80, 0x7F, 0xE0, 0x00, 0xE0, 0x1C, 0x38, 0x00,
  0x70, 0x0E, 0x07, 0x00, 0x1C, 0x07, 0x81, 0xC0, 0x0E, 0x01, 0xC0, 0x70,
  0x07, 0x80, 0xF0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x70,
  0x07, 0x03, 0x80, 0x1C, 0x03, 0x81, 0xE0, 0x0E, 0x00, 0xE0, 0x70, 0x03,
  0x80, 0x38, 0x38, 0x00, 0xE0, 0x0E, 0x0E, 0x00, 0x38, 0x03, 0x87, 0x00,
  0x0E, 0x01, 0xC3, 0xC0, 0x03, 0x80, 0x70, 0xE0, 0xFC, 0xE0, 0x1C, 0x78,
  0xFF, 0xB8, 0x0E, 0x1C, 0x7D, 0xFE, 0x03, 0x8E, 0x1C, 0x1F, 0x81, 0xC3,
  0x8E, 0x07, 0xE0, 0xF1, 0xC7, 0x81, 0xFC, 0x78, 0xF1, 0xC0, 0x77, 0xFC,
  0x38, 0x70, 0x1D, 0xFE, 0x1C, 0x38, 0x07, 0x1F, 0x07, 0x0E, 0x01, 0xC0,
  0x03, 0x83, 0x80, 0x70, 0x00, 0xE1, 0xC0, 0x1C, 0x00, 0x70, 0x70, 0x07,
  0x00, 0x3C, 0x1C, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0xE0, 0x07, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0xE0, 0x0E, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x38, 0x0E,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x38, 0x0E, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x70, 0x03, 0x81, 0xC0, 0x38,
  0x00, 0xF0, 0xF0, 0x1E, 0x00, 0x1C, 0x78, 0x07, 0x00, 0x07, 0xFC, 0x03,
  0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x3C, 0x07, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x38, 0x3C, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x01, 0xF1, 0xE0, 0x1E, 0x1E, 0x07,
  0x80, 0xE0, 0xF0, 0x3C, 0x07, 0x0F, 0x00, 0xE0, 0x78, 0xF0, 0x07, 0x83,
  0x87, 0x00, 0x3C, 0x3C, 0x78, 0x00, 0xF1, 0xC3, 0xC0, 0x07, 0x9E, 0x1C,
  0x00, 0x1C, 0xE0, 0xE0, 0x00, 0xFF, 0x0F, 0x00, 0x07, 0xF0, 0x78, 0x00,
  0x1F, 0x83, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x7E,
  0x03, 0xC0, 0x07, 0xF0, 0x1E, 0x00, 0x7B, 0xC0, 0xF8, 0x0F, 0x9E, 0x03,
  0xFB, 0xF8, 0x78, 0x0F, 0xFF, 0x83, 0xC0, 0x3F, 0xF0, 0x0F, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0xF3, 0xCE, 0x38, 0xE7, 0x9C, 0x71, 0xC7, 0x38, 0xE3,
  0x8E, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x30, 0x1C, 0x01, 0xE0, 0xC0, 0x1F, 0x86,
  0x00, 0x3F, 0x30, 0x38, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFE, 0x00,
  0x1F, 0x00, 0x01, 0xDC, 0x00, 0x1E, 0x70, 0x01, 0xE3, 0x80, 0x1E, 0x0E,
  0x03, 0xE0, 0x70, 0x0E, 0x03, 0xC0, 0x20, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x07,
  0x03, 0xC0, 0xE0, 0x38, 0x1C, 0x0F, 0x00, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3B, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC1,
  0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C,
  0x38, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8E, 0x00, 0x03,
  0xC7, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0x71, 0xC0, 0x00,
  0x78, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00,
  0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x03, 0xC7, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78,
  0x00, 0x1C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0E, 0x0F, 0x00, 0x0F, 0x07,
  0x80, 0x07, 0x83, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0x70, 0x03, 0xC0,
  0x38, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x07, 0x83, 0xE0, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0xF8, 0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0xC1, 0xF7, 0x87, 0x8E, 0x3E,
  0x1C, 0xF8, 0x78, 0xE0, 0xF1, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xE0, 0xFC, 0x00, 0x78, 0x03, 0xE0, 0x03, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0xFE, 0x07, 0xE0,
  0x0F, 0x00, 0x3C, 0x01, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x02, 0x00, 0x07, 0xC0, 0x60,
  0x03, 0xF0, 0x0F, 0xF7, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x07, 0x9C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x78, 0x78,
  0x00, 0x07, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x38, 0x0F, 0x00, 0x07, 0x00, 0xF0, 0x00, 0xF0, 0x0E,
  0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0xC0, 0x1C, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0x80, 0x78, 0x00, 0x38, 0x07,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xBF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x38, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x08, 0x00, 0x1F, 0x00, 0xE0, 0x07, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x03, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0xF8, 0x00,
  0x70, 0xFF, 0x80, 0x3C, 0xFF, 0xF0, 0x0F, 0x7C, 0x7E, 0x03, 0xB8, 0x07,
  0xC0, 0xFC, 0x00, 0xF0, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x87, 0xC0,
  0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1C, 0x3C, 0x00, 0x07,
  0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x3C, 0x00,
  0x1E, 0x07, 0x00, 0x07, 0x81, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0xF0, 0x1E,
  0x00, 0x78, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x1F, 0x00, 0x1F, 0xBF, 0x80,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0,
  0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0xE0, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0xF8, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x01, 0xE0, 0x01,
  0xE0, 0x3C, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x1C, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0xCF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x1C, 0x00, 0x78, 0x0F, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x81, 0xE0, 0x00,
  0xF0, 0x70, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0x87,
  0x80, 0x00, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x0F,
  0x87, 0x80, 0x03, 0xE0, 0xE0, 0x01, 0xF8, 0x3C, 0x00, 0xFC, 0x0F, 0x00,
  0x77, 0x01, 0xE0, 0x3D, 0xC0, 0x7F, 0xFE, 0xF0, 0x0F, 0xFE, 0x38, 0x00,
  0xFF, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x02,
  0x00, 0xF8, 0x00, 0xFB, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xE0, 0xF8, 0x3E, 0x04, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x0C, 0x00, 0x70, 0x70, 0x01, 0xFF, 0x81, 0xC1, 0xC0, 0x1F, 0xFE, 0x07,
  0x0E, 0x00, 0xF0, 0x70, 0x1C, 0x38, 0x07, 0x81, 0xC0, 0x71, 0xC0, 0x3C,
  0x07, 0x01, 0xC7, 0x00, 0xE0, 0x1C, 0x07, 0x1C, 0x07, 0x00, 0xE0, 0x1C,
  0xE0, 0x1C, 0x03, 0x80, 0x73, 0x80, 0xE0, 0x0E, 0x01, 0xCE, 0x03, 0x80,
  0x38, 0x0E, 0x70, 0x1C, 0x01, 0xC0, 0x39, 0xC0, 0x70, 0x07, 0x00, 0xE7,
  0x01, 0xC0, 0x1C, 0x03, 0x9C, 0x0F, 0x00, 0xF0, 0x0C, 0x70, 0x38, 0x03,
  0x80, 0x71, 0xC0, 0xE0, 0x0E, 0x01, 0xCE, 0x03, 0x80, 0x78, 0x0E, 0x38,
  0x0E, 0x01, 0xE0, 0x38, 0xE0, 0x38, 0x07, 0x80, 0xE3, 0x80, 0xE0, 0x3C,
  0x07, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x38, 0x0E, 0x06, 0xE0, 0xE0, 0xE0,
  0x3C, 0x3B, 0x87, 0x03, 0x80, 0x7F, 0xC7, 0xF8, 0x0E, 0x00, 0xFE, 0x1F,
  0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x02, 0x00,
  0x00, 0x1F, 0x80, 0x78, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x78,
  0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00,
  0x1E, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x1C, 0x07,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x07,
  0x80, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x3C, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xE0,
  0x78, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x07, 0x1E,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x1C, 0xF0, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x77, 0x80, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x38, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xF0,
  0x07, 0xE0, 0x07, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x7C, 0x03, 0xC0, 0x01,
  0xE0, 0x1E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x78, 0x07, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x01,
  0xE0, 0x1E, 0x00, 0x1E, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0x00, 0x3E, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xE0,
  0x1F, 0xC0, 0x07, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x01,
  0xE0, 0x1C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x70, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0xE0, 0x1C, 0x01, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xC1,
  0xE0, 0x03, 0xF0, 0x01, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x60, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x3F, 0x00, 0x07, 0x00, 0x1F, 0x00,
  0x0E, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0xE0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x03,
  0x80, 0x00, 0xF8, 0x07, 0x00, 0x03, 0xE0, 0x0E, 0x00, 0x0F, 0x80, 0x3C,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xE0, 0x07, 0xE0, 0x01, 0xC0,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x7E, 0x00,
  0x02, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x3F,
  0xF8, 0x70, 0x00, 0x7F, 0xF8, 0x70, 0x00, 0x7F, 0xF0, 0xF0, 0x00, 0x7F,
  0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x03, 0x80, 0x3E, 0x00, 0x07,
  0x80, 0x1F, 0x00, 0x07, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x80, 0x1C,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x0E, 0x00,
  0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x1C, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x77, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x70, 0x01, 0xE0,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0xE0, 0x0F, 0x80,
  0x00, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x01, 0xC0, 0xF8, 0x00, 0x01, 0xC1, 0xF0, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x03, 0x8F, 0x80, 0x00, 0x03, 0x9F, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x07, 0xBF, 0x00, 0x00, 0x07, 0x7F, 0x00, 0x00, 0x07, 0xF7, 0x00, 0x00,
  0x0F, 0xE7, 0x80, 0x00, 0x0F, 0xC7, 0x80, 0x00, 0x0F, 0x87, 0x80, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x1E, 0x01, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1C, 0x01, 0xE0, 0x00,
  0x1C, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x00,
  0x3D, 0xC0, 0x0E, 0xF0, 0x00, 0x03, 0xBC, 0x01, 0xEF, 0x00, 0x00, 0x7B,
  0xC0, 0x1E, 0xF0, 0x00, 0x07, 0x38, 0x01, 0xC7, 0x00, 0x00, 0xF3, 0x80,
  0x1C, 0x70, 0x00, 0x0E, 0x78, 0x01, 0xC7, 0x00, 0x01, 0xE7, 0x80, 0x3C,
  0x70, 0x00, 0x1C, 0x78, 0x03, 0xC7, 0x00, 0x03, 0xC7, 0x00, 0x38, 0x70,
  0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x07, 0x8F, 0x00, 0x38, 0x70, 0x00,
  0x70, 0xF0, 0x07, 0x87, 0x00, 0x0F, 0x0F, 0x00, 0x78, 0x70, 0x00, 0xE0,
  0xE0, 0x07, 0x07, 0x80, 0x1E, 0x0E, 0x00, 0x70, 0x78, 0x01, 0xC1, 0xE0,
  0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x38, 0x03, 0x81, 0xC0, 0x0F,
  0x03, 0x80, 0x78, 0x1C, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x0E, 0x03,
  0x80, 0xF0, 0x3C, 0x01, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x1E, 0x03, 0x81,
  0xE0, 0x38, 0x01, 0xC0, 0x38, 0x1C, 0x03, 0x80, 0x1C, 0x03, 0x83, 0xC0,
  0x78, 0x01, 0xC0, 0x38, 0x38, 0x07, 0x80, 0x3C, 0x03, 0x87, 0x80, 0x78,
  0x03, 0xC0, 0x3C, 0x70, 0x07, 0x00, 0x38, 0x03, 0xCF, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xDE, 0x00, 0xF0, 0x07, 0x80,
  0x1D, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xFC, 0x00, 0xE0, 0x07, 0x00, 0x1F,
  0x80, 0x0E, 0x00, 0x70, 0x01, 0xF8, 0x01, 0xE0, 0x0F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xC0, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x0F, 0x80, 0x00, 0x1C, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x3F, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x00, 0x1C, 0x00,
  0xFC, 0x00, 0x03, 0x80, 0x3F, 0x80, 0x00, 0x70, 0x07, 0x78, 0x00, 0x1E,
  0x00, 0xE7, 0x00, 0x03, 0xC0, 0x1C, 0xE0, 0x00, 0x70, 0x07, 0x9C, 0x00,
  0x0E, 0x00, 0xF3, 0xC0, 0x03, 0xC0, 0x1C, 0x38, 0x00, 0x78, 0x03, 0x87,
  0x00, 0x0F, 0x00, 0x70, 0xE0, 0x01, 0xC0, 0x1E, 0x1E, 0x00, 0x38, 0x03,
  0xC1, 0xC0, 0x0F, 0x00, 0x70, 0x38, 0x01, 0xE0, 0x0E, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0xF0, 0x07, 0x00, 0x78, 0x1E, 0x00, 0xE0, 0x0F, 0x01, 0xC0,
  0x3C, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x38, 0x07, 0x80, 0xE0, 0x0F, 0x00,
  0xF0, 0x1C, 0x01, 0xE0, 0x0E, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0xF0, 0x07,
  0x00, 0x3C, 0x1E, 0x00, 0xE0, 0x07, 0x83, 0x80, 0x3C, 0x00, 0x70, 0x70,
  0x07, 0x80, 0x0E, 0x1E, 0x00, 0xE0, 0x01, 0xE3, 0xC0, 0x1C, 0x00, 0x3C,
  0x70, 0x03, 0x80, 0x03, 0x8E, 0x00, 0xF0, 0x00, 0x71, 0xC0, 0x1E, 0x00,
  0x0F, 0x78, 0x03, 0x80, 0x01, 0xEF, 0x00, 0x70, 0x00, 0x1D, 0xC0, 0x1E,
  0x00, 0x03, 0xB8, 0x03, 0xC0, 0x00, 0x7F, 0x00, 0x78, 0x00, 0x0F, 0xE0,
  0x0E, 0x00, 0x00, 0xFC, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x0F, 0x00, 0x00, 0x7C, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFC, 0x1F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1C, 0x78,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0xF0, 0x1C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x1F, 0x00, 0x78, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x07,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0x80, 0xFC, 0x00, 0x70, 0x03, 0xE0, 0x07,
  0x00, 0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0xF0, 0x0E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xE0, 0x3C, 0x00,
  0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0x80, 0x03, 0xC0,
  0x38, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x07, 0x00,
  0x3E, 0x00, 0x70, 0x1F, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFC,
  0x1F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x03, 0x9E,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0xE0,
  0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1C, 0x78, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0xF0, 0x1C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1F,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0x80, 0x7C, 0x00, 0x70, 0x03,
  0xE0, 0x07, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xE0, 0x0F, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xE0,
  0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x03, 0x80,
  0x03, 0xC0, 0x38, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x80, 0x78, 0x01, 0xF0,
  0x07, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x0E, 0x03, 0xC0,
  0x01, 0xE0, 0x1C, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x1C,
  0x01, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x07, 0x00, 0x38, 0x00, 0x78, 0x07,
  0x80, 0x07, 0x80, 0x78, 0x00, 0x78, 0x07, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x38, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x20, 0x00, 0x3E, 0x01,
  0xE0, 0x07, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x38, 0x0F,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x0F, 0x70, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x3C,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x01, 0xE0,
  0x1E, 0x00, 0x3C, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0x0F, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x78, 0x00,
  0x70, 0x0E, 0x00, 0x0E, 0x03, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x38, 0x1E,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x1E, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x38, 0xE0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xF0, 0x00, 0x38,
  0xF0, 0x00, 0x77, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x70, 0x00, 0x78, 0xF0,
  0x00, 0x77, 0x00, 0x0F, 0x0F, 0x00, 0x0E, 0x70, 0x00, 0xF0, 0xF0, 0x00,
  0xE7, 0x00, 0x0E, 0x0F, 0x00, 0x1E, 0x70, 0x01, 0xE0, 0xF0, 0x01, 0xC7,
  0x00, 0x1C, 0x0F, 0x00, 0x1C, 0x70, 0x03, 0xC0, 0xF0, 0x03, 0x87, 0x00,
  0x3C, 0x0F, 0x00, 0x38, 0x70, 0x07, 0x80, 0xF0, 0x07, 0x87, 0x00, 0x78,
  0x0F, 0x00, 0x70, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x07, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x07, 0x01, 0xE0, 0x0F, 0x01,
  0xC0, 0xF0, 0x1E, 0x00, 0xF0, 0x1C, 0x0F, 0x01, 0xC0, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x00, 0xF0, 0x38, 0x0F, 0x03, 0x80, 0x0F, 0x03, 0x80, 0xF0,
  0x78, 0x00, 0xF0, 0x70, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x00, 0xF0, 0x70,
  0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0xF0, 0xE0, 0x00,
  0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0x0F, 0x1C, 0x00, 0xF1, 0xC0, 0x00, 0xE1,
  0xC0, 0x0F, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0xE3, 0xC0, 0x00, 0xE3, 0x80,
  0x0E, 0x38, 0x00, 0x0E, 0x78, 0x00, 0xE7, 0x80, 0x00, 0xE7, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x00, 0xEE, 0x00, 0x0E, 0xF0,
  0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x1C,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0x38, 0x1E, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x07, 0x3C, 0x00,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x3C, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x78, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0x70,
  0x00, 0x78, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0x70, 0x01, 0xE0, 0x78,
  0x01, 0xC0, 0x78, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x38, 0x07, 0x80, 0x38,
  0x0F, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x3C,
  0x3C, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0xF0, 0x00, 0x1C,
  0xE0, 0x00, 0x1D, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xE0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x70, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x07, 0x80, 0x07,
  0x80, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0,
  0x1C, 0x00, 0x70, 0x0F, 0x00, 0x1E, 0x03, 0x80, 0x03, 0x81, 0xE0, 0x00,
  0xF0, 0x70, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x1E, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x78, 0x78, 0x38, 0x3C, 0x1C, 0x1E,
  0x0E, 0x07, 0x07, 0x03, 0x00, 0x1F, 0xC1, 0xC0, 0x0F, 0xFC, 0x70, 0x0F,
  0xFF, 0x1C, 0x07, 0xE0, 0xE7, 0x03, 0xE0, 0x1B, 0xC0, 0xF0, 0x03, 0xE0,
  0x78, 0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x03,
  0xC1, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x1E, 0x1E,
  0x00, 0x07, 0x87, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x1C,
  0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xE0, 0xF0, 0x00,
  0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xE0, 0xF0,
  0x01, 0xF0, 0x1C, 0x00, 0xFC, 0x07, 0x80, 0x77, 0x01, 0xF0, 0x39, 0xC0,
  0x3F, 0x7C, 0x70, 0x07, 0xFE, 0x38, 0x00, 0xFF, 0x0E, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x1F, 0xC0, 0x07, 0x1F, 0xF8, 0x01, 0xCF, 0xFF, 0x00, 0xF7, 0x83, 0xE0,
  0x3B, 0x80, 0x78, 0x0E, 0xC0, 0x0E, 0x03, 0xF0, 0x03, 0xC1, 0xF8, 0x00,
  0xF0, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0,
  0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0xF0, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x1E, 0x00, 0x07,
  0x87, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x3C, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x78, 0x7C,
  0x00, 0x1C, 0x1F, 0x00, 0x0F, 0x07, 0xC0, 0x07, 0x81, 0xF0, 0x01, 0xE0,
  0x7E, 0x00, 0xF0, 0x39, 0xC0, 0x78, 0x0E, 0x7E, 0xFC, 0x03, 0x8F, 0xFE,
  0x00, 0xE1, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7E, 0x06, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x40,
  0x3F, 0x9F, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x01, 0xFC, 0x1C, 0x00, 0x0F, 0xFC, 0x70, 0x00,
  0xFF, 0xF9, 0xC0, 0x07, 0xE0, 0xEF, 0x00, 0x3E, 0x01, 0xFC, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x0F, 0x80, 0x1C, 0x00, 0x3E, 0x00, 0xF0, 0x00,
  0x78, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x38, 0x07, 0x80, 0x00, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x70, 0x0F, 0x00, 0x01, 0xC0, 0x3C, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF8, 0x03, 0xC0, 0x07, 0xE0,
  0x0F, 0x00, 0x1F, 0x80, 0x1C, 0x00, 0xFC, 0x00, 0x78, 0x07, 0x70, 0x01,
  0xF0, 0x39, 0xC0, 0x03, 0xF7, 0xC7, 0x00, 0x07, 0xFE, 0x1C, 0x00, 0x0F,
  0xF0, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x7C, 0x1F, 0x03, 0xE0, 0x3C, 0x0F, 0x00, 0x70,
  0x78, 0x01, 0xC3, 0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x78, 0x00, 0x71, 0xE0,
  0x03, 0xCF, 0x00, 0x0E, 0x3C, 0x00, 0x78, 0xE0, 0x03, 0xC3, 0x80, 0x3E,
  0x1E, 0x07, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x20, 0x3F,
  0x8F, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7E, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x30, 0x00, 0xFF, 0xC7, 0x00, 0x3F, 0xFE,
  0x70, 0x07, 0xE0, 0xE7, 0x00, 0xF8, 0x07, 0x70, 0x0F, 0x00, 0x3E, 0x01,
  0xE0, 0x03, 0xE0, 0x1C, 0x00, 0x3E, 0x03, 0xC0, 0x03, 0xE0, 0x38, 0x00,
  0x3E, 0x07, 0x80, 0x03, 0xC0, 0x70, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x38, 0x1E, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x70,
  0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0,
  0x01, 0xF0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x3E,
  0x03, 0xC0, 0x07, 0xE0, 0x3C, 0x00, 0x7E, 0x01, 0xC0, 0x0F, 0xC0, 0x1E,
  0x01, 0xDC, 0x01, 0xF0, 0x39, 0xC0, 0x0F, 0xDF, 0x3C, 0x00, 0x7F, 0xE3,
  0xC0, 0x03, 0xFC, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x08, 0x00, 0x7C, 0x00, 0xC0, 0x0F, 0x80, 0x0F, 0xEF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x07, 0xF0,
  0x03, 0x8F, 0xFC, 0x01, 0xCF, 0xFF, 0x01, 0xEF, 0x07, 0xC0, 0xEE, 0x01,
  0xE0, 0x76, 0x00, 0xF0, 0x3E, 0x00, 0x38, 0x1E, 0x00, 0x1C, 0x1F, 0x00,
  0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0x83, 0xC0,
  0x01, 0xC1, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x38,
  0x00, 0x38, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x07,
  0x00, 0x07, 0x83, 0x80, 0x03, 0x83, 0xC0, 0x01, 0xC1, 0xE0, 0x01, 0xE0,
  0xE0, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x38, 0x00, 0x38, 0x3C, 0x00, 0x1C,
  0x1E, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x07, 0x80, 0x03,
  0x83, 0xC0, 0x01, 0xC1, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x07, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x3C, 0x07, 0x00, 0x1E, 0x01, 0xC0,
  0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x0E, 0x01, 0xE0, 0x03,
  0x80, 0x70, 0x00, 0xE0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x0F, 0x00,
  0x07, 0x07, 0x80, 0x01, 0xC3, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x78,
  0x00, 0x0E, 0x3C, 0x00, 0x03, 0x9F, 0x00, 0x00, 0xEF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xDE, 0x00, 0x07, 0xE7, 0x80, 0x01, 0xF0, 0xE0, 0x00,
  0x78, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0x80, 0x70,
  0x00, 0xE0, 0x1E, 0x00, 0x38, 0x07, 0x80, 0x1E, 0x00, 0xE0, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x0F, 0x00, 0x70, 0x03, 0xC0, 0x3C, 0x00, 0x70, 0x0F,
  0x00, 0x1C, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x01, 0xC1, 0xF8, 0x03, 0xF0, 0x01, 0xC7, 0xFC, 0x0F, 0xFC, 0x01, 0xCF,
  0xFE, 0x1F, 0xFE, 0x03, 0x9C, 0x1F, 0x38, 0x3E, 0x03, 0xB8, 0x0F, 0x70,
  0x1E, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x07,
  0x80, 0x0E, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x07, 0x00, 0x0F, 0x00, 0x0E,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x0F, 0x00,
  0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x0E, 0x00, 0x1E, 0x00,
  0x1C, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x3C,
  0x00, 0x78, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x3C, 0x00, 0x38, 0x00, 0x70,
  0x38, 0x00, 0x78, 0x00, 0x70, 0x38, 0x00, 0x78, 0x00, 0x70, 0x38, 0x00,
  0x70, 0x00, 0xF0, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x78, 0x00, 0x70, 0x00,
  0xE0, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0xF0,
  0x00, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC1, 0xFC, 0x00, 0xE3,
  0xFF, 0x00, 0x73, 0xFF, 0xC0, 0x73, 0xC1, 0xF0, 0x3B, 0x80, 0x78, 0x1F,
  0x80, 0x3C, 0x0F, 0x80, 0x1E, 0x0F, 0xC0, 0x0F, 0x07, 0xC0, 0x07, 0x83,
  0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xE0, 0xF0, 0x00, 0x70,
  0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x0E,
  0x0F, 0x00, 0x07, 0x07, 0x80, 0x07, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x01,
  0xE0, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x70, 0x78, 0x00, 0x78, 0x38, 0x00,
  0x3C, 0x1C, 0x00, 0x1E, 0x1E, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x07, 0x80,
  0x07, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0xE0, 0xF0,
  0x00, 0xF0, 0x78, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xF0, 0x3C, 0x03, 0xE0, 0x1E,
  0x03, 0xC0, 0x0E, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x07,
  0x1E, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x3C, 0x00, 0x07,
  0x3C, 0x00, 0x07, 0x38, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x38, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x70, 0x70, 0x00, 0xF0,
  0x78, 0x01, 0xE0, 0x78, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x3F, 0xBF, 0x80,
  0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x3F,
  0x80, 0x01, 0xC7, 0xFE, 0x00, 0x0E, 0x7F, 0xF8, 0x00, 0xE7, 0x83, 0xE0,
  0x07, 0x38, 0x0F, 0x00, 0x3B, 0x80, 0x38, 0x01, 0xF8, 0x01, 0xE0, 0x0F,
  0x80, 0x0F, 0x00, 0xF8, 0x00, 0x78, 0x07, 0xC0, 0x01, 0xC0, 0x3C, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C,
  0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x78, 0x1E,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x1C, 0x07, 0x80, 0x01, 0xE0, 0x38, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x70, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C,
  0x07, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xE0, 0x1F,
  0x00, 0x0F, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x3B, 0x00,
  0x78, 0x01, 0xDC, 0x07, 0x80, 0x1E, 0xF9, 0xF8, 0x00, 0xF3, 0xFF, 0x80,
  0x07, 0x0F, 0xF8, 0x00, 0x38, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0xC0, 0x0F, 0xFC, 0x70, 0x0F, 0xFF, 0x9C, 0x07, 0xE0, 0xE7,
  0x03, 0xE0, 0x1D, 0xC0, 0xF0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x1C, 0x00,
  0x3E, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0xF0, 0x70,
  0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF1,
  0xE0, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x87, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x1C, 0x3C, 0x00, 0x0F, 0x0F, 0x00,
  0x03, 0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F,
  0x00, 0x0F, 0x83, 0xC0, 0x07, 0xE0, 0xF0, 0x01, 0xF8, 0x1C, 0x00, 0xFC,
  0x07, 0x80, 0x77, 0x01, 0xF0, 0x39, 0xC0, 0x3F, 0x7C, 0xF0, 0x0F, 0xFE,
  0x3C, 0x00, 0xFF, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC1, 0xF8, 0x0E, 0x3F, 0x80,
  0x63, 0xFC, 0x07, 0x3E, 0x20, 0x3B, 0xC0, 0x01, 0xD8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xF8,
  0x0E, 0x07, 0x80, 0x08, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x08, 0x00, 0xF8, 0x30, 0x07, 0xC0, 0xFC, 0xFE, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x07, 0xFE, 0x7F, 0xFC,
  0xFF, 0xF8, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xFD, 0x80, 0xFF, 0x00,
  0xFE, 0x00, 0x70, 0x00, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0xE0, 0x78,
  0x00, 0x38, 0x1E, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x81, 0xC0, 0x01, 0xE0,
  0x70, 0x00, 0x70, 0x3C, 0x00, 0x1C, 0x0F, 0x00, 0x0F, 0x03, 0x80, 0x03,
  0xC0, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x38, 0x1E, 0x00, 0x0E, 0x07, 0x80,
  0x07, 0x81, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x70, 0x3C, 0x00, 0x1C, 0x0F,
  0x00, 0x0F, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x38,
  0x1E, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x01, 0xE0, 0x70, 0x00,
  0x78, 0x1C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0xC0, 0xF0,
  0x03, 0xF0, 0x3C, 0x00, 0xF8, 0x0F, 0x00, 0x6E, 0x01, 0xE0, 0x7B, 0x80,
  0x7F, 0xFC, 0xE0, 0x0F, 0xFE, 0x38, 0x01, 0xFE, 0x1C, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xEE, 0x00, 0x07, 0xB8, 0x00, 0x1C,
  0xE0, 0x00, 0xF3, 0x80, 0x03, 0x8E, 0x00, 0x1E, 0x38, 0x00, 0x70, 0xE0,
  0x03, 0xC3, 0x80, 0x0E, 0x0E, 0x00, 0x78, 0x38, 0x01, 0xC0, 0xE0, 0x0F,
  0x03, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xF0, 0x3C, 0x03,
  0xC0, 0xF0, 0x0F, 0x07, 0x80, 0x1C, 0x1E, 0x00, 0x70, 0x70, 0x01, 0xC3,
  0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x78, 0x00, 0x71, 0xC0, 0x01, 0xCF, 0x00,
  0x07, 0x38, 0x00, 0x1D, 0xE0, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x3F, 0x80,
  0x07, 0x80, 0x07, 0x70, 0x01, 0xF0, 0x01, 0xEE, 0x00, 0x3E, 0x00, 0x39,
  0xC0, 0x06, 0xC0, 0x0F, 0x38, 0x01, 0xD8, 0x01, 0xC7, 0x00, 0x3B, 0x00,
  0x38, 0xE0, 0x0E, 0x60, 0x0F, 0x1C, 0x01, 0xCC, 0x01, 0xC3, 0x80, 0x71,
  0x80, 0x78, 0x70, 0x0E, 0x38, 0x0E, 0x0E, 0x03, 0xC7, 0x01, 0xC1, 0xC0,
  0x70, 0xE0, 0x78, 0x38, 0x0E, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0x83, 0xC0,
  0xE0, 0x70, 0x70, 0x70, 0x1C, 0x1C, 0x0E, 0x1E, 0x03, 0x83, 0x81, 0xC3,
  0x80, 0x70, 0xF0, 0x38, 0x70, 0x0E, 0x1C, 0x07, 0x1E, 0x01, 0xC3, 0x80,
  0xE3, 0x80, 0x38, 0xE0, 0x1C, 0xF0, 0x07, 0x1C, 0x03, 0x9C, 0x00, 0xE7,
  0x80, 0x73, 0x80, 0x1C, 0xE0, 0x0E, 0xF0, 0x03, 0x9C, 0x01, 0xDC, 0x00,
  0x77, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x06, 0xE0, 0x01, 0xF8, 0x00, 0xDC,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x70, 0x01, 0xE0, 0x07,
  0x00, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x03, 0x80, 0x78, 0x00, 0x38, 0x0F,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x1C, 0x38, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x0F, 0x1C, 0x00,
  0x00, 0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x78,
  0x0E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x07, 0x00, 0x1E, 0x00, 0x70,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x03, 0x80, 0xF8,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x03, 0xC0,
  0x07, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x1E,
  0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x03,
  0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x1C,
  0x78, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0x9F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xBF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xF4, 0x00, 0x1F,
  0xF0,
};

const GFXglyph NotoSans_Condensed_LightItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 14, 46, 15, 1, -46 },
  { 82, 15, 16, 20, 7, -46 },
  { 112, 30, 46, 30, 1, -46 },
  { 285, 27, 53, 27, 1, -49 },
  { 464, 34, 48, 41, 4, -47 },
  { 668, 29, 48, 30, 0, -47 },
  { 842, 6, 16, 11, 7, -46 },
  { 854, 19, 56, 17, 2, -46 },
  { 987, 19, 56, 17, -5, -46 },
  { 1120, 21, 22, 26, 7, -49 },
  { 1178, 25, 30, 30, 3, -38 },
  { 1272, 10, 15, 12, -3, -7 },
  { 1291, 15, 3, 18, 1, -19 },
  { 1297, 5, 6, 13, 1, -6 },
  { 1301, 29, 46, 21, -3, -46 },
  { 1468, 25, 48, 27, 2, -47 },
  { 1618, 15, 46, 27, 8, -46 },
  { 1705, 28, 47, 27, -1, -47 },
  { 1870, 27, 48, 27, 0, -47 },
  { 2032, 28, 47, 27, -1, -47 },
  { 2197, 28, 47, 27, 0, -46 },
  { 2362, 26, 48, 27, 2, -47 },
  { 2518, 26, 46, 27, 3, -46 },
  { 2668, 28, 48, 27, 0, -47 },
  { 2836, 26, 48, 27, 1, -47 },
  { 2992, 11, 35, 13, 1, -35 },
  { 3041, 15, 43, 13, -3, -35 },
  { 3122, 25, 29, 30, 3, -38 },
  { 3213, 25, 17, 30, 3, -31 },
  { 3267, 25, 29, 30, 3, -38 },
  { 3358, 20, 47, 20, 2, -47 },
  { 3476, 38, 53, 41, 2, -47 },
  { 3728, 27, 47, 27, -4, -47 },
  { 3887, 29, 46, 30, 1, -46 },
  { 4054, 29, 48, 28, 3, -47 },
  { 4228, 31, 46, 33, 1, -46 },
  { 4407, 28, 46, 26, 1, -46 },
  { 4568, 28, 46, 24, 1, -46 },
  { 4729, 32, 48, 35, 3, -47 },
  { 4921, 34, 46, 34, 1, -46 },
  { 5117, 23, 46, 16, -3, -46 },
  { 5250, 24, 58, 13, -10, -46 },
  { 5424, 32, 46, 28, 1, -46 },
  { 5608, 18, 46, 24, 1, -46 },
  { 5712, 44, 46, 44, 1, -46 },
  { 5965, 35, 46, 36, 1, -46 },
  { 6167, 31, 48, 35, 3, -47 },
  { 6353, 28, 46, 28, 1, -46 },
  { 6514, 31, 58, 35, 3, -47 },
  { 6739, 28, 46, 29, 1, -46 },
  { 6900, 29, 48, 26, -1, -47 },
  { 7074, 23, 46, 24, 6, -46 },
  { 7207, 32, 47, 34, 3, -46 },
  { 7395, 27, 46, 28, 6, -46 },
  { 7551, 44, 46, 45, 6, -46 },
  { 7804, 34, 46, 25, -4, -46 },
  { 8000, 24, 46, 24, 6, -46 },
  { 8138, 30, 46, 25, -2, -46 },
  { 8311, 24, 57, 18, -1, -47 },
  { 8482, 10, 46, 21, 7, -46 },
  { 8540, 24, 57, 18, -4, -47 },
  { 8711, 26, 25, 29, 2, -46 },
  { 8793, 20, 3, 20, -5, 6 },
  { 8801, 8, 11, 15, 9, -50 },
  { 8812, 26, 36, 29, 2, -35 },
  { 8929, 26, 50, 29, 1, -49 },
  { 9092, 22, 36, 22, 2, -35 },
  { 9191, 30, 50, 29, 2, -49 },
  { 9379, 22, 36, 26, 2, -35 },
  { 9478, 31, 66, 15, -8, -50 },
  { 9734, 28, 51, 29, 0, -35 },
  { 9913, 25, 49, 29, 1, -49 },
  { 10067, 13, 47, 12, 1, -47 },
  { 10144, 23, 63, 13, -9, -47 },
  { 10326, 26, 49, 24, 1, -49 },
  { 10486, 14, 49, 12, 1, -49 },
  { 10572, 40, 35, 43, 1, -35 },
  { 10747, 25, 35, 29, 1, -35 },
  { 10857, 24, 36, 28, 2, -35 },
  { 10965, 29, 50, 29, -2, -35 },
  { 11147, 26, 50, 29, 2, -35 },
  { 11310, 21, 35, 19, 1, -35 },
  { 11402, 22, 36, 22, 0, -35 },
  { 11501, 15, 44, 16, 2, -43 },
  { 11584, 26, 36, 29, 2, -35 },
  { 11701, 22, 35, 22, 4, -35 },
  { 11798, 35, 35, 36, 4, -35 },
  { 11952, 28, 35, 23, -3, -35 },
  { 12075, 33, 51, 23, -7, -35 },
  { 12286, 24, 35, 20, -2, -35 },
  { 12391, 23, 56, 21, 2, -46 },
  { 12552, 3, 66, 27, 12, -50 },
  { 12577, 23, 56, 21, -4, -46 },
  { 12738, 25, 6, 30, 3, -26 },
};

const GFXfont NotoSans_Condensed_LightItalic65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic65pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC65PT7B_H_
