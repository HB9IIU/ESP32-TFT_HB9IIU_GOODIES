#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC19PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x22, 0x22, 0x24, 0x40, 0x4C, 0x5A, 0xA5, 0x29, 0x00,
  0x04, 0x84, 0x82, 0x41, 0x23, 0xFA, 0x90, 0x48, 0x44, 0x24, 0x7F, 0x89,
  0x09, 0x04, 0x82, 0x40, 0x04, 0x0E, 0x35, 0x24, 0x28, 0x28, 0x18, 0x0C,
  0x14, 0x12, 0x12, 0x14, 0xF8, 0x20, 0x20, 0x30, 0x52, 0x24, 0x92, 0x24,
  0x8A, 0x24, 0x89, 0x5E, 0x69, 0x6A, 0x44, 0x91, 0x44, 0x91, 0x24, 0x90,
  0xC0, 0x0C, 0x12, 0x12, 0x12, 0x12, 0x14, 0x18, 0x28, 0x49, 0x45, 0x86,
  0x86, 0x86, 0x7B, 0x5A, 0x80, 0x04, 0x21, 0x04, 0x20, 0x84, 0x10, 0x41,
  0x04, 0x20, 0x41, 0x04, 0x10, 0x60, 0x10, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x44, 0x21, 0x10, 0x88, 0x80, 0x12, 0x47, 0xCC, 0xD1, 0x20, 0x10, 0x20,
  0x40, 0x8F, 0xE2, 0x04, 0x08, 0x10, 0x2D, 0x60, 0xF8, 0x70, 0x01, 0x01,
  0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0x80,
  0x1C, 0x6C, 0x8A, 0x14, 0x30, 0x60, 0xC2, 0x85, 0x0A, 0x14, 0x49, 0x9E,
  0x00, 0x09, 0x95, 0x21, 0x08, 0x84, 0x21, 0x18, 0x84, 0x20, 0x0C, 0x33,
  0x01, 0x01, 0x01, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0xFC,
  0x0E, 0x33, 0x01, 0x01, 0x01, 0x02, 0x1C, 0x2C, 0x04, 0x02, 0x02, 0x04,
  0x04, 0xF8, 0x01, 0x03, 0x06, 0x0A, 0x0A, 0x12, 0x22, 0x24, 0x44, 0x84,
  0xFE, 0x04, 0x08, 0x08, 0x1F, 0x10, 0x10, 0x20, 0x20, 0x20, 0x7C, 0x06,
  0x02, 0x02, 0x02, 0x04, 0x04, 0xF8, 0x0E, 0x20, 0x82, 0x04, 0x08, 0x2F,
  0x62, 0x85, 0x0A, 0x14, 0x28, 0x8E, 0x00, 0x7F, 0x02, 0x02, 0x04, 0x04,
  0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x0E, 0x13, 0x21,
  0x21, 0x21, 0x12, 0x1C, 0x3C, 0x44, 0xC2, 0x82, 0x82, 0xC4, 0x78, 0x0C,
  0x12, 0x21, 0x21, 0x41, 0x41, 0x43, 0x26, 0x3A, 0x02, 0x04, 0x04, 0x08,
  0xF0, 0x24, 0x00, 0x00, 0x58, 0x18, 0x80, 0x00, 0x00, 0x00, 0x22, 0x11,
  0x80, 0x02, 0x18, 0xC2, 0x0C, 0x06, 0x03, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x80, 0xC0, 0x60, 0x30, 0x61, 0x0C, 0x60, 0x31, 0x20, 0x42, 0x08,
  0x43, 0x08, 0x41, 0x08, 0x00, 0x82, 0x00, 0x07, 0x01, 0x18, 0xC1, 0x10,
  0x14, 0x72, 0x92, 0x64, 0x4C, 0x91, 0x92, 0x54, 0x4A, 0x9A, 0x4D, 0x88,
  0x01, 0x00, 0x10, 0x81, 0xE0, 0x02, 0x02, 0x06, 0x06, 0x0A, 0x09, 0x11,
  0x11, 0x3F, 0x21, 0x61, 0x41, 0xC1, 0x81, 0x1C, 0x08, 0x84, 0x22, 0x12,
  0x19, 0x08, 0xF8, 0x4C, 0x43, 0x20, 0x90, 0x48, 0x44, 0x67, 0xE0, 0x07,
  0x19, 0x20, 0x60, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40,
  0x7C, 0x1C, 0x09, 0x84, 0x22, 0x12, 0x09, 0x04, 0x82, 0x41, 0x40, 0xA0,
  0x90, 0x48, 0x44, 0x47, 0xC0, 0x1F, 0x10, 0x10, 0x10, 0x20, 0x20, 0x3E,
  0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0xFC, 0x1F, 0x10, 0x10, 0x10, 0x20,
  0x20, 0x20, 0x3E, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x07, 0x0C, 0x48,
  0x0C, 0x04, 0x02, 0x02, 0x01, 0x0E, 0x81, 0x40, 0xA0, 0x50, 0x44, 0x23,
  0xF0, 0x10, 0x44, 0x11, 0x04, 0x41, 0x20, 0x88, 0x23, 0xF8, 0x82, 0x41,
  0x90, 0x44, 0x11, 0x04, 0x41, 0x20, 0x80, 0x1E, 0x10, 0x20, 0x40, 0x82,
  0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x1E, 0x00, 0x02, 0x04, 0x08, 0x10,
  0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0xE0, 0x10,
  0xC4, 0x21, 0x10, 0x48, 0x24, 0x0B, 0x03, 0x80, 0xE0, 0x68, 0x11, 0x04,
  0x41, 0x10, 0x46, 0x20, 0x80, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x41,
  0x04, 0x10, 0x43, 0xF0, 0x18, 0x08, 0xC0, 0xC6, 0x06, 0x50, 0x62, 0x83,
  0x14, 0x28, 0xA1, 0x45, 0x12, 0x48, 0xA2, 0x49, 0x12, 0x48, 0x94, 0x44,
  0x62, 0x42, 0x20, 0x10, 0x23, 0x08, 0x61, 0x14, 0x22, 0x84, 0x48, 0x89,
  0x21, 0x24, 0x44, 0x88, 0x51, 0x0A, 0x21, 0x84, 0x31, 0x02, 0x00, 0x0E,
  0x08, 0x88, 0x28, 0x14, 0x0A, 0x06, 0x03, 0x01, 0x81, 0x40, 0xA0, 0x50,
  0x4C, 0x43, 0xC0, 0x1C, 0x13, 0x11, 0x11, 0x21, 0x21, 0x23, 0x3E, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x80, 0x0E, 0x08, 0x88, 0x28, 0x14, 0x0A, 0x06,
  0x03, 0x01, 0x81, 0x40, 0xA0, 0x50, 0x4C, 0x43, 0xC0, 0x20, 0x10, 0x0C,
  0x00, 0x1C, 0x13, 0x11, 0x11, 0x21, 0x21, 0x23, 0x3C, 0x48, 0x44, 0x44,
  0x44, 0x44, 0x82, 0x0E, 0x31, 0x20, 0x20, 0x20, 0x20, 0x10, 0x08, 0x04,
  0x04, 0x04, 0x04, 0x04, 0xF8, 0xFE, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20,
  0x40, 0x81, 0x04, 0x08, 0x10, 0x00, 0x20, 0x90, 0x48, 0x28, 0x34, 0x12,
  0x09, 0x04, 0x82, 0x82, 0x41, 0x20, 0x90, 0x48, 0x43, 0xC0, 0x83, 0x82,
  0x82, 0x84, 0x84, 0x88, 0x88, 0x90, 0x90, 0xA0, 0xA0, 0xA0, 0xC0, 0xC0,
  0x82, 0x1C, 0x30, 0xA1, 0x85, 0x14, 0x48, 0xA2, 0x45, 0x22, 0x49, 0x12,
  0x48, 0xA2, 0x85, 0x14, 0x30, 0xC1, 0x86, 0x0C, 0x30, 0x41, 0x00, 0x10,
  0x44, 0x20, 0x90, 0x24, 0x0A, 0x02, 0x80, 0xC0, 0x30, 0x14, 0x05, 0x02,
  0x41, 0x98, 0x42, 0x20, 0x80, 0x83, 0x0A, 0x34, 0x49, 0x12, 0x18, 0x30,
  0x40, 0x81, 0x04, 0x08, 0x10, 0x00, 0x1F, 0x80, 0x40, 0x40, 0x20, 0x20,
  0x30, 0x10, 0x10, 0x18, 0x08, 0x08, 0x04, 0x04, 0x07, 0xF0, 0x1E, 0x20,
  0x40, 0x82, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40,
  0xE0, 0x92, 0x48, 0x92, 0x49, 0x22, 0x40, 0x1E, 0x04, 0x10, 0x20, 0x40,
  0x82, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0xE0, 0x04, 0x0C,
  0x14, 0x12, 0x22, 0x22, 0x41, 0xC1, 0xFC, 0xA4, 0x3E, 0x8D, 0x0C, 0x38,
  0x50, 0xA1, 0x46, 0x99, 0xF0, 0x10, 0x10, 0x10, 0x20, 0x2E, 0x31, 0x21,
  0x21, 0x41, 0x43, 0x42, 0x42, 0xC4, 0xB8, 0x3D, 0x04, 0x20, 0x82, 0x08,
  0x20, 0x83, 0xC0, 0x01, 0x01, 0x01, 0x02, 0x3E, 0x46, 0x42, 0x82, 0x84,
  0x84, 0x84, 0x8C, 0x94, 0xF8, 0x3D, 0x14, 0x63, 0xFA, 0x08, 0x20, 0x81,
  0xE0, 0x01, 0x01, 0x41, 0x00, 0x80, 0x40, 0xF0, 0x20, 0x10, 0x08, 0x04,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x10, 0x10, 0x00,
  0x1F, 0x23, 0x21, 0x41, 0x42, 0x42, 0x42, 0x46, 0x4A, 0x7C, 0x04, 0x04,
  0x08, 0x98, 0x60, 0x10, 0x10, 0x10, 0x20, 0x2E, 0x31, 0x21, 0x22, 0x42,
  0x42, 0x42, 0x42, 0x44, 0x84, 0x11, 0x00, 0x22, 0x22, 0x44, 0x44, 0x48,
  0x02, 0x04, 0x00, 0x00, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82,
  0x04, 0x08, 0x11, 0x41, 0x00, 0x10, 0x10, 0x10, 0x20, 0x23, 0x24, 0x2C,
  0x28, 0x50, 0x68, 0x48, 0x48, 0x48, 0x84, 0x11, 0x12, 0x22, 0x22, 0x44,
  0x44, 0x48, 0x2E, 0xF3, 0x31, 0x22, 0x12, 0x21, 0x42, 0x24, 0x22, 0x44,
  0x24, 0x42, 0x44, 0x28, 0x44, 0x2E, 0x31, 0x21, 0x22, 0x42, 0x42, 0x42,
  0x46, 0x44, 0x84, 0x3C, 0x89, 0x0C, 0x18, 0x30, 0xA1, 0x42, 0x89, 0xE0,
  0x17, 0x0C, 0x44, 0x22, 0x12, 0x09, 0x04, 0x84, 0x42, 0x22, 0x2E, 0x10,
  0x08, 0x04, 0x04, 0x00, 0x3E, 0x8D, 0x0C, 0x18, 0x50, 0xA1, 0x46, 0x95,
  0xF0, 0x20, 0x40, 0x82, 0x00, 0x2C, 0xC2, 0x08, 0x41, 0x04, 0x10, 0x42,
  0x00, 0x3D, 0x04, 0x18, 0x30, 0x60, 0x82, 0x0B, 0xC0, 0x24, 0xF4, 0x44,
  0x88, 0x88, 0x8C, 0x42, 0x85, 0x1A, 0x28, 0x50, 0xA1, 0x44, 0x99, 0xD0,
  0x86, 0x18, 0xA2, 0x92, 0x4A, 0x28, 0xC1, 0x00, 0x8C, 0x63, 0x18, 0xCA,
  0x52, 0x95, 0x29, 0x4A, 0x53, 0x18, 0xC6, 0x31, 0x00, 0x31, 0x12, 0x12,
  0x14, 0x08, 0x18, 0x18, 0x24, 0x44, 0xC4, 0x10, 0xC4, 0x21, 0x10, 0x44,
  0x12, 0x02, 0x80, 0xA0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x40, 0x10, 0x28,
  0x0C, 0x00, 0x1E, 0x04, 0x10, 0x40, 0x82, 0x08, 0x10, 0x41, 0xF0, 0x02,
  0x18, 0x20, 0x41, 0x02, 0x04, 0x08, 0x61, 0x40, 0x81, 0x02, 0x04, 0x10,
  0x20, 0x30, 0xFF, 0xFF, 0xE0, 0x10, 0x18, 0x10, 0x20, 0x41, 0x02, 0x04,
  0x06, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0xC0, 0x63, 0x3C,
};

const GFXglyph NotoSans_Condensed_LightItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 14, 4, 0, -14 },
  { 8, 5, 5, 6, 2, -14 },
  { 12, 9, 14, 9, 0, -14 },
  { 28, 8, 15, 8, 0, -14 },
  { 43, 10, 14, 12, 1, -14 },
  { 61, 8, 14, 9, 0, -14 },
  { 75, 2, 5, 3, 2, -14 },
  { 77, 6, 17, 5, 0, -14 },
  { 90, 5, 17, 5, -1, -14 },
  { 101, 6, 6, 8, 2, -14 },
  { 106, 7, 9, 9, 1, -11 },
  { 114, 3, 4, 4, -1, -2 },
  { 116, 5, 1, 5, 0, -6 },
  { 117, 2, 2, 4, 0, -2 },
  { 118, 8, 14, 6, -1, -14 },
  { 132, 7, 14, 8, 1, -14 },
  { 145, 5, 14, 8, 2, -14 },
  { 154, 8, 14, 8, 0, -14 },
  { 168, 8, 14, 8, 0, -14 },
  { 182, 8, 14, 8, 0, -14 },
  { 196, 8, 14, 8, 0, -14 },
  { 210, 7, 14, 8, 1, -14 },
  { 223, 8, 14, 8, 1, -14 },
  { 237, 8, 14, 8, 0, -14 },
  { 251, 8, 14, 8, 0, -14 },
  { 265, 3, 10, 4, 0, -10 },
  { 269, 5, 12, 4, -1, -10 },
  { 277, 7, 8, 9, 1, -11 },
  { 284, 7, 5, 9, 1, -9 },
  { 289, 7, 8, 9, 1, -11 },
  { 296, 6, 14, 6, 1, -14 },
  { 307, 11, 16, 12, 1, -14 },
  { 329, 8, 14, 8, -1, -14 },
  { 343, 9, 14, 9, 0, -14 },
  { 359, 8, 14, 8, 1, -14 },
  { 373, 9, 14, 10, 0, -14 },
  { 389, 8, 14, 8, 0, -14 },
  { 403, 8, 14, 7, 0, -14 },
  { 417, 9, 14, 10, 1, -14 },
  { 433, 10, 14, 10, 0, -14 },
  { 451, 7, 14, 5, -1, -14 },
  { 464, 7, 17, 4, -3, -14 },
  { 479, 10, 14, 8, 0, -14 },
  { 497, 6, 14, 7, 0, -14 },
  { 508, 13, 14, 13, 0, -14 },
  { 531, 11, 14, 10, 0, -14 },
  { 551, 9, 14, 10, 1, -14 },
  { 567, 8, 14, 8, 0, -14 },
  { 581, 9, 17, 10, 1, -14 },
  { 601, 8, 14, 8, 0, -14 },
  { 615, 8, 14, 8, 0, -14 },
  { 629, 7, 14, 7, 2, -14 },
  { 642, 9, 14, 10, 1, -14 },
  { 658, 8, 14, 8, 2, -14 },
  { 672, 13, 14, 13, 2, -14 },
  { 695, 10, 14, 7, -1, -14 },
  { 713, 7, 14, 7, 2, -14 },
  { 726, 9, 14, 7, -1, -14 },
  { 742, 7, 17, 5, 0, -14 },
  { 757, 3, 14, 6, 2, -14 },
  { 763, 7, 17, 5, -1, -14 },
  { 778, 8, 8, 8, 0, -14 },
  { 786, 6, 1, 6, -2, 2 },
  { 787, 2, 3, 4, 3, -15 },
  { 788, 7, 10, 9, 1, -10 },
  { 797, 8, 14, 9, 0, -14 },
  { 811, 6, 10, 6, 1, -10 },
  { 819, 8, 14, 9, 1, -14 },
  { 833, 6, 10, 8, 1, -10 },
  { 841, 9, 20, 4, -2, -15 },
  { 864, 8, 15, 9, 0, -10 },
  { 879, 8, 14, 8, 0, -14 },
  { 893, 4, 14, 4, 0, -14 },
  { 900, 7, 19, 4, -3, -14 },
  { 917, 8, 14, 7, 0, -14 },
  { 931, 4, 14, 4, 0, -14 },
  { 938, 12, 10, 13, 0, -10 },
  { 953, 8, 10, 8, 0, -10 },
  { 963, 7, 10, 8, 1, -10 },
  { 972, 9, 14, 9, -1, -10 },
  { 988, 7, 14, 9, 1, -10 },
  { 1001, 6, 10, 6, 0, -10 },
  { 1009, 6, 10, 6, 0, -10 },
  { 1017, 4, 12, 5, 1, -12 },
  { 1023, 7, 10, 8, 1, -10 },
  { 1032, 6, 10, 7, 1, -10 },
  { 1040, 10, 10, 11, 1, -10 },
  { 1053, 8, 10, 7, -1, -10 },
  { 1063, 10, 15, 7, -2, -10 },
  { 1082, 7, 10, 6, -1, -10 },
  { 1091, 7, 17, 6, 0, -14 },
  { 1106, 1, 19, 8, 4, -14 },
  { 1109, 7, 17, 6, -1, -14 },
  { 1124, 7, 2, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_LightItalic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic19pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC19PT7B_H_
