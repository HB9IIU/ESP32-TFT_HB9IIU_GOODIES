#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC16PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x12, 0x22, 0x24, 0x44, 0x00, 0xC0, 0xBA, 0xAA, 0x0A, 0x12, 0x12,
  0x7F, 0x24, 0x24, 0x28, 0xDE, 0x48, 0x50, 0x50, 0x08, 0x3C, 0xA2, 0x43,
  0x06, 0x06, 0x0C, 0x14, 0x4B, 0xE1, 0x02, 0x00, 0x21, 0x52, 0x92, 0x94,
  0x94, 0xAB, 0xAD, 0x55, 0x29, 0x29, 0x49, 0xC6, 0x08, 0x28, 0x91, 0x22,
  0x82, 0x0C, 0x29, 0x8B, 0x1A, 0x33, 0xA0, 0xF0, 0x18, 0x88, 0x44, 0x21,
  0x10, 0x84, 0x20, 0x84, 0x20, 0x10, 0x82, 0x10, 0x84, 0x42, 0x11, 0x08,
  0x84, 0x40, 0x25, 0x1E, 0xC9, 0x00, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x00,
  0x29, 0x40, 0xF0, 0xC0, 0x02, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20,
  0x82, 0x00, 0x10, 0xA4, 0x51, 0x86, 0x18, 0xA2, 0x8A, 0x49, 0x38, 0x3E,
  0x22, 0x24, 0x44, 0x44, 0x80, 0x18, 0x48, 0x08, 0x10, 0x40, 0x82, 0x08,
  0x20, 0x82, 0x07, 0xC0, 0x18, 0x48, 0x08, 0x10, 0x41, 0x0E, 0x02, 0x04,
  0x08, 0x27, 0x80, 0x02, 0x08, 0x30, 0xA1, 0x44, 0x92, 0x24, 0xFC, 0x10,
  0x20, 0x80, 0x3E, 0x40, 0x82, 0x07, 0x80, 0x81, 0x02, 0x04, 0x13, 0xC0,
  0x0C, 0xC4, 0x10, 0x83, 0xE8, 0xA2, 0x8A, 0x29, 0x3C, 0x7C, 0x10, 0x82,
  0x10, 0x42, 0x08, 0x41, 0x08, 0x00, 0x08, 0x6C, 0x89, 0x12, 0x43, 0x0A,
  0x24, 0x85, 0x0A, 0x13, 0xC0, 0x18, 0x48, 0x8A, 0x14, 0x28, 0x93, 0x1A,
  0x04, 0x10, 0x27, 0x80, 0x24, 0x00, 0x00, 0x80, 0x11, 0x00, 0x00, 0x02,
  0x44, 0x80, 0x0C, 0xC4, 0x20, 0x60, 0x60, 0x40, 0xFC, 0x00, 0x3F, 0x81,
  0x81, 0x83, 0x31, 0x08, 0x00, 0x64, 0x82, 0x21, 0x11, 0x10, 0x80, 0x01,
  0x00, 0x1F, 0x10, 0x50, 0x33, 0xD9, 0x4D, 0x26, 0x93, 0x4A, 0xBE, 0x40,
  0x20, 0x0F, 0x00, 0x04, 0x18, 0x28, 0x91, 0x24, 0x4F, 0x91, 0x42, 0x86,
  0x08, 0x3E, 0x44, 0x89, 0x12, 0x4B, 0x91, 0x21, 0x45, 0x0B, 0xE0, 0x0C,
  0x65, 0x82, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x03, 0xC0, 0x3E, 0x21,
  0x21, 0x21, 0x21, 0x41, 0x42, 0x42, 0x44, 0x8C, 0xF0, 0x3E, 0x40, 0x81,
  0x02, 0x0B, 0x90, 0x20, 0x41, 0x03, 0xE0, 0x3E, 0x40, 0x81, 0x02, 0x0F,
  0x90, 0x20, 0x41, 0x02, 0x00, 0x0C, 0x33, 0x60, 0x40, 0x80, 0x80, 0x8E,
  0x82, 0x84, 0x84, 0x84, 0x7C, 0x31, 0x90, 0x88, 0x44, 0x22, 0x12, 0xF1,
  0x08, 0x84, 0x42, 0x41, 0x21, 0x00, 0x1C, 0x41, 0x04, 0x10, 0x42, 0x08,
  0x20, 0x8F, 0x00, 0x0C, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x82, 0x08,
  0x23, 0x00, 0x33, 0x22, 0x24, 0x28, 0x30, 0x70, 0x48, 0x48, 0x48, 0x88,
  0x84, 0x31, 0x08, 0x42, 0x21, 0x08, 0x44, 0x3E, 0x30, 0x66, 0x0C, 0xC3,
  0x18, 0x63, 0x14, 0xA2, 0x92, 0x92, 0x54, 0x4C, 0x91, 0x92, 0x22, 0x00,
  0x30, 0x98, 0x4C, 0x45, 0x22, 0x92, 0x49, 0x24, 0x8C, 0x46, 0x43, 0x21,
  0x80, 0x08, 0x6D, 0x0A, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0A, 0x23, 0xC0,
  0x3E, 0x44, 0x89, 0x12, 0x2F, 0x90, 0x20, 0x41, 0x02, 0x00, 0x08, 0x6D,
  0x0A, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0A, 0x23, 0xC1, 0x02, 0x02, 0x00,
  0x3E, 0x44, 0x89, 0x12, 0x4F, 0x12, 0x24, 0x49, 0x12, 0x10, 0x08, 0x65,
  0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x10, 0x27, 0x80, 0xFC, 0x82, 0x08,
  0x20, 0x84, 0x10, 0x41, 0x0C, 0x00, 0x43, 0x42, 0x42, 0x42, 0x82, 0x84,
  0x84, 0x84, 0x84, 0x88, 0xF0, 0x83, 0x0A, 0x14, 0x44, 0x8A, 0x14, 0x28,
  0x60, 0xC1, 0x00, 0x88, 0x62, 0x29, 0x8A, 0x62, 0xA9, 0x2A, 0x4C, 0xA3,
  0x28, 0xCA, 0x23, 0x08, 0xC0, 0x11, 0x12, 0x12, 0x0C, 0x08, 0x08, 0x18,
  0x28, 0x24, 0x44, 0x84, 0x85, 0x24, 0x94, 0x51, 0x84, 0x10, 0x41, 0x04,
  0x00, 0x1F, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0xFC,
  0x3C, 0x82, 0x08, 0x21, 0x04, 0x10, 0x42, 0x08, 0x20, 0x83, 0x80, 0xAA,
  0xA5, 0x54, 0x1C, 0x10, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x08, 0x23,
  0x80, 0x18, 0x30, 0x91, 0x24, 0x50, 0x40, 0xF8, 0xD0, 0x35, 0x38, 0xE2,
  0x8A, 0x28, 0xA4, 0xF0, 0x10, 0x40, 0x81, 0x63, 0x44, 0x50, 0xA1, 0x44,
  0x8B, 0x25, 0xC0, 0x3A, 0x21, 0x08, 0x42, 0x10, 0xE0, 0x02, 0x08, 0x11,
  0xA4, 0xD0, 0xA2, 0x44, 0x89, 0x12, 0x67, 0x80, 0x32, 0x63, 0x1F, 0x42,
  0x10, 0xF0, 0x07, 0x04, 0x08, 0x1C, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x20, 0xC0, 0x1A, 0x4D, 0x0A, 0x24, 0x48, 0xA1,
  0x26, 0x78, 0x10, 0x20, 0x8E, 0x00, 0x10, 0x82, 0x0B, 0x34, 0x94, 0x51,
  0x45, 0x18, 0xA2, 0x12, 0x02, 0x24, 0x44, 0x44, 0x88, 0x04, 0x20, 0x02,
  0x08, 0x21, 0x04, 0x10, 0x42, 0x08, 0x20, 0x84, 0x30, 0x10, 0x40, 0x81,
  0x12, 0x49, 0x14, 0x38, 0x50, 0xA2, 0x24, 0x40, 0x12, 0x22, 0x24, 0x44,
  0x44, 0x88, 0x29, 0x8D, 0x92, 0x45, 0x11, 0x44, 0x51, 0x24, 0x8A, 0x22,
  0x88, 0x80, 0x2C, 0xD2, 0x51, 0x45, 0x14, 0x62, 0x88, 0x32, 0x63, 0x18,
  0xC6, 0x32, 0xE0, 0x16, 0x1A, 0x11, 0x21, 0x21, 0x22, 0x22, 0x24, 0x5C,
  0x40, 0x40, 0x40, 0x80, 0x35, 0x38, 0x62, 0x8A, 0x28, 0xA6, 0xF0, 0x41,
  0x04, 0x10, 0x29, 0x88, 0x84, 0x21, 0x10, 0x80, 0x3A, 0x50, 0x82, 0x08,
  0x42, 0xF0, 0x22, 0x72, 0x44, 0x44, 0x48, 0x60, 0x45, 0x18, 0xA2, 0x8A,
  0x28, 0xA4, 0xF0, 0x8C, 0x65, 0x2A, 0x52, 0x98, 0x80, 0x88, 0xCC, 0xA6,
  0x55, 0x4A, 0xA5, 0x53, 0x31, 0x98, 0x88, 0x00, 0x22, 0x44, 0x50, 0xC1,
  0x03, 0x0A, 0x24, 0xCC, 0x11, 0x11, 0x11, 0x12, 0x12, 0x14, 0x14, 0x18,
  0x08, 0x10, 0x10, 0x20, 0xC0, 0x78, 0x44, 0x22, 0x21, 0x10, 0xF0, 0x0C,
  0x41, 0x04, 0x20, 0x8C, 0x08, 0x21, 0x04, 0x10, 0x40, 0x80, 0xFF, 0xFF,
  0x18, 0x20, 0x82, 0x08, 0x40, 0xC4, 0x10, 0x82, 0x08, 0x62, 0x00, 0x42,
  0xF0,
};

const GFXglyph NotoSans_Condensed_LightItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 4, 4, 5, 2, -11 },
  { 9, 8, 11, 7, 0, -11 },
  { 20, 7, 13, 7, 0, -12 },
  { 32, 8, 12, 10, 1, -12 },
  { 44, 7, 12, 7, 0, -12 },
  { 55, 1, 4, 3, 2, -11 },
  { 56, 5, 14, 4, 0, -11 },
  { 65, 5, 14, 4, -1, -11 },
  { 74, 5, 5, 6, 2, -12 },
  { 78, 6, 7, 7, 1, -9 },
  { 84, 3, 4, 3, -1, -2 },
  { 86, 4, 1, 4, 0, -5 },
  { 87, 2, 1, 3, 0, -1 },
  { 88, 7, 11, 5, -1, -11 },
  { 98, 6, 12, 7, 1, -12 },
  { 107, 4, 11, 7, 2, -11 },
  { 113, 7, 12, 7, 0, -12 },
  { 124, 7, 12, 7, 0, -12 },
  { 135, 7, 12, 7, 0, -12 },
  { 146, 7, 11, 7, 0, -11 },
  { 156, 6, 12, 7, 1, -12 },
  { 165, 6, 11, 7, 1, -11 },
  { 174, 7, 12, 7, 0, -12 },
  { 185, 7, 12, 7, 0, -12 },
  { 196, 3, 9, 3, 0, -9 },
  { 200, 4, 11, 3, -1, -9 },
  { 206, 6, 7, 7, 1, -9 },
  { 212, 6, 4, 7, 1, -8 },
  { 215, 6, 7, 7, 1, -9 },
  { 221, 5, 12, 5, 1, -12 },
  { 229, 9, 12, 10, 1, -11 },
  { 243, 7, 11, 7, -1, -11 },
  { 253, 7, 11, 7, 0, -11 },
  { 263, 7, 12, 7, 1, -12 },
  { 274, 8, 11, 8, 0, -11 },
  { 285, 7, 11, 6, 0, -11 },
  { 295, 7, 11, 6, 0, -11 },
  { 305, 8, 12, 9, 1, -12 },
  { 317, 9, 11, 8, 0, -11 },
  { 330, 6, 11, 4, -1, -11 },
  { 339, 6, 14, 3, -2, -11 },
  { 350, 8, 11, 7, 0, -11 },
  { 361, 5, 11, 6, 0, -11 },
  { 368, 11, 11, 11, 0, -11 },
  { 384, 9, 11, 9, 0, -11 },
  { 397, 7, 12, 9, 1, -12 },
  { 408, 7, 11, 7, 0, -11 },
  { 418, 7, 15, 9, 1, -12 },
  { 432, 7, 11, 7, 0, -11 },
  { 442, 7, 12, 6, 0, -12 },
  { 453, 6, 11, 6, 1, -11 },
  { 462, 8, 11, 8, 1, -11 },
  { 473, 7, 11, 7, 1, -11 },
  { 483, 10, 11, 11, 2, -11 },
  { 497, 8, 11, 6, -1, -11 },
  { 508, 6, 11, 6, 1, -11 },
  { 517, 8, 11, 6, -1, -11 },
  { 528, 6, 14, 5, 0, -11 },
  { 539, 2, 11, 5, 2, -11 },
  { 542, 6, 14, 5, -1, -11 },
  { 553, 7, 6, 7, 0, -11 },
  { 559, 5, 1, 5, -1, 1 },
  { 560, 2, 2, 4, 2, -12 },
  { 561, 6, 9, 7, 1, -9 },
  { 568, 7, 12, 7, 0, -12 },
  { 579, 5, 9, 5, 1, -9 },
  { 585, 7, 12, 7, 1, -12 },
  { 596, 5, 9, 6, 1, -9 },
  { 602, 8, 16, 4, -2, -12 },
  { 618, 7, 13, 7, 0, -9 },
  { 630, 6, 12, 7, 0, -12 },
  { 639, 4, 12, 3, 0, -12 },
  { 645, 6, 16, 3, -2, -12 },
  { 657, 7, 12, 6, 0, -12 },
  { 668, 4, 12, 3, 0, -12 },
  { 674, 10, 9, 11, 0, -9 },
  { 686, 6, 9, 7, 0, -9 },
  { 693, 5, 9, 7, 1, -9 },
  { 699, 8, 13, 7, -1, -9 },
  { 712, 6, 13, 7, 1, -9 },
  { 722, 5, 9, 5, 0, -9 },
  { 728, 5, 9, 5, 0, -9 },
  { 734, 4, 11, 4, 0, -11 },
  { 740, 6, 9, 7, 1, -9 },
  { 747, 5, 9, 6, 1, -9 },
  { 753, 9, 9, 9, 1, -9 },
  { 764, 7, 9, 6, -1, -9 },
  { 772, 8, 13, 6, -2, -9 },
  { 785, 5, 9, 5, 0, -9 },
  { 791, 6, 14, 5, 0, -11 },
  { 802, 1, 16, 7, 3, -12 },
  { 804, 6, 14, 5, -1, -11 },
  { 815, 6, 2, 7, 1, -7 },
};

const GFXfont NotoSans_Condensed_LightItalic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic16pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC16PT7B_H_
