#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC21PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0xC4, 0x21, 0x18, 0x84, 0x21, 0x10, 0x00, 0x23, 0x00, 0x4A,
  0x53, 0x29, 0x00, 0x04, 0xC1, 0x20, 0x88, 0x22, 0x3F, 0xC2, 0x41, 0x10,
  0x48, 0x12, 0x3F, 0xE2, 0x40, 0x90, 0x44, 0x11, 0x04, 0x80, 0x02, 0x01,
  0x07, 0xE6, 0x82, 0x41, 0x20, 0x90, 0x30, 0x0C, 0x07, 0x02, 0x81, 0x41,
  0x24, 0xB3, 0xF0, 0x20, 0x20, 0x00, 0x38, 0x69, 0x09, 0x22, 0x24, 0x48,
  0x91, 0x14, 0x22, 0xBC, 0xA9, 0x75, 0x21, 0x24, 0x28, 0x89, 0x12, 0x22,
  0x44, 0x90, 0xE0, 0x0F, 0x0C, 0x84, 0x42, 0x21, 0x20, 0xB0, 0x70, 0x30,
  0x2C, 0xA2, 0x71, 0x50, 0x68, 0x26, 0x39, 0xE4, 0x56, 0x80, 0x0C, 0x41,
  0x08, 0x61, 0x04, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83, 0x00,
  0x18, 0x20, 0x82, 0x0C, 0x10, 0x43, 0x08, 0x20, 0x82, 0x10, 0x42, 0x08,
  0x42, 0x00, 0x08, 0x13, 0x41, 0xF2, 0x89, 0x13, 0x00, 0x08, 0x08, 0x08,
  0x08, 0xFF, 0x08, 0x08, 0x08, 0x08, 0x2D, 0x28, 0xF8, 0x70, 0x00, 0x80,
  0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x0C, 0x04, 0x04,
  0x02, 0x02, 0x00, 0x1E, 0x32, 0x21, 0x41, 0x41, 0x43, 0x82, 0x82, 0x82,
  0x82, 0x86, 0x84, 0x8C, 0x88, 0x70, 0x17, 0xDB, 0x22, 0x22, 0x64, 0x44,
  0x48, 0x80, 0x1F, 0x08, 0x80, 0x60, 0x30, 0x10, 0x08, 0x08, 0x04, 0x04,
  0x04, 0x04, 0x04, 0x04, 0x06, 0x03, 0xF8, 0x1F, 0x18, 0xC0, 0x20, 0x10,
  0x10, 0x08, 0x18, 0x38, 0x02, 0x01, 0x00, 0x80, 0x40, 0x24, 0x23, 0xE0,
  0x01, 0x81, 0x80, 0xC0, 0xA0, 0x90, 0xD8, 0x48, 0x44, 0x42, 0x21, 0x3F,
  0xDF, 0xE0, 0x40, 0x20, 0x30, 0x1F, 0x88, 0x04, 0x02, 0x02, 0x01, 0x00,
  0xF0, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x24, 0x23, 0xE0, 0x0F, 0x10,
  0x20, 0x20, 0x40, 0x40, 0xFC, 0xC2, 0x82, 0x82, 0x82, 0x86, 0x84, 0x8C,
  0x78, 0x7F, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08,
  0x0C, 0x04, 0x06, 0x02, 0x03, 0x00, 0x0F, 0x08, 0xCC, 0x24, 0x13, 0x18,
  0x88, 0x78, 0x38, 0x26, 0x21, 0x20, 0xD0, 0x68, 0x26, 0x11, 0xF0, 0x0F,
  0x08, 0x88, 0x64, 0x32, 0x1B, 0x0D, 0x84, 0x46, 0x3D, 0x00, 0x80, 0x80,
  0x40, 0x40, 0x63, 0xC0, 0x32, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x18, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0x18, 0x84, 0x40, 0x01, 0x06, 0x18, 0x60, 0x80,
  0x60, 0x18, 0x06, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x06, 0x18, 0x60, 0x80, 0x7D, 0x10, 0x41, 0x04, 0x21, 0x08,
  0x41, 0x04, 0x00, 0x02, 0x08, 0x00, 0x07, 0xC0, 0x82, 0x10, 0x12, 0x01,
  0x43, 0x94, 0x49, 0x89, 0x19, 0x11, 0x91, 0x19, 0x12, 0x93, 0x29, 0x54,
  0x89, 0x88, 0x00, 0x80, 0x04, 0x10, 0x3E, 0x00, 0x03, 0x01, 0x81, 0x40,
  0xA0, 0x50, 0x48, 0x24, 0x22, 0x11, 0x1F, 0x88, 0x4C, 0x24, 0x16, 0x0E,
  0x06, 0x1F, 0x04, 0x21, 0x0C, 0x43, 0x10, 0x88, 0x22, 0x30, 0xF8, 0x21,
  0x18, 0x44, 0x19, 0x04, 0x41, 0x10, 0x8F, 0xC0, 0x0F, 0x8C, 0x0C, 0x04,
  0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x02, 0x00,
  0xF0, 0x1F, 0x04, 0x21, 0x04, 0x41, 0x10, 0x48, 0x12, 0x04, 0x81, 0x20,
  0x58, 0x24, 0x09, 0x06, 0x43, 0x11, 0x8F, 0x80, 0x1F, 0x88, 0x04, 0x02,
  0x01, 0x01, 0x00, 0x84, 0x7C, 0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x03,
  0xF0, 0x1F, 0x88, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x7E, 0x20, 0x30,
  0x10, 0x08, 0x04, 0x02, 0x03, 0x00, 0x0F, 0xC6, 0x13, 0x00, 0x80, 0x40,
  0x10, 0x0C, 0x02, 0x0E, 0x84, 0xA0, 0x28, 0x1A, 0x04, 0xC1, 0x10, 0x43,
  0xF0, 0x18, 0x22, 0x04, 0x40, 0x88, 0x31, 0x04, 0x40, 0x88, 0x11, 0xFE,
  0x20, 0xCC, 0x11, 0x02, 0x20, 0x44, 0x08, 0x82, 0x30, 0x40, 0x1E, 0x18,
  0x20, 0x40, 0x81, 0x06, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x3C, 0x00,
  0x03, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08,
  0x08, 0x08, 0x18, 0x10, 0x10, 0x30, 0xE0, 0x18, 0x62, 0x10, 0x46, 0x09,
  0x81, 0x20, 0x48, 0x0A, 0x01, 0xE0, 0x24, 0x0C, 0x81, 0x10, 0x23, 0x04,
  0x20, 0x84, 0x30, 0xC0, 0x18, 0x41, 0x04, 0x10, 0x82, 0x08, 0x21, 0x84,
  0x10, 0x41, 0x0F, 0xC0, 0x18, 0x06, 0x30, 0x18, 0x60, 0x30, 0xC0, 0xA1,
  0x81, 0xC5, 0x85, 0x09, 0x0A, 0x12, 0x24, 0x24, 0x48, 0xC9, 0x31, 0x12,
  0x42, 0x28, 0x84, 0x51, 0x08, 0xC2, 0x31, 0x88, 0x00, 0x18, 0x11, 0x82,
  0x18, 0x21, 0x42, 0x14, 0x22, 0x46, 0x24, 0x42, 0x24, 0x22, 0x46, 0x24,
  0x42, 0xC4, 0x38, 0x41, 0x84, 0x18, 0xC1, 0x80, 0x0F, 0x84, 0x22, 0x04,
  0x81, 0x40, 0x50, 0x1C, 0x06, 0x03, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x81,
  0x10, 0x87, 0xC0, 0x1F, 0x08, 0xC4, 0x22, 0x11, 0x09, 0x04, 0x86, 0x46,
  0x3C, 0x30, 0x10, 0x08, 0x04, 0x02, 0x03, 0x00, 0x0F, 0x84, 0x22, 0x04,
  0x81, 0x40, 0x50, 0x1C, 0x06, 0x03, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x81,
  0x10, 0x87, 0xC0, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x1F, 0x08, 0xC4, 0x22,
  0x11, 0x09, 0x04, 0x84, 0x7E, 0x3C, 0x32, 0x11, 0x08, 0xC4, 0x22, 0x13,
  0x0C, 0x0F, 0x88, 0x48, 0x04, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x80, 0x40, 0x24, 0x23, 0xE0, 0xFE, 0x20, 0x41, 0x82, 0x04, 0x08,
  0x10, 0x60, 0x81, 0x02, 0x04, 0x10, 0x20, 0x00, 0x30, 0x48, 0x12, 0x04,
  0x83, 0x60, 0x90, 0x24, 0x09, 0x02, 0x41, 0x30, 0x48, 0x12, 0x04, 0x82,
  0x31, 0x87, 0xC0, 0x81, 0xC0, 0xA0, 0x90, 0x48, 0x64, 0x22, 0x31, 0x10,
  0x88, 0x48, 0x24, 0x14, 0x0A, 0x06, 0x03, 0x00, 0x83, 0x06, 0x0C, 0x28,
  0x50, 0xA1, 0x46, 0x85, 0x12, 0x24, 0x48, 0x92, 0x24, 0x48, 0x91, 0x62,
  0x45, 0x0A, 0x14, 0x28, 0x60, 0xC2, 0x83, 0x04, 0x0C, 0x30, 0x00, 0x18,
  0x61, 0x08, 0x22, 0x04, 0xC0, 0x90, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x02,
  0xC0, 0x48, 0x11, 0x06, 0x20, 0x84, 0x20, 0xC0, 0x83, 0x82, 0x84, 0x8C,
  0x48, 0x58, 0x50, 0x60, 0x60, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x0F,
  0xC4, 0x30, 0x08, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x08, 0x06, 0x01,
  0x00, 0x80, 0x20, 0x10, 0x0F, 0xE0, 0x1E, 0x20, 0x40, 0x81, 0x04, 0x08,
  0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0xE0, 0x91, 0x24,
  0x92, 0x44, 0x92, 0x48, 0x1E, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x0C,
  0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x11, 0xE0, 0x08, 0x1C, 0x14, 0x24,
  0x22, 0x42, 0xC2, 0x81, 0xFE, 0x89, 0x80, 0x3D, 0x63, 0x43, 0xC2, 0x82,
  0x82, 0x82, 0x86, 0x84, 0x8C, 0xF4, 0x18, 0x08, 0x04, 0x02, 0x01, 0x01,
  0xF8, 0xC6, 0x61, 0x20, 0x90, 0xD0, 0x48, 0x24, 0x12, 0x11, 0x99, 0x78,
  0x3E, 0xC1, 0x06, 0x08, 0x10, 0x20, 0x40, 0x81, 0x01, 0xE0, 0x00, 0x80,
  0x40, 0x20, 0x20, 0x11, 0xE9, 0x8C, 0x86, 0xC2, 0x41, 0x20, 0x90, 0x48,
  0x64, 0x22, 0x31, 0xE8, 0x3E, 0xC5, 0x0E, 0x28, 0xDE, 0x20, 0x40, 0x81,
  0x01, 0xE0, 0x01, 0xC0, 0x40, 0x20, 0x08, 0x02, 0x03, 0xE0, 0x60, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x01, 0x00, 0xC0, 0xE0, 0x00, 0x1E, 0x98, 0xC8, 0x6C, 0x24, 0x12, 0x09,
  0x04, 0x86, 0x42, 0x23, 0x1E, 0x80, 0x40, 0x60, 0x22, 0x31, 0xF0, 0x08,
  0x10, 0x10, 0x10, 0x10, 0x3F, 0x31, 0x21, 0x21, 0x21, 0x61, 0x43, 0x42,
  0x42, 0x42, 0x86, 0x18, 0x80, 0x03, 0x10, 0x84, 0x23, 0x10, 0x84, 0x22,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x02, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x08,
  0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0xE0, 0x08, 0x08, 0x04,
  0x02, 0x01, 0x09, 0x88, 0x88, 0x48, 0x2C, 0x1C, 0x16, 0x0D, 0x04, 0xC2,
  0x21, 0x11, 0x08, 0x08, 0x84, 0x21, 0x18, 0x84, 0x21, 0x18, 0x84, 0x21,
  0x10, 0x3F, 0x79, 0x8C, 0x48, 0x42, 0x42, 0x12, 0x10, 0xB1, 0x89, 0x08,
  0x48, 0x42, 0x42, 0x12, 0x10, 0xA1, 0x08, 0x3F, 0x31, 0x31, 0x21, 0x21,
  0x61, 0x43, 0x42, 0x42, 0x42, 0x86, 0x3E, 0xC5, 0x0E, 0x18, 0x30, 0x60,
  0xC1, 0x85, 0x19, 0xE0, 0x1F, 0x86, 0x31, 0x84, 0x41, 0x10, 0x4C, 0x22,
  0x08, 0x82, 0x21, 0x0C, 0xC5, 0xE1, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00,
  0x3D, 0x63, 0x43, 0xC2, 0x82, 0x82, 0x82, 0x86, 0x84, 0x8C, 0xF4, 0x04,
  0x0C, 0x08, 0x08, 0x08, 0x2E, 0x60, 0xC1, 0x02, 0x0C, 0x10, 0x20, 0x40,
  0x82, 0x00, 0x3E, 0xC1, 0x03, 0x02, 0x03, 0x02, 0x06, 0x0D, 0x13, 0xE0,
  0x21, 0x09, 0xF4, 0x21, 0x08, 0x84, 0x21, 0x08, 0x70, 0x61, 0x43, 0x42,
  0x42, 0x42, 0x82, 0x84, 0x84, 0x84, 0x8C, 0xF4, 0x83, 0x0A, 0x14, 0x68,
  0x93, 0x34, 0x38, 0x60, 0xC1, 0x00, 0x86, 0x38, 0x62, 0x8A, 0x48, 0xA4,
  0x92, 0x49, 0x28, 0xB2, 0x8A, 0x30, 0xA3, 0x0C, 0x30, 0xC2, 0x00, 0x10,
  0x88, 0x84, 0x81, 0x40, 0xC0, 0x40, 0x50, 0x28, 0x24, 0x23, 0x30, 0x80,
  0x18, 0x46, 0x10, 0x88, 0x22, 0x09, 0x02, 0x40, 0xA0, 0x28, 0x0C, 0x03,
  0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x03, 0x80, 0x1F, 0x02, 0x06, 0x04,
  0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0xFC, 0x06, 0x10, 0x40, 0x81, 0x02,
  0x08, 0x10, 0x61, 0x81, 0x02, 0x04, 0x08, 0x10, 0x60, 0xC0, 0xC0, 0xFF,
  0xFF, 0xF8, 0x1C, 0x08, 0x10, 0x20, 0x40, 0x83, 0x04, 0x04, 0x0C, 0x20,
  0xC1, 0x02, 0x04, 0x08, 0x21, 0xC0, 0x20, 0xF9, 0x86,
};

const GFXglyph NotoSans_Condensed_LightItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 15, 5, 0, -15 },
  { 11, 5, 5, 7, 2, -15 },
  { 15, 10, 15, 10, 0, -15 },
  { 34, 9, 17, 9, 0, -16 },
  { 54, 11, 15, 13, 1, -15 },
  { 75, 9, 15, 10, 0, -15 },
  { 92, 2, 5, 4, 2, -15 },
  { 94, 6, 18, 5, 1, -15 },
  { 108, 6, 18, 5, -1, -15 },
  { 122, 7, 7, 8, 2, -16 },
  { 129, 8, 9, 10, 1, -12 },
  { 138, 3, 5, 4, -1, -2 },
  { 140, 5, 1, 6, 0, -6 },
  { 141, 2, 2, 4, 0, -2 },
  { 142, 9, 15, 7, -1, -15 },
  { 159, 8, 15, 9, 1, -15 },
  { 174, 4, 15, 9, 3, -15 },
  { 182, 9, 15, 9, 0, -15 },
  { 199, 9, 15, 9, 0, -15 },
  { 216, 9, 15, 9, 0, -15 },
  { 233, 9, 15, 9, 0, -15 },
  { 250, 8, 15, 9, 1, -15 },
  { 265, 9, 15, 9, 1, -15 },
  { 282, 9, 15, 9, 0, -15 },
  { 299, 9, 15, 9, 0, -15 },
  { 316, 4, 11, 4, 0, -11 },
  { 322, 5, 14, 4, -1, -11 },
  { 331, 8, 9, 10, 1, -12 },
  { 340, 8, 5, 10, 1, -10 },
  { 345, 8, 9, 10, 1, -12 },
  { 354, 6, 15, 7, 1, -15 },
  { 366, 12, 17, 13, 1, -15 },
  { 392, 9, 15, 9, -1, -15 },
  { 409, 10, 15, 10, 0, -15 },
  { 428, 9, 15, 9, 1, -15 },
  { 445, 10, 15, 11, 0, -15 },
  { 464, 9, 15, 8, 0, -15 },
  { 481, 9, 15, 8, 0, -15 },
  { 498, 10, 15, 11, 1, -15 },
  { 517, 11, 15, 11, 0, -15 },
  { 538, 7, 15, 5, -1, -15 },
  { 552, 8, 19, 4, -3, -15 },
  { 571, 11, 15, 9, 0, -15 },
  { 592, 6, 15, 8, 0, -15 },
  { 604, 15, 15, 14, 0, -15 },
  { 633, 12, 15, 12, 0, -15 },
  { 656, 10, 15, 11, 1, -15 },
  { 675, 9, 15, 9, 0, -15 },
  { 692, 10, 19, 11, 1, -15 },
  { 716, 9, 15, 9, 0, -15 },
  { 733, 9, 15, 8, 0, -15 },
  { 750, 7, 15, 8, 2, -15 },
  { 764, 10, 15, 11, 1, -15 },
  { 783, 9, 15, 9, 2, -15 },
  { 800, 14, 15, 14, 2, -15 },
  { 827, 11, 15, 8, -1, -15 },
  { 848, 8, 15, 8, 2, -15 },
  { 863, 10, 15, 8, -1, -15 },
  { 882, 7, 18, 6, 0, -15 },
  { 898, 3, 15, 7, 2, -15 },
  { 904, 7, 18, 6, -1, -15 },
  { 920, 8, 8, 9, 1, -15 },
  { 928, 7, 1, 7, -2, 2 },
  { 929, 3, 3, 5, 3, -16 },
  { 931, 8, 11, 9, 1, -11 },
  { 942, 9, 16, 9, 0, -16 },
  { 960, 7, 11, 7, 1, -11 },
  { 970, 9, 16, 9, 1, -16 },
  { 988, 7, 11, 8, 1, -11 },
  { 998, 10, 21, 5, -3, -16 },
  { 1025, 9, 16, 9, 0, -11 },
  { 1043, 8, 16, 9, 0, -16 },
  { 1059, 5, 15, 4, 0, -15 },
  { 1069, 8, 20, 4, -3, -15 },
  { 1089, 9, 16, 8, 0, -16 },
  { 1107, 5, 16, 4, 0, -16 },
  { 1117, 13, 11, 14, 0, -11 },
  { 1135, 8, 11, 9, 0, -11 },
  { 1146, 7, 11, 9, 1, -11 },
  { 1156, 10, 16, 9, -1, -11 },
  { 1176, 8, 16, 10, 1, -11 },
  { 1192, 7, 11, 6, 0, -11 },
  { 1202, 7, 11, 7, 0, -11 },
  { 1212, 5, 14, 5, 1, -14 },
  { 1221, 8, 11, 9, 1, -11 },
  { 1232, 7, 11, 7, 1, -11 },
  { 1242, 12, 11, 12, 1, -11 },
  { 1259, 9, 11, 8, -1, -11 },
  { 1272, 10, 16, 7, -2, -11 },
  { 1292, 8, 11, 7, -1, -11 },
  { 1303, 7, 18, 7, 1, -15 },
  { 1319, 1, 21, 9, 4, -16 },
  { 1322, 7, 18, 7, -1, -15 },
  { 1338, 8, 3, 10, 1, -9 },
};

const GFXfont NotoSans_Condensed_LightItalic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic21pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC21PT7B_H_
