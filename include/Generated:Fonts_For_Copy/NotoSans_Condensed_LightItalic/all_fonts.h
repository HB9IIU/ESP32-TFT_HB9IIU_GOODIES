#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_Condensed_LightItalic
// Headers: 67

#include "NotoSans_Condensed_LightItalic6pt7b.h"
#include "NotoSans_Condensed_LightItalic7pt7b.h"
#include "NotoSans_Condensed_LightItalic8pt7b.h"
#include "NotoSans_Condensed_LightItalic9pt7b.h"
#include "NotoSans_Condensed_LightItalic10pt7b.h"
#include "NotoSans_Condensed_LightItalic11pt7b.h"
#include "NotoSans_Condensed_LightItalic12pt7b.h"
#include "NotoSans_Condensed_LightItalic13pt7b.h"
#include "NotoSans_Condensed_LightItalic14pt7b.h"
#include "NotoSans_Condensed_LightItalic15pt7b.h"
#include "NotoSans_Condensed_LightItalic16pt7b.h"
#include "NotoSans_Condensed_LightItalic17pt7b.h"
#include "NotoSans_Condensed_LightItalic18pt7b.h"
#include "NotoSans_Condensed_LightItalic19pt7b.h"
#include "NotoSans_Condensed_LightItalic20pt7b.h"
#include "NotoSans_Condensed_LightItalic21pt7b.h"
#include "NotoSans_Condensed_LightItalic22pt7b.h"
#include "NotoSans_Condensed_LightItalic23pt7b.h"
#include "NotoSans_Condensed_LightItalic24pt7b.h"
#include "NotoSans_Condensed_LightItalic25pt7b.h"
#include "NotoSans_Condensed_LightItalic26pt7b.h"
#include "NotoSans_Condensed_LightItalic27pt7b.h"
#include "NotoSans_Condensed_LightItalic28pt7b.h"
#include "NotoSans_Condensed_LightItalic29pt7b.h"
#include "NotoSans_Condensed_LightItalic30pt7b.h"
#include "NotoSans_Condensed_LightItalic31pt7b.h"
#include "NotoSans_Condensed_LightItalic32pt7b.h"
#include "NotoSans_Condensed_LightItalic33pt7b.h"
#include "NotoSans_Condensed_LightItalic34pt7b.h"
#include "NotoSans_Condensed_LightItalic35pt7b.h"
#include "NotoSans_Condensed_LightItalic36pt7b.h"
#include "NotoSans_Condensed_LightItalic37pt7b.h"
#include "NotoSans_Condensed_LightItalic38pt7b.h"
#include "NotoSans_Condensed_LightItalic39pt7b.h"
#include "NotoSans_Condensed_LightItalic40pt7b.h"
#include "NotoSans_Condensed_LightItalic41pt7b.h"
#include "NotoSans_Condensed_LightItalic42pt7b.h"
#include "NotoSans_Condensed_LightItalic43pt7b.h"
#include "NotoSans_Condensed_LightItalic44pt7b.h"
#include "NotoSans_Condensed_LightItalic45pt7b.h"
#include "NotoSans_Condensed_LightItalic46pt7b.h"
#include "NotoSans_Condensed_LightItalic47pt7b.h"
#include "NotoSans_Condensed_LightItalic48pt7b.h"
#include "NotoSans_Condensed_LightItalic49pt7b.h"
#include "NotoSans_Condensed_LightItalic50pt7b.h"
#include "NotoSans_Condensed_LightItalic51pt7b.h"
#include "NotoSans_Condensed_LightItalic52pt7b.h"
#include "NotoSans_Condensed_LightItalic53pt7b.h"
#include "NotoSans_Condensed_LightItalic54pt7b.h"
#include "NotoSans_Condensed_LightItalic55pt7b.h"
#include "NotoSans_Condensed_LightItalic56pt7b.h"
#include "NotoSans_Condensed_LightItalic57pt7b.h"
#include "NotoSans_Condensed_LightItalic58pt7b.h"
#include "NotoSans_Condensed_LightItalic59pt7b.h"
#include "NotoSans_Condensed_LightItalic60pt7b.h"
#include "NotoSans_Condensed_LightItalic61pt7b.h"
#include "NotoSans_Condensed_LightItalic62pt7b.h"
#include "NotoSans_Condensed_LightItalic63pt7b.h"
#include "NotoSans_Condensed_LightItalic64pt7b.h"
#include "NotoSans_Condensed_LightItalic65pt7b.h"
#include "NotoSans_Condensed_LightItalic66pt7b.h"
#include "NotoSans_Condensed_LightItalic67pt7b.h"
#include "NotoSans_Condensed_LightItalic68pt7b.h"
#include "NotoSans_Condensed_LightItalic69pt7b.h"
#include "NotoSans_Condensed_LightItalic70pt7b.h"
#include "NotoSans_Condensed_LightItalic71pt7b.h"
#include "NotoSans_Condensed_LightItalic72pt7b.h"
