#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC27PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0xC2, 0x08, 0x61, 0x84, 0x10, 0x43, 0x0C, 0x20, 0x80,
  0x00, 0x01, 0x8C, 0x00, 0x65, 0x3C, 0xF2, 0x8A, 0x29, 0x80, 0x03, 0x10,
  0x10, 0x80, 0x88, 0x04, 0x40, 0x62, 0x1F, 0xFC, 0xFF, 0xE1, 0x88, 0x08,
  0xC0, 0x44, 0x06, 0x20, 0x21, 0x0F, 0xFE, 0x08, 0x80, 0x84, 0x04, 0x60,
  0x22, 0x03, 0x10, 0x11, 0x80, 0x00, 0x80, 0x08, 0x01, 0x00, 0x7F, 0x19,
  0x21, 0x10, 0x11, 0x01, 0x20, 0x12, 0x01, 0xA0, 0x0E, 0x00, 0x70, 0x05,
  0x80, 0x48, 0x04, 0x80, 0x4C, 0x08, 0x80, 0x98, 0xFF, 0x03, 0xC0, 0x08,
  0x01, 0x00, 0x10, 0x00, 0x08, 0x00, 0xF0, 0x66, 0x41, 0x11, 0x08, 0xC4,
  0x62, 0x11, 0x08, 0x4C, 0x23, 0x20, 0x8D, 0x3A, 0x25, 0xB9, 0xA4, 0x7D,
  0xA1, 0x44, 0x84, 0x32, 0x30, 0x98, 0xC4, 0x42, 0x11, 0x08, 0x84, 0x66,
  0x19, 0x10, 0x38, 0x01, 0x00, 0x7C, 0x0C, 0x40, 0x84, 0x08, 0x40, 0x84,
  0x08, 0x80, 0x98, 0x0F, 0x00, 0x60, 0x1E, 0x03, 0x23, 0x63, 0x34, 0x32,
  0xC1, 0x6C, 0x1C, 0xC0, 0x8C, 0x1C, 0x63, 0x47, 0xC6, 0x6B, 0x69, 0x20,
  0x03, 0x04, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0x40, 0xC0, 0xC0,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x06,
  0x02, 0x02, 0x03, 0x03, 0x03, 0x01, 0x01, 0x03, 0x03, 0x03, 0x03, 0x02,
  0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0xC0, 0x08, 0x06,
  0x02, 0x19, 0x03, 0xF8, 0xC0, 0xE0, 0xC8, 0xC6, 0x02, 0x00, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x3F, 0xF8, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x33, 0x26, 0x4C, 0xFC, 0x78, 0x00, 0x30, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00,
  0x80, 0x00, 0x03, 0x03, 0xE1, 0x8C, 0x41, 0x30, 0x48, 0x16, 0x05, 0x81,
  0x40, 0xD0, 0x3C, 0x0F, 0x02, 0xC0, 0xA0, 0x68, 0x1A, 0x04, 0x83, 0x30,
  0x8C, 0x41, 0xE0, 0x0C, 0x73, 0xF3, 0x08, 0x20, 0x86, 0x18, 0x41, 0x0C,
  0x30, 0xC2, 0x08, 0x61, 0x84, 0x00, 0x00, 0x80, 0x7E, 0x0C, 0x30, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x4F, 0xF8,
  0x01, 0x01, 0xF8, 0x61, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00,
  0xC1, 0xE0, 0x7C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80,
  0x32, 0x0C, 0x7F, 0x00, 0x00, 0x60, 0x1C, 0x07, 0x80, 0xA0, 0x24, 0x0C,
  0x81, 0x30, 0x46, 0x18, 0x82, 0x10, 0x86, 0x30, 0xC4, 0x19, 0xFF, 0xC0,
  0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x00, 0x0F, 0xE1, 0x00, 0x20, 0x0C,
  0x01, 0x80, 0x20, 0x04, 0x01, 0xF0, 0x3F, 0x80, 0x30, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x90, 0x63, 0xF8, 0x00, 0x00, 0xC0,
  0xFC, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x4F, 0x0B, 0x73,
  0x86, 0x60, 0x4C, 0x09, 0x81, 0x20, 0x24, 0x0C, 0xC1, 0x18, 0x61, 0x18,
  0x3E, 0x00, 0x3F, 0xE0, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40,
  0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80,
  0x20, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x00, 0x7C, 0x08, 0x61, 0x82, 0x10,
  0x31, 0x02, 0x18, 0x61, 0x84, 0x0D, 0x80, 0x70, 0x0F, 0x03, 0x18, 0x60,
  0x84, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x08, 0x61, 0x83, 0xE0, 0x01,
  0x00, 0xF8, 0x21, 0x8C, 0x33, 0x02, 0x60, 0x48, 0x09, 0x03, 0x20, 0x64,
  0x0C, 0xC3, 0x0F, 0xA0, 0xC4, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60,
  0x18, 0x7C, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x60,
  0x0C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x21, 0x86, 0x10,
  0x80, 0x00, 0x20, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0xE0, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x0C, 0x06, 0x03, 0x81, 0xC0, 0x60, 0x00, 0x08, 0x7F, 0x23,
  0x01, 0x01, 0x01, 0x03, 0x06, 0x04, 0x08, 0x10, 0x30, 0x20, 0x60, 0x40,
  0x00, 0x00, 0x00, 0xC0, 0xC0, 0x01, 0xF8, 0x06, 0x04, 0x0C, 0x02, 0x18,
  0x02, 0x10, 0x03, 0x20, 0xF3, 0x63, 0x33, 0x42, 0x23, 0x44, 0x23, 0xC4,
  0x22, 0xCC, 0x62, 0x88, 0x42, 0x88, 0x44, 0x88, 0xC4, 0x8D, 0x48, 0x87,
  0x30, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x40, 0x1F, 0xC0, 0x00,
  0x60, 0x0E, 0x00, 0xA0, 0x1A, 0x01, 0x20, 0x32, 0x02, 0x20, 0x22, 0x06,
  0x20, 0x42, 0x0C, 0x20, 0xFE, 0x18, 0x21, 0x02, 0x30, 0x33, 0x03, 0x60,
  0x36, 0x03, 0xC0, 0x30, 0x0F, 0xE0, 0xC3, 0x08, 0x10, 0x81, 0x18, 0x11,
  0x81, 0x18, 0x31, 0x06, 0x1F, 0xC3, 0xFC, 0x30, 0x42, 0x06, 0x20, 0x62,
  0x06, 0x60, 0x66, 0x04, 0x40, 0xC4, 0x38, 0xFE, 0x00, 0x00, 0x40, 0x3F,
  0x0E, 0x10, 0x80, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x70, 0x81, 0xF0, 0x0F, 0xE0, 0x63, 0x82, 0x04, 0x10, 0x31, 0x81, 0x8C,
  0x04, 0x60, 0x22, 0x03, 0x10, 0x19, 0x80, 0xCC, 0x06, 0x40, 0x22, 0x03,
  0x10, 0x11, 0x81, 0x8C, 0x18, 0x41, 0xC2, 0x38, 0x3F, 0x80, 0x0F, 0xF0,
  0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x1F, 0xC3,
  0xFC, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x00, 0x10, 0x03, 0xFC, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x0F, 0xF0,
  0xE0, 0x86, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x0F, 0x30, 0x7C, 0xC0, 0x33, 0x00, 0xCC, 0x02, 0x30, 0x08,
  0x40, 0x61, 0x81, 0x83, 0x04, 0x07, 0xF0, 0x0C, 0x06, 0x18, 0x08, 0x20,
  0x30, 0x40, 0x61, 0x80, 0xC3, 0x01, 0x06, 0x02, 0x08, 0x0C, 0x1F, 0xF8,
  0x7F, 0xF0, 0xC0, 0x41, 0x00, 0x82, 0x03, 0x04, 0x06, 0x18, 0x08, 0x30,
  0x10, 0x40, 0x20, 0x80, 0xC3, 0x01, 0x80, 0x0F, 0x83, 0x01, 0x80, 0xC0,
  0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40,
  0x20, 0x30, 0x18, 0x3E, 0x00, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80,
  0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60,
  0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x0B, 0x83, 0x80, 0x0C,
  0x1C, 0x30, 0x40, 0x82, 0x02, 0x18, 0x18, 0xC0, 0x66, 0x01, 0xB0, 0x04,
  0x80, 0x16, 0x00, 0xE8, 0x03, 0x20, 0x08, 0xC0, 0x23, 0x00, 0x84, 0x06,
  0x18, 0x18, 0x60, 0x40, 0x81, 0x02, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x08,
  0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60,
  0x60, 0x40, 0x40, 0xFF, 0x0E, 0x00, 0xE1, 0xC0, 0x18, 0x38, 0x05, 0x05,
  0x00, 0xE1, 0xA0, 0x2C, 0x34, 0x05, 0x04, 0x81, 0x20, 0x90, 0x24, 0x12,
  0x09, 0x86, 0x41, 0x30, 0xC8, 0x44, 0x11, 0x08, 0x82, 0x32, 0x30, 0x46,
  0x46, 0x18, 0xD0, 0xC3, 0x1A, 0x10, 0x41, 0x82, 0x08, 0x30, 0xC3, 0x04,
  0x18, 0x00, 0x0C, 0x02, 0x1C, 0x0C, 0x38, 0x18, 0x50, 0x21, 0xA0, 0x43,
  0x61, 0x84, 0xC3, 0x08, 0x84, 0x11, 0x08, 0x63, 0x10, 0xC6, 0x61, 0x04,
  0xC2, 0x09, 0x04, 0x12, 0x18, 0x34, 0x30, 0x38, 0x40, 0x70, 0x80, 0xC3,
  0x01, 0x80, 0x00, 0x80, 0x3F, 0x03, 0x0C, 0x30, 0x31, 0x01, 0x98, 0x04,
  0x80, 0x2C, 0x01, 0x60, 0x1A, 0x00, 0xD0, 0x07, 0x80, 0x2C, 0x01, 0x60,
  0x1B, 0x00, 0xD8, 0x0C, 0x40, 0x63, 0x06, 0x1C, 0x60, 0x7E, 0x00, 0x0F,
  0xC0, 0xC6, 0x08, 0x30, 0x83, 0x18, 0x31, 0x83, 0x18, 0x31, 0x02, 0x10,
  0x63, 0x1C, 0x3F, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x3F, 0x03, 0x0C, 0x30, 0x31, 0x01,
  0x98, 0x04, 0x80, 0x2C, 0x01, 0x60, 0x1A, 0x00, 0xD0, 0x07, 0x80, 0x2C,
  0x01, 0x60, 0x1B, 0x00, 0xD8, 0x0C, 0x40, 0x63, 0x06, 0x1C, 0x60, 0x7E,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0F, 0xC0, 0xC6,
  0x08, 0x30, 0x83, 0x18, 0x31, 0x83, 0x18, 0x31, 0x02, 0x10, 0x63, 0xFC,
  0x3F, 0x02, 0x30, 0x21, 0x02, 0x10, 0x61, 0x86, 0x18, 0x40, 0x84, 0x08,
  0xC0, 0xC0, 0x01, 0x80, 0xFF, 0x18, 0x21, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0x80, 0x08, 0x01, 0x80, 0x18, 0x87, 0x0F, 0xE0, 0xFF, 0xC3, 0x00, 0xC0,
  0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20,
  0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x00, 0x18, 0x08, 0x80, 0x44,
  0x06, 0x60, 0x33, 0x01, 0x18, 0x08, 0x80, 0x44, 0x06, 0x60, 0x33, 0x01,
  0x18, 0x08, 0x80, 0xC4, 0x06, 0x60, 0x23, 0x01, 0x18, 0x18, 0xC0, 0x83,
  0x1C, 0x0F, 0xC0, 0xC0, 0x3C, 0x06, 0x40, 0x44, 0x0C, 0x40, 0x84, 0x18,
  0x41, 0x84, 0x10, 0x43, 0x04, 0x20, 0x46, 0x04, 0x40, 0x4C, 0x04, 0x80,
  0x58, 0x05, 0x00, 0x50, 0x07, 0x00, 0x60, 0x00, 0x80, 0x80, 0xE0, 0x60,
  0x68, 0x18, 0x1A, 0x0E, 0x04, 0x82, 0x83, 0x20, 0xA0, 0x88, 0x48, 0x62,
  0x12, 0x10, 0x8C, 0x8C, 0x22, 0x23, 0x09, 0x88, 0x82, 0x42, 0x60, 0x90,
  0x90, 0x2C, 0x2C, 0x0A, 0x0B, 0x03, 0x82, 0x80, 0xC0, 0xE0, 0x30, 0x30,
  0x08, 0x0C, 0x00, 0x06, 0x0C, 0x18, 0x20, 0x21, 0x80, 0x84, 0x02, 0x20,
  0x0D, 0x80, 0x34, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x28, 0x01, 0xA0,
  0x04, 0x80, 0x32, 0x01, 0x8C, 0x04, 0x30, 0x30, 0x41, 0x81, 0x0C, 0x06,
  0x00, 0xC0, 0xD0, 0x24, 0x19, 0x04, 0x63, 0x18, 0x86, 0x60, 0xB0, 0x28,
  0x0E, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04,
  0x00, 0x0F, 0xF8, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06,
  0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x3F, 0xE0, 0x0F, 0x86, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01,
  0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x03, 0xE0, 0x88, 0x8C,
  0xC4, 0x44, 0x46, 0x66, 0x22, 0x22, 0x33, 0x30, 0x07, 0xC0, 0x30, 0x0C,
  0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02,
  0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x0F,
  0x80, 0x06, 0x00, 0xC0, 0x2C, 0x0C, 0x81, 0x10, 0x63, 0x08, 0x23, 0x06,
  0x40, 0x58, 0x0C, 0xFF, 0xFF, 0xD9, 0x12, 0x06, 0x03, 0xEC, 0xC3, 0x10,
  0x66, 0x0C, 0x81, 0x90, 0x36, 0x04, 0xC0, 0x90, 0x32, 0x06, 0x40, 0x8C,
  0x31, 0x8A, 0x1E, 0x40, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10,
  0x06, 0x20, 0xFE, 0x14, 0x63, 0x04, 0xC0, 0x98, 0x13, 0x02, 0x40, 0xC8,
  0x1B, 0x02, 0x60, 0x4C, 0x19, 0x86, 0x39, 0x8D, 0xE0, 0x07, 0x0F, 0xCC,
  0x04, 0x06, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x0C, 0x02,
  0x11, 0xF0, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x06,
  0x61, 0xF6, 0x30, 0xC2, 0x0C, 0x60, 0xC4, 0x0C, 0x40, 0xCC, 0x08, 0xC0,
  0x88, 0x18, 0x81, 0x88, 0x38, 0xC3, 0x0C, 0x50, 0x79, 0x00, 0x02, 0x0F,
  0xCC, 0x24, 0x16, 0x1A, 0x0F, 0x0D, 0xF8, 0xC0, 0x40, 0x20, 0x10, 0x0C,
  0x02, 0x11, 0xF8, 0x00, 0x38, 0x07, 0x80, 0x20, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x01, 0xF8, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x38, 0x00, 0x03,
  0x00, 0xFB, 0x18, 0x61, 0x06, 0x30, 0x62, 0x06, 0x20, 0x66, 0x04, 0x60,
  0x44, 0x0C, 0x40, 0xC4, 0x1C, 0x61, 0x86, 0x28, 0x3D, 0x80, 0x18, 0x01,
  0x00, 0x10, 0x03, 0x08, 0x60, 0xFC, 0x00, 0x04, 0x01, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x10, 0x06, 0x20, 0xFE, 0x14, 0x63, 0x0C, 0x41, 0x98, 0x33,
  0x04, 0x40, 0x88, 0x33, 0x06, 0x60, 0x8C, 0x11, 0x02, 0x20, 0xCC, 0x18,
  0x04, 0x30, 0x80, 0x00, 0x01, 0x84, 0x10, 0x43, 0x0C, 0x20, 0x86, 0x18,
  0x61, 0x04, 0x30, 0x00, 0x40, 0x30, 0x08, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06,
  0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x3C, 0x00,
  0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x08, 0xC2, 0x10,
  0x82, 0x30, 0x4C, 0x1B, 0x03, 0xC0, 0x58, 0x0D, 0x83, 0x30, 0x62, 0x08,
  0x41, 0x0C, 0x21, 0x8C, 0x10, 0x04, 0x30, 0xC2, 0x08, 0x21, 0x86, 0x10,
  0x41, 0x0C, 0x30, 0x82, 0x18, 0x61, 0x04, 0x10, 0xC0, 0x09, 0x82, 0x0B,
  0xE7, 0x86, 0x14, 0x63, 0x0C, 0x31, 0x06, 0x19, 0x82, 0x0C, 0xC1, 0x04,
  0x41, 0x82, 0x20, 0xC3, 0x30, 0x41, 0x98, 0x20, 0xC8, 0x30, 0x44, 0x18,
  0x22, 0x08, 0x33, 0x04, 0x18, 0x09, 0x82, 0xF8, 0x71, 0x8C, 0x33, 0x06,
  0x60, 0xCC, 0x11, 0x02, 0x20, 0xCC, 0x19, 0x82, 0x30, 0x44, 0x08, 0x83,
  0x30, 0x60, 0x06, 0x07, 0xE3, 0x08, 0x83, 0x60, 0xD0, 0x3C, 0x0F, 0x03,
  0xC0, 0xA0, 0x28, 0x1A, 0x04, 0xC3, 0x31, 0x87, 0xC0, 0x04, 0x40, 0x9E,
  0x0A, 0x30, 0xC1, 0x08, 0x11, 0x81, 0x18, 0x11, 0x03, 0x10, 0x33, 0x03,
  0x30, 0x23, 0x06, 0x30, 0xC3, 0x9C, 0x6F, 0x06, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x03, 0xEC, 0xC3, 0x10, 0x66, 0x0C,
  0x81, 0x90, 0x36, 0x04, 0xC0, 0x90, 0x32, 0x06, 0x41, 0xCC, 0x31, 0x8A,
  0x1E, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x01, 0x8B,
  0xC5, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04,
  0x02, 0x03, 0x00, 0x06, 0x0F, 0xCC, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x80, 0x40, 0x24, 0x33, 0xF0, 0x10, 0x41, 0x0C, 0xFC,
  0x82, 0x18, 0x61, 0x04, 0x10, 0xC3, 0x08, 0x20, 0x83, 0xC0, 0x30, 0x48,
  0x12, 0x0D, 0x83, 0x60, 0x90, 0x24, 0x09, 0x06, 0xC1, 0xB0, 0x48, 0x32,
  0x0C, 0xC7, 0x1E, 0xC0, 0xC0, 0xD0, 0x64, 0x11, 0x0C, 0x42, 0x11, 0x84,
  0x41, 0x30, 0x48, 0x16, 0x05, 0x01, 0x40, 0x70, 0x18, 0x00, 0x83, 0x0E,
  0x1C, 0x28, 0x50, 0xA1, 0x46, 0x89, 0x12, 0x24, 0xC9, 0x92, 0x24, 0x58,
  0xB1, 0x42, 0x85, 0x0A, 0x1C, 0x30, 0x60, 0xC1, 0x83, 0x04, 0x00, 0x18,
  0x70, 0x84, 0x08, 0xC0, 0xD8, 0x0D, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0A,
  0x01, 0xA0, 0x33, 0x02, 0x10, 0x61, 0x0C, 0x18, 0x04, 0x0C, 0x10, 0x20,
  0x41, 0x81, 0x04, 0x04, 0x30, 0x10, 0x80, 0x66, 0x01, 0x90, 0x06, 0xC0,
  0x1A, 0x00, 0x78, 0x01, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x20, 0x01, 0x80, 0x3C, 0x00, 0x40, 0x00, 0x1F, 0xC0, 0x20,
  0x18, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x20, 0x18, 0x04, 0x03, 0x01, 0x80,
  0x40, 0x3F, 0x80, 0x03, 0x83, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30,
  0x18, 0x08, 0x0C, 0x18, 0x06, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x18,
  0x08, 0x04, 0x03, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x10, 0x03,
  0x03, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06,
  0x0F, 0x00, 0x78, 0x39, 0xDE, 0x0F, 0x00,
};

const GFXglyph NotoSans_Condensed_LightItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 19, 6, 0, -19 },
  { 16, 6, 7, 8, 3, -19 },
  { 22, 13, 19, 13, 0, -19 },
  { 53, 12, 23, 11, 0, -21 },
  { 88, 14, 20, 17, 2, -20 },
  { 123, 12, 20, 13, 0, -20 },
  { 153, 3, 7, 5, 3, -19 },
  { 156, 8, 23, 7, 1, -19 },
  { 179, 8, 23, 7, -2, -19 },
  { 202, 9, 10, 11, 3, -21 },
  { 214, 11, 13, 12, 1, -16 },
  { 232, 4, 6, 5, -1, -3 },
  { 235, 6, 1, 7, 1, -8 },
  { 236, 3, 2, 5, 0, -2 },
  { 237, 12, 19, 9, -1, -19 },
  { 266, 10, 20, 11, 1, -20 },
  { 291, 6, 19, 11, 3, -19 },
  { 306, 12, 20, 11, -1, -20 },
  { 336, 11, 20, 11, 0, -20 },
  { 364, 11, 19, 11, 0, -19 },
  { 391, 11, 19, 11, 0, -19 },
  { 418, 11, 20, 11, 1, -20 },
  { 446, 11, 19, 11, 1, -19 },
  { 473, 12, 20, 11, 0, -20 },
  { 503, 11, 20, 11, 0, -20 },
  { 531, 5, 14, 5, 0, -14 },
  { 540, 6, 17, 5, -1, -14 },
  { 553, 11, 12, 12, 1, -16 },
  { 570, 11, 7, 12, 1, -13 },
  { 580, 11, 12, 12, 1, -16 },
  { 597, 8, 20, 8, 1, -20 },
  { 617, 16, 21, 17, 1, -19 },
  { 659, 12, 19, 11, -2, -19 },
  { 688, 12, 19, 12, 0, -19 },
  { 717, 12, 20, 12, 1, -20 },
  { 747, 13, 19, 14, 0, -19 },
  { 778, 12, 19, 11, 0, -19 },
  { 807, 12, 19, 10, 0, -19 },
  { 836, 14, 20, 14, 1, -20 },
  { 871, 15, 19, 14, 0, -19 },
  { 907, 9, 19, 6, -1, -19 },
  { 929, 10, 24, 5, -4, -19 },
  { 959, 14, 19, 12, 0, -19 },
  { 993, 8, 19, 10, 0, -19 },
  { 1012, 19, 19, 18, 0, -19 },
  { 1058, 15, 19, 15, 0, -19 },
  { 1094, 13, 20, 15, 1, -20 },
  { 1127, 12, 19, 12, 0, -19 },
  { 1156, 13, 25, 15, 1, -20 },
  { 1197, 12, 19, 12, 0, -19 },
  { 1226, 12, 20, 11, 0, -20 },
  { 1256, 10, 19, 10, 2, -19 },
  { 1280, 13, 19, 14, 1, -19 },
  { 1311, 12, 19, 11, 2, -19 },
  { 1340, 18, 19, 19, 3, -19 },
  { 1383, 14, 19, 10, -2, -19 },
  { 1417, 10, 19, 10, 2, -19 },
  { 1441, 13, 19, 10, -1, -19 },
  { 1472, 9, 23, 8, 0, -19 },
  { 1498, 4, 19, 9, 3, -19 },
  { 1508, 10, 23, 8, -2, -19 },
  { 1537, 11, 10, 12, 1, -19 },
  { 1551, 8, 2, 8, -2, 2 },
  { 1553, 3, 5, 6, 4, -21 },
  { 1555, 11, 15, 12, 1, -15 },
  { 1576, 11, 21, 12, 0, -21 },
  { 1605, 9, 15, 9, 1, -15 },
  { 1622, 12, 21, 12, 1, -21 },
  { 1654, 9, 15, 11, 1, -15 },
  { 1671, 13, 27, 6, -3, -21 },
  { 1715, 12, 21, 12, 0, -15 },
  { 1747, 11, 21, 12, 0, -21 },
  { 1776, 6, 20, 5, 0, -20 },
  { 1791, 10, 26, 5, -4, -20 },
  { 1824, 11, 21, 10, 0, -21 },
  { 1853, 6, 21, 5, 0, -21 },
  { 1869, 17, 15, 18, 0, -15 },
  { 1901, 11, 15, 12, 0, -15 },
  { 1922, 10, 15, 12, 1, -15 },
  { 1941, 12, 21, 12, -1, -15 },
  { 1973, 11, 21, 12, 1, -15 },
  { 2002, 9, 15, 8, 0, -15 },
  { 2019, 9, 15, 9, 0, -15 },
  { 2036, 6, 18, 7, 1, -18 },
  { 2050, 10, 14, 12, 1, -14 },
  { 2068, 10, 14, 9, 1, -14 },
  { 2086, 14, 14, 15, 2, -14 },
  { 2111, 12, 14, 10, -1, -14 },
  { 2132, 14, 21, 10, -3, -14 },
  { 2169, 10, 14, 8, -1, -14 },
  { 2187, 9, 23, 9, 1, -19 },
  { 2213, 1, 28, 11, 5, -21 },
  { 2217, 10, 23, 9, -2, -19 },
  { 2246, 11, 3, 12, 1, -11 },
};

const GFXfont NotoSans_Condensed_LightItalic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic27pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC27PT7B_H_
