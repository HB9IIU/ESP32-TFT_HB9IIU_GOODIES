#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC11PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x29, 0x24, 0x84, 0xB7, 0x00, 0x29, 0x5E, 0xA5, 0x7D, 0x94, 0x13,
  0x58, 0xC2, 0x19, 0x5C, 0x40, 0x4D, 0x75, 0xDB, 0xAD, 0xB3, 0x32, 0x94,
  0x46, 0xD6, 0x5E, 0xE0, 0x32, 0x44, 0x88, 0x88, 0x84, 0x24, 0x92, 0x49,
  0x50, 0xA7, 0xA0, 0x21, 0x3E, 0x42, 0x00, 0xC0, 0xE0, 0x80, 0x08, 0x44,
  0x22, 0x11, 0x18, 0x32, 0x53, 0x19, 0x4A, 0x4C, 0x3C, 0xA4, 0x94, 0x70,
  0x42, 0x22, 0x21, 0x1E, 0x70, 0x42, 0x65, 0x08, 0x5C, 0x08, 0x8C, 0xA5,
  0x68, 0x84, 0x3A, 0x10, 0xC1, 0x08, 0x5C, 0x3A, 0x10, 0xE9, 0x4A, 0x4C,
  0xF1, 0x22, 0x44, 0x88, 0x32, 0x52, 0x65, 0x4A, 0x5C, 0x32, 0x52, 0x97,
  0x08, 0x5C, 0x40, 0x20, 0x20, 0x00, 0xB0, 0x1B, 0x30, 0x60, 0x80, 0xF0,
  0xF0, 0xE0, 0x86, 0xC8, 0x00, 0x71, 0x12, 0x44, 0x08, 0x1C, 0x45, 0x6B,
  0x5A, 0xB5, 0xAF, 0x40, 0x70, 0x08, 0xC6, 0x53, 0xA5, 0x31, 0x3A, 0x52,
  0xE5, 0x46, 0x5E, 0x34, 0x88, 0x88, 0x8E, 0x32, 0x52, 0x94, 0xC6, 0x5C,
  0x3A, 0x10, 0xE4, 0x42, 0x1C, 0x3A, 0x10, 0x87, 0x42, 0x10, 0x3A, 0x21,
  0x0B, 0x4A, 0x5E, 0x25, 0x14, 0x5E, 0x4A, 0x28, 0xA2, 0x69, 0x24, 0xA6,
  0x11, 0x11, 0x12, 0x22, 0x2C, 0x2D, 0x25, 0x18, 0x62, 0x89, 0x24, 0x29,
  0x25, 0x27, 0x21, 0x22, 0x66, 0x66, 0x6A, 0xAA, 0xB4, 0x94, 0x24, 0x96,
  0x55, 0x5A, 0x69, 0xA2, 0x74, 0x63, 0x18, 0xCA, 0x5C, 0x32, 0x52, 0x97,
  0x42, 0x10, 0x74, 0x63, 0x18, 0xCA, 0x5C, 0x21, 0x00, 0x32, 0x52, 0x97,
  0x4A, 0x52, 0x3A, 0x10, 0x82, 0x08, 0x5C, 0xF4, 0x44, 0x48, 0x88, 0x8C,
  0x63, 0x29, 0x4A, 0x5C, 0x8C, 0xA5, 0x4A, 0x63, 0x10, 0x93, 0x26, 0xCD,
  0xAD, 0x5B, 0x26, 0x48, 0x24, 0xA1, 0x84, 0x10, 0xC5, 0x22, 0x9A, 0xAC,
  0x48, 0x88, 0x78, 0x84, 0x44, 0x22, 0x1C, 0x34, 0x44, 0x48, 0x88, 0x8C,
  0xAA, 0x55, 0x31, 0x11, 0x12, 0x22, 0x2C, 0x21, 0x95, 0x90, 0xF0, 0x80,
  0x3A, 0x65, 0x29, 0x38, 0x42, 0x1C, 0x94, 0xC6, 0x5C, 0x34, 0x88, 0x86,
  0x08, 0x4E, 0x98, 0xCA, 0x5E, 0x35, 0xBC, 0x87, 0x19, 0x0C, 0x42, 0x11,
  0x08, 0x42, 0x20, 0x3A, 0x63, 0x29, 0x78, 0x44, 0xC0, 0x44, 0x75, 0x59,
  0x99, 0x45, 0x6A, 0x20, 0x92, 0x92, 0x4A, 0x00, 0x44, 0x55, 0x66, 0xAA,
  0x55, 0x6A, 0x76, 0x95, 0x4C, 0x99, 0x52, 0x80, 0x75, 0x59, 0x99, 0x35,
  0x99, 0x96, 0x72, 0x53, 0x19, 0x72, 0x10, 0x80, 0x3A, 0x63, 0x29, 0x78,
  0x44, 0x20, 0x74, 0x48, 0x88, 0x78, 0x42, 0x2E, 0x4D, 0x29, 0x30, 0x4A,
  0x55, 0x29, 0x78, 0xB7, 0x69, 0x00, 0xA6, 0xAE, 0xAC, 0xB2, 0x80, 0x55,
  0x24, 0xAA, 0x29, 0x4A, 0x62, 0x10, 0x88, 0x80, 0x72, 0x24, 0x8E, 0x12,
  0x22, 0xC4, 0x44, 0x44, 0xFF, 0xE0, 0x31, 0x11, 0x12, 0x22, 0x2C, 0xF8,
};

const GFXglyph NotoSans_Condensed_LightItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 8, 2, 0, -8 },
  { 4, 3, 3, 3, 1, -8 },
  { 6, 5, 8, 5, 0, -8 },
  { 11, 5, 9, 5, 0, -8 },
  { 17, 5, 8, 7, 1, -8 },
  { 22, 5, 8, 5, 0, -8 },
  { 27, 1, 3, 2, 1, -8 },
  { 28, 4, 10, 3, 0, -8 },
  { 33, 3, 10, 3, -1, -8 },
  { 37, 4, 3, 4, 1, -8 },
  { 39, 5, 5, 5, 0, -6 },
  { 43, 1, 2, 2, 0, -1 },
  { 44, 3, 1, 3, 0, -3 },
  { 45, 1, 1, 2, 0, -1 },
  { 46, 5, 8, 4, -1, -8 },
  { 51, 5, 8, 5, 0, -8 },
  { 56, 3, 8, 5, 1, -8 },
  { 59, 5, 8, 5, 0, -8 },
  { 64, 5, 8, 5, 0, -8 },
  { 69, 5, 8, 5, 0, -8 },
  { 74, 5, 8, 5, 0, -8 },
  { 79, 5, 8, 5, 0, -8 },
  { 84, 4, 8, 5, 1, -8 },
  { 88, 5, 8, 5, 0, -8 },
  { 93, 5, 8, 5, 0, -8 },
  { 98, 2, 6, 2, 0, -6 },
  { 100, 3, 7, 2, -1, -6 },
  { 103, 5, 5, 5, 0, -6 },
  { 107, 4, 3, 5, 1, -5 },
  { 109, 5, 5, 5, 0, -6 },
  { 113, 4, 8, 3, 0, -8 },
  { 117, 7, 9, 7, 0, -8 },
  { 125, 5, 8, 5, -1, -8 },
  { 130, 5, 8, 5, 0, -8 },
  { 135, 4, 8, 5, 1, -8 },
  { 139, 5, 8, 6, 0, -8 },
  { 144, 5, 8, 4, 0, -8 },
  { 149, 5, 8, 4, 0, -8 },
  { 154, 5, 8, 6, 1, -8 },
  { 159, 6, 8, 6, 0, -8 },
  { 165, 3, 8, 3, 0, -8 },
  { 168, 4, 10, 2, -2, -8 },
  { 173, 6, 8, 5, 0, -8 },
  { 179, 3, 8, 4, 0, -8 },
  { 182, 8, 8, 7, 0, -8 },
  { 190, 6, 8, 6, 0, -8 },
  { 196, 5, 8, 6, 1, -8 },
  { 201, 5, 8, 5, 0, -8 },
  { 206, 5, 10, 6, 1, -8 },
  { 213, 5, 8, 5, 0, -8 },
  { 218, 5, 8, 4, 0, -8 },
  { 223, 4, 8, 4, 1, -8 },
  { 227, 5, 8, 6, 1, -8 },
  { 232, 5, 8, 5, 1, -8 },
  { 237, 7, 8, 8, 1, -8 },
  { 244, 6, 8, 4, -1, -8 },
  { 250, 4, 8, 4, 1, -8 },
  { 254, 5, 8, 4, 0, -8 },
  { 259, 4, 10, 3, 0, -8 },
  { 264, 2, 8, 4, 1, -8 },
  { 266, 4, 10, 3, -1, -8 },
  { 271, 5, 4, 5, 0, -8 },
  { 274, 4, 1, 3, -1, 1 },
  { 275, 1, 1, 3, 2, -8 },
  { 276, 5, 6, 5, 0, -6 },
  { 280, 5, 8, 5, 0, -8 },
  { 285, 4, 6, 4, 0, -6 },
  { 288, 5, 8, 5, 0, -8 },
  { 293, 4, 6, 4, 0, -6 },
  { 296, 5, 11, 3, -1, -8 },
  { 303, 5, 9, 5, 0, -6 },
  { 309, 4, 8, 5, 0, -8 },
  { 313, 2, 8, 2, 0, -8 },
  { 315, 3, 11, 2, -1, -8 },
  { 320, 4, 8, 4, 0, -8 },
  { 324, 2, 8, 2, 0, -8 },
  { 326, 7, 6, 7, 0, -6 },
  { 332, 4, 6, 5, 0, -6 },
  { 335, 4, 6, 5, 0, -6 },
  { 338, 5, 9, 5, 0, -6 },
  { 344, 5, 9, 5, 0, -6 },
  { 350, 4, 6, 3, 0, -6 },
  { 353, 4, 6, 4, 0, -6 },
  { 356, 3, 7, 3, 0, -7 },
  { 359, 5, 6, 5, 0, -6 },
  { 363, 3, 6, 4, 1, -6 },
  { 366, 6, 6, 6, 1, -6 },
  { 371, 4, 6, 4, 0, -6 },
  { 374, 5, 9, 4, -1, -6 },
  { 380, 4, 6, 3, 0, -6 },
  { 383, 4, 10, 4, 0, -8 },
  { 388, 1, 11, 5, 2, -8 },
  { 390, 4, 10, 4, -1, -8 },
  { 395, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_Condensed_LightItalic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic11pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC11PT7B_H_
