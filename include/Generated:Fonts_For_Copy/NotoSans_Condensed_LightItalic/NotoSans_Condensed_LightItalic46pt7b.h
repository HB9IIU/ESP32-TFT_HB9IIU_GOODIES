#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC46PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07,
  0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x30, 0xEE, 0x19, 0xC3, 0x38,
  0x66, 0x1C, 0xC3, 0x18, 0x67, 0x0C, 0xC1, 0x98, 0x63, 0x0C, 0x61, 0x80,
  0x00, 0x1C, 0x18, 0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x0E, 0x0C, 0x00,
  0x30, 0x30, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60,
  0xC0, 0x01, 0x83, 0x00, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0xC1, 0x80,
  0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x83, 0x00, 0x0C,
  0x0C, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x06, 0x06, 0x01, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x60, 0x01,
  0xC1, 0x80, 0x06, 0x06, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x03, 0x03,
  0x00, 0x0C, 0x1C, 0x00, 0x30, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x03, 0xCC,
  0xE0, 0x30, 0x82, 0x07, 0x08, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0xE1,
  0x80, 0x0E, 0x10, 0x00, 0x63, 0x00, 0x07, 0x30, 0x00, 0x3B, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x04, 0xE0, 0x00, 0x47, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30,
  0x00, 0x83, 0x00, 0x18, 0x70, 0x01, 0x86, 0x08, 0x18, 0xE0, 0xF1, 0xFC,
  0x0F, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x07, 0xC0, 0x0C, 0x0F, 0xE0, 0x1C,
  0x18, 0x60, 0x18, 0x38, 0x60, 0x38, 0x30, 0x60, 0x30, 0x70, 0x60, 0x60,
  0x60, 0x60, 0x60, 0x60, 0x60, 0xC0, 0xE0, 0x61, 0xC0, 0xC0, 0x61, 0x80,
  0xC0, 0xE3, 0x00, 0xC0, 0xC3, 0x00, 0xC0, 0xC6, 0x00, 0xC0, 0xC6, 0x3C,
  0xC1, 0x8C, 0x7E, 0xC1, 0x9C, 0xC7, 0xC3, 0x19, 0xC3, 0xC7, 0x31, 0x83,
  0xFE, 0x33, 0x83, 0x7C, 0x63, 0x03, 0x00, 0xE3, 0x03, 0x00, 0xC7, 0x03,
  0x01, 0xC6, 0x07, 0x01, 0x86, 0x06, 0x03, 0x06, 0x06, 0x03, 0x06, 0x06,
  0x06, 0x06, 0x0E, 0x0E, 0x06, 0x0C, 0x0C, 0x06, 0x0C, 0x1C, 0x06, 0x18,
  0x18, 0x06, 0x38, 0x30, 0x07, 0x70, 0x70, 0x03, 0xE0, 0x00, 0x00, 0x80,
  0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0xE3, 0x80, 0x1C, 0x1C, 0x01, 0x81,
  0xC0, 0x18, 0x1C, 0x01, 0x81, 0xC0, 0x38, 0x18, 0x03, 0x83, 0x80, 0x38,
  0x30, 0x01, 0x87, 0x00, 0x18, 0xE0, 0x01, 0xDC, 0x00, 0x1F, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x77, 0x00, 0x0E, 0x70, 0x31,
  0xC3, 0x83, 0x38, 0x38, 0x73, 0x01, 0x86, 0x70, 0x1C, 0xE6, 0x00, 0xCC,
  0xE0, 0x0F, 0xCE, 0x00, 0xF8, 0xE0, 0x07, 0x8E, 0x00, 0x70, 0xE0, 0x0F,
  0x06, 0x01, 0xF8, 0x70, 0x39, 0x83, 0xFF, 0x1C, 0x1F, 0xC1, 0xC0, 0x33,
  0x77, 0x66, 0x6E, 0xCC, 0xCC, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80,
  0x38, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x0C, 0x06, 0x18, 0x1E, 0x30, 0x0F, 0x43, 0x87, 0xFF, 0x03,
  0xC0, 0x0F, 0x00, 0x32, 0x01, 0xC6, 0x07, 0x0E, 0x0C, 0x0C, 0x08, 0x1C,
  0x00, 0x20, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x1C, 0x30, 0xE1, 0x87, 0x0C, 0x18, 0x60, 0xC3, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0xE1, 0xC0,
  0xE0, 0x70, 0x60, 0x38, 0x70, 0x1C, 0x70, 0x06, 0x38, 0x03, 0x18, 0x01,
  0x9C, 0x00, 0xCC, 0x00, 0xE6, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D, 0x80,
  0x0E, 0xC0, 0x06, 0xE0, 0x03, 0x70, 0x03, 0xB8, 0x01, 0xD8, 0x00, 0xEC,
  0x00, 0x66, 0x00, 0x73, 0x00, 0x39, 0x80, 0x18, 0xC0, 0x1C, 0x60, 0x0E,
  0x30, 0x06, 0x18, 0x07, 0x0C, 0x07, 0x07, 0x03, 0x03, 0xC3, 0x80, 0xFF,
  0x80, 0x3F, 0x80, 0x00, 0x01, 0xC0, 0xF0, 0x7C, 0x7E, 0x3D, 0x9C, 0x6E,
  0x3B, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38,
  0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E,
  0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x00, 0x00, 0x3F,
  0x80, 0x0F, 0xFC, 0x01, 0xC1, 0xE0, 0x18, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0xF0, 0x1E, 0x07, 0x01, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE1, 0x00, 0x38, 0x30, 0x1E, 0x07, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x6C, 0x00, 0x1D, 0x80, 0x03, 0x70, 0x00, 0xCE, 0x00,
  0x39, 0x80, 0x0E, 0x30, 0x01, 0x8E, 0x00, 0x61, 0xC0, 0x1C, 0x30, 0x03,
  0x06, 0x00, 0xC0, 0xC0, 0x38, 0x38, 0x06, 0x07, 0x01, 0x80, 0xC0, 0x70,
  0x18, 0x0C, 0x03, 0x03, 0x00, 0xE0, 0xE0, 0x1C, 0x38, 0x03, 0x07, 0xFF,
  0xFE, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00,
  0xFF, 0xE0, 0x3F, 0xFC, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1B, 0xE0, 0x03, 0xFF, 0x00, 0x71,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE1, 0x00, 0x38, 0x30, 0x1E,
  0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0xFE, 0x07, 0x7F, 0xC1, 0xB0, 0x78, 0x78, 0x0E, 0x3C, 0x01, 0x8E, 0x00,
  0x63, 0x80, 0x1C, 0xE0, 0x07, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18,
  0xC0, 0x0E, 0x30, 0x03, 0x8C, 0x00, 0xC3, 0x00, 0x70, 0xE0, 0x18, 0x38,
  0x0E, 0x07, 0x07, 0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xC1, 0xE0,
  0x38, 0x0E, 0x03, 0x00, 0x60, 0x70, 0x07, 0x07, 0x00, 0x70, 0x60, 0x06,
  0x06, 0x00, 0x60, 0x70, 0x0E, 0x07, 0x00, 0xC0, 0x30, 0x1C, 0x03, 0x83,
  0x80, 0x1C, 0x70, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x79,
  0xC0, 0x0E, 0x0E, 0x01, 0xC0, 0x60, 0x38, 0x07, 0x07, 0x00, 0x30, 0x60,
  0x03, 0x86, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x0E,
  0x00, 0x30, 0x60, 0x07, 0x07, 0x00, 0xE0, 0x38, 0x1E, 0x03, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x38, 0x78, 0x1C, 0x0E,
  0x0E, 0x01, 0x83, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x18, 0x01, 0xCE,
  0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0xE3, 0x80,
  0x38, 0xE0, 0x1E, 0x38, 0x07, 0x87, 0x07, 0xE1, 0xFF, 0xB0, 0x3F, 0xCC,
  0x01, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x02, 0x07, 0x07, 0x07, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x70, 0xF0, 0x60, 0x00, 0x40, 0x3C, 0x07, 0x80,
  0xE0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x1C, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x00,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0xE1, 0x83, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0x80,
  0xE0, 0x03, 0x80, 0x0C, 0x01, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0x60, 0x70,
  0x00, 0x0C, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC7, 0x00, 0xF0, 0x31,
  0x80, 0xFF, 0x0C, 0xC0, 0x71, 0x83, 0x30, 0x30, 0x60, 0xCC, 0x18, 0x18,
  0x36, 0x06, 0x06, 0x0D, 0x83, 0x03, 0x03, 0x60, 0xC0, 0xC0, 0xF0, 0x60,
  0x30, 0x3C, 0x18, 0x0C, 0x1B, 0x06, 0x06, 0x06, 0xC1, 0x81, 0x81, 0xB0,
  0xE0, 0x60, 0xCC, 0x38, 0x38, 0x33, 0x0E, 0x0E, 0x18, 0xC1, 0x87, 0x86,
  0x30, 0x63, 0x63, 0x0C, 0x1F, 0x8F, 0x83, 0x03, 0xC1, 0xC0, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0E, 0xC0, 0x00, 0xCE,
  0x00, 0x1C, 0xE0, 0x01, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x0E, 0x00, 0x30,
  0xE0, 0x07, 0x0E, 0x00, 0x60, 0xE0, 0x0E, 0x0E, 0x00, 0xC0, 0xE0, 0x1C,
  0x0E, 0x01, 0x80, 0x60, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x70, 0x06, 0x07,
  0x00, 0x60, 0xE0, 0x06, 0x0E, 0x00, 0x60, 0xC0, 0x06, 0x1C, 0x00, 0x61,
  0x80, 0x06, 0x38, 0x00, 0x63, 0x00, 0x06, 0x70, 0x00, 0x67, 0x00, 0x06,
  0xE0, 0x00, 0x70, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0x87, 0xE0, 0x30,
  0x0F, 0x03, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x30, 0x70, 0x07, 0x06,
  0x00, 0x70, 0x60, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x0E, 0x0E, 0x00, 0xC0,
  0xC0, 0x3C, 0x0C, 0x0F, 0x81, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0x80, 0x70,
  0x18, 0x03, 0x81, 0x80, 0x18, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x30, 0x01,
  0xC3, 0x00, 0x1C, 0x70, 0x01, 0x87, 0x00, 0x18, 0x70, 0x03, 0x86, 0x00,
  0x38, 0x60, 0x07, 0x0E, 0x00, 0xE0, 0xE0, 0x7C, 0x0F, 0xFF, 0x80, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3C, 0x0C, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x10, 0x03,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xE3,
  0xF8, 0x06, 0x01, 0xC0, 0x30, 0x07, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0xE0,
  0xE0, 0x07, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC3, 0x80, 0x06, 0x1C, 0x00,
  0x30, 0xE0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0xE3, 0x80, 0x07, 0x1C,
  0x00, 0x38, 0xC0, 0x01, 0xC6, 0x00, 0x0C, 0x30, 0x00, 0xE3, 0x80, 0x07,
  0x1C, 0x00, 0x30, 0xC0, 0x03, 0x86, 0x00, 0x1C, 0x70, 0x01, 0xC3, 0x80,
  0x0E, 0x1C, 0x00, 0xE0, 0xC0, 0x0E, 0x06, 0x00, 0xE0, 0x70, 0x1E, 0x03,
  0x87, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xF8, 0x1F, 0xFE,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xE0, 0x78, 0x0F, 0x00, 0x20, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x07, 0xF8, 0xC0,
  0x1F, 0xE3, 0x80, 0x3F, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00,
  0x0C, 0x38, 0x00, 0x18, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01,
  0xC1, 0x80, 0x03, 0x03, 0x80, 0x06, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x38,
  0x07, 0x80, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x01, 0x80, 0x07,
  0x03, 0x80, 0x07, 0x03, 0x80, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x0E,
  0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0C, 0x06, 0x00, 0x0C,
  0x06, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x18, 0x0E, 0x00, 0x18,
  0x0C, 0x00, 0x38, 0x0C, 0x00, 0x38, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x18, 0x00, 0x30, 0x18, 0x00, 0x70, 0x18, 0x00, 0x70, 0x38, 0x00, 0x70,
  0x38, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0xE0, 0x70, 0x00, 0xE0,
  0x70, 0x00, 0xC0, 0x70, 0x00, 0xC0, 0x60, 0x01, 0xC0, 0x60, 0x01, 0xC0,
  0xE0, 0x01, 0xC0, 0xE0, 0x01, 0x80, 0xE0, 0x01, 0x80, 0xC0, 0x03, 0x80,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x1C, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x01, 0x80,
  0x1C, 0x0E, 0x00, 0xE0, 0x38, 0x03, 0x00, 0xC0, 0x1C, 0x03, 0x00, 0xE0,
  0x1C, 0x07, 0x00, 0x70, 0x38, 0x01, 0xC1, 0xC0, 0x06, 0x07, 0x00, 0x18,
  0x38, 0x00, 0xE1, 0xC0, 0x03, 0x8E, 0x00, 0x0E, 0x70, 0x00, 0x33, 0x80,
  0x00, 0xCE, 0x00, 0x07, 0x78, 0x00, 0x1F, 0xE0, 0x00, 0x7D, 0x80, 0x01,
  0xE7, 0x00, 0x07, 0x1C, 0x00, 0x38, 0x30, 0x00, 0xE0, 0xC0, 0x03, 0x03,
  0x80, 0x0C, 0x0E, 0x00, 0x70, 0x18, 0x01, 0xC0, 0x70, 0x07, 0x01, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0E, 0x03, 0x80, 0x38, 0x0E, 0x00, 0xE0, 0x38,
  0x01, 0x80, 0xC0, 0x07, 0x00, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00,
  0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x01,
  0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x36, 0x03, 0x70, 0x00, 0xEC, 0x06, 0x60, 0x01, 0x98, 0x0C, 0xC0,
  0x07, 0x70, 0x39, 0x80, 0x0C, 0xE0, 0x73, 0x00, 0x39, 0x80, 0xC6, 0x00,
  0x63, 0x01, 0x8C, 0x01, 0xCE, 0x03, 0x18, 0x03, 0x1C, 0x0E, 0x30, 0x0E,
  0x38, 0x1C, 0x60, 0x18, 0x60, 0x30, 0xE0, 0x70, 0xC0, 0x61, 0xC0, 0xC3,
  0x80, 0xC3, 0x83, 0x87, 0x03, 0x87, 0x06, 0x0C, 0x07, 0x06, 0x1C, 0x18,
  0x0C, 0x0C, 0x30, 0x30, 0x18, 0x18, 0xE0, 0xE0, 0x70, 0x31, 0x81, 0xC0,
  0xE0, 0x67, 0x03, 0x01, 0x80, 0xCC, 0x06, 0x03, 0x01, 0xB8, 0x0C, 0x06,
  0x03, 0x60, 0x38, 0x1C, 0x07, 0xC0, 0x70, 0x38, 0x0F, 0x00, 0xC0, 0x60,
  0x1E, 0x01, 0x80, 0xC0, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x03, 0x81, 0xE0,
  0x01, 0xC0, 0xF0, 0x00, 0xC0, 0x78, 0x00, 0x60, 0x3C, 0x00, 0x70, 0x3F,
  0x00, 0x38, 0x1D, 0x80, 0x18, 0x0C, 0xC0, 0x0C, 0x06, 0x60, 0x06, 0x03,
  0x38, 0x07, 0x03, 0x8C, 0x03, 0x81, 0xC6, 0x01, 0x80, 0xC3, 0x00, 0xC0,
  0x61, 0xC0, 0x60, 0x30, 0x60, 0x70, 0x38, 0x30, 0x38, 0x1C, 0x18, 0x18,
  0x0C, 0x0E, 0x0C, 0x06, 0x03, 0x0E, 0x03, 0x01, 0x87, 0x03, 0x80, 0xC3,
  0x01, 0xC0, 0x71, 0x80, 0xC0, 0x38, 0xC0, 0x60, 0x0C, 0xE0, 0x70, 0x06,
  0x70, 0x38, 0x03, 0xB0, 0x18, 0x01, 0xD8, 0x0C, 0x00, 0x6C, 0x06, 0x00,
  0x3E, 0x07, 0x00, 0x1F, 0x03, 0x80, 0x0F, 0x01, 0x80, 0x03, 0x80, 0xC0,
  0x01, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x1E, 0x0F, 0x00,
  0xF0, 0x0E, 0x03, 0x80, 0x38, 0x1C, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80,
  0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07,
  0x30, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x60,
  0x00, 0x19, 0x80, 0x00, 0x6E, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00,
  0x33, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x18, 0xE0, 0x00, 0xE3,
  0x80, 0x03, 0x8E, 0x00, 0x1C, 0x18, 0x00, 0xE0, 0x70, 0x03, 0x81, 0xE0,
  0x1C, 0x03, 0xC1, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0xF0, 0x0E, 0x3F, 0x01, 0x80, 0xF0, 0x30, 0x0E, 0x0E, 0x00,
  0xC1, 0xC0, 0x18, 0x38, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x38, 0x01,
  0x87, 0x00, 0x70, 0xE0, 0x0E, 0x18, 0x03, 0x83, 0x00, 0x70, 0xE0, 0x1C,
  0x1C, 0x0F, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xC0, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x1E,
  0x0F, 0x00, 0xF0, 0x0E, 0x03, 0x80, 0x38, 0x1C, 0x00, 0x70, 0xE0, 0x01,
  0xC3, 0x80, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x73, 0x80, 0x01, 0xCE,
  0x00, 0x07, 0x30, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00,
  0x07, 0x60, 0x00, 0x19, 0x80, 0x00, 0x6E, 0x00, 0x03, 0xB8, 0x00, 0x0E,
  0xE0, 0x00, 0x33, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x18, 0xE0,
  0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x1C, 0x18, 0x00, 0xE0, 0x70, 0x03,
  0x81, 0xE0, 0x1C, 0x03, 0xC1, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xFE,
  0x00, 0x7F, 0xF0, 0x0E, 0x3F, 0x01, 0x80, 0xF0, 0x30, 0x0E, 0x0E, 0x00,
  0xC1, 0xC0, 0x18, 0x38, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x38, 0x03,
  0x87, 0x00, 0x70, 0xE0, 0x0C, 0x18, 0x03, 0x83, 0x00, 0xE0, 0xE0, 0x3C,
  0x1C, 0x3F, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x0C, 0x18, 0x03, 0x83, 0x00,
  0x70, 0x70, 0x0C, 0x0E, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x81,
  0xC0, 0x70, 0x30, 0x06, 0x06, 0x00, 0xC1, 0xC0, 0x1C, 0x38, 0x03, 0x87,
  0x00, 0x70, 0xC0, 0x07, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0x7C,
  0x1C, 0x07, 0x80, 0x20, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x40, 0x07, 0x03,
  0x80, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x0E, 0x00,
  0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03,
  0x83, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x38, 0x00, 0x70,
  0x70, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x0E, 0x0E,
  0x00, 0x1C, 0x1C, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x01, 0xC1, 0xC0,
  0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00,
  0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x0E,
  0x07, 0x00, 0x18, 0x0E, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x1E, 0x07, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0x70, 0x00, 0xEE, 0x00, 0x19, 0xC0, 0x07, 0x38, 0x00, 0xC7, 0x00,
  0x38, 0xE0, 0x06, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x30, 0x0E, 0x06, 0x01,
  0xC0, 0xC0, 0x30, 0x18, 0x0E, 0x03, 0x01, 0x80, 0x60, 0x70, 0x0C, 0x0C,
  0x01, 0x83, 0x80, 0x30, 0x60, 0x06, 0x1C, 0x00, 0xC3, 0x00, 0x18, 0xE0,
  0x03, 0x1C, 0x00, 0x63, 0x00, 0x0C, 0xE0, 0x01, 0x98, 0x00, 0x37, 0x00,
  0x06, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x07, 0x00, 0x1F, 0x80, 0x0E, 0x00,
  0x37, 0x00, 0x3C, 0x00, 0xEE, 0x00, 0x78, 0x01, 0x9C, 0x01, 0xF0, 0x07,
  0x38, 0x03, 0x60, 0x0E, 0x70, 0x06, 0xC0, 0x18, 0xE0, 0x19, 0x80, 0x71,
  0xC0, 0x33, 0x00, 0xC3, 0x80, 0xE6, 0x03, 0x87, 0x01, 0x8C, 0x07, 0x0E,
  0x07, 0x18, 0x1C, 0x1C, 0x0C, 0x30, 0x38, 0x38, 0x18, 0x60, 0x60, 0x70,
  0x70, 0xC1, 0xC0, 0xE0, 0xC1, 0x83, 0x01, 0xC3, 0x83, 0x0E, 0x03, 0x86,
  0x06, 0x1C, 0x07, 0x0C, 0x0C, 0x30, 0x0E, 0x30, 0x18, 0xE0, 0x1C, 0x60,
  0x31, 0x80, 0x39, 0xC0, 0x67, 0x00, 0x73, 0x00, 0xCE, 0x00, 0xEE, 0x01,
  0x98, 0x01, 0xD8, 0x03, 0x70, 0x03, 0xB0, 0x06, 0xC0, 0x07, 0xE0, 0x0F,
  0x80, 0x0F, 0x80, 0x1E, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0xE0, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x60, 0x1C, 0x00, 0x70, 0x1C,
  0x00, 0x70, 0x38, 0x00, 0x30, 0x30, 0x00, 0x30, 0x70, 0x00, 0x30, 0xE0,
  0x00, 0x38, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x1B, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x76, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0xC6, 0x00, 0x01, 0xC7, 0x00, 0x03, 0x87, 0x00, 0x03, 0x07, 0x00,
  0x07, 0x03, 0x00, 0x0E, 0x03, 0x00, 0x0E, 0x03, 0x80, 0x1C, 0x03, 0x80,
  0x18, 0x03, 0x80, 0x38, 0x01, 0x80, 0x70, 0x01, 0x80, 0xE0, 0x01, 0xC0,
  0xE0, 0x03, 0xF0, 0x01, 0xB8, 0x01, 0xCC, 0x00, 0xC6, 0x00, 0xE3, 0x00,
  0xE1, 0x80, 0x70, 0xE0, 0x70, 0x70, 0x30, 0x38, 0x38, 0x0C, 0x18, 0x06,
  0x1C, 0x03, 0x0C, 0x01, 0x8E, 0x00, 0xEE, 0x00, 0x76, 0x00, 0x3F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x80, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x38, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xFE,
  0x01, 0xFF, 0x00, 0xC1, 0x83, 0x06, 0x0E, 0x1C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x87, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xE1, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x38, 0x70, 0x60, 0xC1, 0x83, 0x07, 0x0E, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0D, 0xC0, 0x03, 0x98, 0x00,
  0x63, 0x00, 0x18, 0x70, 0x03, 0x06, 0x00, 0xC0, 0xE0, 0x38, 0x0C, 0x06,
  0x01, 0x81, 0xC0, 0x38, 0x30, 0x03, 0x0E, 0x00, 0x61, 0x80, 0x0E, 0x60,
  0x00, 0xDC, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFC, 0xE7, 0x18, 0xE3, 0x0C,
  0x60, 0x00, 0xF0, 0x00, 0xFE, 0x30, 0x79, 0xDC, 0x38, 0x1E, 0x1C, 0x07,
  0x86, 0x00, 0xE3, 0x80, 0x38, 0xC0, 0x0E, 0x70, 0x03, 0x1C, 0x00, 0xC6,
  0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0x8C, 0x00, 0x63, 0x00,
  0x38, 0xC0, 0x0E, 0x30, 0x03, 0x0C, 0x01, 0xC3, 0x00, 0x70, 0xC0, 0x3C,
  0x38, 0x1F, 0x0E, 0x0D, 0x81, 0xFE, 0x60, 0x3F, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x3C,
  0x03, 0x9F, 0xC0, 0x77, 0x3C, 0x0D, 0x81, 0xC1, 0xE0, 0x38, 0x38, 0x07,
  0x0F, 0x00, 0x61, 0xC0, 0x0C, 0x38, 0x01, 0x86, 0x00, 0x70, 0xC0, 0x0E,
  0x38, 0x01, 0xC7, 0x00, 0x38, 0xC0, 0x06, 0x18, 0x00, 0xC7, 0x00, 0x38,
  0xE0, 0x07, 0x1C, 0x00, 0xC3, 0x80, 0x38, 0x70, 0x06, 0x1E, 0x01, 0xC3,
  0x40, 0x70, 0x6C, 0x1C, 0x0C, 0xFF, 0x03, 0x8F, 0xC0, 0x00, 0x00, 0xF8,
  0x07, 0xFC, 0x1E, 0x30, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x08, 0x3F, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0xF0,
  0xC0, 0x3F, 0xCC, 0x07, 0x9D, 0xC0, 0xE0, 0x7C, 0x1C, 0x03, 0x81, 0x80,
  0x38, 0x38, 0x03, 0x83, 0x00, 0x38, 0x70, 0x03, 0x07, 0x00, 0x30, 0x60,
  0x03, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x60, 0xC0, 0x06, 0x0C,
  0x00, 0xE0, 0xC0, 0x0E, 0x0C, 0x01, 0xE0, 0xC0, 0x1C, 0x0C, 0x03, 0xC0,
  0xC0, 0x3C, 0x0E, 0x07, 0xC0, 0xE0, 0xDC, 0x07, 0xF9, 0x80, 0x3F, 0x18,
  0x00, 0x00, 0xF8, 0x07, 0xF8, 0x1E, 0x78, 0x70, 0x71, 0xC0, 0x63, 0x00,
  0xCE, 0x01, 0x98, 0x07, 0x70, 0x0C, 0xC0, 0x3B, 0x81, 0xE7, 0x3F, 0x8F,
  0xFC, 0x1F, 0x80, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x04, 0x3F, 0xF8, 0x1F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xF3,
  0x01, 0xE7, 0x30, 0x38, 0x1F, 0x07, 0x00, 0xE0, 0x60, 0x0E, 0x0E, 0x00,
  0xE0, 0xC0, 0x0E, 0x1C, 0x00, 0xC1, 0xC0, 0x0C, 0x18, 0x00, 0xC3, 0x80,
  0x1C, 0x38, 0x01, 0xC3, 0x80, 0x18, 0x30, 0x01, 0x83, 0x00, 0x38, 0x30,
  0x03, 0x83, 0x00, 0x78, 0x30, 0x07, 0x03, 0x00, 0xF0, 0x30, 0x0F, 0x03,
  0x81, 0xF0, 0x38, 0x37, 0x01, 0xFE, 0x60, 0x0F, 0xC6, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x80, 0x70, 0x0E, 0x1F, 0x00, 0xFF, 0xC0, 0x03, 0xF8,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0xF0, 0x1C, 0xFE, 0x07, 0x73, 0xC1, 0xB0, 0x30, 0x78, 0x0C, 0x1C,
  0x03, 0x0F, 0x00, 0xC3, 0x80, 0x30, 0xE0, 0x1C, 0x30, 0x07, 0x0C, 0x01,
  0xC7, 0x00, 0x61, 0xC0, 0x18, 0x60, 0x0E, 0x18, 0x03, 0x86, 0x00, 0xE3,
  0x80, 0x30, 0xE0, 0x0C, 0x30, 0x07, 0x0C, 0x01, 0xC7, 0x00, 0x61, 0xC0,
  0x18, 0x70, 0x06, 0x18, 0x03, 0x8E, 0x00, 0xE0, 0x01, 0xC0, 0x70, 0x1C,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x1C, 0x06,
  0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01,
  0x80, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x9E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x83, 0x80, 0xE0, 0x70,
  0x38, 0x0E, 0x06, 0x01, 0x81, 0xC0, 0x30, 0x70, 0x0E, 0x1C, 0x01, 0xC7,
  0x00, 0x31, 0xC0, 0x06, 0x30, 0x00, 0xCC, 0x00, 0x3B, 0xC0, 0x06, 0xF8,
  0x00, 0xF3, 0x00, 0x1E, 0x60, 0x03, 0x8E, 0x00, 0xE1, 0xC0, 0x1C, 0x18,
  0x03, 0x03, 0x80, 0x60, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xC0, 0x60, 0x1C,
  0x0C, 0x03, 0x83, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01,
  0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0,
  0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60,
  0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18,
  0x0E, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x39, 0xFC, 0x7F, 0x81, 0x98, 0xE7,
  0x3C, 0x0D, 0x83, 0xE0, 0x70, 0x78, 0x1E, 0x03, 0x83, 0x80, 0xF0, 0x1C,
  0x3C, 0x07, 0x00, 0xE1, 0xC0, 0x38, 0x06, 0x0E, 0x01, 0xC0, 0x30, 0x60,
  0x0C, 0x01, 0x83, 0x00, 0x60, 0x1C, 0x38, 0x07, 0x00, 0xE1, 0xC0, 0x38,
  0x06, 0x0C, 0x01, 0x80, 0x30, 0x60, 0x0C, 0x01, 0x87, 0x00, 0xE0, 0x1C,
  0x38, 0x07, 0x00, 0xE1, 0xC0, 0x38, 0x06, 0x0C, 0x01, 0x80, 0x30, 0x60,
  0x0C, 0x01, 0x87, 0x00, 0xE0, 0x1C, 0x38, 0x07, 0x00, 0xE1, 0x80, 0x30,
  0x06, 0x0C, 0x01, 0x80, 0x30, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x1F, 0x01,
  0xCF, 0xE0, 0x67, 0x3C, 0x1B, 0x07, 0x07, 0x80, 0xC1, 0xC0, 0x30, 0xF0,
  0x0C, 0x38, 0x03, 0x0E, 0x01, 0xC3, 0x00, 0x70, 0xC0, 0x1C, 0x70, 0x06,
  0x1C, 0x01, 0x86, 0x00, 0xE1, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x0E,
  0x00, 0xC3, 0x00, 0x70, 0xC0, 0x1C, 0x70, 0x06, 0x1C, 0x01, 0x87, 0x00,
  0x61, 0x80, 0x38, 0xE0, 0x0E, 0x00, 0x00, 0xF8, 0x01, 0xFE, 0x01, 0xE7,
  0x81, 0xC0, 0xE1, 0xC0, 0x70, 0xC0, 0x18, 0xE0, 0x0C, 0x60, 0x07, 0x70,
  0x03, 0xB0, 0x01, 0x98, 0x00, 0xDC, 0x00, 0x6E, 0x00, 0x36, 0x00, 0x3B,
  0x00, 0x1D, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x07, 0x30, 0x03, 0x18, 0x03,
  0x8C, 0x01, 0x87, 0x01, 0xC1, 0xC1, 0xC0, 0xFF, 0xC0, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x0E, 0x7F, 0x00, 0x67, 0x3C, 0x03, 0x60, 0x70, 0x1E,
  0x03, 0x80, 0xF0, 0x1C, 0x0F, 0x00, 0x60, 0x70, 0x03, 0x03, 0x80, 0x18,
  0x1C, 0x00, 0xC0, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x00,
  0x18, 0x18, 0x00, 0xC0, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x03,
  0x80, 0x38, 0x1C, 0x01, 0x81, 0xE0, 0x1C, 0x0F, 0x01, 0xC0, 0x6C, 0x1C,
  0x03, 0x3F, 0xC0, 0x18, 0xFC, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0xFF, 0x30, 0x79, 0xCC, 0x38, 0x1F, 0x1C, 0x07, 0x86, 0x00,
  0xE3, 0x80, 0x38, 0xC0, 0x0E, 0x70, 0x03, 0x1C, 0x00, 0xC6, 0x00, 0x33,
  0x80, 0x1C, 0xE0, 0x07, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x38, 0xC0,
  0x0E, 0x30, 0x07, 0x8C, 0x01, 0xC3, 0x00, 0xF0, 0xC0, 0x3C, 0x38, 0x1F,
  0x0E, 0x0D, 0xC1, 0xFE, 0x60, 0x3F, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x0E, 0x7C,
  0x19, 0xF8, 0x36, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xFC, 0x3C,
  0x78, 0x60, 0x11, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E,
  0x20, 0x38, 0x7F, 0xF0, 0xFF, 0x80, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00,
  0x60, 0x0C, 0x0F, 0xFB, 0xFF, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0,
  0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x07, 0xE0, 0xFC, 0x00,
  0x1C, 0x01, 0xC7, 0x00, 0x61, 0x80, 0x38, 0x60, 0x0E, 0x38, 0x03, 0x0E,
  0x00, 0xC3, 0x80, 0x30, 0xC0, 0x1C, 0x30, 0x07, 0x1C, 0x01, 0x87, 0x00,
  0x61, 0x80, 0x18, 0x60, 0x0E, 0x18, 0x03, 0x8E, 0x00, 0xC3, 0x80, 0x70,
  0xC0, 0x1C, 0x30, 0x07, 0x0C, 0x03, 0xC3, 0x00, 0xE0, 0xC0, 0x78, 0x38,
  0x36, 0x0F, 0xF9, 0x81, 0xFC, 0xC0, 0xC0, 0x0F, 0x80, 0x1B, 0x00, 0x76,
  0x00, 0xCC, 0x03, 0x98, 0x06, 0x30, 0x1C, 0x60, 0x30, 0xC0, 0xE1, 0x81,
  0x83, 0x07, 0x06, 0x0C, 0x0C, 0x38, 0x1C, 0x70, 0x38, 0xC0, 0x73, 0x80,
  0xE6, 0x01, 0xDC, 0x03, 0xB0, 0x07, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xC0, 0x1C, 0x03, 0xE0, 0x1E, 0x03, 0xB0, 0x0F, 0x01,
  0x98, 0x0D, 0x81, 0xCC, 0x06, 0xC0, 0xE6, 0x07, 0x60, 0x63, 0x03, 0x30,
  0x71, 0x81, 0x98, 0x30, 0xC1, 0x8C, 0x38, 0x60, 0xC6, 0x18, 0x30, 0xC3,
  0x0C, 0x18, 0x61, 0x8E, 0x0C, 0x70, 0xC6, 0x06, 0x30, 0x67, 0x03, 0x18,
  0x33, 0x01, 0x98, 0x19, 0x80, 0xCC, 0x0D, 0xC0, 0x6C, 0x06, 0xC0, 0x36,
  0x03, 0xE0, 0x1F, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x70, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x00, 0x70, 0x38, 0x0E, 0x03,
  0x81, 0xC0, 0x18, 0x18, 0x01, 0x83, 0x80, 0x1C, 0x70, 0x00, 0xC6, 0x00,
  0x0C, 0xE0, 0x00, 0xDC, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xB0, 0x00, 0x3B, 0x80, 0x07, 0x18,
  0x00, 0x61, 0x80, 0x0E, 0x1C, 0x01, 0xC1, 0xC0, 0x38, 0x0C, 0x03, 0x80,
  0xC0, 0x70, 0x0E, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0C, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x38,
  0x00, 0xE0, 0x30, 0x00, 0xE0, 0x70, 0x00, 0x60, 0x60, 0x00, 0x60, 0xE0,
  0x00, 0x60, 0xC0, 0x00, 0x61, 0xC0, 0x00, 0x61, 0x80, 0x00, 0x63, 0x80,
  0x00, 0x63, 0x80, 0x00, 0x63, 0x00, 0x00, 0x67, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x8F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xFF,
  0xF0, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70,
  0x03, 0xF8, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x1F, 0xE0, 0x1F, 0xFE, 0x1F,
  0x03, 0xFF, 0x80, 0x3F, 0x00,
};

const GFXglyph NotoSans_Condensed_LightItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 10, 33, 10, 1, -33 },
  { 43, 11, 12, 14, 5, -33 },
  { 60, 22, 33, 21, 0, -33 },
  { 151, 20, 38, 19, 0, -35 },
  { 246, 24, 34, 29, 3, -33 },
  { 348, 20, 33, 21, 0, -33 },
  { 431, 4, 12, 8, 5, -33 },
  { 437, 14, 40, 12, 1, -33 },
  { 507, 13, 40, 12, -3, -33 },
  { 572, 15, 16, 18, 5, -35 },
  { 602, 18, 21, 21, 2, -27 },
  { 650, 7, 11, 9, -2, -5 },
  { 660, 10, 3, 13, 1, -14 },
  { 664, 3, 4, 9, 1, -4 },
  { 666, 20, 33, 15, -2, -33 },
  { 749, 17, 33, 19, 2, -33 },
  { 820, 10, 33, 19, 6, -33 },
  { 862, 20, 33, 19, -1, -33 },
  { 945, 19, 33, 19, 0, -33 },
  { 1024, 19, 33, 19, 0, -33 },
  { 1103, 19, 33, 19, 0, -33 },
  { 1182, 18, 33, 19, 2, -33 },
  { 1257, 19, 33, 19, 2, -33 },
  { 1336, 20, 33, 19, 0, -33 },
  { 1419, 18, 33, 19, 1, -33 },
  { 1494, 8, 25, 9, 0, -25 },
  { 1519, 11, 31, 9, -2, -25 },
  { 1562, 18, 21, 21, 2, -27 },
  { 1610, 18, 12, 21, 2, -22 },
  { 1637, 18, 21, 21, 2, -27 },
  { 1685, 14, 33, 14, 2, -33 },
  { 1743, 26, 37, 29, 2, -33 },
  { 1864, 20, 33, 19, -3, -33 },
  { 1947, 20, 33, 21, 1, -33 },
  { 2030, 21, 33, 20, 2, -33 },
  { 2117, 21, 33, 23, 1, -33 },
  { 2204, 19, 33, 19, 1, -33 },
  { 2283, 19, 33, 17, 1, -33 },
  { 2362, 23, 33, 25, 2, -33 },
  { 2457, 24, 33, 24, 1, -33 },
  { 2556, 16, 33, 11, -2, -33 },
  { 2622, 17, 41, 9, -7, -33 },
  { 2710, 22, 33, 20, 1, -33 },
  { 2801, 13, 33, 17, 1, -33 },
  { 2855, 31, 33, 31, 1, -33 },
  { 2983, 25, 33, 25, 1, -33 },
  { 3087, 22, 33, 25, 2, -33 },
  { 3178, 19, 33, 20, 1, -33 },
  { 3257, 22, 41, 25, 2, -33 },
  { 3370, 19, 33, 20, 1, -33 },
  { 3449, 21, 33, 18, -1, -33 },
  { 3536, 17, 33, 17, 4, -33 },
  { 3607, 23, 33, 24, 2, -33 },
  { 3702, 19, 33, 20, 4, -33 },
  { 3781, 31, 33, 32, 4, -33 },
  { 3909, 24, 33, 18, -3, -33 },
  { 4008, 17, 33, 17, 4, -33 },
  { 4079, 21, 33, 18, -1, -33 },
  { 4166, 17, 40, 13, -1, -33 },
  { 4251, 7, 33, 15, 5, -33 },
  { 4280, 17, 40, 13, -3, -33 },
  { 4365, 19, 18, 20, 1, -33 },
  { 4408, 15, 2, 14, -4, 4 },
  { 4412, 5, 7, 11, 7, -35 },
  { 4417, 18, 25, 21, 2, -25 },
  { 4474, 19, 35, 21, 0, -35 },
  { 4558, 15, 25, 16, 2, -25 },
  { 4605, 20, 35, 21, 2, -35 },
  { 4693, 15, 25, 18, 2, -25 },
  { 4740, 22, 46, 11, -6, -35 },
  { 4867, 20, 36, 21, 0, -25 },
  { 4957, 18, 35, 20, 0, -35 },
  { 5036, 10, 33, 9, 0, -33 },
  { 5078, 16, 44, 9, -6, -33 },
  { 5166, 19, 35, 17, 0, -35 },
  { 5250, 10, 35, 9, 0, -35 },
  { 5294, 29, 25, 31, 0, -25 },
  { 5385, 18, 25, 20, 0, -25 },
  { 5442, 17, 25, 20, 2, -25 },
  { 5496, 21, 36, 21, -2, -25 },
  { 5591, 18, 36, 21, 2, -25 },
  { 5672, 15, 25, 13, 0, -25 },
  { 5719, 15, 25, 15, 0, -25 },
  { 5766, 11, 30, 11, 1, -30 },
  { 5808, 18, 24, 20, 2, -24 },
  { 5862, 15, 24, 16, 3, -24 },
  { 5907, 25, 24, 26, 3, -24 },
  { 5982, 20, 24, 17, -2, -24 },
  { 6042, 24, 35, 16, -5, -24 },
  { 6147, 16, 24, 14, -1, -24 },
  { 6195, 17, 40, 15, 1, -33 },
  { 6280, 2, 46, 19, 9, -35 },
  { 6292, 17, 40, 15, -3, -33 },
  { 6377, 18, 5, 21, 2, -19 },
};

const GFXfont NotoSans_Condensed_LightItalic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic46pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC46PT7B_H_
