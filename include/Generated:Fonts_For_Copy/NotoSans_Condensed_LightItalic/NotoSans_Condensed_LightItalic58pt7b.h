#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC58PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x3C, 0xE0, 0xE3,
  0x83, 0x8E, 0x0E, 0x38, 0x39, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0x71,
  0x81, 0x86, 0x06, 0x38, 0x38, 0xE0, 0xE3, 0x03, 0x0C, 0x0C, 0x00, 0x00,
  0x07, 0x01, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x18, 0x0E, 0x00, 0x07, 0x01,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x18, 0x0E, 0x00, 0x07, 0x01, 0x80, 0x00,
  0xE0, 0x70, 0x00, 0x18, 0x0E, 0x00, 0x07, 0x01, 0x80, 0x00, 0xE0, 0x30,
  0x00, 0x18, 0x0E, 0x00, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC0, 0x1C,
  0x0E, 0x00, 0x03, 0x01, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x1C, 0x0E, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x01, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x00, 0x60, 0x38,
  0x00, 0x1C, 0x06, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x1C,
  0x07, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x0C, 0x07, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x70, 0x38, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xFF, 0x01, 0xFF, 0x7E, 0x01, 0xE3, 0x06, 0x03, 0x83, 0x00,
  0x07, 0x83, 0x00, 0x07, 0x06, 0x00, 0x07, 0x06, 0x00, 0x07, 0x06, 0x00,
  0x07, 0x06, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x0C, 0x00,
  0x07, 0x8C, 0x00, 0x03, 0xCC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x37, 0x80,
  0x00, 0x33, 0xC0, 0x00, 0x31, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x30, 0xE0,
  0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0xE0, 0x00, 0x60, 0xE0,
  0x00, 0xE0, 0xE0, 0x00, 0xC1, 0xE0, 0x00, 0xC1, 0xC0, 0xC0, 0xC7, 0x80,
  0xFC, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x70, 0x1F,
  0xF0, 0x01, 0xC0, 0x78, 0x60, 0x03, 0x00, 0xE0, 0xE0, 0x0E, 0x03, 0x81,
  0xC0, 0x38, 0x07, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0E,
  0x03, 0x80, 0x70, 0x1C, 0x0E, 0x00, 0xC0, 0x38, 0x18, 0x03, 0x80, 0x60,
  0x70, 0x07, 0x00, 0xC1, 0xC0, 0x0E, 0x03, 0x83, 0x80, 0x18, 0x07, 0x0E,
  0x00, 0x30, 0x0E, 0x1C, 0x00, 0xE0, 0x18, 0x70, 0x01, 0xC0, 0x70, 0xC3,
  0xF3, 0x80, 0xE3, 0x8F, 0xF7, 0x01, 0x8E, 0x3C, 0xFE, 0x07, 0x1C, 0xF0,
  0xEC, 0x1C, 0x71, 0xC1, 0xDC, 0x38, 0xC7, 0x03, 0xBF, 0xE3, 0x8E, 0x07,
  0x3F, 0x8E, 0x18, 0x0E, 0x3C, 0x1C, 0x70, 0x1C, 0x00, 0x70, 0xE0, 0x38,
  0x00, 0xE1, 0x80, 0x70, 0x03, 0x87, 0x00, 0xE0, 0x06, 0x0E, 0x01, 0x80,
  0x1C, 0x1C, 0x03, 0x00, 0x70, 0x38, 0x0E, 0x00, 0xE0, 0x60, 0x1C, 0x03,
  0x80, 0xC0, 0x30, 0x07, 0x01, 0x80, 0xE0, 0x1C, 0x03, 0x01, 0xC0, 0x30,
  0x06, 0x03, 0x00, 0xE0, 0x0C, 0x0E, 0x03, 0x80, 0x1C, 0x38, 0x07, 0x00,
  0x38, 0xF0, 0x1C, 0x00, 0x3F, 0xC0, 0x78, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xF0, 0xF0, 0x00, 0x78, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01,
  0xC0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x0E,
  0x03, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x38, 0x1C, 0x00,
  0x0F, 0x0E, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x73, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0x38, 0x07, 0x0F, 0x0F, 0x03, 0x87,
  0x81, 0xC0, 0xE1, 0xC0, 0x70, 0x38, 0xE0, 0x1E, 0x1C, 0x78, 0x03, 0x87,
  0x1C, 0x00, 0xF3, 0x87, 0x00, 0x1C, 0xE1, 0xC0, 0x07, 0x70, 0xF0, 0x00,
  0xFC, 0x38, 0x00, 0x3E, 0x0E, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0,
  0x01, 0xF8, 0x1C, 0x00, 0xEE, 0x07, 0x80, 0x7B, 0xC0, 0xF8, 0x78, 0x70,
  0x3F, 0xFC, 0x1C, 0x03, 0xFE, 0x07, 0x80, 0x38, 0x00, 0x00, 0x3C, 0xE3,
  0x8E, 0x39, 0xC7, 0x1C, 0x71, 0x86, 0x38, 0xE3, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x04, 0x07,
  0x00, 0xC0, 0xE0, 0x3E, 0x18, 0x01, 0xF3, 0x01, 0x0F, 0xE7, 0xE0, 0x7F,
  0xFC, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0x7B, 0x00, 0x1E, 0x60, 0x07, 0x8E,
  0x01, 0xE0, 0xE0, 0x78, 0x1C, 0x02, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x38,
  0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x0F, 0x00, 0x7F, 0xFB, 0xFF, 0xFF, 0xFE,
  0x77, 0xFF, 0xEF, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xF0, 0x38,
  0x01, 0xC1, 0xE0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0xE0, 0x01,
  0xC3, 0x80, 0x07, 0x1E, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xCF,
  0x00, 0x07, 0x38, 0x00, 0x3C, 0xE0, 0x00, 0xF3, 0x80, 0x03, 0x9E, 0x00,
  0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00, 0x07, 0x9C, 0x00, 0x1E,
  0xF0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x0F, 0x38, 0x00, 0x38, 0xE0,
  0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x03,
  0xC3, 0x80, 0x0E, 0x0E, 0x00, 0x78, 0x38, 0x01, 0xC0, 0xF0, 0x0F, 0x01,
  0xC0, 0x78, 0x07, 0x83, 0xC0, 0x1F, 0x3E, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x7E, 0x0F, 0xE0,
  0xF7, 0x0F, 0x39, 0xF1, 0xDF, 0x1E, 0x60, 0xE2, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0x03,
  0xE0, 0x06, 0x00, 0xF0, 0x02, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xF0, 0x3E,
  0x01, 0xC0, 0x0F, 0x00, 0x80, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x80, 0x07, 0x80, 0xF8, 0x3F, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x61, 0xC0, 0x00,
  0x71, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00,
  0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x07, 0x00,
  0x1C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x07, 0x00, 0x3C, 0x07, 0x80, 0x1C,
  0x03, 0x80, 0x0E, 0x03, 0x80, 0x07, 0x01, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0x80, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x80, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x04, 0x00, 0x7C, 0x03, 0xC0, 0xFC, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x71, 0xFF,
  0x00, 0xE7, 0xFF, 0x01, 0xDC, 0x1F, 0x07, 0xF0, 0x1E, 0x0F, 0x80, 0x1E,
  0x1F, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE3,
  0xC0, 0x01, 0xC7, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x1E, 0x38,
  0x00, 0x3C, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x03, 0xC3, 0x80,
  0x07, 0x07, 0x80, 0x1E, 0x07, 0x00, 0x38, 0x0E, 0x00, 0xF0, 0x1E, 0x03,
  0xC0, 0x1F, 0x1F, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0x03, 0xC0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x38, 0x07, 0x00, 0x1E, 0x03, 0x80, 0x07,
  0x03, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0xC0, 0xE0, 0x01, 0xC0, 0x70, 0x00,
  0xE0, 0x3C, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x78, 0x00, 0xE0, 0x78, 0x00, 0x38, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x9F, 0x00, 0x0F,
  0x87, 0x80, 0x0F, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x1C, 0x07,
  0x00, 0x0F, 0x07, 0x80, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE1,
  0xE0, 0x00, 0x70, 0xF0, 0x00, 0x38, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x1E,
  0x0E, 0x00, 0x0E, 0x07, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0x00, 0xF0, 0x07,
  0x80, 0x7E, 0x1F, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x0F,
  0x83, 0xC0, 0x1C, 0x03, 0xC0, 0x78, 0x03, 0x81, 0xE0, 0x07, 0x03, 0x80,
  0x0F, 0x0F, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00,
  0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x8E, 0x00, 0x0F,
  0x1C, 0x00, 0x1C, 0x38, 0x00, 0x78, 0x70, 0x00, 0xF0, 0xE0, 0x01, 0xE1,
  0xE0, 0x07, 0xC3, 0xC0, 0x1B, 0x83, 0xC0, 0x7E, 0x07, 0xFF, 0xDC, 0x07,
  0xFF, 0x38, 0x03, 0xF8, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x60, 0xFC, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x03, 0x81, 0xF0, 0x7C, 0x1E, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xF8, 0x38,
  0x1E, 0x08, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x60, 0x38, 0x00,
  0x00, 0x18, 0x1C, 0x00, 0x00, 0x07, 0x06, 0x00, 0x3F, 0x01, 0xC3, 0x80,
  0x3F, 0xF0, 0x70, 0xC0, 0x3E, 0x78, 0x1C, 0x70, 0x0E, 0x0E, 0x07, 0x18,
  0x07, 0x03, 0x81, 0xCE, 0x03, 0x80, 0xC0, 0x73, 0x81, 0xC0, 0x70, 0x1C,
  0xC0, 0x70, 0x1C, 0x06, 0x70, 0x38, 0x07, 0x01, 0x9C, 0x0E, 0x01, 0x80,
  0xE7, 0x03, 0x00, 0xE0, 0x39, 0x81, 0xC0, 0x38, 0x0E, 0x60, 0x70, 0x0E,
  0x03, 0x38, 0x1C, 0x03, 0x01, 0xCE, 0x06, 0x01, 0xC0, 0x73, 0x81, 0x80,
  0x70, 0x18, 0xE0, 0x60, 0x3C, 0x0E, 0x38, 0x18, 0x0F, 0x03, 0x0E, 0x06,
  0x07, 0xC1, 0xC3, 0x81, 0xC1, 0xB0, 0xE0, 0xE0, 0x70, 0xCC, 0x78, 0x38,
  0x0F, 0xE3, 0xFC, 0x0E, 0x03, 0xF0, 0x7C, 0x03, 0x80, 0x30, 0x04, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0x60, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x70,
  0xE0, 0x00, 0x38, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E,
  0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x03,
  0x80, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x38, 0x01, 0xE0, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x38, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x1C,
  0x0F, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x07, 0x80, 0x03, 0xC3, 0x80, 0x01,
  0xE3, 0xC0, 0x00, 0xF1, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x0E, 0xF0, 0x00, 0x07, 0x78, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0E, 0x0F, 0xF0, 0x03, 0x80, 0x3E,
  0x00, 0xE0, 0x07, 0x80, 0x78, 0x00, 0xE0, 0x1C, 0x00, 0x3C, 0x07, 0x00,
  0x0F, 0x01, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x3C, 0x00, 0x38, 0x0E,
  0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x78, 0x00, 0xF0,
  0x1C, 0x00, 0x78, 0x07, 0x00, 0x3C, 0x01, 0xC0, 0x3E, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0x80, 0x3E, 0x00, 0xE0,
  0x03, 0x80, 0x38, 0x00, 0xF0, 0x1E, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01,
  0xC0, 0x01, 0xE0, 0x70, 0x00, 0x78, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x07,
  0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x3C, 0x1E, 0x00,
  0x0E, 0x07, 0x00, 0x07, 0x81, 0xC0, 0x03, 0xC0, 0x70, 0x01, 0xF0, 0x1C,
  0x01, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0xF8, 0x0E, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x04, 0x00, 0x7E, 0x1E, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0x87, 0xFC, 0x00, 0x70, 0x0F, 0xC0, 0x0E,
  0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x0F,
  0x01, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x38,
  0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00,
  0x07, 0x87, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x70, 0x70, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x70, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xF0, 0x70,
  0x00, 0x1E, 0x0E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x3C,
  0x0F, 0x00, 0x0F, 0x01, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0xF0, 0x07, 0x00,
  0x7C, 0x00, 0xE0, 0x3F, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0x80, 0x02, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x78, 0x00, 0xFF, 0xC3, 0xC0, 0x07, 0xFE, 0x1C, 0x00, 0x3F,
  0xF0, 0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0x70, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x38, 0x07, 0x80, 0x01, 0xC0,
  0x1E, 0x00, 0x0E, 0x00, 0xF8, 0x00, 0xF0, 0x03, 0xFC, 0x7F, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xF0, 0x0E,
  0x00, 0x03, 0x80, 0x78, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x07, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x38,
  0x03, 0x80, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x78, 0x07, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x0F, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x67, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x0E, 0x00, 0x1E, 0x00, 0xE0, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1E, 0x00, 0xF0, 0x01,
  0xC0, 0x1E, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x1C, 0x07,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x38, 0x1E, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x38, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x1E,
  0x00, 0x00, 0x73, 0xC0, 0x00, 0x07, 0x7C, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0E, 0xFC, 0x00, 0x00, 0xFD, 0xE0, 0x00, 0x0F, 0x8E, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1C, 0x07, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x3C, 0x07, 0x80, 0x03, 0x80, 0x38, 0x00, 0x38,
  0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x38, 0x03, 0xC0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x70, 0x00, 0xE0, 0x07,
  0x00, 0x0E, 0x00, 0xF0, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x0D, 0x80, 0x00, 0x0F,
  0xC0, 0x3B, 0x80, 0x00, 0x3B, 0x80, 0x77, 0x00, 0x00, 0x77, 0x00, 0xEE,
  0x00, 0x01, 0xDC, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x03, 0xB8, 0x00, 0x0E,
  0x70, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x1C, 0xE0, 0x00, 0x73, 0xC0, 0x39,
  0xC0, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x03, 0x8E, 0x01, 0xE7, 0x00, 0x07,
  0x1C, 0x03, 0x8E, 0x00, 0x1C, 0x38, 0x07, 0x1C, 0x00, 0x38, 0xF0, 0x0E,
  0x18, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x70, 0x70, 0x07,
  0x07, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x03,
  0x83, 0x80, 0x70, 0x70, 0x07, 0x07, 0x01, 0xC0, 0xE0, 0x1C, 0x0E, 0x03,
  0x81, 0xC0, 0x38, 0x1C, 0x0E, 0x07, 0x80, 0x70, 0x38, 0x1C, 0x0E, 0x00,
  0xE0, 0x70, 0x70, 0x1C, 0x03, 0xC0, 0xE0, 0xE0, 0x38, 0x07, 0x00, 0xC3,
  0x80, 0x70, 0x0E, 0x01, 0x87, 0x01, 0xE0, 0x1C, 0x03, 0x9C, 0x03, 0x80,
  0x38, 0x07, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0xE0, 0x0E, 0x01, 0xC0, 0x1D,
  0xC0, 0x1C, 0x03, 0x80, 0x3F, 0x00, 0x70, 0x07, 0x00, 0x7E, 0x00, 0xE0,
  0x0E, 0x00, 0xF8, 0x01, 0xC0, 0x38, 0x01, 0xF0, 0x03, 0x80, 0x70, 0x03,
  0xC0, 0x0F, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0xF8, 0x00, 0x0E, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0xF8, 0x00, 0x0E,
  0x00, 0xF8, 0x00, 0x1E, 0x01, 0xDC, 0x00, 0x1C, 0x01, 0xDC, 0x00, 0x1C,
  0x01, 0xDC, 0x00, 0x1C, 0x01, 0xDC, 0x00, 0x1C, 0x01, 0xCE, 0x00, 0x38,
  0x03, 0x8E, 0x00, 0x38, 0x03, 0x8E, 0x00, 0x38, 0x03, 0x8E, 0x00, 0x38,
  0x03, 0x87, 0x00, 0x78, 0x07, 0x87, 0x00, 0x70, 0x07, 0x07, 0x00, 0x70,
  0x07, 0x07, 0x00, 0x70, 0x07, 0x03, 0x80, 0x70, 0x07, 0x03, 0x80, 0xF0,
  0x0E, 0x03, 0x80, 0xE0, 0x0E, 0x03, 0x80, 0xE0, 0x0E, 0x01, 0xC0, 0xE0,
  0x0E, 0x01, 0xC0, 0xE0, 0x0E, 0x01, 0xC1, 0xC0, 0x1C, 0x01, 0xC1, 0xC0,
  0x1C, 0x01, 0xE1, 0xC0, 0x1C, 0x00, 0xE1, 0xC0, 0x1C, 0x00, 0xE1, 0xC0,
  0x3C, 0x00, 0xE3, 0x80, 0x38, 0x00, 0xF3, 0x80, 0x38, 0x00, 0x73, 0x80,
  0x38, 0x00, 0x73, 0x80, 0x38, 0x00, 0x73, 0x80, 0x70, 0x00, 0x77, 0x00,
  0x70, 0x00, 0x3F, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x70, 0x00, 0x3F, 0x00,
  0x70, 0x00, 0x3E, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x07,
  0x80, 0xF0, 0x00, 0x70, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0x1C, 0x38, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E,
  0x38, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x0E, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03,
  0xC7, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0xF0, 0x78, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x80, 0xF0, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x38, 0x7F, 0x80, 0x1C, 0x03, 0xC0, 0x0E, 0x00, 0xF0, 0x0F, 0x00,
  0x38, 0x07, 0x00, 0x1E, 0x03, 0x80, 0x0F, 0x01, 0xC0, 0x07, 0x80, 0xE0,
  0x03, 0xC0, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0xF0, 0x38, 0x00, 0x70, 0x1C,
  0x00, 0x38, 0x1E, 0x00, 0x1C, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x0E, 0x03,
  0x80, 0x0F, 0x01, 0xC0, 0x0F, 0x01, 0xE0, 0x0F, 0x00, 0xE0, 0x1F, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80,
  0xF0, 0x00, 0x70, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xE1, 0xE0, 0x00,
  0x1C, 0x38, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38,
  0x00, 0x01, 0xCF, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x77, 0x80, 0x00, 0x0E,
  0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0xC7,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0xF0, 0x38, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x0F,
  0x00, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x38, 0x7F, 0x80, 0x1C, 0x03, 0xC0,
  0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x38, 0x07, 0x00, 0x1E, 0x03, 0x80, 0x0F,
  0x01, 0xC0, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0x70, 0x00,
  0xF0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x3C, 0x0E, 0x00,
  0x1C, 0x07, 0x00, 0x1E, 0x03, 0x80, 0x1E, 0x01, 0xC0, 0x1F, 0x01, 0xE0,
  0x1F, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x1C,
  0x1E, 0x00, 0x1E, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x03,
  0x80, 0xF0, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x00, 0xE0, 0x1C, 0x00, 0x70,
  0x0E, 0x00, 0x3C, 0x07, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x03, 0xC0, 0x03,
  0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xF0, 0x1E, 0x00, 0xF0, 0x00,
  0x80, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x20, 0x00, 0x78, 0x0E,
  0x00, 0x7C, 0x03, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03,
  0x80, 0x00, 0xE0, 0x78, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x0E, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x3C, 0x0E, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38,
  0x1C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x70, 0x38, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x1C, 0x0F, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x78, 0x0E,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x0E, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x1C, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x70, 0x70, 0x00,
  0xF0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x70, 0x01,
  0xC0, 0x70, 0x03, 0xC0, 0x70, 0x03, 0x80, 0x70, 0x07, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x1E, 0x00, 0x70, 0x1C,
  0x00, 0x70, 0x1C, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x70,
  0x00, 0x70, 0x70, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xE0, 0x00, 0x71, 0xE0,
  0x00, 0x71, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0x73, 0x80, 0x00, 0x73, 0x80,
  0x00, 0x77, 0x00, 0x00, 0x37, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x03,
  0xB8, 0x00, 0x3C, 0x00, 0x1E, 0xE0, 0x01, 0xF0, 0x00, 0x73, 0x80, 0x07,
  0xC0, 0x01, 0xCE, 0x00, 0x1B, 0x00, 0x0F, 0x38, 0x00, 0xEC, 0x00, 0x38,
  0xE0, 0x03, 0xB0, 0x01, 0xE3, 0x80, 0x1C, 0xC0, 0x07, 0x0E, 0x00, 0x73,
  0x00, 0x1C, 0x38, 0x01, 0x8C, 0x00, 0xE0, 0xE0, 0x0E, 0x30, 0x03, 0x83,
  0x80, 0x38, 0xC0, 0x1E, 0x0E, 0x01, 0xC3, 0x00, 0x70, 0x38, 0x07, 0x0C,
  0x01, 0xC0, 0xE0, 0x38, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0xC0, 0x38, 0x0E,
  0x03, 0x83, 0x01, 0xE0, 0x38, 0x1C, 0x0C, 0x07, 0x00, 0xE0, 0x70, 0x30,
  0x3C, 0x03, 0x83, 0x80, 0xC0, 0xE0, 0x0E, 0x0E, 0x03, 0x03, 0x80, 0x38,
  0x30, 0x0C, 0x1C, 0x00, 0xE1, 0xC0, 0x30, 0x70, 0x03, 0x87, 0x00, 0xC3,
  0xC0, 0x0C, 0x38, 0x03, 0x0E, 0x00, 0x30, 0xE0, 0x0C, 0x38, 0x00, 0xC7,
  0x00, 0x31, 0xC0, 0x03, 0x1C, 0x00, 0xC7, 0x00, 0x0C, 0x70, 0x03, 0x3C,
  0x00, 0x33, 0x80, 0x0C, 0xE0, 0x00, 0xCE, 0x00, 0x33, 0x80, 0x03, 0x70,
  0x00, 0xDC, 0x00, 0x0D, 0xC0, 0x03, 0x70, 0x00, 0x36, 0x00, 0x0D, 0x80,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x70, 0x07, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x38, 0x3C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E,
  0x3C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xE0, 0x3C,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x00,
  0x07, 0x80, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xE0, 0x07,
  0x80, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xEF, 0x00, 0x07, 0x1C, 0x00, 0x3C, 0x70, 0x00,
  0xE1, 0xC0, 0x07, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xE0, 0x70, 0x07, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x0E, 0x03, 0x80, 0x38, 0x1C, 0x00, 0xE0,
  0xF0, 0x03, 0x83, 0x80, 0x0E, 0x1E, 0x00, 0x1C, 0x70, 0x00, 0x73, 0x80,
  0x01, 0xCE, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0xE0, 0x70, 0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x07, 0x03, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x01, 0xC1, 0xC0, 0x03,
  0x83, 0x80, 0x0E, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0,
  0x0E, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x70, 0x00,
  0x71, 0xE0, 0x00, 0x73, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x01,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0xF0, 0xF0, 0xE1,
  0xC1, 0xC3, 0x83, 0x83, 0x06, 0x00, 0x7F, 0x06, 0x01, 0xFF, 0x9C, 0x07,
  0xEF, 0x38, 0x1E, 0x07, 0x70, 0x78, 0x06, 0xC1, 0xE0, 0x07, 0x83, 0x80,
  0x0F, 0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x78, 0x00, 0x70, 0xE0, 0x00,
  0xE1, 0xC0, 0x01, 0xC7, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x1C, 0x00, 0x1C,
  0x38, 0x00, 0x38, 0xF0, 0x00, 0x71, 0xE0, 0x01, 0xE3, 0x80, 0x03, 0x87,
  0x00, 0x07, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x78, 0x70,
  0x01, 0xE0, 0xE0, 0x03, 0xC1, 0xE0, 0x0F, 0x83, 0xC0, 0x37, 0x03, 0xC0,
  0xEC, 0x07, 0xC7, 0x98, 0x07, 0xFE, 0x70, 0x07, 0xF0, 0xE0, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0xFE, 0x00, 0xE7, 0xFE, 0x01, 0xDF, 0x7E, 0x07,
  0x70, 0x3C, 0x0E, 0xC0, 0x3C, 0x1F, 0x00, 0x78, 0x3E, 0x00, 0x70, 0x78,
  0x00, 0xE1, 0xE0, 0x01, 0xC3, 0xC0, 0x03, 0x87, 0x80, 0x07, 0x0E, 0x00,
  0x0E, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0xF1, 0xC0, 0x01,
  0xC3, 0x80, 0x03, 0x8F, 0x00, 0x07, 0x1C, 0x00, 0x1E, 0x38, 0x00, 0x38,
  0x70, 0x00, 0x70, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0x87, 0x80, 0x0F, 0x0F,
  0x00, 0x1C, 0x1E, 0x00, 0x78, 0x36, 0x01, 0xE0, 0xEC, 0x07, 0x81, 0xDE,
  0x1F, 0x03, 0x9F, 0xFC, 0x06, 0x1F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xE7, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x02, 0x03, 0xE1, 0xC0, 0x7F, 0xF8, 0x03, 0xFE,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xE3,
  0x80, 0x0F, 0xFC, 0xE0, 0x07, 0xEF, 0x38, 0x03, 0xC0, 0x6E, 0x01, 0xE0,
  0x1B, 0x00, 0xF0, 0x03, 0xC0, 0x38, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x07,
  0x00, 0x0F, 0x03, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x38,
  0x1E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x81, 0xC0, 0x01, 0xC0, 0x70, 0x00,
  0x70, 0x3C, 0x00, 0x1C, 0x0E, 0x00, 0x0F, 0x03, 0x80, 0x03, 0xC0, 0xE0,
  0x00, 0xE0, 0x38, 0x00, 0x78, 0x0E, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x80,
  0xE0, 0x03, 0xC0, 0x38, 0x01, 0xF0, 0x0E, 0x00, 0x7C, 0x03, 0xC0, 0x37,
  0x00, 0x70, 0x1D, 0xC0, 0x1F, 0x1E, 0x60, 0x03, 0xFF, 0x18, 0x00, 0x7F,
  0x0E, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x01,
  0xF3, 0xE0, 0x3C, 0x0E, 0x07, 0x80, 0x70, 0xF0, 0x07, 0x0E, 0x00, 0x71,
  0xC0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x01, 0xE3, 0x80, 0x3C,
  0x70, 0x07, 0x87, 0x03, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0x80,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x20, 0x3E, 0x0E, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3E,
  0x60, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xE1, 0x80, 0x1F, 0xF8, 0xC0, 0x1F, 0xBC, 0xE0, 0x1E,
  0x03, 0x70, 0x1E, 0x01, 0xB8, 0x1E, 0x00, 0x78, 0x0E, 0x00, 0x3C, 0x0F,
  0x00, 0x1E, 0x07, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x03, 0x80, 0x03, 0x81,
  0xC0, 0x01, 0xC1, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x70,
  0x38, 0x00, 0x38, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x0F,
  0x07, 0x00, 0x07, 0x03, 0x80, 0x07, 0x81, 0xC0, 0x03, 0xC0, 0xE0, 0x03,
  0xE0, 0x70, 0x01, 0xF0, 0x38, 0x01, 0xF0, 0x1C, 0x00, 0xF8, 0x0F, 0x00,
  0xDC, 0x03, 0x80, 0xEE, 0x01, 0xF1, 0xEE, 0x00, 0x7F, 0xE7, 0x00, 0x1F,
  0xC3, 0x80, 0x01, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x80, 0x0F, 0x00, 0x70, 0x1F, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x1F,
  0xC0, 0x39, 0xFF, 0x80, 0xEF, 0xBF, 0x07, 0x70, 0x3C, 0x1D, 0x80, 0x70,
  0x7C, 0x01, 0xC1, 0xE0, 0x07, 0x07, 0x80, 0x1C, 0x3C, 0x00, 0x70, 0xF0,
  0x01, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE1, 0xC0, 0x03,
  0x87, 0x00, 0x0E, 0x1C, 0x00, 0x78, 0x70, 0x01, 0xC3, 0xC0, 0x07, 0x0E,
  0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x03, 0xC3, 0x80, 0x0E, 0x1E, 0x00,
  0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x1C, 0x1C, 0x00, 0x70,
  0xF0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0x00,
  0xE0, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x03, 0xC0, 0xE0, 0x0F,
  0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x1C, 0x07, 0x00,
  0x38, 0x1C, 0x00, 0x70, 0x78, 0x01, 0xC1, 0xE0, 0x03, 0x87, 0x80, 0x07,
  0x0E, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0xC0, 0x00, 0xEF,
  0xC0, 0x01, 0xFB, 0x80, 0x03, 0xE7, 0x00, 0x0F, 0x8E, 0x00, 0x1F, 0x1E,
  0x00, 0x3C, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x03, 0x80, 0xF0,
  0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80,
  0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x8F, 0xE0, 0x3F, 0x80, 0x63,
  0xFE, 0x1F, 0xF8, 0x0C, 0xF3, 0xE7, 0xDF, 0x83, 0xB8, 0x1D, 0xC0, 0xF0,
  0x7E, 0x03, 0xB0, 0x0E, 0x0F, 0x80, 0x7C, 0x01, 0xC1, 0xE0, 0x0F, 0x80,
  0x38, 0x3C, 0x01, 0xE0, 0x07, 0x0F, 0x00, 0x3C, 0x00, 0xE1, 0xE0, 0x07,
  0x00, 0x1C, 0x38, 0x00, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x00, 0xE0, 0xE0,
  0x07, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x00, 0x70,
  0xE0, 0x03, 0x80, 0x1E, 0x1C, 0x00, 0x70, 0x03, 0x87, 0x80, 0x1C, 0x00,
  0x70, 0xE0, 0x03, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0x01, 0xC3, 0x80, 0x0E,
  0x00, 0x70, 0x70, 0x03, 0xC0, 0x0E, 0x1E, 0x00, 0x70, 0x01, 0xC3, 0x80,
  0x0E, 0x00, 0x38, 0x70, 0x01, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x01, 0xC1,
  0xC0, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x00,
  0xE1, 0xC0, 0x07, 0x00, 0x3C, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x03, 0x87,
  0xF0, 0x0C, 0x7F, 0xE0, 0x33, 0xEF, 0xC1, 0xDC, 0x0F, 0x07, 0xE0, 0x1C,
  0x1F, 0x00, 0x70, 0x78, 0x01, 0xC1, 0xE0, 0x07, 0x0F, 0x00, 0x1C, 0x3C,
  0x00, 0x70, 0xE0, 0x03, 0xC3, 0x80, 0x0E, 0x1E, 0x00, 0x38, 0x70, 0x00,
  0xE1, 0xC0, 0x03, 0x87, 0x00, 0x1E, 0x1C, 0x00, 0x70, 0xF0, 0x01, 0xC3,
  0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0x87, 0x80,
  0x0E, 0x1C, 0x00, 0x38, 0x70, 0x01, 0xE1, 0xC0, 0x07, 0x07, 0x00, 0x1C,
  0x3C, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x38, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x7C, 0xFC, 0x07, 0x81, 0xE0, 0x78,
  0x07, 0x87, 0x80, 0x1C, 0x38, 0x00, 0xE3, 0xC0, 0x07, 0x1C, 0x00, 0x39,
  0xE0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x77, 0x80, 0x03, 0xB8, 0x00,
  0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xB8,
  0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x0F, 0x70, 0x00, 0x73, 0x80, 0x07,
  0x9C, 0x00, 0x38, 0xE0, 0x03, 0xC7, 0x80, 0x1C, 0x1C, 0x01, 0xE0, 0xF0,
  0x1E, 0x03, 0xE3, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x30, 0x00,
  0x00, 0x70, 0xFE, 0x00, 0x1C, 0xFF, 0xC0, 0x06, 0x79, 0xF8, 0x03, 0x98,
  0x1E, 0x00, 0xEC, 0x03, 0xC0, 0x3E, 0x00, 0x70, 0x0F, 0x80, 0x1C, 0x03,
  0xC0, 0x07, 0x01, 0xF0, 0x01, 0xC0, 0x78, 0x00, 0x70, 0x1E, 0x00, 0x1C,
  0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0x70, 0x38, 0x00,
  0x3C, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x70,
  0x00, 0x38, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x03, 0xC0,
  0xF0, 0x00, 0xE0, 0x3C, 0x00, 0x38, 0x0F, 0x00, 0x1C, 0x03, 0xC0, 0x0F,
  0x00, 0xF8, 0x07, 0x80, 0x76, 0x03, 0xC0, 0x1C, 0xE1, 0xF0, 0x07, 0x3F,
  0xF8, 0x01, 0xC7, 0xF8, 0x00, 0x70, 0x20, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x86, 0x01, 0xFF, 0x8C, 0x07, 0xCF, 0x38, 0x1E, 0x07, 0x70, 0x78,
  0x06, 0xE1, 0xE0, 0x07, 0x83, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1C, 0x00,
  0x3C, 0x78, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC7, 0x80, 0x03,
  0x8E, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0xF0, 0x00, 0x71,
  0xC0, 0x00, 0xE3, 0x80, 0x03, 0xC7, 0x00, 0x07, 0x0E, 0x00, 0x1E, 0x1C,
  0x00, 0x3C, 0x38, 0x00, 0x78, 0x70, 0x01, 0xF0, 0xE0, 0x07, 0xC1, 0xC0,
  0x0F, 0x83, 0xC0, 0x37, 0x03, 0x80, 0xEE, 0x07, 0xC7, 0xB8, 0x07, 0xFE,
  0x70, 0x07, 0xF0, 0xE0, 0x01, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x8F, 0xC0,
  0xC7, 0xF0, 0x33, 0xFC, 0x1D, 0xC0, 0x07, 0x60, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFC,
  0x1F, 0x8F, 0x83, 0xC0, 0x20, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x40,
  0x0F, 0x0F, 0x07, 0xC1, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x50, 0x00, 0x01,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x07,
  0xFF, 0x7F, 0xF9, 0xFF, 0xE0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x3C, 0x40, 0xFF, 0x01, 0xFC, 0x00, 0x80, 0x00, 0x07, 0x00, 0x1E, 0x0E,
  0x00, 0x38, 0x3C, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0,
  0x07, 0x03, 0x80, 0x0E, 0x0F, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00,
  0x70, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E,
  0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x70, 0x78, 0x00, 0xE0, 0xE0, 0x01, 0xC1,
  0xC0, 0x03, 0x83, 0x80, 0x0F, 0x07, 0x00, 0x1C, 0x1E, 0x00, 0x38, 0x38,
  0x00, 0xF0, 0x70, 0x01, 0xE0, 0xE0, 0x07, 0x81, 0xC0, 0x1F, 0x03, 0x80,
  0x3E, 0x07, 0x80, 0xDC, 0x0F, 0x8F, 0x38, 0x0F, 0xFC, 0x60, 0x0F, 0xF0,
  0xC0, 0x03, 0x00, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0xE0, 0x00, 0xEE,
  0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x38, 0xF0, 0x03, 0x87, 0x00, 0x70,
  0x70, 0x07, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x03, 0xC0, 0x70, 0x38, 0x07, 0x07, 0x80, 0x70, 0x70, 0x07, 0x0F,
  0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x73,
  0x80, 0x07, 0x38, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x07,
  0x80, 0x1F, 0xC0, 0x0F, 0x00, 0x3B, 0x80, 0x1E, 0x00, 0x77, 0x00, 0x7C,
  0x01, 0xCE, 0x00, 0xF8, 0x03, 0x9C, 0x03, 0xF0, 0x0F, 0x38, 0x07, 0xE0,
  0x1C, 0x70, 0x1D, 0xC0, 0x38, 0xE0, 0x3B, 0x80, 0xE1, 0xC0, 0x67, 0x01,
  0xC3, 0x81, 0xCE, 0x07, 0x07, 0x03, 0x1C, 0x0E, 0x0E, 0x0E, 0x38, 0x1C,
  0x1C, 0x1C, 0x70, 0x70, 0x38, 0x70, 0xE0, 0xE0, 0x70, 0xE1, 0xC3, 0x80,
  0xE1, 0x83, 0x87, 0x01, 0xC7, 0x07, 0x0E, 0x03, 0x8E, 0x0E, 0x38, 0x07,
  0x38, 0x1C, 0x70, 0x0E, 0x70, 0x39, 0xC0, 0x1D, 0xC0, 0x73, 0x80, 0x3B,
  0x80, 0xE6, 0x00, 0x66, 0x01, 0xDC, 0x00, 0xDC, 0x03, 0xB8, 0x01, 0xB8,
  0x07, 0xE0, 0x03, 0x60, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x07, 0x80, 0xE0, 0x07, 0x80, 0x70, 0x03, 0x80, 0x3C, 0x03, 0x80,
  0x0E, 0x03, 0xC0, 0x07, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x00, 0xE1, 0xE0,
  0x00, 0x70, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0x70,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x3D,
  0xC0, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x0E,
  0x0E, 0x00, 0x0E, 0x03, 0x80, 0x0F, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x07, 0x80, 0x1C, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0,
  0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x38, 0x03, 0xC0, 0x01, 0xC0, 0x1C,
  0x00, 0x0E, 0x01, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x01, 0x80, 0xF0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x70, 0x78, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x27, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x04, 0x00, 0x00,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFC, 0x7F, 0x8F, 0xC0, 0x3F, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0x08, 0x00,
};

const GFXglyph NotoSans_Condensed_LightItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 13, 41, 13, 1, -41 },
  { 68, 14, 15, 18, 6, -41 },
  { 95, 27, 41, 27, 1, -41 },
  { 234, 24, 47, 24, 1, -44 },
  { 375, 31, 43, 36, 3, -42 },
  { 542, 26, 43, 27, 0, -42 },
  { 682, 6, 15, 10, 6, -41 },
  { 694, 16, 50, 15, 2, -41 },
  { 794, 17, 50, 15, -4, -41 },
  { 901, 19, 20, 23, 6, -44 },
  { 949, 22, 27, 27, 3, -34 },
  { 1024, 9, 13, 11, -3, -6 },
  { 1039, 13, 3, 16, 1, -17 },
  { 1044, 5, 5, 11, 1, -5 },
  { 1048, 26, 41, 18, -3, -41 },
  { 1182, 22, 43, 24, 2, -42 },
  { 1301, 13, 41, 24, 7, -41 },
  { 1368, 25, 42, 24, -1, -42 },
  { 1500, 24, 43, 24, 0, -42 },
  { 1629, 25, 42, 24, -1, -42 },
  { 1761, 25, 42, 24, 0, -41 },
  { 1893, 23, 43, 24, 2, -42 },
  { 2017, 23, 41, 24, 3, -41 },
  { 2135, 25, 43, 24, 0, -42 },
  { 2270, 23, 43, 24, 1, -42 },
  { 2394, 10, 31, 11, 1, -31 },
  { 2433, 14, 38, 11, -3, -31 },
  { 2500, 22, 25, 27, 3, -33 },
  { 2569, 22, 15, 27, 3, -28 },
  { 2611, 22, 25, 27, 3, -33 },
  { 2680, 18, 42, 18, 2, -42 },
  { 2775, 34, 47, 37, 2, -42 },
  { 2975, 25, 42, 24, -4, -42 },
  { 3107, 26, 41, 27, 1, -41 },
  { 3241, 26, 43, 25, 3, -42 },
  { 3381, 27, 41, 29, 1, -41 },
  { 3520, 25, 41, 23, 1, -41 },
  { 3649, 25, 41, 22, 1, -41 },
  { 3778, 29, 43, 31, 3, -42 },
  { 3934, 30, 41, 31, 1, -41 },
  { 4088, 20, 41, 14, -2, -41 },
  { 4191, 22, 52, 12, -9, -41 },
  { 4334, 28, 41, 25, 1, -41 },
  { 4478, 16, 41, 21, 1, -41 },
  { 4560, 39, 41, 39, 1, -41 },
  { 4760, 32, 41, 32, 1, -41 },
  { 4924, 27, 43, 32, 3, -42 },
  { 5070, 25, 41, 25, 1, -41 },
  { 5199, 27, 52, 32, 3, -42 },
  { 5375, 25, 41, 26, 1, -41 },
  { 5504, 26, 43, 23, -1, -42 },
  { 5644, 21, 41, 22, 5, -41 },
  { 5752, 28, 42, 30, 3, -41 },
  { 5899, 24, 41, 25, 5, -41 },
  { 6022, 38, 41, 40, 6, -41 },
  { 6217, 30, 41, 23, -3, -41 },
  { 6371, 22, 41, 22, 5, -41 },
  { 6484, 27, 41, 22, -2, -41 },
  { 6623, 21, 51, 16, -1, -42 },
  { 6757, 9, 41, 19, 6, -41 },
  { 6804, 22, 51, 16, -4, -42 },
  { 6945, 23, 22, 26, 2, -41 },
  { 7009, 19, 3, 18, -5, 5 },
  { 7017, 7, 9, 14, 8, -44 },
  { 7025, 23, 32, 26, 2, -31 },
  { 7117, 23, 45, 26, 1, -44 },
  { 7247, 19, 32, 20, 2, -31 },
  { 7323, 26, 45, 26, 2, -44 },
  { 7470, 20, 32, 23, 2, -31 },
  { 7550, 28, 58, 13, -7, -44 },
  { 7753, 25, 45, 26, 0, -31 },
  { 7894, 22, 44, 25, 1, -44 },
  { 8015, 12, 42, 11, 1, -42 },
  { 8078, 21, 56, 11, -8, -42 },
  { 8225, 23, 44, 21, 1, -44 },
  { 8352, 12, 44, 11, 1, -44 },
  { 8418, 35, 31, 38, 1, -31 },
  { 8554, 22, 31, 25, 1, -31 },
  { 8640, 21, 32, 25, 2, -31 },
  { 8724, 26, 44, 26, -2, -31 },
  { 8867, 23, 45, 26, 2, -31 },
  { 8997, 18, 31, 17, 1, -31 },
  { 9067, 19, 32, 19, 0, -31 },
  { 9143, 14, 39, 14, 2, -38 },
  { 9212, 23, 32, 26, 2, -31 },
  { 9304, 20, 31, 20, 3, -31 },
  { 9382, 31, 31, 32, 4, -31 },
  { 9503, 25, 31, 21, -2, -31 },
  { 9600, 29, 45, 20, -6, -31 },
  { 9764, 21, 31, 18, -2, -31 },
  { 9846, 21, 50, 19, 1, -41 },
  { 9978, 3, 58, 24, 11, -44 },
  { 10000, 20, 50, 19, -3, -41 },
  { 10125, 22, 7, 27, 3, -24 },
};

const GFXfont NotoSans_Condensed_LightItalic58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic58pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC58PT7B_H_
