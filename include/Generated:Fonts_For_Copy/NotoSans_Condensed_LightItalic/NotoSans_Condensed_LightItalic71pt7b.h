#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC71PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x1E, 0x07, 0x8F, 0x03, 0xC7,
  0x81, 0xE3, 0xC0, 0xF1, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E,
  0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x07, 0x8F, 0x03, 0xC7, 0x01, 0xC3, 0x80,
  0xE1, 0xC0, 0x70, 0xE0, 0x38, 0x60, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xF0,
  0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x3C,
  0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x70, 0x00, 0x03, 0x80, 0x78, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x03, 0x80, 0x78, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFD, 0x9F, 0xC0, 0x3E, 0x1C, 0x1C, 0x01,
  0xE0, 0xE0, 0x20, 0x1E, 0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x0F, 0x03,
  0x80, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0xF0, 0x30, 0x00, 0x07, 0x83, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x07, 0x86, 0x00, 0x00, 0x3E, 0x30, 0x00, 0x00, 0xFB,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xDF, 0x80, 0x00, 0x06, 0x7C, 0x00, 0x00, 0x71, 0xF0, 0x00, 0x03,
  0x87, 0x80, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0xC0, 0xF0, 0x00, 0x06, 0x07,
  0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x1C, 0x0F, 0x00,
  0x00, 0xC0, 0x78, 0x00, 0x06, 0x03, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x03,
  0x83, 0xE0, 0x40, 0x18, 0x3E, 0x03, 0xC0, 0xC3, 0xE0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x07, 0xFC, 0x00, 0x07, 0x80,
  0x3F, 0xF8, 0x00, 0x1C, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0x07, 0x03, 0xC0,
  0x07, 0x80, 0x3C, 0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0xF0, 0x07,
  0x80, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x3C, 0x03, 0x80, 0x0E, 0x00, 0xF0, 0x1E, 0x00, 0x38,
  0x03, 0xC0, 0x70, 0x01, 0xE0, 0x0E, 0x03, 0xC0, 0x07, 0x00, 0x38, 0x0E,
  0x00, 0x1C, 0x00, 0xE0, 0x78, 0x00, 0x70, 0x07, 0x83, 0xC0, 0x01, 0xC0,
  0x1E, 0x0E, 0x00, 0x0F, 0x00, 0x70, 0x78, 0x00, 0x3C, 0x01, 0xC1, 0xC0,
  0x00, 0xE0, 0x0F, 0x0F, 0x07, 0xE3, 0x80, 0x38, 0x38, 0x3F, 0xCE, 0x00,
  0xE1, 0xE3, 0xFF, 0xB8, 0x07, 0x8F, 0x0F, 0x1E, 0xE0, 0x1C, 0x38, 0x78,
  0x3B, 0xC0, 0xF1, 0xE3, 0xC0, 0xFF, 0x03, 0x87, 0x0E, 0x03, 0xDC, 0x1E,
  0x3C, 0x78, 0x07, 0x7F, 0xF0, 0xE1, 0xC0, 0x1C, 0xFF, 0x87, 0x0F, 0x00,
  0xF1, 0xF8, 0x3C, 0x38, 0x03, 0xC0, 0x00, 0xE0, 0xE0, 0x0F, 0x00, 0x07,
  0x83, 0x80, 0x38, 0x00, 0x1C, 0x1E, 0x00, 0xE0, 0x00, 0xF0, 0x70, 0x03,
  0x80, 0x03, 0x81, 0xC0, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x78, 0x00, 0xF0,
  0x3C, 0x01, 0xE0, 0x03, 0x80, 0xF0, 0x07, 0x00, 0x1E, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x0E, 0x00, 0xF0, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x1E, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x78, 0x03, 0xC0, 0x0E, 0x01, 0xC0,
  0x0E, 0x00, 0x38, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x38, 0x01, 0xC0, 0x03,
  0xC1, 0xE0, 0x0F, 0x00, 0x07, 0x9F, 0x00, 0x78, 0x00, 0x1F, 0xF8, 0x01,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x01,
  0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x1C, 0x3E,
  0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x03, 0xE3, 0xE0, 0x0F, 0x07, 0x81, 0xE0, 0x1E, 0x0F, 0x81, 0xE0,
  0x1E, 0x1F, 0x00, 0xF0, 0x1C, 0x1E, 0x00, 0xF0, 0x3C, 0x3C, 0x00, 0x78,
  0x3C, 0x3C, 0x00, 0x78, 0x78, 0x78, 0x00, 0x7C, 0x78, 0x78, 0x00, 0x3C,
  0xF0, 0x78, 0x00, 0x3C, 0xF0, 0x70, 0x00, 0x1F, 0xE0, 0x70, 0x00, 0x1F,
  0xC0, 0xF0, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x3F, 0x80, 0x78, 0x00, 0x7B,
  0xC0, 0x7C, 0x00, 0xF3, 0xC0, 0x3E, 0x03, 0xE1, 0xE0, 0x3F, 0xFF, 0xC1,
  0xE0, 0x1F, 0xFF, 0x81, 0xF0, 0x07, 0xFE, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x38,
  0x78, 0x78, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x18, 0x07, 0x00, 0x7C, 0x1C, 0x00, 0xFC, 0x38, 0x00,
  0x7E, 0x70, 0x0C, 0x3F, 0xE7, 0xF8, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xEE, 0x00, 0x07, 0x8E, 0x00, 0x1E,
  0x1C, 0x00, 0x78, 0x3C, 0x03, 0xE0, 0x38, 0x07, 0x80, 0x78, 0x06, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01,
  0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03,
  0x80, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x79,
  0xFF, 0xFF, 0xF9, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0x87, 0xE0,
  0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x78, 0x07, 0x80,
  0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xC1, 0xE0, 0x00,
  0x38, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x78,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C,
  0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x70, 0x00,
  0x0F, 0x0E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xE0, 0x3C,
  0x00, 0x78, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0xF0,
  0x01, 0xF0, 0x7C, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x0F, 0xDE, 0x1F, 0x1C, 0x3E, 0x3C,
  0xFC, 0x3C, 0xF0, 0x3C, 0x60, 0x38, 0x40, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xE0, 0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0,
  0x02, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x40, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFC, 0x0F, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x06, 0x00, 0x0F, 0x80, 0x08, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x30, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x03, 0xBC, 0x00,
  0x00, 0x0E, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xE0,
  0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1C, 0x01,
  0xE0, 0x00, 0x78, 0x03, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC3, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x08, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFE, 0x02, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x1F, 0xE0, 0x03, 0xC7, 0xFF, 0x80, 0x3C, 0xFF, 0xFC, 0x03, 0x9E, 0x07,
  0xC0, 0x7B, 0x80, 0x3E, 0x07, 0xF0, 0x01, 0xE0, 0x7E, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0xF8, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1E, 0x0E, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3C,
  0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0xF0, 0x07, 0x80, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x03, 0xE0, 0x7C,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x07, 0x80, 0x03, 0xC0, 0x1C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x78, 0xFC,
  0x00, 0x00, 0xF7, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7E, 0x1F, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x1F, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0xC0,
  0x03, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x38, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x0F, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x3F, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x0F,
  0x80, 0x1E, 0x01, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0xF0, 0x3C, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0xFE,
  0x07, 0x80, 0x1D, 0xC0, 0x7C, 0x07, 0x9C, 0x03, 0xFF, 0xFB, 0xC0, 0x1F,
  0xFE, 0x3C, 0x00, 0xFF, 0xC3, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x08, 0x03, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x1F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x3E, 0x0F, 0xC0, 0x60, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x0E, 0x00, 0x3C, 0x0E, 0x00, 0x1F, 0xFC, 0x07, 0x07, 0x80,
  0x1F, 0xFE, 0x01, 0xC1, 0xC0, 0x0F, 0x87, 0x80, 0x70, 0xF0, 0x07, 0x80,
  0xE0, 0x1C, 0x38, 0x03, 0xC0, 0x78, 0x07, 0x0E, 0x00, 0xE0, 0x1C, 0x01,
  0xC7, 0x80, 0x70, 0x07, 0x00, 0xF1, 0xC0, 0x3C, 0x01, 0xC0, 0x3C, 0x70,
  0x0E, 0x00, 0xF0, 0x0E, 0x3C, 0x07, 0x80, 0x38, 0x03, 0x8E, 0x01, 0xC0,
  0x0E, 0x00, 0xE3, 0x80, 0x70, 0x03, 0x80, 0x38, 0xE0, 0x3C, 0x01, 0xE0,
  0x1E, 0x78, 0x0E, 0x00, 0x70, 0x07, 0x1C, 0x03, 0x80, 0x1C, 0x01, 0xC7,
  0x01, 0xE0, 0x0F, 0x00, 0x71, 0xC0, 0x78, 0x03, 0xC0, 0x38, 0x70, 0x1C,
  0x00, 0xE0, 0x0E, 0x1C, 0x07, 0x00, 0x78, 0x07, 0x8F, 0x01, 0xC0, 0x1E,
  0x01, 0xC3, 0xC0, 0x70, 0x07, 0x80, 0x70, 0xF0, 0x1C, 0x03, 0xE0, 0x38,
  0x3C, 0x07, 0x01, 0xF8, 0x1E, 0x0F, 0x01, 0xE0, 0x6E, 0x07, 0x03, 0xC0,
  0x3C, 0x39, 0xC7, 0x80, 0xF0, 0x0F, 0xFC, 0x7F, 0xC0, 0x3C, 0x01, 0xFE,
  0x1F, 0xE0, 0x07, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x40, 0x00,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x73, 0xC0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0xF0,
  0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x70, 0x07,
  0x00, 0x03, 0xC0, 0x1C, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x78, 0x01, 0xE0,
  0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x0E, 0x78, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3C, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x7C, 0x01, 0xE0, 0x00, 0xF8, 0x01, 0xC0, 0x01, 0xF0, 0x03, 0xC0,
  0x03, 0xE0, 0x03, 0xC0, 0x3F, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x3F, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0xF0, 0x0E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x1F, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x78, 0x1F, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xF0, 0x1E, 0x00, 0x0F, 0xC0, 0x06, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x1C, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3C, 0x01, 0xFC, 0x00,
  0x0F, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x01, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xF0, 0x1E,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x01, 0xF0,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x78, 0x00, 0x3F,
  0x00, 0x1E, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x3F, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0x04,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0xFF, 0xF0, 0x78, 0x00, 0x1F, 0xFF, 0x07, 0x80,
  0x01, 0xFF, 0xE0, 0x78, 0x00, 0x1F, 0xFE, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00,
  0x70, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x0E, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x03, 0x80, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x01,
  0xC0, 0x0F, 0x80, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x07,
  0x8F, 0x80, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x00, 0x1E, 0xFC, 0x00, 0x00,
  0x03, 0xDF, 0x80, 0x00, 0x00, 0xF7, 0xF8, 0x00, 0x00, 0x1F, 0xEF, 0x00,
  0x00, 0x03, 0xF9, 0xE0, 0x00, 0x00, 0x7E, 0x3C, 0x00, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xDE, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xDC, 0x00, 0x77, 0x80, 0x00, 0x03, 0xBC, 0x00, 0x77, 0x80, 0x00, 0x07,
  0xBC, 0x00, 0xF3, 0x80, 0x00, 0x07, 0x3C, 0x00, 0xF3, 0x80, 0x00, 0x0F,
  0x38, 0x00, 0xF3, 0x80, 0x00, 0x0E, 0x78, 0x00, 0xE3, 0x80, 0x00, 0x1E,
  0x78, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x78, 0x01, 0xE3, 0x80, 0x00, 0x3C,
  0x78, 0x01, 0xE3, 0xC0, 0x00, 0x38, 0x70, 0x01, 0xE3, 0xC0, 0x00, 0x78,
  0xF0, 0x01, 0xC3, 0xC0, 0x00, 0x70, 0xF0, 0x03, 0xC3, 0xC0, 0x00, 0xF0,
  0xF0, 0x03, 0xC3, 0xC0, 0x00, 0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0x01, 0xE0,
  0xE0, 0x03, 0xC3, 0xC0, 0x01, 0xC1, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0xC1,
  0xE0, 0x07, 0x81, 0xC0, 0x03, 0x81, 0xE0, 0x07, 0x81, 0xC0, 0x07, 0x81,
  0xE0, 0x07, 0x81, 0xC0, 0x07, 0x03, 0xC0, 0x07, 0x81, 0xC0, 0x0F, 0x03,
  0xC0, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0x0E, 0x01, 0xE0, 0x38, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x78, 0x07,
  0x80, 0x1E, 0x01, 0xE0, 0x70, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0xF0, 0x07,
  0x00, 0x1E, 0x00, 0xE0, 0xE0, 0x0F, 0x00, 0x1C, 0x00, 0xE1, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xE1, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE3, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE3, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xE7, 0x80, 0x1E,
  0x00, 0x38, 0x00, 0xF7, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xFF, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xFC, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0xFC, 0x00, 0x00, 0x70, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x03, 0xF0, 0x00,
  0x03, 0xC0, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x1F, 0xE0, 0x00, 0x0F, 0x00,
  0x3F, 0xC0, 0x00, 0x1C, 0x00, 0x7F, 0x80, 0x00, 0x78, 0x00, 0xE7, 0x00,
  0x00, 0xF0, 0x01, 0xCF, 0x00, 0x01, 0xE0, 0x07, 0x9E, 0x00, 0x03, 0x80,
  0x0F, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x00, 0x38, 0x78,
  0x00, 0x3C, 0x00, 0x70, 0xF0, 0x00, 0x78, 0x01, 0xE1, 0xE0, 0x00, 0xE0,
  0x03, 0xC1, 0xC0, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x07, 0x80, 0x0E, 0x07,
  0x80, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x0E, 0x00, 0x38,
  0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x03, 0x80,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x1E, 0x00, 0xF0, 0x1E,
  0x00, 0x3C, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x78, 0x00, 0xE0,
  0x03, 0x80, 0xF0, 0x03, 0xC0, 0x07, 0x81, 0xC0, 0x07, 0x80, 0x0F, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1C, 0x00, 0x1C, 0x1E, 0x00, 0x78,
  0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x70, 0x01, 0xE0, 0x00, 0xF1,
  0xE0, 0x03, 0xC0, 0x01, 0xE3, 0xC0, 0x07, 0x00, 0x01, 0xC7, 0x80, 0x1E,
  0x00, 0x03, 0xCE, 0x00, 0x3C, 0x00, 0x07, 0x9C, 0x00, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0xF0, 0x00, 0x0E, 0xF0, 0x01, 0xC0, 0x00, 0x1F, 0xE0, 0x07,
  0x80, 0x00, 0x3F, 0x80, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x00,
  0x7E, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x70, 0x00, 0x01, 0xF8, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03, 0xC7, 0xC0,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x0F, 0x3E,
  0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x00, 0x3C, 0xF8, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xC0, 0x3F, 0x80, 0x07,
  0x80, 0x1F, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xC0, 0x00, 0xF8, 0x07, 0x80,
  0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0xC0, 0x3C, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x78, 0x07, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x7C, 0x01, 0xE0, 0x01, 0xF0,
  0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x3F, 0x00, 0x1E, 0x07, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03, 0xC7, 0xC0, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x0F, 0x3E, 0x00,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x7C, 0xF0,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00,
  0x3C, 0xF8, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x1F, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xC0, 0x3F, 0x80, 0x07, 0x80, 0x1F,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0,
  0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x07,
  0x80, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x0F, 0x80, 0x78,
  0x00, 0x3E, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xF0, 0x03, 0xC0,
  0x0F, 0xC0, 0x0F, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x38, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80,
  0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x80, 0x70, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x03,
  0xF0, 0x01, 0xC0, 0x0F, 0x80, 0x00, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xF0, 0x10, 0x00, 0x07, 0xC0, 0x30, 0x00, 0x3F, 0x00, 0x7C, 0x01, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x38,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x07, 0xC7, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xF8, 0x70, 0x00, 0x03,
  0xC1, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x1E,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80,
  0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x01, 0xE0,
  0x01, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x78, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0xC0,
  0x00, 0x78, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x77, 0x00,
  0x03, 0xE3, 0x80, 0x01, 0xEE, 0x00, 0x07, 0x87, 0x00, 0x03, 0xDC, 0x00,
  0x0F, 0x0E, 0x00, 0x07, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x70, 0x00,
  0x78, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0xF1, 0xC0, 0x03,
  0xC0, 0xE0, 0x01, 0xE3, 0x80, 0x07, 0x81, 0xC0, 0x03, 0x87, 0x00, 0x1E,
  0x03, 0x80, 0x0F, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0xF0,
  0x0E, 0x00, 0x78, 0x38, 0x01, 0xE0, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0xC0,
  0x38, 0x03, 0xC0, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x81, 0xC0, 0x1E, 0x00,
  0xE0, 0x0E, 0x03, 0x80, 0x78, 0x01, 0xC0, 0x3C, 0x07, 0x00, 0xF0, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x07, 0x01, 0xE0, 0x1C, 0x07, 0x80, 0x0E,
  0x03, 0xC0, 0x38, 0x0F, 0x00, 0x1C, 0x07, 0x00, 0x70, 0x3C, 0x00, 0x38,
  0x1E, 0x00, 0xE0, 0x78, 0x00, 0x70, 0x38, 0x01, 0xC1, 0xE0, 0x00, 0xE0,
  0xF0, 0x03, 0x83, 0xC0, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x80, 0x03, 0x87,
  0x80, 0x0E, 0x1E, 0x00, 0x07, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x1C,
  0x00, 0x38, 0xF0, 0x00, 0x1C, 0x78, 0x00, 0x71, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0xE3, 0x80, 0x00, 0x73, 0xC0, 0x01, 0xCF, 0x00, 0x00, 0xE7, 0x80,
  0x03, 0x9E, 0x00, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x03, 0xBC, 0x00,
  0x0E, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x7C, 0x00, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x07,
  0x1E, 0x00, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x00, 0x78, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x83, 0xC0,
  0x01, 0xF0, 0x78, 0x00, 0x3C, 0x07, 0x00, 0x0F, 0x80, 0xF0, 0x01, 0xE0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x1E, 0x00, 0x1C, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00,
  0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xF0, 0x1E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1C,
  0x38, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x78, 0x07, 0x80, 0x07,
  0x80, 0x70, 0x00, 0x38, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1E,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x0F, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0xF8, 0x3C, 0x1F, 0x07,
  0x83, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0xE0, 0x00, 0x0F, 0xF0,
  0x38, 0x00, 0xFF, 0xE3, 0xC0, 0x1F, 0xFF, 0x1C, 0x01, 0xF8, 0x3C, 0xE0,
  0x1F, 0x80, 0x67, 0x00, 0xF0, 0x03, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0xF8,
  0x00, 0x7C, 0x07, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xC0, 0x00,
  0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x78, 0x3C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x3F, 0x01, 0xE0, 0x01,
  0xF8, 0x0F, 0x00, 0x1F, 0x80, 0x78, 0x01, 0xDC, 0x03, 0xE0, 0x1C, 0xE0,
  0x0F, 0x81, 0xCF, 0x00, 0x7F, 0xFC, 0x70, 0x01, 0xFF, 0xC3, 0x80, 0x07,
  0xFC, 0x1C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0xFF, 0x00, 0x0F, 0x0F, 0xFC,
  0x00, 0x79, 0xFF, 0xF0, 0x03, 0xDF, 0x07, 0xC0, 0x1E, 0xE0, 0x1E, 0x00,
  0xEE, 0x00, 0x78, 0x0F, 0xE0, 0x03, 0xC0, 0x7E, 0x00, 0x1E, 0x03, 0xF0,
  0x00, 0xF0, 0x1F, 0x00, 0x03, 0x80, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0xF0, 0x7C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x3C, 0x1C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x03,
  0xC0, 0x76, 0x00, 0x3E, 0x03, 0xB8, 0x03, 0xE0, 0x1D, 0xE0, 0x3E, 0x01,
  0xC7, 0xFF, 0xE0, 0x0E, 0x1F, 0xFE, 0x00, 0x70, 0x7F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFC, 0x06, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x01, 0x80,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x78, 0x00, 0x0F,
  0xFE, 0x3C, 0x00, 0x1F, 0xFF, 0x9E, 0x00, 0x1F, 0x83, 0xCE, 0x00, 0x1F,
  0x80, 0x77, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F,
  0x80, 0x07, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x07,
  0xC0, 0x0F, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xE0, 0x01,
  0xF8, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0x78, 0x01, 0xDC, 0x00, 0x3E, 0x01,
  0xCE, 0x00, 0x0F, 0x81, 0xE7, 0x00, 0x07, 0xFF, 0xE7, 0x80, 0x01, 0xFF,
  0xE3, 0x80, 0x00, 0x7F, 0xC1, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0x83, 0xE0,
  0x1F, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x07, 0x80, 0x07, 0x87, 0x80, 0x03, 0x83, 0xC0, 0x03, 0xC3, 0xC0, 0x01,
  0xE1, 0xE0, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0x78, 0x01,
  0xF0, 0x3C, 0x07, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x07, 0xE8, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x10, 0x0F, 0xC0, 0x38,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0x82, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0x1F, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x0E, 0x00, 0x0F, 0xFE, 0x1C, 0x00,
  0x7F, 0xFE, 0x78, 0x01, 0xF8, 0x1C, 0xE0, 0x07, 0xE0, 0x1D, 0xC0, 0x0F,
  0x00, 0x1B, 0x80, 0x3E, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x7E, 0x01, 0xE0,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x3E, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01,
  0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0xF8, 0x07, 0x80, 0x03, 0xF0, 0x07,
  0x80, 0x07, 0xE0, 0x0F, 0x00, 0x1F, 0xC0, 0x1E, 0x00, 0x77, 0x00, 0x3E,
  0x01, 0xDE, 0x00, 0x3E, 0x07, 0xBC, 0x00, 0x7F, 0xFE, 0x78, 0x00, 0x7F,
  0xF8, 0xE0, 0x00, 0x7F, 0xC1, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0,
  0x01, 0x00, 0x03, 0xC0, 0x03, 0x00, 0x1F, 0x00, 0x07, 0xE1, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0xFF, 0x00, 0x1C,
  0x7F, 0xF8, 0x07, 0x9F, 0xFF, 0x00, 0xF7, 0x83, 0xF0, 0x1D, 0xE0, 0x1E,
  0x03, 0xB0, 0x03, 0xC0, 0xFE, 0x00, 0x38, 0x1F, 0x80, 0x07, 0x03, 0xE0,
  0x00, 0xE0, 0x7C, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF0,
  0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x70, 0x38, 0x00,
  0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07,
  0x80, 0x01, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xE0, 0xF0, 0x00, 0x38, 0x1C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0,
  0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x3C,
  0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x70, 0x00, 0x00, 0x08, 0x00, 0x78, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x47, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x0E, 0x00, 0x1E, 0x01, 0xE0, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x1C, 0x01, 0xF0, 0x03,
  0xC0, 0x3E, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x0F,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0x87, 0xC0, 0x00,
  0x78, 0x78, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x0F, 0x3E,
  0x00, 0x00, 0xF7, 0xF0, 0x00, 0x0E, 0xFF, 0x00, 0x00, 0xEE, 0xF0, 0x00,
  0x1F, 0xCF, 0x00, 0x01, 0xF8, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xE0,
  0x78, 0x00, 0x1E, 0x03, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0,
  0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x01, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x70, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x0F,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0xFF,
  0x00, 0xFF, 0x00, 0x3C, 0x7F, 0xF0, 0x7F, 0xF8, 0x07, 0x9F, 0xFE, 0x1F,
  0xFF, 0x00, 0xE7, 0x83, 0xE7, 0x83, 0xF0, 0x1D, 0xC0, 0x3D, 0xE0, 0x1E,
  0x03, 0xB0, 0x07, 0xB8, 0x03, 0xC0, 0xFC, 0x00, 0x7E, 0x00, 0x78, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xE0, 0x7C, 0x00,
  0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x83, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0x81, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x3C, 0x00,
  0x1E, 0x00, 0x0E, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x81,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0xFF, 0x00, 0x3C, 0x7F, 0xF8, 0x07, 0x9F, 0xFF, 0x00, 0xE7, 0xC3, 0xF0,
  0x1D, 0xE0, 0x1E, 0x03, 0xB8, 0x03, 0xC0, 0xFE, 0x00, 0x78, 0x1F, 0x80,
  0x07, 0x03, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F,
  0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x38, 0x1C, 0x00, 0x0F, 0x07, 0x80,
  0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xE0,
  0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x1E, 0x07, 0x80,
  0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x0E, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x3C, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x7C,
  0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0xF8, 0x07, 0x80,
  0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x0F, 0xF0, 0x00,
  0x07, 0x0F, 0xFE, 0x00, 0x07, 0x9F, 0xFF, 0x00, 0x03, 0x8F, 0x07, 0xC0,
  0x01, 0xCE, 0x01, 0xF0, 0x00, 0xEE, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x3C,
  0x00, 0x7E, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x03,
  0x80, 0x0F, 0x80, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0xF0, 0x07, 0xC0, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x0F, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x3C, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x1F,
  0x80, 0x07, 0xC0, 0x0F, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xB8, 0x03, 0xE0, 0x01, 0xCE, 0x07, 0xE0, 0x01, 0xE7, 0xFF, 0xE0, 0x00,
  0xF1, 0xFF, 0xE0, 0x00, 0x78, 0x7F, 0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x38, 0x00, 0xFF, 0xE1, 0xC0, 0x1F, 0xFF,
  0x9E, 0x01, 0xF8, 0x3C, 0xE0, 0x1F, 0x00, 0x77, 0x00, 0xF0, 0x03, 0xB8,
  0x0F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x07, 0x80, 0x03, 0xE0, 0x7C,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x3E, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x3E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78,
  0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x3C, 0x0E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF8,
  0x3C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x3F, 0x01, 0xE0, 0x01, 0xF8, 0x0F, 0x00, 0x1F, 0xC0, 0x78, 0x01,
  0xDC, 0x03, 0xE0, 0x1D, 0xE0, 0x0F, 0x81, 0xEF, 0x00, 0x7F, 0xFE, 0x78,
  0x01, 0xFF, 0xE3, 0x80, 0x07, 0xFC, 0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0xFE, 0x03, 0xC7, 0xF8, 0x07, 0x1F, 0xF0, 0x0E, 0x7E, 0x60, 0x1D, 0xE0,
  0x00, 0x3B, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0x01,
  0xE0, 0x1E, 0x00, 0x20, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x60, 0x01, 0xF0, 0x3C, 0x01,
  0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xFF, 0xCF,
  0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF0, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0E, 0x03, 0x80,
  0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x38, 0x1E, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x70, 0x1C,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0xF0, 0x3C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07,
  0x80, 0x01, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xC0, 0x70, 0x00,
  0x7C, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0xFC, 0x0F, 0x00, 0x0F, 0xC0,
  0xF8, 0x01, 0xB8, 0x07, 0x80, 0x3B, 0x80, 0x7C, 0x0F, 0x38, 0x07, 0xFF,
  0xE7, 0x80, 0x3F, 0xFC, 0x70, 0x01, 0xFF, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x01,
  0xE0, 0xF0, 0x03, 0xC0, 0x70, 0x03, 0xC0, 0x70, 0x07, 0x80, 0x70, 0x07,
  0x80, 0x70, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0x70, 0x1E, 0x00, 0x70, 0x1E,
  0x00, 0x70, 0x1C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x38, 0x00, 0x78, 0x78,
  0x00, 0x78, 0x70, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x79, 0xE0,
  0x00, 0x79, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x7B, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0xE0, 0x00, 0xF8, 0x00, 0x7B, 0xC0, 0x01, 0xF0, 0x00, 0xF7, 0x80, 0x07,
  0xE0, 0x03, 0xCF, 0x00, 0x0F, 0xC0, 0x07, 0x9E, 0x00, 0x3B, 0x80, 0x0E,
  0x3C, 0x00, 0x7F, 0x00, 0x3C, 0x78, 0x01, 0xFE, 0x00, 0x78, 0xF0, 0x03,
  0xBC, 0x01, 0xE1, 0xE0, 0x07, 0x78, 0x03, 0xC3, 0xC0, 0x1C, 0xF0, 0x07,
  0x07, 0x80, 0x39, 0xE0, 0x1E, 0x0F, 0x00, 0xF3, 0xC0, 0x38, 0x1E, 0x01,
  0xC7, 0x80, 0xF0, 0x3C, 0x07, 0x8F, 0x01, 0xE0, 0x78, 0x0E, 0x1E, 0x07,
  0x80, 0xF0, 0x1C, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x78, 0x1C, 0x03, 0xC0,
  0xE0, 0xF0, 0x78, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x0F, 0x07, 0x03, 0xC3,
  0xC0, 0x1E, 0x1E, 0x07, 0x87, 0x80, 0x3C, 0x38, 0x0F, 0x0E, 0x00, 0x78,
  0x70, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x3C, 0x70, 0x01, 0xE3, 0x80, 0x79,
  0xE0, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x07, 0x9C, 0x01, 0xE7, 0x00, 0x0F,
  0x78, 0x03, 0xDE, 0x00, 0x0E, 0xE0, 0x07, 0xB8, 0x00, 0x1D, 0xC0, 0x0F,
  0x70, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x01, 0xDE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x03,
  0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x07, 0xC0, 0x1C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x0F, 0x00, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x07, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00,
  0x07, 0x9C, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x07, 0xB8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x08, 0x7E, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x11, 0xFF, 0x80, 0x01, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xF0,
  0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xC0,
};

const GFXglyph NotoSans_Condensed_LightItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 16, 51, 16, 1, -51 },
  { 103, 17, 19, 22, 7, -51 },
  { 144, 33, 51, 33, 1, -51 },
  { 355, 29, 58, 30, 1, -54 },
  { 566, 38, 52, 45, 4, -51 },
  { 813, 32, 52, 33, 0, -51 },
  { 1021, 8, 19, 12, 7, -51 },
  { 1040, 21, 62, 18, 2, -51 },
  { 1203, 21, 62, 18, -5, -51 },
  { 1366, 23, 24, 28, 8, -54 },
  { 1435, 28, 33, 33, 3, -42 },
  { 1551, 11, 17, 14, -3, -8 },
  { 1575, 16, 4, 20, 2, -21 },
  { 1583, 6, 6, 14, 1, -6 },
  { 1588, 31, 51, 23, -3, -51 },
  { 1786, 27, 52, 30, 2, -51 },
  { 1962, 16, 51, 30, 9, -51 },
  { 2064, 31, 51, 30, -2, -51 },
  { 2262, 31, 52, 30, -1, -51 },
  { 2464, 31, 51, 30, -1, -51 },
  { 2662, 30, 52, 30, 0, -51 },
  { 2857, 28, 52, 30, 3, -51 },
  { 3039, 28, 51, 30, 4, -51 },
  { 3218, 30, 52, 30, 0, -51 },
  { 3413, 28, 52, 30, 1, -51 },
  { 3595, 12, 38, 14, 1, -38 },
  { 3652, 16, 47, 14, -3, -38 },
  { 3746, 28, 31, 33, 3, -41 },
  { 3855, 28, 18, 33, 3, -34 },
  { 3918, 28, 31, 33, 3, -41 },
  { 4027, 23, 51, 22, 2, -51 },
  { 4174, 42, 57, 45, 2, -51 },
  { 4474, 30, 51, 30, -4, -51 },
  { 4666, 32, 51, 33, 1, -51 },
  { 4870, 32, 52, 31, 3, -51 },
  { 5078, 34, 51, 36, 1, -51 },
  { 5295, 30, 51, 29, 1, -51 },
  { 5487, 31, 51, 27, 1, -51 },
  { 5685, 36, 52, 38, 3, -51 },
  { 5919, 37, 51, 37, 1, -51 },
  { 6155, 25, 51, 17, -3, -51 },
  { 6315, 27, 64, 14, -11, -51 },
  { 6531, 35, 51, 30, 1, -51 },
  { 6755, 20, 51, 26, 1, -51 },
  { 6883, 48, 51, 48, 1, -51 },
  { 7189, 39, 51, 39, 1, -51 },
  { 7438, 34, 52, 39, 3, -51 },
  { 7659, 31, 51, 31, 1, -51 },
  { 7857, 34, 63, 39, 3, -51 },
  { 8125, 31, 51, 31, 1, -51 },
  { 8323, 31, 52, 28, -1, -51 },
  { 8525, 26, 51, 26, 6, -51 },
  { 8691, 35, 52, 37, 3, -51 },
  { 8919, 30, 51, 30, 6, -51 },
  { 9111, 47, 51, 49, 7, -51 },
  { 9411, 37, 51, 28, -4, -51 },
  { 9647, 27, 51, 27, 6, -51 },
  { 9820, 33, 51, 27, -2, -51 },
  { 10031, 26, 62, 20, -1, -51 },
  { 10233, 11, 51, 23, 7, -51 },
  { 10304, 26, 62, 20, -5, -51 },
  { 10506, 28, 28, 32, 2, -51 },
  { 10604, 23, 4, 22, -6, 6 },
  { 10616, 9, 11, 17, 10, -54 },
  { 10629, 29, 39, 32, 2, -38 },
  { 10771, 29, 55, 32, 1, -54 },
  { 10971, 24, 39, 24, 2, -38 },
  { 11088, 33, 55, 32, 2, -54 },
  { 11315, 25, 39, 28, 2, -38 },
  { 11437, 34, 71, 16, -9, -54 },
  { 11739, 31, 55, 32, 0, -38 },
  { 11953, 27, 54, 31, 1, -54 },
  { 12136, 15, 52, 14, 1, -52 },
  { 12234, 25, 69, 14, -9, -52 },
  { 12450, 28, 54, 26, 1, -54 },
  { 12639, 15, 54, 13, 1, -54 },
  { 12741, 43, 38, 47, 1, -38 },
  { 12946, 27, 38, 31, 1, -38 },
  { 13075, 27, 39, 31, 2, -38 },
  { 13207, 33, 54, 32, -3, -38 },
  { 13430, 29, 55, 32, 2, -38 },
  { 13630, 23, 38, 21, 1, -38 },
  { 13740, 25, 39, 24, -1, -38 },
  { 13862, 17, 48, 17, 2, -47 },
  { 13964, 28, 39, 31, 2, -38 },
  { 14101, 24, 38, 24, 4, -38 },
  { 14215, 39, 38, 40, 4, -38 },
  { 14401, 31, 38, 26, -3, -38 },
  { 14549, 36, 55, 25, -7, -38 },
  { 14797, 26, 38, 22, -2, -38 },
  { 14921, 25, 62, 23, 2, -51 },
  { 15115, 4, 71, 29, 13, -54 },
  { 15151, 25, 62, 23, -4, -51 },
  { 15345, 28, 8, 33, 3, -29 },
};

const GFXfont NotoSans_Condensed_LightItalic71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic71pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC71PT7B_H_
