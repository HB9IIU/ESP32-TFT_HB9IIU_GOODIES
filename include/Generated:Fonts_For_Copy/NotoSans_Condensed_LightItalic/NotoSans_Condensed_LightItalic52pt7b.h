#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC52PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0x60, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x1E, 0x03,
  0xC0, 0x78, 0x0E, 0x00, 0x3C, 0x39, 0xC1, 0x8E, 0x1C, 0x70, 0xE3, 0x07,
  0x18, 0x31, 0xC1, 0x8E, 0x1C, 0x60, 0xE3, 0x06, 0x18, 0x30, 0xC1, 0x8C,
  0x1C, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x1C, 0x0C, 0x00, 0x1C, 0x0C, 0x00,
  0x18, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x38, 0x18, 0x00, 0x30, 0x38, 0x00,
  0x30, 0x30, 0x00, 0x70, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x70, 0x1F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x00, 0xC0, 0xE0, 0x00, 0xC0, 0xC0, 0x01,
  0xC0, 0xC0, 0x01, 0x81, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x81, 0x80, 0x03,
  0x03, 0x80, 0x03, 0x03, 0x00, 0x07, 0x03, 0x00, 0x06, 0x03, 0x00, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x0E, 0x06, 0x00, 0x0C, 0x0E, 0x00, 0x0C,
  0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x38,
  0x18, 0x00, 0x30, 0x38, 0x00, 0x30, 0x38, 0x00, 0x70, 0x30, 0x00, 0x60,
  0x30, 0x00, 0x60, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xF0, 0x1F, 0x27,
  0xC0, 0x71, 0x82, 0x03, 0x86, 0x00, 0x1C, 0x18, 0x00, 0x70, 0x60, 0x01,
  0xC1, 0x00, 0x07, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x70, 0xC0, 0x01, 0xE3,
  0x00, 0x03, 0x98, 0x00, 0x07, 0x60, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x03, 0x78, 0x00, 0x0C, 0xE0, 0x00,
  0x31, 0xC0, 0x00, 0x87, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60,
  0xC0, 0x01, 0x83, 0x00, 0x0C, 0x1C, 0x00, 0x30, 0x70, 0x80, 0xC3, 0x81,
  0x83, 0x3C, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x1C, 0x0F, 0xF0, 0x03, 0x80,
  0xE3, 0x80, 0x30, 0x1C, 0x18, 0x07, 0x01, 0x81, 0x80, 0x60, 0x38, 0x18,
  0x0E, 0x03, 0x01, 0x81, 0xC0, 0x70, 0x18, 0x18, 0x07, 0x03, 0x83, 0x80,
  0x60, 0x38, 0x30, 0x06, 0x03, 0x07, 0x00, 0xE0, 0x30, 0x60, 0x0E, 0x03,
  0x0E, 0x00, 0xE0, 0x71, 0xC0, 0x0C, 0x07, 0x18, 0x30, 0xC0, 0x63, 0x8F,
  0xCC, 0x0E, 0x31, 0xFE, 0xC0, 0xC7, 0x38, 0x6E, 0x1C, 0xE3, 0x07, 0xE1,
  0x8C, 0x70, 0x77, 0xF9, 0xC6, 0x07, 0x7F, 0x18, 0xE0, 0x70, 0x83, 0x8C,
  0x06, 0x00, 0x30, 0xC0, 0x60, 0x07, 0x1C, 0x06, 0x00, 0xE1, 0xC0, 0x60,
  0x0C, 0x18, 0x0E, 0x01, 0xC1, 0x80, 0xE0, 0x18, 0x18, 0x0C, 0x03, 0x81,
  0x80, 0xC0, 0x30, 0x18, 0x1C, 0x07, 0x01, 0x81, 0x80, 0xE0, 0x18, 0x38,
  0x0C, 0x01, 0x83, 0x01, 0xC0, 0x1C, 0x70, 0x18, 0x01, 0xFE, 0x03, 0x80,
  0x0F, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x80, 0x03, 0x87, 0x80, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00,
  0x30, 0x1C, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xC0, 0x07,
  0x03, 0x80, 0x0E, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x18, 0x70, 0x00, 0x39,
  0xC0, 0x00, 0x77, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x7B, 0x80, 0x01, 0xE3, 0x81, 0xC7, 0x87, 0x03,
  0x8E, 0x0E, 0x06, 0x38, 0x0E, 0x1C, 0x60, 0x1C, 0x31, 0xC0, 0x1C, 0xE3,
  0x80, 0x39, 0x86, 0x00, 0x3F, 0x1C, 0x00, 0x7C, 0x38, 0x00, 0xF8, 0x70,
  0x00, 0xE0, 0xE0, 0x03, 0xC0, 0xE0, 0x0F, 0xC1, 0xC0, 0x3B, 0x83, 0xC1,
  0xE3, 0x83, 0xFF, 0x87, 0x03, 0xFC, 0x0F, 0x00, 0x40, 0x00, 0x00, 0x1C,
  0xE3, 0x8E, 0x38, 0xC7, 0x1C, 0x71, 0x86, 0x18, 0xE0, 0x00, 0x0F, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01,
  0x80, 0x0F, 0x00, 0x00, 0x00, 0x80, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0xC0, 0xC0, 0xF1, 0x80, 0x7D, 0x81, 0x0F, 0xFF, 0x03, 0xFF,
  0x03, 0x80, 0x06, 0xC0, 0x1C, 0xC0, 0x38, 0x60, 0x78, 0x70, 0x70, 0x70,
  0x20, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x0F,
  0x0E, 0x0E, 0x1C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x60, 0xE0, 0xC0, 0xFF,
  0xFF, 0xFF, 0x6F, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x1E, 0x1C, 0x03, 0xC0, 0xE0,
  0x38, 0x0E, 0x07, 0x00, 0x60, 0xE0, 0x06, 0x0E, 0x00, 0x70, 0xC0, 0x07,
  0x1C, 0x00, 0x71, 0xC0, 0x07, 0x38, 0x00, 0x63, 0x80, 0x06, 0x38, 0x00,
  0xE3, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00,
  0x0E, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0,
  0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x70, 0xC0, 0x07, 0x0C,
  0x00, 0x70, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x1C, 0x0E, 0x03, 0xC0,
  0x70, 0x38, 0x07, 0x8F, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x70, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xE3, 0xCE, 0x78, 0xEF,
  0x0E, 0x40, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x7C, 0x1E, 0x00, 0xC0, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0xF8, 0x1E, 0x01, 0x80, 0x38, 0x04, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x08, 0x00, 0xF0, 0x38, 0x0F, 0x80, 0xFF, 0xFC, 0x01,
  0xFF, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0D, 0xC0, 0x00, 0x3B, 0x00,
  0x00, 0xEE, 0x00, 0x01, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x1C, 0x70, 0x00,
  0x30, 0xC0, 0x00, 0xE3, 0x80, 0x03, 0x87, 0x00, 0x06, 0x0E, 0x00, 0x1C,
  0x18, 0x00, 0x70, 0x30, 0x00, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x0E, 0x03,
  0x80, 0x38, 0x06, 0x00, 0x60, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70,
  0x0C, 0x00, 0xE0, 0x38, 0x01, 0x80, 0xE0, 0x07, 0x01, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xC8, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x18, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x02,
  0x00, 0x3C, 0x0E, 0x03, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x1F, 0x80, 0x31, 0xFF, 0x03, 0xBE,
  0xF8, 0x1F, 0x81, 0xE0, 0xF8, 0x07, 0x07, 0x80, 0x1C, 0x38, 0x00, 0xE3,
  0xC0, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00,
  0x71, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0C, 0x1C,
  0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x70, 0x1C, 0x07, 0x00, 0xF0, 0x78,
  0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFF, 0xF9,
  0xFF, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3C, 0x1E, 0x01, 0xC0,
  0x3C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x00, 0x1C,
  0x0C, 0x00, 0x70, 0x30, 0x01, 0xC0, 0xE0, 0x06, 0x03, 0x80, 0x38, 0x0E,
  0x01, 0xC0, 0x1C, 0x0F, 0x00, 0x78, 0x78, 0x00, 0xE7, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xCF, 0x00, 0x3C, 0x1E, 0x01,
  0xE0, 0x38, 0x07, 0x00, 0x70, 0x38, 0x01, 0xC1, 0xC0, 0x03, 0x87, 0x00,
  0x0E, 0x18, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E,
  0x38, 0x00, 0x30, 0x70, 0x01, 0xC1, 0xC0, 0x0F, 0x07, 0x80, 0x38, 0x0F,
  0x03, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x1E, 0x1E, 0x03, 0x80, 0xE0,
  0x70, 0x07, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x31, 0xC0, 0x03,
  0x1C, 0x00, 0x31, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0x80, 0x07, 0x38, 0x00,
  0x73, 0x80, 0x07, 0x38, 0x00, 0xF1, 0x80, 0x0F, 0x1C, 0x01, 0xE1, 0xC0,
  0x3E, 0x1E, 0x07, 0xE0, 0xFF, 0xEE, 0x07, 0xFC, 0xC0, 0x3E, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x08, 0x1E, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x81, 0xC1, 0xE0, 0xF0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x78, 0x3C, 0x3C, 0x0E, 0x00, 0x00, 0x60, 0x0F,
  0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x0E, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x0F, 0xFC, 0x1F, 0xFE, 0x1C, 0x1E, 0x10, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x30,
  0x07, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x0F, 0x80, 0xC7, 0x00,
  0xFF, 0x83, 0x18, 0x07, 0x0C, 0x0C, 0x60, 0x38, 0x30, 0x33, 0x81, 0xC1,
  0xC0, 0xCC, 0x0E, 0x07, 0x03, 0x70, 0x30, 0x18, 0x1D, 0xC1, 0xC0, 0x60,
  0x76, 0x06, 0x03, 0x81, 0x98, 0x18, 0x0E, 0x06, 0xE0, 0xE0, 0x30, 0x1B,
  0x83, 0x00, 0xC0, 0xEE, 0x0C, 0x07, 0x03, 0x30, 0x30, 0x1C, 0x0C, 0xC0,
  0xC0, 0xE0, 0x73, 0x03, 0x03, 0x81, 0x8C, 0x0C, 0x0E, 0x0E, 0x30, 0x30,
  0x78, 0x30, 0xC0, 0xE3, 0x71, 0x83, 0x03, 0xF8, 0xFE, 0x0C, 0x07, 0xC1,
  0xE0, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x04, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xB0, 0x00, 0x0E, 0xC0,
  0x00, 0x33, 0x00, 0x01, 0xCE, 0x00, 0x06, 0x38, 0x00, 0x38, 0xE0, 0x00,
  0xE3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x60, 0xE0, 0x03, 0x83,
  0x80, 0x0C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x0E, 0x03, 0x80,
  0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x83, 0x80, 0x06,
  0x0E, 0x00, 0x18, 0x70, 0x00, 0x61, 0xC0, 0x01, 0x8E, 0x00, 0x06, 0x38,
  0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1C, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0x07, 0xE0, 0x0E, 0x01,
  0xE0, 0x1C, 0x01, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07,
  0x03, 0x80, 0x0E, 0x06, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0xE0,
  0x70, 0x01, 0xC0, 0xE0, 0x07, 0x01, 0x80, 0x1C, 0x07, 0x00, 0xF8, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x0E, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x1C, 0x0C, 0x00, 0x38, 0x38, 0x00,
  0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x00, 0x07,
  0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x70, 0x03, 0xC0,
  0xC0, 0x1F, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x07, 0xC0, 0x60,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x30, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01,
  0xC3, 0xF8, 0x01, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x03, 0x80, 0x0E, 0x03,
  0x80, 0x0F, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x00, 0x07, 0x07,
  0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x06,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E,
  0x00, 0x07, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C,
  0x00, 0x0E, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x38,
  0x00, 0x38, 0x38, 0x00, 0x78, 0x30, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x70,
  0x01, 0xE0, 0x70, 0x03, 0xC0, 0x70, 0x07, 0x80, 0x60, 0x1F, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0x80, 0xF0, 0x1F, 0x00, 0x10,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0x8E, 0x00,
  0x7F, 0xC7, 0x00, 0x3F, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xC0,
  0x00, 0x38, 0x60, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E,
  0x00, 0x03, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0,
  0x70, 0x00, 0x70, 0x3C, 0x00, 0x30, 0x0F, 0x00, 0x38, 0x07, 0xE0, 0x7C,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xE0,
  0x18, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x1C, 0x00,
  0x0C, 0x03, 0x80, 0x03, 0x80, 0x60, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03,
  0x80, 0x01, 0xC0, 0x70, 0x00, 0x30, 0x0E, 0x00, 0x0E, 0x01, 0x80, 0x01,
  0xC0, 0x70, 0x00, 0x38, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x18,
  0x07, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x60, 0x1C, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0x80, 0x70, 0x00,
  0x70, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x30, 0x0E,
  0x00, 0x0E, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x23, 0xC0, 0x0F,
  0xF8, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x03, 0x80,
  0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x18, 0x03, 0xC0, 0x1C, 0x03, 0xC0,
  0x0E, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0x81, 0xE0,
  0x01, 0xC1, 0xE0, 0x00, 0xE1, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x18, 0xE0, 0x00, 0x1C, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0x78,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xF7, 0x00, 0x01, 0xF3, 0x80, 0x00, 0xF0,
  0xE0, 0x00, 0x70, 0x70, 0x00, 0x30, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C,
  0x07, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x70, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xEC, 0x00, 0x07,
  0x70, 0x1D, 0x80, 0x00, 0xEC, 0x03, 0x30, 0x00, 0x3B, 0x80, 0x66, 0x00,
  0x07, 0x70, 0x1C, 0xC0, 0x01, 0xCE, 0x03, 0x9C, 0x00, 0x39, 0x80, 0x73,
  0x80, 0x0E, 0x70, 0x0C, 0x70, 0x01, 0xCE, 0x01, 0x8E, 0x00, 0x71, 0xC0,
  0x71, 0xC0, 0x0E, 0x38, 0x0E, 0x38, 0x03, 0x86, 0x01, 0xC7, 0x00, 0x71,
  0xC0, 0x30, 0xE0, 0x1C, 0x38, 0x0E, 0x0C, 0x03, 0x87, 0x01, 0xC1, 0x80,
  0xE0, 0xE0, 0x38, 0x30, 0x1C, 0x18, 0x07, 0x06, 0x07, 0x07, 0x00, 0xC0,
  0xC0, 0xE0, 0xE0, 0x38, 0x1C, 0x38, 0x1C, 0x07, 0x03, 0x87, 0x03, 0x80,
  0xE0, 0x71, 0xC0, 0xE0, 0x1C, 0x0E, 0x38, 0x1C, 0x03, 0x01, 0xCE, 0x03,
  0x80, 0xE0, 0x39, 0xC0, 0x70, 0x1C, 0x07, 0x70, 0x0C, 0x03, 0x80, 0xEE,
  0x03, 0x80, 0x60, 0x0F, 0x80, 0x70, 0x1C, 0x01, 0xF0, 0x0E, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x70, 0x07, 0x80, 0x30, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x70, 0x1E, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x70, 0x1F,
  0x00, 0x06, 0x01, 0xF0, 0x00, 0xE0, 0x3F, 0x00, 0x0E, 0x03, 0xB0, 0x00,
  0xE0, 0x3B, 0x80, 0x0E, 0x03, 0xB8, 0x00, 0xC0, 0x33, 0x80, 0x1C, 0x07,
  0x18, 0x01, 0xC0, 0x71, 0xC0, 0x1C, 0x07, 0x1C, 0x01, 0x80, 0x61, 0xC0,
  0x38, 0x06, 0x0C, 0x03, 0x80, 0xE0, 0xE0, 0x38, 0x0E, 0x0E, 0x03, 0x80,
  0xE0, 0xE0, 0x30, 0x0C, 0x06, 0x07, 0x01, 0xC0, 0x70, 0x70, 0x1C, 0x07,
  0x07, 0x01, 0xC0, 0x70, 0x70, 0x1C, 0x03, 0x06, 0x01, 0x80, 0x38, 0xE0,
  0x38, 0x03, 0x8E, 0x03, 0x80, 0x38, 0xE0, 0x38, 0x01, 0x8E, 0x03, 0x80,
  0x1C, 0xC0, 0x30, 0x01, 0xDC, 0x07, 0x00, 0x1D, 0xC0, 0x70, 0x00, 0xDC,
  0x07, 0x00, 0x0F, 0x80, 0x60, 0x00, 0xF8, 0x0E, 0x00, 0x0F, 0x80, 0xE0,
  0x00, 0x78, 0x0E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0x03, 0xC0, 0x0E,
  0x00, 0xF0, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x07,
  0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0x71,
  0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07,
  0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00,
  0x1C, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x07, 0x1C, 0x00,
  0x03, 0x86, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xE0, 0xE0,
  0x00, 0xE0, 0x70, 0x00, 0xF0, 0x1C, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x03,
  0xC1, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1C, 0x7F, 0x00, 0x70, 0x1E, 0x01,
  0x80, 0x38, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80,
  0x1C, 0x0C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C,
  0x1C, 0x00, 0xE0, 0x60, 0x03, 0x83, 0x80, 0x1E, 0x0E, 0x00, 0xF0, 0x38,
  0x07, 0x80, 0xE0, 0x3C, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0x03, 0xC0, 0x0E, 0x00, 0xF0, 0x0E, 0x00,
  0x38, 0x0E, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x07, 0x00, 0x03, 0x87, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x07, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x86, 0x00, 0x01,
  0xC3, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0x70, 0x00,
  0xF0, 0x1C, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x03, 0xC1, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x1C, 0x7F, 0x00, 0x70, 0x1E, 0x01, 0xC0, 0x3C, 0x0E,
  0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0C, 0x00,
  0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xE0,
  0x60, 0x03, 0x83, 0x80, 0x1C, 0x0E, 0x00, 0xF0, 0x38, 0x0F, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0,
  0x06, 0x07, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x38, 0x03, 0x80, 0xE0, 0x0E,
  0x03, 0x80, 0x30, 0x07, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x70, 0x1C, 0x01,
  0xC0, 0x70, 0x03, 0x81, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0,
  0xE0, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF8,
  0x07, 0xC0, 0xF0, 0x1E, 0x00, 0x40, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x1E, 0x07, 0xC1, 0xF8, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFE, 0x80, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70,
  0x38, 0x00, 0x38, 0x0C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0xE0, 0x70, 0x00, 0x30, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80,
  0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x18, 0x0E, 0x00, 0x0E, 0x07,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x1C,
  0x06, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00,
  0x18, 0x0E, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70,
  0x00, 0x38, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0x80, 0x01, 0xC0,
  0xE0, 0x00, 0x70, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x07,
  0x00, 0x70, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x0E, 0x70, 0x00,
  0x73, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38,
  0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x07, 0x03, 0x80, 0x38,
  0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0,
  0xE0, 0x0E, 0x07, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x0C, 0x18, 0x00,
  0x61, 0xC0, 0x03, 0x0E, 0x00, 0x18, 0xE0, 0x00, 0xC7, 0x00, 0x06, 0x70,
  0x00, 0x33, 0x80, 0x01, 0xB8, 0x00, 0x0D, 0xC0, 0x00, 0x6C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x3B, 0x80, 0x07, 0x80, 0x07,
  0x70, 0x00, 0xF0, 0x01, 0xCE, 0x00, 0x3E, 0x00, 0x39, 0xC0, 0x07, 0xC0,
  0x0E, 0x38, 0x01, 0xF8, 0x01, 0xC7, 0x00, 0x37, 0x00, 0x38, 0xE0, 0x0E,
  0xE0, 0x0E, 0x1C, 0x01, 0xDC, 0x01, 0xC3, 0x80, 0x33, 0x80, 0x70, 0x70,
  0x0E, 0x70, 0x0E, 0x0E, 0x01, 0x8E, 0x01, 0xC1, 0xC0, 0x71, 0xC0, 0x70,
  0x38, 0x0E, 0x38, 0x0E, 0x07, 0x01, 0x87, 0x03, 0x80, 0xE0, 0x70, 0xE0,
  0x70, 0x1C, 0x0C, 0x1C, 0x0C, 0x03, 0x83, 0x83, 0x83, 0x80, 0x70, 0x60,
  0x70, 0x70, 0x0E, 0x1C, 0x0E, 0x1C, 0x01, 0xC3, 0x81, 0xC3, 0x80, 0x38,
  0x60, 0x38, 0x60, 0x07, 0x1C, 0x07, 0x1C, 0x00, 0xE3, 0x00, 0xE3, 0x80,
  0x1C, 0xE0, 0x1C, 0xE0, 0x03, 0x9C, 0x03, 0x9C, 0x00, 0x73, 0x00, 0x73,
  0x00, 0x0E, 0xE0, 0x0E, 0xE0, 0x01, 0xD8, 0x01, 0xD8, 0x00, 0x3F, 0x00,
  0x37, 0x00, 0x06, 0xE0, 0x06, 0xE0, 0x00, 0xD8, 0x00, 0xD8, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x18, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0x70,
  0x1E, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x18, 0x1C, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x06, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80,
  0x70, 0x00, 0xF0, 0x06, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0x03, 0x80, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0xFC, 0x00, 0x3B, 0x80, 0x0F, 0x70, 0x01, 0xCE, 0x00, 0x71, 0xC0, 0x0E,
  0x18, 0x03, 0x83, 0x00, 0x70, 0x70, 0x1C, 0x0E, 0x07, 0x81, 0xC0, 0xE0,
  0x38, 0x38, 0x07, 0x07, 0x00, 0x61, 0xC0, 0x0C, 0x38, 0x01, 0xCE, 0x00,
  0x39, 0x80, 0x07, 0x70, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xE0, 0x60, 0x60,
  0x60, 0x70, 0x70, 0x70, 0x70, 0x30, 0x30, 0x30, 0x38, 0x38, 0x38, 0x38,
  0x18, 0x18, 0x18, 0x1C, 0x1C, 0x1C, 0x1C, 0x0C, 0x0C, 0x0C, 0x0E, 0x0E,
  0x0E, 0x0E, 0x06, 0x06, 0x06, 0x07, 0x07, 0x07, 0x07, 0x03, 0x00, 0x7F,
  0xE0, 0x0F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x6C, 0x00, 0x07, 0x70, 0x00, 0x33,
  0x80, 0x03, 0x8C, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x1C, 0x0C, 0x00,
  0xC0, 0x70, 0x0E, 0x03, 0x80, 0x60, 0x0E, 0x07, 0x00, 0x70, 0x70, 0x01,
  0x83, 0x80, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x01, 0x9C, 0x00, 0x0F, 0xC0,
  0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0x8E, 0x1C, 0x30, 0xE1, 0x87,
  0x00, 0x7C, 0x38, 0x0F, 0xF9, 0x80, 0xF9, 0xCC, 0x0F, 0x03, 0x60, 0xF0,
  0x1F, 0x0F, 0x00, 0x78, 0x70, 0x03, 0x87, 0x80, 0x1C, 0x38, 0x00, 0xE1,
  0xC0, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x70, 0x00,
  0xE3, 0x80, 0x07, 0x1C, 0x00, 0x30, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38,
  0x00, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x70, 0x70, 0x07, 0x83, 0x80, 0x3C,
  0x1C, 0x03, 0xE0, 0xF0, 0x37, 0x03, 0xC3, 0x30, 0x1F, 0xF1, 0x80, 0x7F,
  0x0C, 0x00, 0x40, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0xF8, 0x03, 0x9F, 0xF0, 0x1D, 0xE7, 0x80, 0xDC, 0x0E, 0x07,
  0xC0, 0x70, 0x7C, 0x03, 0x83, 0xC0, 0x0E, 0x1E, 0x00, 0x70, 0xE0, 0x03,
  0x8F, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x06, 0x1C, 0x00, 0x70, 0xC0,
  0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x0E, 0x1C, 0x00, 0x70,
  0xC0, 0x03, 0x8E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1E, 0x00,
  0xE0, 0xF0, 0x0F, 0x0F, 0x80, 0xF0, 0x66, 0x0F, 0x03, 0x3F, 0xF0, 0x18,
  0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0xF8, 0xC0,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x08,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0xC3, 0x80, 0x3F, 0xE7, 0x00,
  0xF9, 0xCC, 0x03, 0xC0, 0xF8, 0x0F, 0x01, 0xF0, 0x3C, 0x01, 0xE0, 0x70,
  0x03, 0x81, 0xE0, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x1C, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0x60, 0x70, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07,
  0x07, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0,
  0x70, 0x03, 0xC0, 0xE0, 0x07, 0x81, 0xC0, 0x1E, 0x03, 0x80, 0x3C, 0x07,
  0x00, 0xF8, 0x0F, 0x03, 0x70, 0x0F, 0x0E, 0xC0, 0x1F, 0xF9, 0x80, 0x1F,
  0xC3, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x3C, 0x78,
  0x1C, 0x0E, 0x0E, 0x01, 0x87, 0x80, 0x71, 0xC0, 0x18, 0xE0, 0x0E, 0x38,
  0x03, 0x9C, 0x01, 0xC7, 0x00, 0xF1, 0xC0, 0x78, 0x60, 0xFC, 0x3F, 0xFC,
  0x0F, 0xFC, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1E, 0x07, 0x03, 0xFF, 0xC0, 0x7F, 0xC0, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x06, 0x00, 0xFF, 0x9C,
  0x03, 0xE7, 0x30, 0x0F, 0x03, 0x60, 0x3C, 0x07, 0xC0, 0xF0, 0x07, 0x81,
  0xC0, 0x0F, 0x07, 0x80, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x70,
  0x00, 0xE0, 0xE0, 0x01, 0x81, 0xC0, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00,
  0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03,
  0x81, 0xC0, 0x0F, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x78, 0x0E, 0x00, 0xF0,
  0x1C, 0x03, 0xE0, 0x3C, 0x0D, 0xC0, 0x38, 0x3B, 0x00, 0x7F, 0xE6, 0x00,
  0x7F, 0x1C, 0x00, 0x10, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x08, 0x01, 0xC0, 0x1C, 0x0F, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x0F, 0x80, 0x73, 0xFE,
  0x07, 0x79, 0xE0, 0x6C, 0x0F, 0x07, 0x80, 0x70, 0xF8, 0x07, 0x0F, 0x00,
  0x70, 0xE0, 0x07, 0x0E, 0x00, 0x71, 0xE0, 0x06, 0x1C, 0x00, 0xE1, 0xC0,
  0x0E, 0x1C, 0x00, 0xE1, 0x80, 0x0C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38,
  0x01, 0xC3, 0x80, 0x1C, 0x30, 0x01, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87,
  0x00, 0x38, 0x70, 0x03, 0x86, 0x00, 0x30, 0xE0, 0x07, 0x0E, 0x00, 0x70,
  0xE0, 0x07, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E,
  0x03, 0x80, 0xE0, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x70, 0x70, 0x0E, 0x07, 0x01, 0xC0,
  0x70, 0x3C, 0x06, 0x03, 0x80, 0xE0, 0x70, 0x0E, 0x0E, 0x00, 0xE1, 0xC0,
  0x0C, 0x38, 0x01, 0xC7, 0x80, 0x1C, 0x70, 0x01, 0xCE, 0x00, 0x1D, 0xE0,
  0x01, 0xBE, 0x00, 0x3F, 0x70, 0x03, 0xE7, 0x00, 0x3C, 0x70, 0x03, 0x87,
  0x00, 0x30, 0x38, 0x07, 0x03, 0x80, 0x70, 0x38, 0x07, 0x03, 0x80, 0x60,
  0x1C, 0x06, 0x01, 0xC0, 0xE0, 0x1C, 0x0E, 0x00, 0xC0, 0xE0, 0x0E, 0x0C,
  0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0x07, 0x1F, 0x81,
  0xF8, 0x07, 0x3F, 0xC3, 0xFC, 0x06, 0x73, 0xE7, 0x3E, 0x06, 0xC0, 0xEC,
  0x0E, 0x07, 0x80, 0xF8, 0x06, 0x0F, 0x00, 0xF0, 0x07, 0x0F, 0x00, 0xF0,
  0x06, 0x0E, 0x00, 0xE0, 0x06, 0x0E, 0x00, 0xE0, 0x0E, 0x1E, 0x00, 0xE0,
  0x0E, 0x1C, 0x00, 0xC0, 0x0E, 0x1C, 0x01, 0xC0, 0x0E, 0x1C, 0x01, 0xC0,
  0x0C, 0x18, 0x01, 0xC0, 0x1C, 0x38, 0x01, 0xC0, 0x1C, 0x38, 0x01, 0x80,
  0x1C, 0x38, 0x03, 0x80, 0x18, 0x38, 0x03, 0x80, 0x38, 0x30, 0x03, 0x80,
  0x38, 0x70, 0x03, 0x80, 0x38, 0x70, 0x03, 0x00, 0x38, 0x70, 0x07, 0x00,
  0x30, 0x70, 0x07, 0x00, 0x70, 0x60, 0x07, 0x00, 0x70, 0xE0, 0x06, 0x00,
  0x70, 0xE0, 0x0E, 0x00, 0x70, 0xE0, 0x0E, 0x00, 0x60, 0xC0, 0x0E, 0x00,
  0xE0, 0x07, 0x1F, 0x80, 0x73, 0xFE, 0x06, 0x7B, 0xE0, 0x6E, 0x0F, 0x0F,
  0x80, 0x70, 0xF8, 0x07, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x71,
  0xE0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0x80, 0x0E,
  0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x30, 0x01,
  0x87, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x8E, 0x00,
  0x30, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0C, 0x00, 0x70, 0x00,
  0x7E, 0x00, 0x3F, 0xE0, 0x0F, 0x9E, 0x03, 0x80, 0xE0, 0xE0, 0x1C, 0x3C,
  0x01, 0xC7, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1D, 0xC0,
  0x03, 0xB8, 0x00, 0x77, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x37, 0x00,
  0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00,
  0x39, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x70, 0x70, 0x1C, 0x0F, 0x0F,
  0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x30, 0x00, 0x00, 0xE1, 0xF0, 0x00,
  0xE7, 0xFC, 0x00, 0xCE, 0x3C, 0x00, 0xDC, 0x0E, 0x00, 0xD8, 0x0E, 0x01,
  0xF0, 0x06, 0x01, 0xE0, 0x07, 0x01, 0xE0, 0x07, 0x01, 0xC0, 0x07, 0x01,
  0xC0, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x06, 0x03, 0x80, 0x0E, 0x03,
  0x80, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07,
  0x00, 0x1C, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x0E,
  0x00, 0x38, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1D,
  0x83, 0xC0, 0x1D, 0xFF, 0x80, 0x18, 0xFF, 0x00, 0x18, 0x10, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x18, 0x0F,
  0xF9, 0xC0, 0xF9, 0xCC, 0x0F, 0x03, 0x60, 0xF0, 0x1F, 0x0F, 0x00, 0x78,
  0x70, 0x03, 0xC7, 0x80, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x1C, 0x00,
  0x38, 0xE0, 0x01, 0x87, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C,
  0x00, 0x38, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x0F,
  0x0E, 0x00, 0x78, 0x70, 0x07, 0x83, 0x80, 0x3C, 0x1C, 0x03, 0xE0, 0xE0,
  0x37, 0x03, 0x83, 0xB8, 0x1F, 0xFB, 0x80, 0x7F, 0x1C, 0x00, 0x40, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x07, 0x1F, 0x06, 0x3F, 0x06, 0x7F, 0x06,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xF1, 0xE1, 0xC0, 0x10, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x80, 0x38, 0x60, 0x7C, 0x3F, 0xFC, 0x1F, 0xF8,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x1F, 0xF7, 0xFF, 0x7F, 0xE0, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0E, 0x00, 0xFE, 0x07, 0xE0, 0x10, 0x00, 0x0E, 0x00, 0x70, 0xE0,
  0x07, 0x0E, 0x00, 0x70, 0xC0, 0x06, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C,
  0x00, 0xE1, 0xC0, 0x0E, 0x18, 0x00, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3,
  0x80, 0x1C, 0x30, 0x01, 0xC7, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x38,
  0x70, 0x03, 0x86, 0x00, 0x30, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x0F,
  0x0E, 0x00, 0xF0, 0xE0, 0x1E, 0x0E, 0x01, 0xE0, 0xE0, 0x3E, 0x0F, 0x0E,
  0xE0, 0x7F, 0xCE, 0x03, 0xF8, 0xC0, 0x0C, 0x00, 0x00, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x73, 0x80, 0x39,
  0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x0E, 0x0E, 0x07,
  0x07, 0x07, 0x01, 0x83, 0x80, 0xC3, 0x80, 0x61, 0xC0, 0x30, 0xC0, 0x18,
  0xE0, 0x0C, 0x60, 0x06, 0x70, 0x03, 0x30, 0x01, 0xB8, 0x00, 0xD8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x7E, 0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x00, 0xEE, 0x01, 0xF0, 0x0E, 0xE0,
  0x1F, 0x00, 0xCE, 0x01, 0xF0, 0x1C, 0xE0, 0x3F, 0x01, 0xCE, 0x03, 0x70,
  0x38, 0xE0, 0x77, 0x03, 0x8E, 0x06, 0x70, 0x30, 0xE0, 0xE7, 0x07, 0x0E,
  0x0C, 0x70, 0x70, 0xE0, 0xC7, 0x0E, 0x0E, 0x1C, 0x70, 0xE0, 0xE1, 0x87,
  0x0C, 0x0E, 0x38, 0x71, 0xC0, 0xE3, 0x07, 0x18, 0x0E, 0x70, 0x73, 0x80,
  0xE6, 0x07, 0x38, 0x0E, 0x60, 0x73, 0x00, 0xEE, 0x07, 0x70, 0x0E, 0xC0,
  0x76, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x07, 0xC0,
  0x0F, 0x80, 0x7C, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x1C, 0x0E, 0x00, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x01, 0xC0,
  0xE0, 0x03, 0x03, 0x80, 0x0E, 0x1C, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80,
  0x01, 0x9C, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0x70,
  0x00, 0x39, 0xC0, 0x00, 0xE3, 0x00, 0x07, 0x0E, 0x00, 0x38, 0x38, 0x00,
  0xE0, 0x60, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00,
  0x30, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x06,
  0x00, 0x38, 0x01, 0x80, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x18, 0x01, 0xC0,
  0x06, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07,
  0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x1C,
  0x1C, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xC0, 0x00,
  0x1C, 0x70, 0x00, 0x07, 0x18, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x0D, 0xC0, 0x00, 0x03, 0x70, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xF0, 0x7F, 0xFE,
  0x00, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x7E, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x0B, 0xFF, 0x00, 0xFC, 0x7E, 0x1F, 0x80, 0x7F, 0xE8,
  0x00, 0xFE, 0x00,
};

const GFXglyph NotoSans_Condensed_LightItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 11, 37, 12, 1, -37 },
  { 52, 13, 13, 16, 5, -37 },
  { 74, 24, 37, 24, 1, -37 },
  { 185, 22, 42, 22, 0, -39 },
  { 301, 28, 39, 33, 3, -38 },
  { 438, 23, 39, 24, 0, -38 },
  { 551, 6, 13, 9, 5, -37 },
  { 561, 16, 45, 13, 1, -37 },
  { 651, 15, 45, 13, -4, -37 },
  { 736, 16, 18, 21, 6, -40 },
  { 772, 21, 25, 24, 2, -31 },
  { 838, 8, 13, 10, -2, -6 },
  { 851, 12, 2, 14, 1, -15 },
  { 854, 4, 5, 10, 1, -5 },
  { 857, 22, 37, 17, -2, -37 },
  { 959, 20, 39, 22, 2, -38 },
  { 1057, 12, 37, 22, 6, -37 },
  { 1113, 22, 38, 22, -1, -38 },
  { 1218, 22, 39, 22, 0, -38 },
  { 1326, 23, 37, 22, -1, -37 },
  { 1433, 22, 38, 22, 0, -37 },
  { 1538, 21, 39, 22, 2, -38 },
  { 1641, 21, 37, 22, 3, -37 },
  { 1739, 22, 39, 22, 0, -38 },
  { 1847, 20, 39, 22, 1, -38 },
  { 1945, 9, 28, 10, 0, -28 },
  { 1977, 12, 35, 10, -2, -28 },
  { 2030, 21, 23, 24, 2, -30 },
  { 2091, 20, 13, 24, 2, -25 },
  { 2124, 21, 23, 24, 2, -30 },
  { 2185, 16, 38, 16, 2, -38 },
  { 2261, 30, 42, 33, 2, -37 },
  { 2419, 22, 37, 22, -3, -37 },
  { 2521, 23, 37, 24, 1, -37 },
  { 2628, 23, 39, 22, 3, -38 },
  { 2741, 24, 37, 26, 1, -37 },
  { 2852, 22, 37, 21, 1, -37 },
  { 2954, 22, 37, 20, 1, -37 },
  { 3056, 25, 39, 28, 3, -38 },
  { 3178, 27, 37, 27, 1, -37 },
  { 3303, 18, 37, 12, -2, -37 },
  { 3387, 19, 46, 10, -8, -37 },
  { 3497, 25, 37, 22, 1, -37 },
  { 3613, 14, 37, 19, 1, -37 },
  { 3678, 35, 37, 35, 1, -37 },
  { 3840, 28, 37, 29, 1, -37 },
  { 3970, 25, 39, 28, 2, -38 },
  { 4092, 22, 37, 23, 1, -37 },
  { 4194, 25, 47, 28, 2, -38 },
  { 4341, 22, 37, 23, 1, -37 },
  { 4443, 23, 39, 21, -1, -38 },
  { 4556, 20, 37, 19, 4, -37 },
  { 4649, 26, 38, 27, 2, -37 },
  { 4773, 21, 37, 22, 5, -37 },
  { 4871, 35, 37, 36, 5, -37 },
  { 5033, 27, 37, 20, -3, -37 },
  { 5158, 19, 37, 20, 5, -37 },
  { 5246, 25, 37, 20, -2, -37 },
  { 5362, 19, 45, 15, -1, -37 },
  { 5469, 8, 37, 17, 5, -37 },
  { 5506, 19, 45, 15, -3, -37 },
  { 5613, 21, 20, 23, 1, -37 },
  { 5666, 16, 2, 16, -4, 5 },
  { 5670, 6, 8, 12, 8, -40 },
  { 5676, 21, 29, 23, 2, -28 },
  { 5753, 21, 41, 23, 1, -40 },
  { 5861, 17, 29, 18, 2, -28 },
  { 5923, 23, 41, 24, 2, -40 },
  { 6041, 18, 29, 21, 2, -28 },
  { 6107, 25, 52, 12, -7, -40 },
  { 6270, 23, 40, 24, 0, -28 },
  { 6385, 20, 40, 23, 1, -40 },
  { 6485, 10, 38, 10, 1, -38 },
  { 6533, 18, 50, 10, -7, -38 },
  { 6646, 20, 40, 19, 1, -40 },
  { 6746, 11, 40, 10, 1, -40 },
  { 6801, 32, 28, 34, 1, -28 },
  { 6913, 20, 28, 23, 1, -28 },
  { 6983, 19, 29, 23, 2, -28 },
  { 7052, 24, 40, 23, -2, -28 },
  { 7172, 21, 40, 24, 2, -28 },
  { 7277, 16, 28, 15, 1, -28 },
  { 7333, 17, 29, 17, 0, -28 },
  { 7395, 12, 35, 13, 2, -34 },
  { 7448, 20, 29, 23, 2, -28 },
  { 7521, 17, 28, 18, 3, -28 },
  { 7581, 28, 28, 29, 3, -28 },
  { 7679, 22, 28, 19, -2, -28 },
  { 7756, 26, 41, 18, -5, -28 },
  { 7890, 19, 28, 16, -2, -28 },
  { 7957, 19, 45, 17, 1, -37 },
  { 8064, 2, 53, 21, 10, -40 },
  { 8078, 19, 45, 17, -3, -37 },
  { 8185, 21, 5, 24, 2, -21 },
};

const GFXfont NotoSans_Condensed_LightItalic52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic52pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC52PT7B_H_
