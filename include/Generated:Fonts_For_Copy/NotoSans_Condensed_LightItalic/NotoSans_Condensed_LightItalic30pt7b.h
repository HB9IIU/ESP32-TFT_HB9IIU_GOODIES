#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC30PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0x86, 0x18, 0x61, 0x04, 0x30, 0xC2, 0x08, 0x21, 0x86,
  0x00, 0x00, 0x08, 0x30, 0xC0, 0x66, 0xCD, 0x1A, 0x2C, 0x58, 0xA3, 0x00,
  0x01, 0x8C, 0x04, 0x20, 0x11, 0x80, 0xC6, 0x02, 0x10, 0x08, 0x43, 0xFF,
  0xC1, 0x08, 0x04, 0x20, 0x31, 0x80, 0xC4, 0x02, 0x10, 0x08, 0xC3, 0xFF,
  0xC1, 0x08, 0x04, 0x60, 0x31, 0x80, 0x84, 0x02, 0x10, 0x18, 0xC0, 0x42,
  0x00, 0x00, 0x40, 0x06, 0x00, 0x20, 0x0F, 0xF0, 0xC9, 0x0C, 0x40, 0x64,
  0x02, 0x20, 0x11, 0x00, 0xC8, 0x03, 0x40, 0x0C, 0x00, 0x38, 0x01, 0xE0,
  0x0B, 0x00, 0xCC, 0x04, 0x60, 0x22, 0x01, 0x11, 0x09, 0x8F, 0xF8, 0x0E,
  0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x0C, 0x02, 0x3E, 0x04, 0x22, 0x0C,
  0x62, 0x18, 0x42, 0x10, 0xC2, 0x30, 0xC2, 0x20, 0x86, 0x60, 0x86, 0x40,
  0x84, 0x9E, 0x8D, 0xB2, 0x89, 0x23, 0xFB, 0x63, 0x62, 0x43, 0x06, 0x42,
  0x04, 0xC2, 0x08, 0xC2, 0x18, 0xC6, 0x10, 0x86, 0x30, 0xC4, 0x20, 0xCC,
  0x60, 0x78, 0x01, 0x80, 0x1F, 0x01, 0x88, 0x08, 0x60, 0xC2, 0x06, 0x10,
  0x31, 0x81, 0x98, 0x04, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x03, 0x30, 0x90,
  0x8D, 0x86, 0x68, 0x36, 0xC0, 0xF6, 0x07, 0x30, 0x31, 0x83, 0xC6, 0x32,
  0x1F, 0x18, 0x6D, 0x25, 0xA0, 0x03, 0x83, 0x01, 0x01, 0x81, 0x80, 0x80,
  0xC0, 0x40, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x40, 0x30, 0x00, 0x06,
  0x01, 0x80, 0xC0, 0x20, 0x10, 0x08, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40,
  0x20, 0x10, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0,
  0xC0, 0x40, 0x40, 0x60, 0x00, 0x06, 0x01, 0x00, 0x43, 0x90, 0x35, 0xC3,
  0xF1, 0xC0, 0xD8, 0x62, 0x10, 0xC0, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x0F, 0xFF, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x33, 0x26, 0x4C, 0x80, 0xFF, 0xF0, 0xBC, 0x00, 0x18,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0x00, 0x03, 0x80, 0xF8,
  0x31, 0x8C, 0x11, 0x02, 0x60, 0x4C, 0x0B, 0x01, 0x60, 0x2C, 0x0D, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xB0, 0x36, 0x06, 0xC0, 0x98, 0x33, 0x06, 0x61,
  0x86, 0x60, 0xF8, 0x00, 0x0E, 0x39, 0xB6, 0x68, 0x81, 0x06, 0x0C, 0x18,
  0x20, 0x41, 0x83, 0x06, 0x08, 0x30, 0x60, 0xC1, 0x82, 0x0C, 0x00, 0x01,
  0xE0, 0x3F, 0x81, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x02, 0x7F, 0xE0, 0x01,
  0xC0, 0x7F, 0x06, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x60, 0x06, 0x03, 0xE0, 0x1F, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x08, 0x38, 0x7F, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x50, 0x0F, 0x00, 0xB0, 0x12, 0x03, 0x20, 0x26, 0x04,
  0x60, 0xC6, 0x08, 0x41, 0x04, 0x30, 0xC6, 0x0C, 0x40, 0xCC, 0x08, 0xFF,
  0xF0, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x07, 0xF8, 0x60, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x61, 0x87, 0x0F, 0xE0, 0x00, 0x00, 0xF0, 0x3F, 0x06, 0x00,
  0xC0, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0xF8, 0x58, 0xC6,
  0x0C, 0xE0, 0x4C, 0x04, 0xC0, 0x4C, 0x04, 0xC0, 0xCC, 0x0C, 0xC0, 0x8C,
  0x18, 0x63, 0x03, 0xE0, 0x7F, 0xF0, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x3F, 0x83, 0x0C, 0x10, 0x31, 0x81, 0x8C, 0x0C, 0x60, 0x41,
  0x06, 0x0C, 0x60, 0x26, 0x01, 0xE0, 0x1F, 0x01, 0x8C, 0x18, 0x61, 0x81,
  0x98, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x18, 0x81, 0x87, 0x18, 0x1F, 0x80,
  0x01, 0xC0, 0x7E, 0x0C, 0x31, 0x83, 0x18, 0x11, 0x01, 0x30, 0x13, 0x01,
  0x30, 0x33, 0x03, 0x30, 0x73, 0x07, 0x1F, 0xA0, 0xF2, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x86, 0x0F, 0xC0, 0x18, 0xC6, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x23, 0x98, 0x04, 0x1C, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x0C, 0x30, 0x60, 0x83, 0x04,
  0x00, 0x00, 0x30, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x10, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x00, 0x80, 0x00, 0x0E, 0x1F, 0xC8, 0x60, 0x10, 0x08, 0x04, 0x06,
  0x02, 0x03, 0x03, 0x03, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x00, 0x00,
  0x00, 0x08, 0x0C, 0x06, 0x00, 0x01, 0xFE, 0x00, 0xC0, 0xC0, 0x60, 0x18,
  0x30, 0x02, 0x18, 0x00, 0x84, 0x08, 0x22, 0x0F, 0x8C, 0x84, 0x63, 0x63,
  0x18, 0x90, 0x84, 0x24, 0x61, 0x0B, 0x10, 0xC2, 0xC4, 0x31, 0xA1, 0x08,
  0x48, 0xC6, 0x32, 0x11, 0x88, 0x87, 0xBC, 0x20, 0xC6, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xFE, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x02, 0x80, 0x14, 0x01, 0xA0, 0x09, 0x00, 0xC8, 0x04, 0x40, 0x62,
  0x02, 0x10, 0x30, 0x81, 0x84, 0x18, 0x20, 0xFF, 0x04, 0x0C, 0x60, 0x62,
  0x03, 0x30, 0x19, 0x00, 0xD8, 0x06, 0xC0, 0x3C, 0x01, 0x80, 0x07, 0xF0,
  0x10, 0x60, 0xC0, 0xC3, 0x03, 0x0C, 0x0C, 0x20, 0x30, 0x80, 0x86, 0x06,
  0x18, 0x30, 0x7F, 0x01, 0x1E, 0x0C, 0x0C, 0x30, 0x30, 0xC0, 0xC2, 0x03,
  0x08, 0x0C, 0x60, 0x31, 0x81, 0x86, 0x0E, 0x11, 0xF0, 0xFF, 0x00, 0x00,
  0xF0, 0x0F, 0xF0, 0x70, 0x43, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x38, 0x80,
  0x7E, 0x00, 0x07, 0xF0, 0x08, 0x70, 0x30, 0x30, 0x60, 0x60, 0xC0, 0x41,
  0x00, 0xC2, 0x01, 0x8C, 0x03, 0x18, 0x04, 0x30, 0x08, 0x40, 0x31, 0x80,
  0x63, 0x00, 0xC6, 0x01, 0x08, 0x06, 0x10, 0x08, 0x60, 0x30, 0xC0, 0xC1,
  0x83, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x20, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xFF, 0x07, 0xF8,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x20, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0xF8, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x07, 0xFC, 0x1C, 0x08, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x02, 0x07, 0xE4, 0x0F, 0x98, 0x03, 0x30, 0x06, 0x60, 0x0C, 0x40, 0x18,
  0x80, 0x21, 0x80, 0xC3, 0x01, 0x83, 0x87, 0x03, 0xFC, 0x00, 0x06, 0x03,
  0x04, 0x03, 0x0C, 0x03, 0x0C, 0x02, 0x0C, 0x06, 0x08, 0x06, 0x18, 0x06,
  0x18, 0x06, 0x18, 0x04, 0x1F, 0xFC, 0x1F, 0xFC, 0x30, 0x0C, 0x30, 0x08,
  0x30, 0x08, 0x20, 0x18, 0x20, 0x18, 0x60, 0x18, 0x60, 0x10, 0x60, 0x10,
  0x40, 0x30, 0xC0, 0x30, 0x0F, 0xC0, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80,
  0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60,
  0x10, 0x04, 0x03, 0x00, 0xC0, 0xFC, 0x00, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x0F, 0x80, 0x06, 0x06,
  0x08, 0x18, 0x30, 0x60, 0x61, 0x80, 0xC6, 0x01, 0x18, 0x06, 0x30, 0x0C,
  0xC0, 0x1B, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xC8, 0x03, 0x18, 0x06, 0x30,
  0x08, 0x60, 0x10, 0x40, 0x60, 0xC0, 0xC1, 0x81, 0x83, 0x02, 0x03, 0x0C,
  0x06, 0x00, 0x06, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18,
  0x0C, 0x04, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x0F,
  0xFF, 0xF8, 0x06, 0x00, 0x38, 0x30, 0x03, 0x83, 0xC0, 0x14, 0x1E, 0x01,
  0xE0, 0xF0, 0x0B, 0x05, 0x80, 0xD8, 0x6C, 0x04, 0x83, 0x60, 0x6C, 0x1B,
  0x02, 0x60, 0x88, 0x33, 0x04, 0x41, 0x10, 0x62, 0x18, 0x83, 0x10, 0x8C,
  0x18, 0x8C, 0x60, 0x84, 0x43, 0x04, 0x26, 0x10, 0x61, 0xA0, 0x83, 0x0F,
  0x0C, 0x18, 0x70, 0x60, 0x83, 0x83, 0x0C, 0x18, 0x10, 0x00, 0x06, 0x01,
  0x83, 0x00, 0x83, 0xC0, 0x41, 0xE0, 0x60, 0xB0, 0x30, 0x48, 0x18, 0x66,
  0x08, 0x33, 0x04, 0x19, 0x86, 0x08, 0x43, 0x04, 0x21, 0x86, 0x18, 0x83,
  0x0C, 0xC1, 0x82, 0x60, 0x81, 0x30, 0x40, 0xD0, 0x60, 0x68, 0x30, 0x1C,
  0x18, 0x0E, 0x08, 0x07, 0x0C, 0x03, 0x00, 0x00, 0xE0, 0x07, 0xF0, 0x18,
  0x30, 0x60, 0x61, 0x80, 0x42, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x60, 0x06,
  0xC0, 0x09, 0x80, 0x13, 0x00, 0x64, 0x00, 0xC8, 0x01, 0xB0, 0x02, 0x60,
  0x0C, 0xC0, 0x18, 0x80, 0x61, 0x80, 0xC3, 0x03, 0x03, 0x1C, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x21, 0xC3, 0x06, 0x18, 0x10, 0xC0, 0x84, 0x04, 0x20,
  0x63, 0x03, 0x18, 0x10, 0xC1, 0x84, 0x38, 0x7F, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x00,
  0x00, 0xE0, 0x07, 0xF0, 0x18, 0x30, 0x60, 0x61, 0x80, 0x42, 0x00, 0xCC,
  0x01, 0x98, 0x03, 0x60, 0x06, 0xC0, 0x09, 0x80, 0x13, 0x00, 0x64, 0x00,
  0xC8, 0x01, 0xB0, 0x02, 0x60, 0x0C, 0xC0, 0x18, 0x80, 0x61, 0x80, 0xC3,
  0x03, 0x03, 0x1C, 0x03, 0xF0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x07, 0xF0, 0x21, 0xC3, 0x06, 0x18, 0x10, 0xC0, 0x84,
  0x04, 0x20, 0x63, 0x03, 0x18, 0x30, 0xC3, 0x87, 0xF8, 0x7E, 0x03, 0x18,
  0x18, 0xC0, 0x82, 0x04, 0x10, 0x60, 0xC3, 0x06, 0x18, 0x30, 0x80, 0x8C,
  0x06, 0x00, 0x01, 0xC0, 0x3F, 0xC3, 0x04, 0x30, 0x01, 0x80, 0x08, 0x00,
  0x40, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x0C, 0x38,
  0x7F, 0x00, 0xFF, 0xE1, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x08, 0x06, 0x30, 0x0C, 0x60,
  0x10, 0xC0, 0x21, 0x00, 0xC2, 0x01, 0x8C, 0x03, 0x18, 0x04, 0x30, 0x08,
  0x40, 0x31, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x08, 0x06, 0x10, 0x0C, 0x60,
  0x18, 0xC0, 0x21, 0x80, 0xC1, 0x83, 0x03, 0x8E, 0x03, 0xF0, 0x00, 0x80,
  0x38, 0x02, 0x80, 0x68, 0x04, 0x80, 0xC8, 0x08, 0xC1, 0x8C, 0x18, 0xC3,
  0x0C, 0x30, 0xC6, 0x0C, 0x60, 0xC4, 0x0C, 0xC0, 0xC8, 0x0D, 0x80, 0xD0,
  0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x00, 0x80, 0x60, 0x38, 0x0E, 0x06,
  0x80, 0xE0, 0x68, 0x1E, 0x04, 0x81, 0xE0, 0xC8, 0x16, 0x0C, 0x83, 0x61,
  0x88, 0x26, 0x18, 0x86, 0x61, 0x08, 0x66, 0x30, 0x84, 0x62, 0x08, 0xC6,
  0x60, 0x88, 0x66, 0x09, 0x86, 0x40, 0x90, 0x6C, 0x0B, 0x06, 0x80, 0xB0,
  0x78, 0x0A, 0x07, 0x80, 0xE0, 0x70, 0x0C, 0x07, 0x00, 0xC0, 0x60, 0x00,
  0x06, 0x03, 0x02, 0x06, 0x03, 0x0C, 0x03, 0x08, 0x03, 0x18, 0x01, 0x30,
  0x01, 0x30, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x02, 0xC0, 0x06, 0xC0, 0x0C, 0x40, 0x0C, 0x40, 0x18, 0x60, 0x30, 0x60,
  0x30, 0x60, 0x60, 0x20, 0xC0, 0x30, 0x80, 0x78, 0x1B, 0x06, 0x60, 0xCC,
  0x30, 0x84, 0x11, 0x82, 0x20, 0x6C, 0x0F, 0x01, 0xE0, 0x38, 0x02, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x07,
  0xFC, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x03, 0xF0, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00,
  0x7C, 0x0F, 0xC0, 0xC6, 0x30, 0x84, 0x21, 0x8C, 0x63, 0x08, 0x42, 0x18,
  0xC6, 0x10, 0x84, 0x21, 0x80, 0x07, 0xE0, 0x0C, 0x01, 0x00, 0x20, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x60, 0xFC, 0x1F, 0x80, 0x03, 0x00, 0x70, 0x05, 0x80, 0xD8, 0x08,
  0x81, 0x8C, 0x30, 0x42, 0x06, 0x60, 0x64, 0x02, 0xC0, 0x30, 0xFF, 0x80,
  0xC6, 0x63, 0x10, 0x0F, 0x91, 0xCF, 0x30, 0x73, 0x06, 0x60, 0x66, 0x06,
  0x40, 0x6C, 0x06, 0xC0, 0x4C, 0x0C, 0xC0, 0xCC, 0x0C, 0xC1, 0x8C, 0x38,
  0x66, 0x87, 0xD8, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x08, 0x00, 0x9E, 0x1A, 0x31, 0xC3, 0x18, 0x11, 0x81, 0x10, 0x13, 0x01,
  0x30, 0x12, 0x03, 0x20, 0x36, 0x02, 0x60, 0x66, 0x06, 0x60, 0xC5, 0x18,
  0xDF, 0x00, 0x07, 0xC7, 0x13, 0x00, 0xC0, 0x60, 0x18, 0x04, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x20, 0xF8, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x03, 0xEC,
  0x1C, 0xF0, 0xC1, 0xC3, 0x06, 0x18, 0x18, 0x60, 0x61, 0x01, 0x8C, 0x06,
  0x30, 0x10, 0xC0, 0xC3, 0x03, 0x0C, 0x0C, 0x30, 0x70, 0xC3, 0x81, 0x9A,
  0x07, 0xD8, 0x00, 0x07, 0x87, 0x33, 0x04, 0xC1, 0x60, 0xD8, 0x34, 0x3B,
  0xF8, 0xE8, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x10, 0xFC, 0x00,
  0x1E, 0x00, 0x68, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x01, 0xF8, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x80, 0x1E, 0x00, 0x00, 0x07, 0xC8, 0x73, 0xC6,
  0x0E, 0x30, 0x63, 0x03, 0x18, 0x18, 0x80, 0xCC, 0x06, 0x60, 0x23, 0x03,
  0x18, 0x18, 0xC0, 0xC6, 0x0E, 0x30, 0xE0, 0xCD, 0x07, 0xD8, 0x00, 0xC0,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x30, 0x63, 0x83, 0xF0, 0x00, 0x06, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x9E, 0x1E, 0x71,
  0xC3, 0x18, 0x31, 0x83, 0x10, 0x33, 0x02, 0x30, 0x23, 0x06, 0x20, 0x66,
  0x06, 0x60, 0x46, 0x04, 0x40, 0xC4, 0x0C, 0xC0, 0xC0, 0x04, 0x1C, 0x10,
  0x00, 0x00, 0x02, 0x0C, 0x18, 0x30, 0x40, 0x83, 0x06, 0x0C, 0x10, 0x60,
  0xC1, 0x82, 0x04, 0x18, 0x00, 0x00, 0x40, 0x1C, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x18, 0x0F, 0x00, 0x06, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x83, 0x18, 0x61, 0x8C,
  0x18, 0x81, 0x18, 0x13, 0x03, 0x60, 0x3E, 0x03, 0xA0, 0x33, 0x06, 0x30,
  0x63, 0x06, 0x10, 0x41, 0x84, 0x18, 0xC1, 0x80, 0x06, 0x0C, 0x10, 0x60,
  0xC1, 0x82, 0x04, 0x18, 0x30, 0x60, 0x81, 0x06, 0x0C, 0x18, 0x20, 0xC1,
  0x83, 0x04, 0x08, 0x30, 0x00, 0x0B, 0xE7, 0xC3, 0xCD, 0x9C, 0x70, 0xE1,
  0x8C, 0x18, 0x31, 0x83, 0x06, 0x20, 0x40, 0x8C, 0x18, 0x11, 0x83, 0x06,
  0x30, 0x60, 0xC4, 0x08, 0x19, 0x81, 0x02, 0x30, 0x60, 0x46, 0x0C, 0x18,
  0x81, 0x83, 0x10, 0x20, 0x46, 0x0C, 0x08, 0x09, 0xE1, 0xE7, 0x1C, 0x31,
  0x83, 0x18, 0x31, 0x03, 0x30, 0x23, 0x02, 0x30, 0x62, 0x06, 0x60, 0x66,
  0x04, 0x60, 0x44, 0x0C, 0x40, 0xCC, 0x0C, 0x0F, 0x83, 0x98, 0xC1, 0x98,
  0x36, 0x06, 0xC0, 0xD0, 0x1E, 0x03, 0xC0, 0x78, 0x0B, 0x03, 0x60, 0x6C,
  0x09, 0x83, 0x18, 0xC1, 0xF0, 0x04, 0xF0, 0x68, 0xC3, 0x86, 0x18, 0x10,
  0xC0, 0x84, 0x04, 0x60, 0x23, 0x01, 0x18, 0x18, 0x80, 0xCC, 0x04, 0x60,
  0x63, 0x03, 0x18, 0x30, 0xA3, 0x0D, 0xF0, 0x60, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x0F, 0x91, 0xCF, 0x30, 0x73,
  0x06, 0x60, 0x66, 0x06, 0x40, 0x6C, 0x06, 0xC0, 0x4C, 0x0C, 0xC0, 0xCC,
  0x0C, 0xC1, 0xCC, 0x38, 0x66, 0x87, 0xD8, 0x01, 0x80, 0x10, 0x01, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x0B, 0xC7, 0xD1, 0xC0, 0x60, 0x18,
  0x04, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04,
  0x03, 0x00, 0x0F, 0xC6, 0x33, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC8, 0x63, 0xF0, 0x08, 0x30,
  0x60, 0x87, 0xE6, 0x0C, 0x18, 0x20, 0xC1, 0x83, 0x04, 0x08, 0x30, 0x60,
  0xC1, 0x83, 0x07, 0x80, 0x30, 0x33, 0x02, 0x30, 0x22, 0x06, 0x20, 0x66,
  0x06, 0x60, 0x46, 0x04, 0x40, 0xC4, 0x0C, 0xC0, 0xCC, 0x18, 0xC1, 0x8C,
  0x38, 0xC7, 0x87, 0xD0, 0x80, 0xE0, 0x68, 0x1A, 0x04, 0x83, 0x20, 0x88,
  0x63, 0x10, 0xCC, 0x32, 0x0D, 0x83, 0x40, 0xF0, 0x38, 0x0E, 0x03, 0x00,
  0x81, 0x83, 0x83, 0x82, 0x82, 0x86, 0x83, 0x86, 0x87, 0x84, 0x85, 0x8C,
  0x8D, 0x88, 0x89, 0x98, 0x99, 0x90, 0x91, 0xB0, 0x90, 0xB0, 0xB0, 0xA0,
  0xA0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x18, 0x18, 0x41, 0x83,
  0x18, 0x18, 0x80, 0x4C, 0x02, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x78,
  0x02, 0xC0, 0x32, 0x03, 0x18, 0x30, 0xC1, 0x82, 0x18, 0x18, 0x06, 0x06,
  0x0C, 0x08, 0x18, 0x30, 0x30, 0x60, 0x61, 0x80, 0xC3, 0x01, 0x8C, 0x03,
  0x18, 0x06, 0x60, 0x04, 0xC0, 0x09, 0x00, 0x16, 0x00, 0x28, 0x00, 0x70,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xE0, 0x0C, 0x03, 0x00, 0x40,
  0x18, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00,
  0xC0, 0x10, 0x07, 0xF8, 0x01, 0xE0, 0x60, 0x18, 0x03, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x18, 0x0E, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x38, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x18, 0x03,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00,
  0xC0, 0x0E, 0x03, 0x80, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xC0, 0xF0, 0x18, 0x00, 0x7C, 0x1C, 0x7F, 0x81,
  0xE0,
};

const GFXglyph NotoSans_Condensed_LightItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 21, 7, 1, -21 },
  { 17, 7, 7, 9, 3, -21 },
  { 24, 14, 21, 14, 0, -21 },
  { 61, 13, 25, 13, 0, -23 },
  { 102, 16, 22, 19, 2, -22 },
  { 146, 13, 22, 14, 0, -22 },
  { 182, 3, 7, 5, 3, -21 },
  { 185, 9, 26, 8, 1, -21 },
  { 215, 9, 26, 8, -2, -21 },
  { 245, 10, 10, 12, 3, -23 },
  { 258, 12, 14, 14, 1, -18 },
  { 279, 4, 7, 6, -1, -3 },
  { 283, 6, 2, 8, 1, -9 },
  { 285, 2, 3, 6, 1, -3 },
  { 286, 13, 21, 10, -1, -21 },
  { 321, 11, 22, 13, 1, -22 },
  { 352, 7, 21, 13, 4, -21 },
  { 371, 13, 22, 13, -1, -22 },
  { 407, 13, 22, 13, 0, -22 },
  { 443, 12, 22, 13, 0, -22 },
  { 476, 13, 21, 13, 0, -21 },
  { 511, 12, 22, 13, 1, -22 },
  { 544, 12, 21, 13, 2, -21 },
  { 576, 13, 22, 13, 0, -22 },
  { 612, 12, 22, 13, 0, -22 },
  { 645, 5, 16, 6, 0, -16 },
  { 655, 7, 20, 6, -1, -16 },
  { 673, 12, 13, 14, 1, -17 },
  { 693, 12, 7, 14, 1, -14 },
  { 704, 12, 13, 14, 1, -17 },
  { 724, 9, 22, 9, 1, -22 },
  { 749, 18, 24, 19, 1, -21 },
  { 803, 13, 21, 13, -2, -21 },
  { 838, 14, 21, 14, 0, -21 },
  { 875, 14, 22, 13, 1, -22 },
  { 914, 15, 21, 15, 0, -21 },
  { 954, 13, 21, 12, 0, -21 },
  { 989, 13, 21, 11, 0, -21 },
  { 1024, 15, 22, 16, 1, -22 },
  { 1066, 16, 21, 16, 0, -21 },
  { 1108, 10, 21, 7, -1, -21 },
  { 1135, 12, 26, 6, -5, -21 },
  { 1174, 15, 21, 13, 0, -21 },
  { 1214, 9, 21, 11, 0, -21 },
  { 1238, 21, 21, 20, 0, -21 },
  { 1294, 17, 21, 16, 0, -21 },
  { 1339, 15, 22, 16, 1, -22 },
  { 1381, 13, 21, 13, 0, -21 },
  { 1416, 15, 27, 16, 1, -22 },
  { 1467, 13, 21, 13, 0, -21 },
  { 1502, 13, 22, 12, 0, -22 },
  { 1538, 11, 21, 11, 3, -21 },
  { 1567, 15, 21, 16, 1, -21 },
  { 1607, 12, 21, 13, 3, -21 },
  { 1639, 20, 21, 21, 3, -21 },
  { 1692, 16, 21, 12, -2, -21 },
  { 1734, 11, 21, 11, 3, -21 },
  { 1763, 14, 21, 12, -1, -21 },
  { 1800, 12, 26, 9, -1, -21 },
  { 1839, 5, 21, 10, 3, -21 },
  { 1853, 11, 26, 9, -2, -21 },
  { 1889, 12, 11, 13, 1, -21 },
  { 1906, 9, 1, 9, -2, 3 },
  { 1908, 4, 5, 7, 4, -23 },
  { 1911, 12, 16, 13, 1, -16 },
  { 1935, 12, 23, 13, 0, -23 },
  { 1970, 10, 16, 10, 1, -16 },
  { 1990, 14, 23, 14, 1, -23 },
  { 2031, 10, 16, 12, 1, -16 },
  { 2051, 15, 30, 7, -4, -23 },
  { 2108, 13, 23, 14, 0, -16 },
  { 2146, 12, 23, 13, 0, -23 },
  { 2181, 7, 22, 6, 0, -22 },
  { 2201, 11, 29, 6, -4, -22 },
  { 2241, 12, 23, 11, 0, -23 },
  { 2276, 7, 23, 6, 0, -23 },
  { 2297, 19, 16, 20, 0, -16 },
  { 2335, 12, 16, 13, 0, -16 },
  { 2359, 11, 16, 13, 1, -16 },
  { 2381, 13, 23, 13, -1, -16 },
  { 2419, 12, 23, 14, 1, -16 },
  { 2454, 10, 16, 9, 0, -16 },
  { 2474, 10, 16, 10, 0, -16 },
  { 2494, 7, 20, 7, 1, -20 },
  { 2512, 12, 16, 13, 1, -16 },
  { 2536, 10, 16, 10, 2, -16 },
  { 2556, 16, 16, 17, 2, -16 },
  { 2588, 13, 16, 11, -1, -16 },
  { 2614, 15, 23, 11, -3, -16 },
  { 2658, 11, 16, 9, -1, -16 },
  { 2680, 11, 26, 10, 1, -21 },
  { 2716, 1, 30, 12, 6, -23 },
  { 2720, 11, 26, 10, -2, -21 },
  { 2756, 12, 3, 14, 1, -12 },
};

const GFXfont NotoSans_Condensed_LightItalic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic30pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC30PT7B_H_
