#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC53PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0x60, 0x0C, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x00, 0x1C, 0x39, 0xC1, 0xCE, 0x0E, 0x70,
  0x63, 0x87, 0x18, 0x38, 0xC1, 0xCE, 0x0C, 0x70, 0x63, 0x07, 0x18, 0x38,
  0xC1, 0x86, 0x0C, 0x60, 0x60, 0x00, 0x0E, 0x06, 0x00, 0x06, 0x07, 0x00,
  0x07, 0x03, 0x00, 0x03, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xE0,
  0x00, 0xE0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x38, 0x00, 0x38, 0x18,
  0x00, 0x18, 0x0C, 0x03, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x03, 0x03, 0x80, 0x01, 0x81, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xC0,
  0x60, 0x00, 0x60, 0x70, 0x00, 0x70, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18,
  0x1C, 0x00, 0x1C, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x03, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xE0, 0x00,
  0xE0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x38, 0x00, 0x38, 0x18, 0x00,
  0x18, 0x0C, 0x00, 0x0C, 0x0E, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x03, 0x00,
  0x03, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0xF1, 0x86, 0x03, 0x86, 0x00, 0x07, 0x0C, 0x00, 0x1C, 0x18, 0x00,
  0x38, 0x30, 0x00, 0x70, 0x60, 0x00, 0xE1, 0x80, 0x01, 0xC3, 0x00, 0x03,
  0x86, 0x00, 0x03, 0x8C, 0x00, 0x07, 0x98, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1B,
  0xC0, 0x00, 0x33, 0xC0, 0x00, 0x63, 0x80, 0x00, 0xC3, 0x80, 0x03, 0x07,
  0x00, 0x06, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x30, 0x00, 0x30, 0xE0,
  0x00, 0xC1, 0xC1, 0x01, 0x87, 0x01, 0xC3, 0x3C, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xC0,
  0x7F, 0x00, 0x1C, 0x0E, 0x38, 0x03, 0x81, 0xC1, 0x80, 0x30, 0x18, 0x18,
  0x07, 0x03, 0x81, 0x80, 0x60, 0x38, 0x18, 0x0E, 0x03, 0x01, 0x80, 0xC0,
  0x70, 0x18, 0x1C, 0x07, 0x01, 0x83, 0x80, 0x60, 0x38, 0x30, 0x06, 0x03,
  0x87, 0x00, 0xE0, 0x30, 0x60, 0x0E, 0x03, 0x0E, 0x00, 0xE0, 0x71, 0xC0,
  0x0E, 0x07, 0x18, 0x7C, 0xC0, 0x63, 0x8F, 0xEC, 0x0E, 0x31, 0xC7, 0xE0,
  0xC7, 0x38, 0x7E, 0x1C, 0x63, 0x03, 0x63, 0x8E, 0x70, 0x37, 0xF1, 0xC6,
  0x03, 0x3E, 0x18, 0x60, 0x30, 0x03, 0x8E, 0x03, 0x00, 0x30, 0xC0, 0x70,
  0x07, 0x0C, 0x07, 0x00, 0x60, 0xC0, 0x70, 0x0E, 0x1C, 0x06, 0x01, 0xC1,
  0xC0, 0x60, 0x18, 0x18, 0x0E, 0x03, 0x81, 0x80, 0xE0, 0x30, 0x18, 0x0C,
  0x07, 0x01, 0x81, 0xC0, 0xE0, 0x18, 0x18, 0x0E, 0x01, 0xC3, 0x81, 0xC0,
  0x1C, 0x70, 0x18, 0x00, 0xFF, 0x03, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x70,
  0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x30, 0x00, 0xC0,
  0x70, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0xE0, 0x00, 0xC0,
  0xE0, 0x00, 0xC1, 0xC0, 0x00, 0xE3, 0x80, 0x00, 0xE7, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0x9C, 0x01, 0x0F, 0x1C, 0x06, 0x1E, 0x1C, 0x0E, 0x1C, 0x0E,
  0x0E, 0x38, 0x0E, 0x1C, 0x70, 0x07, 0x1C, 0x70, 0x07, 0x38, 0x70, 0x07,
  0x38, 0x60, 0x03, 0xF0, 0xE0, 0x03, 0xF0, 0xE0, 0x01, 0xE0, 0xE0, 0x01,
  0xC0, 0xE0, 0x03, 0xE0, 0x70, 0x07, 0xE0, 0x70, 0x0E, 0xF0, 0x7C, 0x3C,
  0x70, 0x3F, 0xF8, 0x70, 0x1F, 0xF0, 0x38, 0x01, 0x00, 0x00, 0x1C, 0x73,
  0x8E, 0x38, 0xE3, 0x0C, 0x71, 0xC6, 0x18, 0x63, 0x80, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x04, 0x0C, 0x07,
  0x86, 0x03, 0xF3, 0x00, 0x3D, 0x3F, 0x07, 0xFF, 0x81, 0xF0, 0x01, 0xF0,
  0x01, 0xDC, 0x01, 0xC6, 0x01, 0xC3, 0x81, 0xC0, 0xC0, 0x40, 0x70, 0x00,
  0x38, 0x00, 0x08, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x0F,
  0x0E, 0x0E, 0x1C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x60, 0xE0, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x6F, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xFC, 0x00, 0xF3, 0xE0, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x07,
  0x07, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00,
  0x71, 0xC0, 0x07, 0x38, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x73, 0x00,
  0x07, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0xE0,
  0x00, 0xEE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE,
  0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07, 0x0E, 0x00, 0x70,
  0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x1C, 0x0E, 0x01, 0xC0, 0x70, 0x38,
  0x07, 0x8F, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xF0, 0x1E, 0x03, 0xE0, 0x7E, 0x1E, 0xE3, 0xCC, 0x79, 0xCE, 0x1C, 0xC1,
  0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xF0, 0x07, 0xE1, 0xF0, 0x07, 0x01, 0xE0, 0x08, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0x0F, 0x80, 0x60, 0x0E, 0x01, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x07, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x08, 0x00, 0xF0, 0x38, 0x0F,
  0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x0F,
  0xC0, 0x00, 0x1B, 0x80, 0x00, 0x77, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x38,
  0x00, 0x0E, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x61, 0xC0, 0x01, 0xC3, 0x00,
  0x07, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x30, 0x38, 0x00, 0xE0, 0x70, 0x03,
  0x80, 0xC0, 0x06, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xC0,
  0x18, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x18, 0x01, 0xC0, 0x70, 0x03,
  0x81, 0xC0, 0x06, 0x03, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x90, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xBF, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x40, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x08, 0x00, 0xF0,
  0x38, 0x0F, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0x86, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x1F, 0xC0, 0x33, 0xFF, 0x03, 0xB8, 0x3C, 0x1F,
  0x80, 0xE0, 0xF8, 0x03, 0x87, 0x80, 0x1C, 0x38, 0x00, 0xE3, 0xC0, 0x07,
  0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0,
  0x03, 0x8E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0xE0,
  0xE0, 0x07, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x80, 0xF0, 0x78, 0x03, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xE1, 0xE0, 0x0F, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80,
  0x0C, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x03,
  0x80, 0x38, 0x0E, 0x00, 0x70, 0x38, 0x00, 0x70, 0xE0, 0x00, 0xF7, 0x80,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x7C, 0x70, 0x01,
  0xE0, 0x70, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0xE0,
  0x01, 0xC1, 0xC0, 0x03, 0x83, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00,
  0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0x70, 0x01, 0xC0, 0xE0, 0x03,
  0x81, 0xE0, 0x0E, 0x01, 0xE0, 0x78, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0x78, 0x78,
  0x07, 0x81, 0xE0, 0x78, 0x07, 0x03, 0x80, 0x38, 0x38, 0x00, 0xE1, 0xC0,
  0x07, 0x0E, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71,
  0xC0, 0x03, 0x8C, 0x00, 0x1C, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x18, 0x00,
  0xF0, 0xE0, 0x07, 0x87, 0x00, 0x7C, 0x3C, 0x07, 0xE0, 0xF0, 0x76, 0x07,
  0xFF, 0x70, 0x1F, 0xE3, 0x80, 0x1C, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x01,
  0x03, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x03,
  0x80, 0xF0, 0x7C, 0x1E, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x78, 0x1E, 0x0F, 0x01, 0xC0, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x0E, 0x01,
  0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00, 0x07, 0xF8,
  0x1F, 0xFE, 0x1E, 0x1E, 0x08, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3E,
  0x0F, 0x80, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x03, 0x00, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x0C, 0x0E, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x38, 0x60, 0x0F, 0xF0,
  0x71, 0xC0, 0x7F, 0xE0, 0xE3, 0x01, 0xC1, 0xC1, 0xCE, 0x03, 0x03, 0x03,
  0x9C, 0x0E, 0x06, 0x07, 0x30, 0x38, 0x1C, 0x0E, 0xE0, 0x60, 0x38, 0x19,
  0xC1, 0xC0, 0x60, 0x33, 0x03, 0x00, 0xC0, 0x66, 0x06, 0x03, 0x81, 0xDC,
  0x1C, 0x07, 0x03, 0xB8, 0x38, 0x0C, 0x06, 0x70, 0x60, 0x18, 0x1C, 0xC0,
  0xC0, 0x70, 0x39, 0x81, 0x80, 0xE0, 0x63, 0x03, 0x03, 0xC1, 0xC6, 0x06,
  0x05, 0x83, 0x0C, 0x0C, 0x1B, 0x0E, 0x18, 0x1C, 0x66, 0x38, 0x30, 0x1F,
  0xCF, 0xE0, 0x60, 0x1E, 0x0F, 0x80, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x30,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x06, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xCE, 0x00,
  0x07, 0x38, 0x00, 0x18, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x1C,
  0x38, 0x00, 0x70, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x30, 0x38,
  0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x38, 0x06, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0x60, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x1C, 0x00,
  0x70, 0x70, 0x01, 0xC3, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x71,
  0xC0, 0x01, 0xC7, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x77, 0x00,
  0x01, 0xDC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x01,
  0xE0, 0x38, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x0E,
  0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x01, 0xC0,
  0xE0, 0x03, 0x81, 0xC0, 0x0E, 0x03, 0x00, 0x38, 0x0E, 0x01, 0xE0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x70, 0x7E, 0x01, 0xC0, 0x1E, 0x03, 0x80,
  0x1E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x70, 0x00,
  0xF0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E,
  0x1C, 0x00, 0x3C, 0x38, 0x00, 0x70, 0x70, 0x01, 0xE0, 0xE0, 0x07, 0x81,
  0x80, 0x1E, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xF8, 0x78, 0x07, 0x80, 0x20,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x30, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x38, 0x0F, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70,
  0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x03,
  0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00,
  0x1C, 0x1C, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x87, 0x00,
  0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0,
  0x00, 0x78, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x1E, 0x1C,
  0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81,
  0x80, 0x03, 0x81, 0xC0, 0x03, 0xC0, 0xE0, 0x03, 0xC0, 0x70, 0x03, 0xC0,
  0x38, 0x03, 0xC0, 0x18, 0x07, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xF0,
  0xFC, 0x03, 0xC0, 0x06, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x0F, 0xF8, 0xE0, 0x07, 0xFE, 0x38,
  0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C,
  0x38, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00,
  0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x03, 0xC0, 0x01, 0xC0, 0x70,
  0x00, 0x70, 0x1E, 0x00, 0x1C, 0x03, 0xC0, 0x07, 0x00, 0x7C, 0x0F, 0x80,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x70, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0C, 0x03, 0x80, 0x01, 0xC0, 0x38,
  0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x07,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00,
  0x0C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0,
  0x38, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x07, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70,
  0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x83, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x03, 0xC0, 0x70, 0x01, 0xE0, 0x1C, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x0F, 0x00, 0x38, 0x07, 0x80,
  0x0E, 0x03, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x30, 0x38,
  0x00, 0x1C, 0x1E, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x71,
  0xC0, 0x00, 0x18, 0xE0, 0x00, 0x0E, 0x78, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0xEF, 0x80, 0x00, 0x3E, 0xE0, 0x00, 0x1F, 0x38, 0x00, 0x07, 0x87, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x03,
  0x80, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x0C,
  0x01, 0xC0, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x01,
  0xC0, 0x38, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x1B, 0x00, 0x00, 0x6E, 0x03, 0xB0, 0x00, 0x0F,
  0xC0, 0x3B, 0x00, 0x00, 0xDC, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x3B, 0x80,
  0x01, 0x9C, 0x03, 0x38, 0x00, 0x39, 0x80, 0x73, 0x80, 0x03, 0x38, 0x07,
  0x38, 0x00, 0x73, 0x80, 0x73, 0x80, 0x06, 0x38, 0x07, 0x38, 0x00, 0xE3,
  0x80, 0x63, 0x80, 0x0C, 0x30, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0xE1, 0x80,
  0x18, 0x70, 0x0E, 0x18, 0x03, 0x87, 0x00, 0xC1, 0x80, 0x30, 0x70, 0x1C,
  0x18, 0x07, 0x0E, 0x01, 0xC1, 0xC0, 0x60, 0xE0, 0x1C, 0x1C, 0x0E, 0x0E,
  0x01, 0xC1, 0xC0, 0xC0, 0xE0, 0x18, 0x1C, 0x1C, 0x0C, 0x03, 0x81, 0xC1,
  0x81, 0xC0, 0x38, 0x1C, 0x38, 0x1C, 0x03, 0x81, 0xC3, 0x01, 0xC0, 0x38,
  0x1C, 0x70, 0x1C, 0x03, 0x01, 0xC6, 0x01, 0x80, 0x70, 0x0C, 0xE0, 0x38,
  0x07, 0x00, 0xCC, 0x03, 0x80, 0x70, 0x0D, 0xC0, 0x38, 0x07, 0x00, 0xD8,
  0x03, 0x80, 0xE0, 0x0F, 0x80, 0x70, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x0F, 0x00, 0x01, 0x80, 0x7C, 0x00, 0x1C, 0x03, 0xE0, 0x00, 0xE0, 0x1F,
  0x00, 0x07, 0x00, 0xD8, 0x00, 0x38, 0x0E, 0xE0, 0x01, 0x80, 0x77, 0x00,
  0x1C, 0x03, 0xB8, 0x00, 0xE0, 0x1C, 0xC0, 0x07, 0x00, 0xC7, 0x00, 0x38,
  0x0E, 0x38, 0x03, 0x80, 0x71, 0xC0, 0x1C, 0x03, 0x86, 0x00, 0xE0, 0x1C,
  0x38, 0x07, 0x00, 0xC1, 0xC0, 0x30, 0x0E, 0x0E, 0x03, 0x80, 0x70, 0x30,
  0x1C, 0x03, 0x81, 0xC0, 0xE0, 0x18, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x30,
  0x0E, 0x03, 0x83, 0x80, 0x70, 0x0C, 0x1C, 0x03, 0x80, 0x70, 0xE0, 0x18,
  0x03, 0x87, 0x01, 0xC0, 0x1C, 0x30, 0x0E, 0x00, 0x63, 0x80, 0x70, 0x03,
  0x9C, 0x03, 0x80, 0x1C, 0xE0, 0x18, 0x00, 0xE6, 0x01, 0xC0, 0x03, 0x30,
  0x0E, 0x00, 0x1F, 0x80, 0x70, 0x00, 0xFC, 0x03, 0x80, 0x07, 0xE0, 0x38,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x1F, 0x00,
  0x3C, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x1C,
  0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1D, 0xC0, 0x00,
  0x1E, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0xB8, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0x38,
  0x00, 0x07, 0x1C, 0x00, 0x07, 0x8E, 0x00, 0x03, 0x87, 0x00, 0x03, 0xC3,
  0x80, 0x01, 0xC1, 0xC0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x38, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x07, 0xC3, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x0E, 0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0xE0, 0x07,
  0x01, 0xC0, 0x0F, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x1C, 0x0C, 0x00, 0x70,
  0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x0F, 0x03,
  0x00, 0x1C, 0x0E, 0x00, 0x78, 0x1C, 0x01, 0xE0, 0x38, 0x07, 0x80, 0x70,
  0x3E, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x3E, 0x1F, 0x00, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x3C, 0x00,
  0x38, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x8E, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x39, 0xC0,
  0x00, 0x1D, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38,
  0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x1E,
  0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03,
  0x87, 0x00, 0x03, 0xC3, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xE0, 0xF0, 0x01,
  0xE0, 0x38, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x07, 0xC3, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0E, 0x03, 0xC0, 0x1C, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x0E, 0x07,
  0x00, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0,
  0x03, 0x81, 0xC0, 0x0E, 0x03, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x1C, 0x01,
  0xE0, 0x38, 0x0F, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x07, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x1C, 0x00,
  0xE0, 0x38, 0x01, 0xC0, 0x78, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x01, 0x80,
  0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0xFE, 0x3E, 0x00, 0xF0, 0x06, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0xC0, 0x07, 0x80, 0xF8, 0x3F, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x01, 0xC0, 0xE0,
  0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03,
  0x83, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00,
  0x07, 0x03, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C,
  0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x70,
  0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xC0, 0x00,
  0x60, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0xC0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x01,
  0xC0, 0x03, 0x80, 0x70, 0x01, 0xE0, 0x1C, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x00, 0xF8, 0x3E, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00,
  0x1C, 0xE0, 0x00, 0x73, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x70,
  0xE0, 0x01, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0,
  0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0xE0, 0x38, 0x03, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x38, 0x0E, 0x00, 0xE0, 0x70, 0x01,
  0x81, 0xC0, 0x06, 0x07, 0x00, 0x18, 0x38, 0x00, 0x60, 0xE0, 0x01, 0x87,
  0x00, 0x06, 0x1C, 0x00, 0x18, 0xE0, 0x00, 0x63, 0x80, 0x01, 0x9C, 0x00,
  0x07, 0x70, 0x00, 0x1D, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xB8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0x00, 0x0E, 0xE0, 0x01, 0xE0, 0x00,
  0xEE, 0x00, 0x1E, 0x00, 0x1C, 0xE0, 0x01, 0xE0, 0x01, 0xCE, 0x00, 0x3E,
  0x00, 0x38, 0xE0, 0x03, 0x60, 0x03, 0x8E, 0x00, 0x76, 0x00, 0x38, 0xE0,
  0x07, 0x60, 0x07, 0x0E, 0x00, 0x66, 0x00, 0x70, 0xE0, 0x0E, 0x60, 0x0E,
  0x0E, 0x00, 0xC6, 0x00, 0xE0, 0xE0, 0x1C, 0x60, 0x1C, 0x0E, 0x01, 0xC6,
  0x01, 0xC0, 0xE0, 0x38, 0x60, 0x1C, 0x0E, 0x03, 0x86, 0x03, 0x80, 0xE0,
  0x30, 0x60, 0x38, 0x0E, 0x07, 0x06, 0x07, 0x00, 0xE0, 0x60, 0x60, 0x70,
  0x0E, 0x0E, 0x06, 0x07, 0x00, 0xE0, 0xE0, 0x60, 0xE0, 0x0E, 0x0C, 0x06,
  0x0E, 0x00, 0xE1, 0xC0, 0x61, 0xC0, 0x0E, 0x18, 0x06, 0x1C, 0x00, 0xE3,
  0x80, 0x61, 0x80, 0x0E, 0x38, 0x06, 0x38, 0x00, 0xE7, 0x00, 0x63, 0x80,
  0x0E, 0x70, 0x06, 0x70, 0x00, 0xE6, 0x00, 0x67, 0x00, 0x0E, 0xE0, 0x06,
  0x60, 0x00, 0xEC, 0x00, 0x6E, 0x00, 0x0F, 0xC0, 0x0E, 0xE0, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0xC0, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x70, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x19,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x38, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x70,
  0x07, 0x00, 0x1E, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80,
  0x3C, 0x00, 0x70, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0x70, 0x01, 0xEE, 0x00, 0x39, 0xC0,
  0x0E, 0x18, 0x01, 0xC3, 0x80, 0x70, 0x70, 0x0E, 0x0E, 0x03, 0x81, 0xC0,
  0xF0, 0x38, 0x1C, 0x07, 0x07, 0x00, 0x60, 0xE0, 0x0E, 0x38, 0x01, 0xC7,
  0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xEE, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xE0, 0x30, 0x18, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x30, 0x18, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x30, 0x18, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x30, 0x18, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x30, 0x18, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x30, 0x1C, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x37, 0x00, 0x01, 0xDC, 0x00, 0x0E, 0x30, 0x00, 0x38, 0xE0,
  0x01, 0xC3, 0x80, 0x06, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xC0, 0x30, 0x07,
  0x00, 0xE0, 0x38, 0x03, 0x80, 0xE0, 0x06, 0x07, 0x00, 0x1C, 0x1C, 0x00,
  0x70, 0xE0, 0x00, 0xE3, 0x00, 0x03, 0x9C, 0x00, 0x06, 0xE0, 0x00, 0x1C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0x8F, 0x1C, 0x30, 0xE1, 0x87, 0x0C, 0x00,
  0x18, 0x00, 0x07, 0xF0, 0xC0, 0xFF, 0xCE, 0x0F, 0x87, 0x70, 0x70, 0x1B,
  0x07, 0x00, 0x78, 0x78, 0x03, 0xC3, 0x80, 0x1E, 0x38, 0x00, 0xE1, 0xC0,
  0x07, 0x0E, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x63,
  0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00,
  0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x03, 0xC3, 0x80, 0x1E, 0x1C,
  0x01, 0xE0, 0xE0, 0x1F, 0x07, 0x81, 0xB8, 0x1E, 0x1D, 0xC0, 0xFF, 0xCC,
  0x01, 0xF8, 0x60, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x0E, 0x00, 0x71, 0xFC, 0x03, 0x9F, 0xF0, 0x1D, 0xC3, 0xC0, 0xD8, 0x0E,
  0x07, 0x80, 0x38, 0x7C, 0x01, 0xC3, 0xC0, 0x0E, 0x1E, 0x00, 0x70, 0xE0,
  0x03, 0x8F, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38,
  0xC0, 0x01, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00,
  0x70, 0xE0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x01, 0xC3, 0xC0, 0x0E, 0x1E,
  0x00, 0xE0, 0xF0, 0x0F, 0x0F, 0xC0, 0xF0, 0x77, 0x0F, 0x03, 0x3F, 0xF0,
  0x18, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x7F, 0xC0, 0x7F,
  0xE0, 0xF8, 0x10, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1E, 0x06, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x18, 0x38, 0x00, 0xFE,
  0x38, 0x03, 0xFF, 0x38, 0x07, 0xC3, 0xB8, 0x07, 0x01, 0xB0, 0x0E, 0x00,
  0xF0, 0x1E, 0x00, 0xF0, 0x1C, 0x00, 0xF0, 0x38, 0x00, 0xF0, 0x38, 0x00,
  0xE0, 0x38, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00,
  0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01,
  0xC0, 0xE0, 0x03, 0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x07, 0x80, 0xE0, 0x07,
  0x80, 0xE0, 0x0F, 0x80, 0xE0, 0x0F, 0x00, 0xE0, 0x1B, 0x00, 0xF0, 0x3F,
  0x00, 0x78, 0x77, 0x00, 0x7F, 0xE7, 0x00, 0x3F, 0x86, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x1E, 0x0E, 0x07, 0x01,
  0xC3, 0x80, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x38, 0x01, 0xCE, 0x00, 0xE7,
  0x00, 0x79, 0xC0, 0x3C, 0x70, 0x1E, 0x18, 0xFF, 0x0F, 0xFF, 0x03, 0xFE,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0x07,
  0x81, 0xC0, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xC2, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0x8C, 0x03,
  0xFF, 0x38, 0x0F, 0x87, 0x70, 0x1C, 0x06, 0xC0, 0x70, 0x07, 0x81, 0xE0,
  0x0F, 0x03, 0x80, 0x1E, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x70, 0x38, 0x00,
  0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x0E, 0x00, 0x1C,
  0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0xC1,
  0xC0, 0x07, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x3C, 0x0E, 0x00, 0xF8, 0x1C,
  0x01, 0xE0, 0x38, 0x06, 0xC0, 0x78, 0x1F, 0x80, 0x78, 0x77, 0x00, 0xFF,
  0xCE, 0x00, 0xFE, 0x18, 0x00, 0x30, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x10, 0x03, 0x80, 0x30, 0x1F, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x78,
  0x07, 0x1F, 0xE0, 0x73, 0xFE, 0x07, 0x70, 0xF0, 0x6C, 0x07, 0x07, 0x80,
  0x70, 0xF0, 0x07, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x71, 0xE0,
  0x07, 0x1C, 0x00, 0x61, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x38,
  0x00, 0xE3, 0x80, 0x0C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x30, 0x01, 0xC7,
  0x00, 0x1C, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x86, 0x00, 0x38,
  0xE0, 0x03, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0x01, 0xE0,
  0x3C, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x10, 0x70, 0x07, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x78, 0x06,
  0x03, 0x80, 0x70, 0x38, 0x03, 0x83, 0x80, 0x1C, 0x38, 0x00, 0xE3, 0x80,
  0x0E, 0x3C, 0x00, 0x71, 0xC0, 0x03, 0x9C, 0x00, 0x1D, 0xE0, 0x00, 0xDF,
  0x80, 0x0F, 0xDC, 0x00, 0x7C, 0xE0, 0x03, 0xC7, 0x00, 0x1C, 0x1C, 0x00,
  0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x03, 0x80, 0xE0, 0x1C, 0x07,
  0x00, 0xC0, 0x38, 0x0E, 0x00, 0xC0, 0x70, 0x07, 0x03, 0x80, 0x38, 0x1C,
  0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x70, 0x07, 0x1F, 0xC1, 0xFC, 0x07, 0x7F, 0xE3, 0xFE, 0x06, 0xE0, 0xE7,
  0x0F, 0x06, 0xC0, 0xEC, 0x07, 0x07, 0x80, 0x78, 0x07, 0x0F, 0x00, 0x78,
  0x07, 0x0F, 0x00, 0x70, 0x07, 0x0E, 0x00, 0x70, 0x07, 0x0E, 0x00, 0xE0,
  0x07, 0x1E, 0x00, 0xE0, 0x06, 0x1C, 0x00, 0xE0, 0x0E, 0x1C, 0x00, 0xE0,
  0x0E, 0x1C, 0x00, 0xC0, 0x0E, 0x1C, 0x01, 0xC0, 0x0E, 0x38, 0x01, 0xC0,
  0x0C, 0x38, 0x01, 0xC0, 0x1C, 0x38, 0x01, 0x80, 0x1C, 0x38, 0x03, 0x80,
  0x1C, 0x30, 0x03, 0x80, 0x1C, 0x70, 0x03, 0x80, 0x18, 0x70, 0x03, 0x80,
  0x38, 0x70, 0x03, 0x00, 0x38, 0x70, 0x07, 0x00, 0x38, 0x60, 0x07, 0x00,
  0x38, 0xE0, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x00, 0x70, 0xE0, 0x06, 0x00,
  0x70, 0xE0, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x80, 0x71, 0xFE, 0x07, 0x7F,
  0xE0, 0x67, 0x0F, 0x06, 0xC0, 0x70, 0x78, 0x07, 0x0F, 0x00, 0x70, 0xF0,
  0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x1E, 0x00, 0x71, 0xC0, 0x06, 0x1C,
  0x00, 0xE1, 0xC0, 0x0E, 0x18, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x01, 0xC3,
  0x80, 0x1C, 0x38, 0x01, 0xC3, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x38,
  0x70, 0x03, 0x87, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x30, 0xE0, 0x07,
  0x0E, 0x00, 0x70, 0xE0, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xE0, 0x0F,
  0xFE, 0x03, 0xC1, 0xE0, 0x70, 0x1E, 0x1C, 0x01, 0xC7, 0x00, 0x38, 0xE0,
  0x07, 0x38, 0x00, 0xE7, 0x00, 0x1D, 0xE0, 0x03, 0xB8, 0x00, 0x77, 0x00,
  0x0E, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3B, 0x80, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x01,
  0xC7, 0x00, 0x38, 0xE0, 0x0E, 0x0E, 0x03, 0xC1, 0xE0, 0xF0, 0x1F, 0xFC,
  0x01, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xE3, 0xFC,
  0x00, 0xE7, 0xFC, 0x00, 0xEE, 0x1E, 0x00, 0xD8, 0x0E, 0x00, 0xF8, 0x07,
  0x01, 0xF0, 0x07, 0x01, 0xE0, 0x07, 0x01, 0xE0, 0x07, 0x01, 0xC0, 0x07,
  0x01, 0xC0, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07,
  0x03, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E,
  0x07, 0x00, 0x0E, 0x07, 0x00, 0x1C, 0x0F, 0x00, 0x1C, 0x0F, 0x00, 0x38,
  0x0F, 0x00, 0x38, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x1D, 0x01, 0xE0,
  0x1D, 0xC3, 0xC0, 0x1C, 0xFF, 0x80, 0x1C, 0x7F, 0x00, 0x18, 0x10, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x07, 0xF0, 0xC0, 0xFF, 0xCE, 0x0F, 0x07, 0x70, 0x70, 0x1B, 0x07, 0x00,
  0x78, 0x78, 0x03, 0xC3, 0x80, 0x1E, 0x38, 0x00, 0xF1, 0xC0, 0x07, 0x0E,
  0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x73, 0x80, 0x07,
  0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0xF1, 0xC0,
  0x07, 0x0E, 0x00, 0x78, 0x70, 0x03, 0xC3, 0x80, 0x3E, 0x1C, 0x01, 0xE0,
  0xE0, 0x1B, 0x07, 0x81, 0xF8, 0x1E, 0x1D, 0xC0, 0xFF, 0xCE, 0x03, 0xF8,
  0x60, 0x03, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x83, 0x8F, 0x81, 0xCF, 0xC0, 0xCE, 0x00, 0x6C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xE0, 0x7F, 0xFC, 0x3C, 0x06, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x20, 0x0E,
  0x0C, 0x07, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x07, 0xFF, 0x7F, 0xF0,
  0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0F,
  0xE0, 0x7E, 0x01, 0x00, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70,
  0xC0, 0x07, 0x1C, 0x00, 0x61, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E,
  0x18, 0x00, 0xE3, 0x80, 0x0C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01,
  0xC7, 0x00, 0x1C, 0x70, 0x01, 0x87, 0x00, 0x38, 0x70, 0x03, 0x86, 0x00,
  0x38, 0xE0, 0x07, 0x8E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xE0,
  0x0F, 0x0E, 0x01, 0xE0, 0xE0, 0x36, 0x0F, 0x0E, 0x60, 0x7F, 0xCE, 0x03,
  0xF8, 0xE0, 0x04, 0x00, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0xEE, 0x00, 0x3B,
  0x80, 0x1C, 0xE0, 0x07, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x70, 0xE0,
  0x1C, 0x38, 0x0E, 0x0E, 0x03, 0x83, 0x81, 0xC0, 0x60, 0x70, 0x18, 0x38,
  0x06, 0x0E, 0x01, 0x83, 0x00, 0x61, 0xC0, 0x18, 0x60, 0x06, 0x38, 0x01,
  0x8E, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x3F,
  0x00, 0x78, 0x03, 0xB8, 0x03, 0xC0, 0x1D, 0xC0, 0x3E, 0x01, 0xCE, 0x01,
  0xB0, 0x0E, 0x70, 0x0D, 0x80, 0x63, 0x80, 0xEC, 0x07, 0x1C, 0x06, 0x60,
  0x38, 0xE0, 0x73, 0x03, 0x87, 0x03, 0x18, 0x1C, 0x38, 0x38, 0xC0, 0xC1,
  0xC1, 0xC6, 0x0E, 0x0E, 0x0C, 0x30, 0x70, 0x70, 0xE1, 0x87, 0x03, 0x86,
  0x0C, 0x38, 0x1C, 0x70, 0x63, 0x80, 0xE3, 0x03, 0x1C, 0x07, 0x38, 0x18,
  0xC0, 0x39, 0xC0, 0xCE, 0x01, 0xCC, 0x06, 0x70, 0x0E, 0xE0, 0x37, 0x00,
  0x76, 0x01, 0xB8, 0x03, 0xF0, 0x0D, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0xF8,
  0x03, 0xC0, 0x07, 0xC0, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x1E, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x0E,
  0x03, 0x80, 0x1C, 0x0F, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x70, 0x00, 0x71,
  0xC0, 0x00, 0x63, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0x30, 0x00, 0x1C, 0x70, 0x00,
  0x70, 0xE0, 0x01, 0xC0, 0xC0, 0x03, 0x81, 0xC0, 0x0E, 0x03, 0x80, 0x38,
  0x07, 0x00, 0xF0, 0x06, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0xE0, 0x06, 0x00, 0x1C, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x80, 0x38, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x01,
  0xC0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x70,
  0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E,
  0x0C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x03, 0x1C, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x20, 0x7F,
  0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x03, 0xC0,
  0x00, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x06, 0x00,
  0x01, 0xFE, 0x00, 0x5F, 0xFC, 0x07, 0xE1, 0xFD, 0xFC, 0x03, 0xFF, 0x40,
  0x03, 0xE0,
};

const GFXglyph NotoSans_Condensed_LightItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 11, 38, 12, 1, -38 },
  { 54, 13, 14, 17, 5, -38 },
  { 77, 25, 38, 25, 1, -38 },
  { 196, 23, 43, 22, 0, -40 },
  { 320, 28, 39, 33, 3, -38 },
  { 457, 24, 39, 25, 0, -38 },
  { 574, 6, 14, 9, 5, -38 },
  { 585, 16, 46, 13, 1, -38 },
  { 677, 16, 46, 13, -4, -38 },
  { 769, 17, 18, 21, 6, -40 },
  { 808, 21, 25, 24, 2, -31 },
  { 874, 8, 13, 10, -2, -6 },
  { 887, 12, 3, 15, 1, -16 },
  { 892, 4, 5, 10, 1, -5 },
  { 895, 23, 38, 17, -2, -38 },
  { 1005, 20, 39, 22, 2, -38 },
  { 1103, 12, 38, 22, 7, -38 },
  { 1160, 23, 38, 22, -1, -38 },
  { 1270, 22, 39, 22, 0, -38 },
  { 1378, 23, 38, 22, -1, -38 },
  { 1488, 22, 39, 22, 0, -38 },
  { 1596, 21, 39, 22, 2, -38 },
  { 1699, 21, 38, 22, 3, -38 },
  { 1799, 23, 39, 22, 0, -38 },
  { 1912, 21, 39, 22, 1, -38 },
  { 2015, 10, 28, 10, 0, -28 },
  { 2050, 12, 35, 10, -2, -28 },
  { 2103, 21, 24, 24, 2, -31 },
  { 2166, 21, 14, 24, 2, -26 },
  { 2203, 21, 24, 24, 2, -31 },
  { 2266, 16, 38, 16, 2, -38 },
  { 2342, 31, 43, 34, 2, -38 },
  { 2509, 22, 38, 22, -3, -38 },
  { 2614, 23, 38, 24, 1, -38 },
  { 2724, 23, 39, 23, 3, -38 },
  { 2837, 25, 38, 27, 1, -38 },
  { 2956, 22, 38, 21, 1, -38 },
  { 3061, 23, 38, 20, 1, -38 },
  { 3171, 26, 39, 28, 3, -38 },
  { 3298, 28, 38, 28, 1, -38 },
  { 3431, 18, 38, 13, -2, -38 },
  { 3517, 20, 48, 11, -8, -38 },
  { 3637, 26, 38, 23, 1, -38 },
  { 3761, 15, 38, 20, 1, -38 },
  { 3833, 36, 38, 36, 1, -38 },
  { 4004, 29, 38, 29, 1, -38 },
  { 4142, 25, 39, 29, 3, -38 },
  { 4264, 23, 38, 23, 1, -38 },
  { 4374, 25, 47, 29, 3, -38 },
  { 4521, 23, 38, 23, 1, -38 },
  { 4631, 24, 39, 21, -1, -38 },
  { 4748, 20, 38, 20, 4, -38 },
  { 4843, 26, 39, 28, 2, -38 },
  { 4970, 22, 38, 23, 5, -38 },
  { 5075, 36, 38, 37, 5, -38 },
  { 5246, 27, 38, 21, -3, -38 },
  { 5375, 19, 38, 20, 5, -38 },
  { 5466, 25, 38, 20, -2, -38 },
  { 5585, 20, 46, 15, -1, -38 },
  { 5700, 9, 38, 17, 5, -38 },
  { 5743, 20, 46, 15, -4, -38 },
  { 5858, 22, 21, 24, 1, -38 },
  { 5916, 16, 2, 17, -4, 5 },
  { 5920, 6, 9, 12, 8, -41 },
  { 5927, 21, 30, 24, 2, -29 },
  { 6006, 21, 41, 24, 1, -40 },
  { 6114, 17, 30, 18, 2, -29 },
  { 6178, 24, 41, 24, 2, -40 },
  { 6301, 18, 30, 21, 2, -29 },
  { 6369, 26, 54, 12, -7, -41 },
  { 6545, 23, 42, 24, 0, -29 },
  { 6666, 20, 40, 23, 1, -40 },
  { 6766, 11, 38, 10, 1, -38 },
  { 6819, 19, 51, 10, -7, -38 },
  { 6941, 21, 40, 20, 1, -40 },
  { 7046, 11, 40, 10, 1, -40 },
  { 7101, 32, 29, 35, 1, -29 },
  { 7217, 20, 29, 23, 1, -29 },
  { 7290, 19, 30, 23, 2, -29 },
  { 7362, 24, 41, 24, -2, -29 },
  { 7485, 21, 42, 24, 2, -29 },
  { 7596, 17, 29, 16, 1, -29 },
  { 7658, 18, 30, 18, 0, -29 },
  { 7726, 12, 36, 13, 2, -35 },
  { 7780, 20, 29, 23, 2, -28 },
  { 7853, 18, 28, 18, 3, -28 },
  { 7916, 29, 28, 30, 3, -28 },
  { 8018, 23, 28, 19, -2, -28 },
  { 8099, 27, 41, 19, -6, -28 },
  { 8238, 20, 28, 17, -2, -28 },
  { 8308, 19, 46, 17, 1, -38 },
  { 8418, 2, 53, 22, 10, -40 },
  { 8432, 19, 46, 17, -3, -38 },
  { 8542, 21, 6, 24, 2, -22 },
};

const GFXfont NotoSans_Condensed_LightItalic53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic53pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC53PT7B_H_
