#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC42PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x07,
  0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x10, 0x1C, 0x0E, 0x06, 0x00, 0x38,
  0xCC, 0x33, 0x0D, 0xC7, 0x61, 0x98, 0x66, 0x19, 0x86, 0x43, 0x30, 0xCC,
  0x30, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0x40, 0x06, 0x0C, 0x00,
  0x60, 0xC0, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x81,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x18, 0x30, 0x01, 0x86, 0x00, 0x30, 0x60,
  0x03, 0x06, 0x00, 0x30, 0x40, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C,
  0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0xC1, 0x80, 0x0C, 0x30, 0x01, 0x83,
  0x00, 0x18, 0x30, 0x01, 0x82, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30,
  0x60, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x71, 0x08, 0x18, 0x40, 0x0E, 0x30,
  0x03, 0x0C, 0x00, 0xC2, 0x00, 0x30, 0x80, 0x0E, 0x20, 0x01, 0x98, 0x00,
  0x76, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03,
  0x70, 0x00, 0x8C, 0x00, 0x23, 0x80, 0x18, 0x60, 0x06, 0x18, 0x01, 0x0E,
  0x00, 0x43, 0x00, 0x11, 0xC3, 0x8C, 0xE0, 0xFF, 0xF0, 0x0F, 0xF0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x07, 0xC0, 0x18,
  0x1D, 0x80, 0x60, 0x61, 0x80, 0xC0, 0xC3, 0x03, 0x03, 0x06, 0x06, 0x06,
  0x0C, 0x18, 0x18, 0x18, 0x70, 0x30, 0x30, 0xC0, 0x60, 0x63, 0x00, 0xC1,
  0x86, 0x01, 0x83, 0x18, 0x02, 0x06, 0x30, 0x0C, 0x0C, 0xC7, 0xD8, 0x33,
  0x1F, 0xB0, 0x66, 0x61, 0xB1, 0x99, 0x83, 0x76, 0x33, 0x06, 0x78, 0xC6,
  0x0C, 0x01, 0x98, 0x18, 0x06, 0x30, 0x60, 0x18, 0x60, 0xC0, 0x30, 0xC1,
  0x80, 0xC3, 0x03, 0x01, 0x86, 0x06, 0x06, 0x0C, 0x18, 0x1C, 0x18, 0x30,
  0x30, 0x30, 0xC0, 0xC0, 0x61, 0x81, 0x80, 0x6E, 0x06, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x07, 0x1C, 0x00, 0xC1, 0x80, 0x30, 0x30,
  0x06, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x38, 0x03, 0x06, 0x00, 0x61, 0x80,
  0x0C, 0x70, 0x01, 0xDC, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3F, 0x00, 0x0C, 0xE0, 0xE3, 0x0C, 0x18, 0xE1, 0xC3, 0x38, 0x18, 0xE6,
  0x03, 0x98, 0xC0, 0x37, 0x38, 0x06, 0xC7, 0x00, 0xF0, 0xE0, 0x0E, 0x1C,
  0x03, 0xC3, 0x80, 0xF8, 0x38, 0x3B, 0x87, 0xFE, 0x30, 0x7F, 0x07, 0x00,
  0x39, 0x8C, 0x67, 0x31, 0x8C, 0x42, 0x30, 0x00, 0x30, 0x06, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x1C, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x18, 0x00, 0xC1, 0x06, 0x0C, 0x30, 0x79, 0x00, 0x7F, 0xE0, 0xFF,
  0x0F, 0x00, 0xD8, 0x0C, 0x61, 0xC3, 0x06, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x0E, 0x18, 0x70, 0xC3, 0x86, 0x0C, 0x30, 0xE0, 0xFF, 0xFF,
  0xC0, 0x5F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFE, 0x03, 0x87, 0x07, 0x03, 0x06,
  0x03, 0x0E, 0x03, 0x0C, 0x03, 0x1C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x38,
  0x03, 0x30, 0x03, 0x30, 0x03, 0x70, 0x03, 0x70, 0x07, 0x60, 0x07, 0x60,
  0x06, 0x60, 0x06, 0x60, 0x0E, 0x60, 0x0E, 0xE0, 0x0C, 0xE0, 0x0C, 0xE0,
  0x1C, 0xE0, 0x18, 0xE0, 0x38, 0x60, 0x30, 0x60, 0x60, 0x70, 0xE0, 0x3F,
  0xC0, 0x1F, 0x80, 0x01, 0xC0, 0xE0, 0xF8, 0x76, 0x39, 0xBC, 0xE4, 0x30,
  0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03,
  0x00, 0xC0, 0x70, 0x18, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x38, 0x1C,
  0x04, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFC, 0x3F, 0xFF,
  0x00, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0x70, 0x38, 0x10, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x17,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x03, 0x82, 0x01, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xE0, 0x01, 0xB0, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xCC,
  0x00, 0xC6, 0x00, 0x67, 0x00, 0x63, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x30,
  0x60, 0x30, 0x70, 0x18, 0x30, 0x18, 0x18, 0x18, 0x0C, 0x1C, 0x0E, 0x0C,
  0x07, 0x0C, 0x03, 0x0E, 0x01, 0x87, 0xFF, 0xFB, 0xFF, 0xFC, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x81, 0xC0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x03, 0x82, 0x01, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0xFF, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x80, 0x67, 0xF0, 0x6E,
  0x78, 0xF8, 0x18, 0xF0, 0x1C, 0xE0, 0x0C, 0xE0, 0x0C, 0xC0, 0x0C, 0xC0,
  0x0C, 0xC0, 0x1C, 0xC0, 0x1C, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x38, 0xC0,
  0x30, 0xC0, 0x70, 0xE0, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0xFF, 0x9F,
  0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x38, 0x38, 0x1C, 0x07, 0x06, 0x01,
  0xC1, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x07, 0x06, 0x01, 0x81, 0x80, 0xE0,
  0x70, 0x30, 0x0C, 0x18, 0x03, 0x9C, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x1F,
  0xC0, 0x0E, 0x38, 0x07, 0x07, 0x03, 0x80, 0xC1, 0xC0, 0x38, 0x60, 0x06,
  0x18, 0x01, 0x8E, 0x00, 0x63, 0x80, 0x18, 0xE0, 0x06, 0x38, 0x03, 0x86,
  0x00, 0xC1, 0xC0, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0xFF, 0x80, 0xE0, 0xC0, 0xE0, 0x70, 0x60, 0x18, 0x60, 0x0C, 0x30, 0x06,
  0x38, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x71, 0x80,
  0x38, 0xC0, 0x1C, 0x70, 0x1C, 0x38, 0x1E, 0x0F, 0x3B, 0x03, 0xF9, 0x80,
  0x61, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x3C, 0x0F, 0xF8, 0x07, 0xF8,
  0x00, 0x02, 0x07, 0x0F, 0x0E, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x70, 0xF0, 0x60,
  0x00, 0x80, 0x70, 0x3C, 0x0E, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x1C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x0F, 0xF0, 0x7F,
  0xE1, 0x83, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x1C, 0x00, 0xF0, 0x01,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1C, 0x03, 0x80,
  0x18, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x18, 0x00, 0x18, 0x18, 0x00, 0x06,
  0x1C, 0x00, 0x03, 0x0C, 0x03, 0x81, 0x8C, 0x07, 0xF0, 0xC6, 0x06, 0x18,
  0x66, 0x06, 0x18, 0x33, 0x06, 0x0C, 0x19, 0x86, 0x06, 0x0D, 0x83, 0x03,
  0x06, 0xC1, 0x83, 0x06, 0x61, 0x81, 0x83, 0x30, 0xC0, 0xC1, 0x98, 0x60,
  0xE0, 0xC8, 0x30, 0x60, 0xCC, 0x18, 0x30, 0x66, 0x0C, 0x38, 0x63, 0x06,
  0x34, 0x31, 0x83, 0xB3, 0x70, 0xC0, 0xF1, 0xF0, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x3C, 0x0C, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0D,
  0x80, 0x03, 0x60, 0x01, 0x98, 0x00, 0x66, 0x00, 0x31, 0x80, 0x0C, 0x60,
  0x07, 0x18, 0x01, 0x86, 0x00, 0xE1, 0x80, 0x30, 0x60, 0x1C, 0x18, 0x06,
  0x07, 0x01, 0x81, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1C, 0x07, 0x06, 0x01,
  0xC3, 0x80, 0x30, 0xC0, 0x0C, 0x70, 0x03, 0x18, 0x00, 0xCE, 0x00, 0x33,
  0x00, 0x0D, 0xC0, 0x03, 0x70, 0x00, 0xF8, 0x00, 0x30, 0x03, 0xFE, 0x00,
  0xFF, 0xE0, 0x70, 0x38, 0x1C, 0x07, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x60,
  0x0C, 0x38, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x70, 0xC0, 0x18, 0x30, 0x0E,
  0x1C, 0x0F, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x60, 0xF0, 0x38, 0x0E, 0x0E,
  0x01, 0xC3, 0x00, 0x70, 0xC0, 0x0C, 0x30, 0x03, 0x1C, 0x00, 0xC7, 0x00,
  0x71, 0x80, 0x1C, 0x60, 0x06, 0x18, 0x03, 0x8E, 0x01, 0xC3, 0x01, 0xE0,
  0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xFC, 0x07, 0x01,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x04, 0x01,
  0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x1C, 0x1E,
  0x03, 0x80, 0xE0, 0x60, 0x0C, 0x0C, 0x01, 0xC1, 0x80, 0x18, 0x70, 0x03,
  0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x31, 0xC0, 0x06,
  0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x18,
  0xC0, 0x03, 0x18, 0x00, 0xE3, 0x00, 0x18, 0xE0, 0x07, 0x18, 0x00, 0xC3,
  0x00, 0x38, 0x60, 0x0E, 0x0C, 0x03, 0x83, 0x80, 0xE0, 0x60, 0x78, 0x0F,
  0xFE, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x70, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xF0, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x7F,
  0xF0, 0x3F, 0xFC, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x07, 0xFF, 0xC0, 0x78, 0x0C, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x9C, 0x03, 0xF8, 0xE0, 0x1F, 0xC7, 0x00, 0x06, 0x30, 0x00, 0x71, 0x80,
  0x03, 0x8C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x80, 0x06, 0x1C, 0x00, 0x70,
  0x60, 0x03, 0x03, 0x80, 0x18, 0x1C, 0x00, 0xC0, 0x78, 0x06, 0x01, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0x03, 0x00, 0x1C, 0x0C, 0x00, 0x60, 0x70, 0x01,
  0x81, 0xC0, 0x06, 0x06, 0x00, 0x38, 0x18, 0x00, 0xE0, 0x60, 0x03, 0x03,
  0x80, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x01, 0xC0, 0xC0, 0x06, 0x03, 0x00,
  0x18, 0x1C, 0x00, 0x60, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x06, 0x00, 0x30,
  0x38, 0x00, 0xC0, 0xE0, 0x03, 0x03, 0x00, 0x1C, 0x0C, 0x00, 0x70, 0x30,
  0x01, 0x81, 0xC0, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0xE0, 0x60, 0x03,
  0x01, 0x80, 0x0C, 0x0E, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x07, 0x03,
  0x00, 0x18, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x07, 0xF8, 0x1F, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x06, 0xF0, 0x0F, 0xC0, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x70, 0x30, 0x0E, 0x07, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x03,
  0x80, 0x60, 0x70, 0x06, 0x0E, 0x00, 0xE1, 0xC0, 0x0C, 0x18, 0x00, 0xC3,
  0x80, 0x0C, 0x70, 0x00, 0xCE, 0x00, 0x1D, 0xC0, 0x01, 0x9C, 0x00, 0x1B,
  0xC0, 0x01, 0xEC, 0x00, 0x3C, 0xC0, 0x03, 0x8E, 0x00, 0x30, 0x60, 0x03,
  0x06, 0x00, 0x30, 0x70, 0x07, 0x07, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00,
  0x60, 0x38, 0x06, 0x01, 0x80, 0xE0, 0x18, 0x0C, 0x01, 0xC0, 0xC0, 0x1C,
  0x0C, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x03, 0x80, 0x60, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x00,
  0xF0, 0x38, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07,
  0xC0, 0x03, 0xE0, 0x6C, 0x00, 0x36, 0x06, 0xC0, 0x07, 0xE0, 0xEC, 0x00,
  0x6C, 0x0C, 0xC0, 0x0E, 0xC0, 0xCC, 0x00, 0xCC, 0x0C, 0xC0, 0x1C, 0xC0,
  0xCC, 0x01, 0x9C, 0x1C, 0xC0, 0x39, 0x81, 0x8C, 0x03, 0x18, 0x18, 0xC0,
  0x71, 0x81, 0x8C, 0x06, 0x38, 0x38, 0xC0, 0xE3, 0x83, 0x0E, 0x0C, 0x30,
  0x30, 0x61, 0xC3, 0x03, 0x06, 0x18, 0x30, 0x30, 0x63, 0x87, 0x07, 0x06,
  0x30, 0x60, 0x60, 0x67, 0x06, 0x06, 0x06, 0x60, 0x60, 0x60, 0x6E, 0x06,
  0x06, 0x06, 0xC0, 0xE0, 0xE0, 0x7C, 0x0C, 0x0C, 0x07, 0x80, 0xC0, 0xC0,
  0x78, 0x0C, 0x0C, 0x07, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x18,
  0x1E, 0x00, 0x30, 0x3C, 0x00, 0x60, 0x7C, 0x01, 0xC0, 0xD8, 0x03, 0x01,
  0xB0, 0x06, 0x07, 0x60, 0x0C, 0x0C, 0xE0, 0x18, 0x18, 0xC0, 0x70, 0x31,
  0x80, 0xC0, 0x63, 0x01, 0x81, 0xC7, 0x03, 0x03, 0x06, 0x0E, 0x06, 0x0C,
  0x18, 0x0C, 0x18, 0x30, 0x38, 0x38, 0x60, 0x60, 0x30, 0xC0, 0xC0, 0x63,
  0x81, 0x80, 0xC6, 0x03, 0x01, 0xCC, 0x0E, 0x01, 0x98, 0x18, 0x03, 0x30,
  0x30, 0x06, 0xE0, 0x60, 0x0F, 0x80, 0xC0, 0x0F, 0x03, 0x80, 0x1E, 0x06,
  0x00, 0x3C, 0x0C, 0x00, 0x78, 0x18, 0x00, 0x60, 0x00, 0x00, 0x7F, 0x00,
  0x1F, 0xFC, 0x03, 0x81, 0xE0, 0x70, 0x0E, 0x06, 0x00, 0x60, 0xC0, 0x07,
  0x1C, 0x00, 0x71, 0x80, 0x07, 0x38, 0x00, 0x33, 0x80, 0x03, 0x30, 0x00,
  0x77, 0x00, 0x07, 0x70, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x6E, 0x00,
  0x06, 0xE0, 0x00, 0x6E, 0x00, 0x0E, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0,
  0x01, 0xCC, 0x00, 0x18, 0xC0, 0x01, 0x8E, 0x00, 0x38, 0xE0, 0x07, 0x06,
  0x00, 0x60, 0x70, 0x0E, 0x07, 0x83, 0xC0, 0x3F, 0xF8, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x70, 0x78, 0x1C, 0x0E, 0x06, 0x01, 0x81,
  0x80, 0x70, 0x60, 0x1C, 0x38, 0x07, 0x0C, 0x01, 0xC3, 0x00, 0x60, 0xC0,
  0x18, 0x30, 0x0E, 0x1C, 0x03, 0x06, 0x01, 0xC1, 0x80, 0xE0, 0x61, 0xF0,
  0x3F, 0xF8, 0x0F, 0xF0, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F,
  0xFC, 0x03, 0x81, 0xE0, 0x70, 0x0E, 0x06, 0x00, 0x60, 0xC0, 0x07, 0x1C,
  0x00, 0x71, 0x80, 0x07, 0x38, 0x00, 0x33, 0x80, 0x03, 0x30, 0x00, 0x77,
  0x00, 0x07, 0x70, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x6E, 0x00, 0x06,
  0xE0, 0x00, 0x6E, 0x00, 0x0E, 0xC0, 0x00, 0xEC, 0x00, 0x0C, 0xC0, 0x01,
  0xCC, 0x00, 0x18, 0xC0, 0x01, 0x8E, 0x00, 0x38, 0xE0, 0x07, 0x06, 0x00,
  0x60, 0x70, 0x0E, 0x07, 0x83, 0xC0, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x70, 0x78,
  0x1C, 0x0E, 0x06, 0x01, 0x81, 0x80, 0x70, 0x60, 0x1C, 0x38, 0x07, 0x0C,
  0x01, 0xC3, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x0E, 0x1C, 0x03, 0x06, 0x01,
  0xC1, 0x81, 0xE0, 0x7F, 0xF0, 0x3F, 0xE0, 0x0E, 0x18, 0x03, 0x06, 0x00,
  0xC1, 0xC0, 0x30, 0x70, 0x1C, 0x0C, 0x07, 0x03, 0x01, 0x80, 0xE0, 0x60,
  0x38, 0x18, 0x06, 0x0E, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x1C, 0x30, 0x07,
  0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0x01, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x20, 0x1C, 0x0F, 0xFF, 0x80, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x38, 0x70, 0x01, 0x83, 0x80, 0x0C, 0x18, 0x00, 0xE0, 0xC0, 0x07, 0x06,
  0x00, 0x30, 0x70, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0xE0, 0xC0, 0x06,
  0x0E, 0x00, 0x30, 0x70, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0xE0, 0xC0,
  0x06, 0x0E, 0x00, 0x30, 0x70, 0x01, 0x83, 0x00, 0x1C, 0x18, 0x00, 0xE0,
  0xC0, 0x06, 0x0E, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x1C, 0x18, 0x00,
  0xC0, 0xC0, 0x0E, 0x07, 0x00, 0x60, 0x38, 0x07, 0x00, 0xE0, 0x70, 0x03,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xD8,
  0x00, 0xEC, 0x00, 0x66, 0x00, 0x73, 0x00, 0x31, 0x80, 0x38, 0xC0, 0x18,
  0x60, 0x1C, 0x30, 0x0C, 0x18, 0x06, 0x0C, 0x07, 0x06, 0x03, 0x03, 0x03,
  0x81, 0x81, 0x80, 0xE1, 0xC0, 0x70, 0xC0, 0x38, 0xE0, 0x1C, 0x60, 0x06,
  0x30, 0x03, 0x30, 0x01, 0x98, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x06, 0x00,
  0x3C, 0x00, 0xE0, 0x07, 0xC0, 0x0E, 0x00, 0x6C, 0x00, 0xE0, 0x0E, 0xC0,
  0x1E, 0x00, 0xCC, 0x01, 0xE0, 0x1C, 0xC0, 0x36, 0x01, 0x8C, 0x03, 0x60,
  0x18, 0xC0, 0x76, 0x03, 0x8C, 0x06, 0x60, 0x30, 0xC0, 0x66, 0x07, 0x0C,
  0x0C, 0x60, 0x60, 0xC0, 0xC6, 0x06, 0x0C, 0x18, 0x60, 0xE0, 0xC1, 0x86,
  0x0C, 0x0C, 0x18, 0x61, 0xC0, 0xC3, 0x06, 0x18, 0x0C, 0x30, 0x61, 0x80,
  0xC6, 0x06, 0x30, 0x0C, 0x60, 0x63, 0x00, 0xCE, 0x06, 0x70, 0x0C, 0xC0,
  0x66, 0x00, 0xCC, 0x06, 0x60, 0x0D, 0x80, 0x6C, 0x00, 0xD8, 0x06, 0xC0,
  0x0F, 0x80, 0x7C, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x00, 0xE0,
  0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x01, 0x80, 0x18, 0x0C, 0x01, 0x80,
  0x70, 0x1C, 0x03, 0x80, 0xC0, 0x0C, 0x0E, 0x00, 0x60, 0x60, 0x03, 0x06,
  0x00, 0x1C, 0x70, 0x00, 0x63, 0x00, 0x03, 0x30, 0x00, 0x1B, 0x80, 0x00,
  0xD8, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xF8, 0x00, 0x06, 0xC0, 0x00, 0x66, 0x00, 0x07, 0x30, 0x00, 0x31,
  0x80, 0x03, 0x0E, 0x00, 0x38, 0x30, 0x01, 0x81, 0x80, 0x1C, 0x0C, 0x01,
  0xC0, 0x60, 0x0C, 0x03, 0x80, 0xE0, 0x1C, 0x0E, 0x00, 0x60, 0x60, 0x03,
  0x00, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x76, 0x00, 0xCE, 0x03, 0x9C, 0x06,
  0x18, 0x1C, 0x30, 0x30, 0x60, 0xE0, 0xC1, 0x81, 0x86, 0x03, 0x9C, 0x03,
  0x30, 0x06, 0xE0, 0x0D, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xC0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x03, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC0, 0xC0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x36, 0x00, 0x1B, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x0C, 0x18, 0x0E, 0x0C,
  0x06, 0x07, 0x07, 0x01, 0x83, 0x00, 0xC3, 0x00, 0x71, 0x80, 0x19, 0x80,
  0x0D, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xE3, 0x1C, 0x63, 0x0C, 0x20,
  0x00, 0xF0, 0x01, 0xFC, 0xC1, 0xE7, 0x61, 0xC0, 0xB0, 0xC0, 0x78, 0xE0,
  0x38, 0x60, 0x1C, 0x70, 0x0E, 0x30, 0x07, 0x38, 0x03, 0x1C, 0x01, 0x8C,
  0x00, 0xC6, 0x00, 0x63, 0x00, 0x71, 0x80, 0x31, 0xC0, 0x18, 0xE0, 0x1C,
  0x70, 0x0E, 0x18, 0x0F, 0x0C, 0x0F, 0x07, 0x0D, 0x81, 0xFC, 0xC0, 0xFC,
  0x60, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x0E, 0x01, 0x9F,
  0xC0, 0xDC, 0xF0, 0x78, 0x38, 0x68, 0x0C, 0x3C, 0x06, 0x1C, 0x03, 0x0C,
  0x01, 0x86, 0x00, 0xC7, 0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x1C,
  0xE0, 0x0E, 0x70, 0x06, 0x30, 0x03, 0x18, 0x03, 0x8C, 0x01, 0x8E, 0x01,
  0xC7, 0x81, 0xC3, 0x41, 0xC1, 0xBF, 0xC1, 0x8F, 0xC0, 0x00, 0x78, 0x0F,
  0xF0, 0x78, 0xC3, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x20, 0xFF, 0x81,
  0xFC, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x1E, 0x30, 0x0F, 0xE6, 0x03, 0xCE, 0xC0, 0xE0, 0x58, 0x18, 0x0F, 0x07,
  0x00, 0xC0, 0xC0, 0x18, 0x38, 0x07, 0x06, 0x00, 0xE1, 0xC0, 0x1C, 0x38,
  0x03, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x03, 0x87, 0x00, 0x60, 0xE0,
  0x0C, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x70, 0x1E, 0x06, 0x07, 0x80, 0xE1,
  0xB0, 0x0F, 0xE6, 0x01, 0xF8, 0xC0, 0x00, 0x70, 0x07, 0xF8, 0x1E, 0x70,
  0x70, 0x70, 0xC0, 0x63, 0x00, 0xCE, 0x03, 0x98, 0x06, 0x30, 0x1C, 0xE0,
  0x71, 0x87, 0xC3, 0xFE, 0x07, 0xC0, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x01, 0x07, 0xFE, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x7F, 0x30, 0x3C, 0xEC, 0x1C, 0x0B, 0x06, 0x03, 0xC3, 0x80,
  0xE0, 0xC0, 0x18, 0x70, 0x0E, 0x18, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x30,
  0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x01, 0xC7, 0x00, 0x61, 0xC0, 0x18, 0x70,
  0x0E, 0x1C, 0x03, 0x87, 0x01, 0xE0, 0xC0, 0xF0, 0x38, 0x6C, 0x07, 0xF3,
  0x01, 0xF8, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x0C, 0x0E, 0x03, 0xFF, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x0E, 0x01,
  0x9F, 0xC0, 0xDC, 0xE0, 0x78, 0x38, 0x78, 0x0C, 0x38, 0x06, 0x1C, 0x07,
  0x0C, 0x03, 0x86, 0x01, 0x87, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x70, 0xC0,
  0x30, 0xE0, 0x18, 0x70, 0x0C, 0x30, 0x06, 0x18, 0x07, 0x0C, 0x03, 0x0E,
  0x01, 0x86, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x71, 0xC0, 0x30, 0x03, 0x81,
  0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x03, 0x01, 0x81, 0xC0,
  0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xC0,
  0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x07, 0x00, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x3F, 0x00, 0x7C, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0xE0, 0xC0,
  0xE0, 0x60, 0xE0, 0x70, 0xE0, 0x30, 0x60, 0x18, 0x60, 0x0C, 0x60, 0x06,
  0x70, 0x07, 0x70, 0x03, 0x78, 0x01, 0xBC, 0x00, 0xF6, 0x00, 0xF3, 0x80,
  0x71, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x0C, 0x1C, 0x0E, 0x0E, 0x06, 0x03,
  0x03, 0x01, 0x81, 0x80, 0xE1, 0xC0, 0x70, 0x01, 0x80, 0xC0, 0x60, 0x70,
  0x38, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x30,
  0x18, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18,
  0x0C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0x00, 0x1C, 0x06, 0x01, 0x9F,
  0x8F, 0xE0, 0x6C, 0x77, 0x3C, 0x1E, 0x0D, 0x03, 0x0F, 0x03, 0xC0, 0xC3,
  0x80, 0xE0, 0x30, 0xE0, 0x30, 0x0C, 0x30, 0x0C, 0x03, 0x0C, 0x03, 0x01,
  0xC7, 0x01, 0xC0, 0x61, 0x80, 0x60, 0x18, 0x60, 0x18, 0x06, 0x18, 0x06,
  0x01, 0x8E, 0x03, 0x80, 0xE3, 0x80, 0xE0, 0x30, 0xC0, 0x30, 0x0C, 0x30,
  0x0C, 0x03, 0x0C, 0x03, 0x00, 0xC7, 0x01, 0xC0, 0x71, 0x80, 0x60, 0x18,
  0x60, 0x18, 0x06, 0x18, 0x06, 0x01, 0x8E, 0x03, 0x80, 0xE0, 0x00, 0x1C,
  0x03, 0x3F, 0x81, 0xB9, 0xC0, 0xF0, 0x70, 0xF0, 0x18, 0x70, 0x1C, 0x38,
  0x0E, 0x18, 0x07, 0x1C, 0x03, 0x0E, 0x01, 0x86, 0x00, 0xC3, 0x00, 0xE1,
  0x80, 0x61, 0xC0, 0x30, 0xE0, 0x18, 0x60, 0x0C, 0x30, 0x0E, 0x18, 0x06,
  0x1C, 0x03, 0x0C, 0x01, 0x86, 0x01, 0xC3, 0x00, 0xE3, 0x80, 0x60, 0x00,
  0xF0, 0x03, 0xFC, 0x07, 0x9E, 0x0E, 0x06, 0x0C, 0x07, 0x18, 0x07, 0x38,
  0x03, 0x30, 0x03, 0x30, 0x03, 0x70, 0x03, 0x70, 0x07, 0x60, 0x07, 0x60,
  0x06, 0x60, 0x06, 0xE0, 0x06, 0xE0, 0x0E, 0xE0, 0x0C, 0xE0, 0x1C, 0x60,
  0x18, 0x60, 0x38, 0x70, 0x70, 0x3F, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0x00,
  0x33, 0xF8, 0x06, 0xE7, 0x80, 0xF0, 0x70, 0x34, 0x06, 0x07, 0x80, 0xC0,
  0xE0, 0x18, 0x1C, 0x03, 0x03, 0x00, 0x60, 0xE0, 0x0C, 0x18, 0x01, 0x83,
  0x00, 0x30, 0x60, 0x06, 0x1C, 0x01, 0xC3, 0x80, 0x30, 0x60, 0x06, 0x0C,
  0x01, 0xC1, 0x80, 0x30, 0x70, 0x0E, 0x0F, 0x03, 0x81, 0xA0, 0xE0, 0x37,
  0xF8, 0x06, 0x7E, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x01, 0xFC, 0xC1, 0xE7, 0x61, 0xC0,
  0xB0, 0xC0, 0x78, 0xE0, 0x38, 0x60, 0x0C, 0x70, 0x0E, 0x30, 0x07, 0x38,
  0x03, 0x9C, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x73, 0x80, 0x31,
  0xC0, 0x18, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x0F, 0x0C, 0x0F, 0x07, 0x0D,
  0x83, 0xFC, 0xC0, 0xFC, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x19, 0xF0, 0x6F, 0x81, 0xE0, 0x0D, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0xF0,
  0xE1, 0xC7, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x80, 0xC3, 0xFF, 0x0F, 0xF0,
  0x00, 0x02, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x07, 0xFD, 0xFF, 0x1C,
  0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x38, 0x07, 0xC1, 0xF0,
  0x0C, 0x03, 0x86, 0x01, 0x87, 0x00, 0xC3, 0x80, 0x61, 0x80, 0x30, 0xC0,
  0x38, 0x60, 0x18, 0x70, 0x0C, 0x30, 0x06, 0x18, 0x07, 0x0C, 0x03, 0x86,
  0x01, 0x87, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x70, 0xC0, 0x30, 0x60, 0x38,
  0x70, 0x1C, 0x38, 0x1E, 0x0C, 0x1B, 0x07, 0xF9, 0x01, 0xF9, 0x80, 0xE0,
  0x0F, 0xC0, 0x3B, 0x80, 0x67, 0x01, 0xC6, 0x03, 0x0C, 0x0E, 0x18, 0x18,
  0x30, 0x30, 0x60, 0xC0, 0xC1, 0x81, 0x86, 0x03, 0x0C, 0x06, 0x30, 0x0C,
  0x60, 0x19, 0xC0, 0x33, 0x00, 0x6E, 0x00, 0xD8, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x00, 0xC0, 0x70, 0x0F, 0x01, 0xC0, 0x6C, 0x0F,
  0x01, 0xB0, 0x3C, 0x0E, 0xC0, 0xF0, 0x33, 0x06, 0xC0, 0xCC, 0x1B, 0x06,
  0x30, 0xCC, 0x18, 0xC3, 0x30, 0xE3, 0x1C, 0xC3, 0x0C, 0x63, 0x1C, 0x31,
  0x8C, 0x60, 0xCC, 0x31, 0x83, 0x30, 0xCC, 0x0D, 0x83, 0x30, 0x36, 0x0D,
  0xC0, 0xD8, 0x36, 0x03, 0xC0, 0xD8, 0x0F, 0x03, 0xC0, 0x38, 0x0F, 0x00,
  0xE0, 0x38, 0x03, 0x00, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0xC0, 0x60, 0x30,
  0x38, 0x0E, 0x1C, 0x01, 0x86, 0x00, 0x63, 0x00, 0x19, 0xC0, 0x07, 0x60,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xFC, 0x00, 0x73, 0x00, 0x18, 0xC0, 0x0C, 0x30, 0x07, 0x06, 0x01, 0x81,
  0x80, 0xC0, 0x60, 0x70, 0x1C, 0x38, 0x03, 0x00, 0x01, 0x80, 0x38, 0x0C,
  0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x18, 0x0E, 0x00, 0xC0, 0x60,
  0x06, 0x07, 0x00, 0x30, 0x30, 0x01, 0x83, 0x80, 0x0C, 0x18, 0x00, 0x60,
  0xC0, 0x03, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00,
  0x1B, 0x00, 0x00, 0xD8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0F, 0xFE, 0x1F,
  0xFC, 0x00, 0x00, 0x1E, 0x00, 0xFC, 0x01, 0xC0, 0x06, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x01, 0xF0, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x30, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xC0, 0x03, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x70, 0x03,
  0xC0, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E,
  0x00, 0x18, 0x01, 0xF0, 0x07, 0xC0, 0x0C, 0x00, 0x00, 0x3E, 0x01, 0xFF,
  0x81, 0xC1, 0xFF, 0x80, 0x7E,
};

const GFXglyph NotoSans_Condensed_LightItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 9, 30, 9, 1, -30 },
  { 35, 10, 11, 13, 4, -30 },
  { 49, 20, 30, 20, 0, -30 },
  { 124, 18, 34, 18, 0, -32 },
  { 201, 23, 30, 26, 2, -30 },
  { 288, 19, 30, 20, 0, -30 },
  { 360, 5, 11, 7, 4, -30 },
  { 367, 12, 37, 11, 1, -30 },
  { 423, 12, 37, 11, -3, -30 },
  { 479, 13, 14, 17, 5, -32 },
  { 502, 16, 20, 19, 2, -25 },
  { 542, 7, 9, 8, -2, -4 },
  { 550, 9, 2, 12, 1, -12 },
  { 553, 3, 4, 8, 1, -4 },
  { 555, 19, 30, 13, -2, -30 },
  { 627, 16, 30, 18, 1, -30 },
  { 687, 10, 30, 18, 5, -30 },
  { 725, 18, 30, 18, -1, -30 },
  { 793, 18, 30, 18, 0, -30 },
  { 861, 17, 30, 18, 0, -30 },
  { 925, 18, 30, 18, 0, -30 },
  { 993, 16, 30, 18, 2, -30 },
  { 1053, 17, 30, 18, 2, -30 },
  { 1117, 18, 30, 18, 0, -30 },
  { 1185, 17, 30, 18, 0, -30 },
  { 1249, 8, 23, 8, 0, -23 },
  { 1272, 10, 28, 8, -2, -23 },
  { 1307, 16, 18, 19, 2, -24 },
  { 1343, 16, 11, 19, 2, -20 },
  { 1365, 16, 18, 19, 2, -24 },
  { 1401, 14, 30, 13, 1, -30 },
  { 1454, 25, 34, 27, 1, -30 },
  { 1561, 18, 30, 18, -3, -30 },
  { 1629, 18, 30, 19, 1, -30 },
  { 1697, 19, 30, 18, 2, -30 },
  { 1769, 19, 30, 21, 1, -30 },
  { 1841, 18, 30, 17, 1, -30 },
  { 1909, 18, 30, 16, 1, -30 },
  { 1977, 21, 30, 23, 2, -30 },
  { 2056, 22, 30, 22, 1, -30 },
  { 2139, 15, 30, 10, -2, -30 },
  { 2196, 15, 38, 8, -6, -30 },
  { 2268, 20, 30, 18, 1, -30 },
  { 2343, 11, 30, 16, 1, -30 },
  { 2385, 28, 30, 29, 1, -30 },
  { 2490, 23, 30, 23, 1, -30 },
  { 2577, 20, 30, 23, 2, -30 },
  { 2652, 18, 30, 18, 1, -30 },
  { 2720, 20, 37, 23, 2, -30 },
  { 2813, 18, 30, 19, 1, -30 },
  { 2881, 19, 30, 17, -1, -30 },
  { 2953, 15, 30, 16, 4, -30 },
  { 3010, 21, 30, 22, 2, -30 },
  { 3089, 17, 30, 18, 4, -30 },
  { 3153, 28, 30, 29, 4, -30 },
  { 3258, 21, 30, 16, -2, -30 },
  { 3337, 15, 30, 16, 4, -30 },
  { 3394, 19, 30, 16, -1, -30 },
  { 3466, 16, 37, 12, -1, -30 },
  { 3540, 7, 30, 14, 4, -30 },
  { 3567, 16, 37, 12, -3, -30 },
  { 3641, 17, 16, 19, 1, -30 },
  { 3675, 13, 2, 13, -3, 4 },
  { 3679, 5, 7, 10, 6, -32 },
  { 3684, 17, 23, 19, 1, -23 },
  { 3733, 17, 32, 19, 0, -32 },
  { 3801, 14, 23, 14, 1, -23 },
  { 3842, 19, 32, 19, 1, -32 },
  { 3918, 15, 23, 17, 1, -23 },
  { 3962, 20, 42, 10, -5, -32 },
  { 4067, 18, 33, 19, 0, -23 },
  { 4142, 17, 32, 18, 0, -32 },
  { 4210, 9, 30, 8, 0, -30 },
  { 4244, 15, 40, 8, -6, -30 },
  { 4319, 17, 32, 16, 0, -32 },
  { 4387, 9, 32, 8, 0, -32 },
  { 4423, 26, 23, 28, 0, -23 },
  { 4498, 17, 23, 18, 0, -23 },
  { 4547, 16, 23, 18, 1, -23 },
  { 4593, 19, 33, 19, -2, -23 },
  { 4672, 17, 33, 19, 1, -23 },
  { 4743, 14, 23, 12, 0, -23 },
  { 4784, 14, 23, 14, 0, -23 },
  { 4825, 10, 28, 10, 1, -28 },
  { 4860, 17, 22, 18, 1, -22 },
  { 4907, 15, 22, 14, 2, -22 },
  { 4949, 22, 22, 23, 3, -22 },
  { 5010, 18, 22, 15, -2, -22 },
  { 5060, 21, 32, 15, -4, -22 },
  { 5144, 15, 22, 13, -1, -22 },
  { 5186, 15, 37, 14, 1, -30 },
  { 5256, 2, 42, 17, 8, -32 },
  { 5267, 15, 37, 14, -2, -30 },
  { 5337, 16, 4, 19, 2, -17 },
};

const GFXfont NotoSans_Condensed_LightItalic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic42pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC42PT7B_H_
