#ifndef _IBMPLEXMONO_MEDIUMITALIC38PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x1E, 0x00, 0x3C, 0x79, 0xC3, 0xCE,
  0x1E, 0xF0, 0xE7, 0x87, 0x3C, 0x79, 0xE3, 0xCE, 0x1E, 0x70, 0xF7, 0x87,
  0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x38, 0x00,
  0x3C, 0x78, 0x00, 0x38, 0x70, 0x00, 0x78, 0x70, 0x00, 0x78, 0xF0, 0x00,
  0x70, 0xE0, 0x1F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x01,
  0xE1, 0xC0, 0x01, 0xC3, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0xC3, 0x80, 0x03,
  0x87, 0x80, 0x7F, 0x87, 0xF8, 0x7F, 0x8F, 0xF8, 0xFF, 0x0F, 0xF8, 0x07,
  0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x1E,
  0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x07, 0xF0,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xF3, 0x9F, 0x1F, 0x1C, 0x70, 0xF0,
  0xE1, 0x07, 0x87, 0x00, 0x3C, 0x30, 0x01, 0xE1, 0x80, 0x0F, 0x1C, 0x00,
  0x7C, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0xEF, 0xC0, 0x07, 0x1E, 0x00, 0x38, 0xF8, 0x01, 0xC3, 0xC0,
  0x0C, 0x3E, 0x20, 0x61, 0xF3, 0x07, 0x0F, 0x3C, 0x38, 0xF9, 0xF9, 0xCF,
  0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0xFF,
  0x00, 0xE0, 0x7F, 0xC0, 0x70, 0x3C, 0x78, 0x3C, 0x0E, 0x0E, 0x0E, 0x03,
  0x83, 0x87, 0x01, 0xE0, 0xE3, 0xC0, 0x70, 0x39, 0xE0, 0x1C, 0x1E, 0x70,
  0x07, 0x07, 0x38, 0x01, 0xE3, 0xDE, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x01,
  0xEF, 0x1E, 0x00, 0x73, 0x83, 0x80, 0x39, 0xE0, 0xE0, 0x1E, 0x70, 0x38,
  0x0F, 0x1C, 0x1E, 0x03, 0x87, 0x07, 0x01, 0xC1, 0xC1, 0xC0, 0xF0, 0x78,
  0xF0, 0x38, 0x0F, 0xF8, 0x1C, 0x03, 0xFC, 0x0F, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0x0F, 0x00, 0x3C,
  0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC0,
  0xF0, 0x07, 0x81, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x1E, 0x00, 0x7E, 0x78,
  0x03, 0xFF, 0xC0, 0x0F, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00,
  0xF0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE1, 0xDE,
  0x03, 0xC3, 0xFE, 0x0B, 0xCE, 0x3C, 0x33, 0xBC, 0x7F, 0xE7, 0xF0, 0x7F,
  0x87, 0xE0, 0x7C, 0x07, 0x00, 0x7B, 0xDE, 0xF7, 0xBB, 0xDE, 0xF7, 0xBC,
  0x00, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x04, 0x0F, 0x02, 0x78,
  0xF1, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF1, 0xFF, 0xF8, 0x03, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xF8, 0x00, 0xFB, 0xC0, 0x1F, 0x3C, 0x03, 0xE1, 0xE0,
  0x7C, 0x1E, 0x03, 0x80, 0xF0, 0x10, 0x08, 0x00, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xC0, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xC7, 0xE3, 0xE1,
  0xE1, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x1C, 0x00, 0xFF, 0xFF, 0xFE, 0xFF,
  0xEF, 0xFE, 0x7D, 0xFB, 0xFF, 0xEF, 0xCF, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xC0, 0xF8, 0x3E, 0x1F, 0x01, 0xE1, 0xE0, 0x0F, 0x3C, 0x00, 0xF3,
  0xC0, 0x0F, 0x7C, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0xF0, 0xF7, 0x8F, 0x0F,
  0xF8, 0xF1, 0xFF, 0x9F, 0x1F, 0xF0, 0xE1, 0xFF, 0x00, 0x1E, 0xF0, 0x01,
  0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00,
  0x78, 0x78, 0x0F, 0x87, 0xC1, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x07,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0x78, 0x0F,
  0x9E, 0x07, 0xC7, 0x83, 0xE3, 0xE1, 0xF8, 0xF0, 0x3C, 0x3C, 0x06, 0x0F,
  0x01, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFC,
  0x3F, 0x1F, 0x01, 0xF1, 0xE0, 0x0F, 0x0E, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xF8, 0x3F, 0x1F, 0x01, 0xF0,
  0x60, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xFF,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE6, 0x00, 0x3C, 0xF0, 0x07, 0xCF, 0xC1, 0xF8, 0x7F,
  0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x00,
  0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x07, 0x8F, 0x00, 0x78, 0x78,
  0x07, 0x83, 0xC0, 0x7C, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x0F, 0x03, 0xC0,
  0x78, 0x3E, 0x03, 0xC1, 0xE0, 0x1E, 0x1E, 0x00, 0xF0, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x8F, 0x80, 0x3D,
  0xFF, 0x01, 0xDF, 0xFC, 0x0F, 0x83, 0xF0, 0xF8, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x18, 0x01, 0xF1, 0xE0, 0x1F, 0x1F, 0xC1, 0xF0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF9, 0xF8, 0x1E, 0xFF, 0xC7, 0xFF, 0xF8,
  0xFE, 0x1F, 0xBF, 0x00, 0xF7, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3D, 0xE0, 0x0F, 0x9E, 0x01, 0xE3,
  0xE0, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0x80, 0x1F, 0x78, 0x03, 0xE7, 0x80,
  0x3C, 0x70, 0x07, 0xC7, 0x00, 0x78, 0x80, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00,
  0xFF, 0xFC, 0x0F, 0x83, 0xE0, 0xF8, 0x0F, 0x87, 0x80, 0x3C, 0x7C, 0x01,
  0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0x83, 0xC0, 0x78, 0x1F,
  0x07, 0xC0, 0x7F, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xE0, 0xFC,
  0x3C, 0x01, 0xE3, 0xC0, 0x0F, 0x9E, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80,
  0x1F, 0x7C, 0x00, 0xF1, 0xE0, 0x0F, 0x8F, 0xC1, 0xF8, 0x3F, 0xFF, 0x80,
  0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xFE,
  0x1F, 0x83, 0xE3, 0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0x7F, 0xC0, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7C,
  0xF8, 0x37, 0x9F, 0xFD, 0xF1, 0xFF, 0x3C, 0x0F, 0xCF, 0x80, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x0F,
  0xCF, 0xE7, 0xF3, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF1, 0xF8, 0xFE, 0x7E, 0x3F, 0x0F, 0x00, 0x03, 0xC0, 0xFC,
  0x3F, 0x87, 0xF0, 0xFC, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x1E,
  0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x04, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x03, 0xE0, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xFC,
  0x7F, 0xFE, 0x7C, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0x20, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x3C, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xF8, 0x3E,
  0x0F, 0x00, 0xE1, 0xE0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x38, 0x3C,
  0xF7, 0x87, 0xEF, 0x78, 0xFF, 0xF7, 0x0F, 0x1E, 0x71, 0xE0, 0xE7, 0x1C,
  0x0E, 0xF1, 0xC0, 0xEF, 0x3C, 0x1E, 0xF3, 0xC1, 0xEE, 0x3C, 0x1C, 0xE3,
  0xC1, 0xCE, 0x3C, 0x3C, 0xE3, 0xC7, 0xCE, 0x3F, 0xFC, 0xE1, 0xFB, 0xCE,
  0x1F, 0xB8, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0,
  0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x07, 0x8F, 0x00, 0x3C,
  0x78, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0,
  0xF0, 0x1E, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1E, 0x01,
  0xF1, 0xE0, 0x0F, 0x8F, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x7C,
  0x00, 0x7B, 0xC0, 0x03, 0xFE, 0x00, 0x1E, 0x0F, 0xFF, 0x01, 0xFF, 0xF0,
  0x3F, 0xFF, 0x0F, 0x01, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78,
  0xF0, 0x0F, 0x1E, 0x01, 0xE7, 0xC0, 0x3C, 0xF0, 0x0F, 0x1E, 0x03, 0xE3,
  0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0xC3, 0xE0, 0x3C, 0x78, 0x03, 0xCF,
  0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3D, 0xF0, 0x07, 0xBC,
  0x01, 0xF7, 0x80, 0x7C, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xC3, 0xF1, 0xF0, 0x1E,
  0x7C, 0x03, 0xCF, 0x00, 0x7B, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x01, 0x0F,
  0x00, 0x7D, 0xE0, 0x0F, 0x3E, 0x03, 0xE3, 0xE1, 0xF8, 0x3F, 0xFE, 0x03,
  0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC1, 0xF0, 0x7C, 0x1E, 0x03, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xF1, 0xE0,
  0x0F, 0x1E, 0x00, 0xF3, 0xE0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x1F, 0x3C,
  0x01, 0xF3, 0xC0, 0x1F, 0x3C, 0x01, 0xE7, 0xC0, 0x1E, 0x7C, 0x01, 0xE7,
  0x80, 0x3E, 0x78, 0x03, 0xE7, 0x80, 0x3C, 0x78, 0x07, 0xCF, 0x80, 0x78,
  0xF8, 0x0F, 0x8F, 0x03, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0xFC, 0x3E, 0x0F, 0x01, 0xF1,
  0xE0, 0x0F, 0x3E, 0x00, 0xE3, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x83, 0xFE, 0xF8, 0x3F,
  0xEF, 0x87, 0xFC, 0xF8, 0x01, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00,
  0x3C, 0xF8, 0x03, 0xC7, 0x80, 0x7C, 0x78, 0x0F, 0x87, 0xE1, 0xF8, 0x3F,
  0xF7, 0x81, 0xFE, 0x78, 0x0F, 0xC7, 0x80, 0x0F, 0x80, 0x3C, 0x3E, 0x01,
  0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0,
  0xF0, 0x07, 0x87, 0xC0, 0x3E, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0,
  0x0F, 0x07, 0x80, 0x3C, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE,
  0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x1F,
  0x00, 0xF8, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00,
  0xF0, 0x78, 0x03, 0xC3, 0xE0, 0x1F, 0x0F, 0x00, 0x78, 0x00, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x40, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x70, 0x0F, 0x0F, 0x01, 0xF0, 0xF0, 0x1E, 0x0F, 0x83,
  0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x07, 0x80, 0x3F,
  0x07, 0x80, 0x7E, 0x0F, 0x80, 0xFC, 0x0F, 0x00, 0xF8, 0x0F, 0x01, 0xF0,
  0x0F, 0x03, 0xE0, 0x0F, 0x07, 0xC0, 0x0F, 0x0F, 0x80, 0x1F, 0x1F, 0x00,
  0x1E, 0x3E, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xBE, 0x00, 0x3F, 0x1E, 0x00,
  0x3E, 0x1F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x7C, 0x0F, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0x78, 0x03, 0xE0,
  0x78, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0xC7, 0xF0, 0x3F, 0x1F,
  0xC1, 0xFC, 0x7F, 0x0F, 0xF1, 0xDC, 0x3B, 0x87, 0x71, 0xEE, 0x1D, 0xE7,
  0x78, 0xF3, 0xBD, 0xE3, 0xCE, 0xE7, 0x8F, 0x3F, 0x9E, 0x3C, 0xFC, 0x70,
  0xE1, 0xE1, 0xC3, 0x87, 0x8F, 0x1E, 0x1C, 0x3C, 0x78, 0x70, 0xF1, 0xE1,
  0x83, 0xC7, 0x82, 0x0E, 0x1C, 0x10, 0x38, 0x70, 0x01, 0xE3, 0xC0, 0x07,
  0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xC3, 0xC0, 0x07, 0x0E,
  0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x3C, 0x3F, 0x00, 0xF0, 0xFE, 0x03, 0x83,
  0xF8, 0x1E, 0x0F, 0xE0, 0x78, 0x3F, 0x81, 0xE0, 0xEE, 0x07, 0x87, 0xBC,
  0x1E, 0x1E, 0xF0, 0x70, 0x7B, 0xC1, 0xC1, 0xE7, 0x0F, 0x07, 0x1C, 0x3C,
  0x1C, 0x78, 0xF0, 0xF1, 0xE3, 0xC3, 0xC7, 0x8E, 0x0F, 0x0E, 0x38, 0x3C,
  0x39, 0xE0, 0xE0, 0xF7, 0x83, 0x83, 0xDE, 0x1E, 0x0F, 0x78, 0x78, 0x1D,
  0xC1, 0xE0, 0x7F, 0x07, 0x81, 0xFC, 0x1C, 0x07, 0xF0, 0x70, 0x1F, 0xC3,
  0xC0, 0x3F, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xC0, 0xF8, 0x3E, 0x1F, 0x01, 0xE1, 0xE0, 0x1F, 0x3E, 0x00, 0xF3,
  0xC0, 0x0F, 0x7C, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1E, 0xF0, 0x01,
  0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF0, 0x07, 0xCF, 0x80,
  0x78, 0x78, 0x0F, 0x87, 0xC1, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x07,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE1, 0xF0, 0x1F,
  0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00,
  0xF3, 0xE0, 0x0F, 0x3E, 0x01, 0xF3, 0xC0, 0x1E, 0x3C, 0x03, 0xE3, 0xFF,
  0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xF8, 0x3E, 0x1F, 0x01, 0xE1, 0xE0,
  0x1F, 0x3E, 0x00, 0xF3, 0xC0, 0x0F, 0x7C, 0x00, 0xF7, 0x80, 0x0F, 0x78,
  0x00, 0xF7, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x3C,
  0xF0, 0x07, 0xCF, 0x80, 0x78, 0x78, 0x0F, 0x87, 0xC1, 0xF0, 0x3F, 0xFE,
  0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0xC0, 0x0F,
  0x1E, 0x00, 0x7B, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x0F,
  0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE1, 0xF0, 0x1F, 0x1E, 0x00, 0xF1,
  0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF3, 0xE0, 0x0F,
  0x3E, 0x01, 0xF3, 0xC0, 0x1E, 0x3C, 0x03, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF,
  0x87, 0xFF, 0xC0, 0x78, 0x78, 0x07, 0x83, 0xC0, 0x78, 0x3C, 0x07, 0x83,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x1F, 0x0F, 0x00, 0xF0, 0xF0,
  0x0F, 0x0F, 0x00, 0xF8, 0xF0, 0x07, 0x80, 0x00, 0x7F, 0x80, 0x1F, 0xFF,
  0x01, 0xFF, 0xFC, 0x1F, 0x83, 0xF0, 0xF0, 0x07, 0x0F, 0x80, 0x10, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x10, 0x01, 0xF3, 0xC0, 0x0F, 0x1F, 0x81, 0xF8, 0x7F, 0xFF,
  0x81, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x78,
  0xF0, 0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00,
  0x78, 0xF8, 0x03, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x0F,
  0x00, 0x78, 0x78, 0x03, 0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x0F,
  0x8F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xF0,
  0x0F, 0x8F, 0x80, 0x78, 0x7C, 0x03, 0xC1, 0xE0, 0x3E, 0x0F, 0x83, 0xE0,
  0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0xBC, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x3E, 0x7C, 0x01, 0xE1,
  0xE0, 0x1F, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x78, 0x1E, 0x03,
  0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x3C, 0x1F, 0x01, 0xE0, 0xF0, 0x07,
  0x87, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x3C, 0x00, 0x79, 0xE0,
  0x03, 0xCF, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x0F, 0x1C, 0x00,
  0x0E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00,
  0x1C, 0x3C, 0x00, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x7C, 0x3C, 0x38, 0x7C,
  0x38, 0x38, 0x7C, 0x38, 0x38, 0xFC, 0x78, 0x38, 0xEC, 0x78, 0x78, 0xEC,
  0x70, 0x79, 0xCC, 0x70, 0x79, 0xCC, 0x70, 0x79, 0xCC, 0xF0, 0x7B, 0x8C,
  0xF0, 0x73, 0x8C, 0xE0, 0x73, 0x0C, 0xE0, 0x77, 0x0D, 0xE0, 0x77, 0x0F,
  0xE0, 0x76, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0xC0, 0xF0, 0x03, 0xC0, 0x3E,
  0x01, 0xF0, 0x07, 0x80, 0xF8, 0x01, 0xE0, 0x3C, 0x00, 0x7C, 0x1E, 0x00,
  0x0F, 0x0F, 0x80, 0x03, 0xE7, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x7D, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0xC3, 0xE0,
  0x03, 0xE0, 0x78, 0x01, 0xF0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x00,
  0xF0, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7D, 0xE0,
  0x03, 0xE7, 0xC0, 0x0F, 0x1F, 0x00, 0x7C, 0x3C, 0x03, 0xE0, 0xF8, 0x0F,
  0x01, 0xE0, 0x7C, 0x07, 0x83, 0xE0, 0x1F, 0x0F, 0x00, 0x3C, 0x7C, 0x00,
  0xF3, 0xE0, 0x03, 0xCF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x81, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x3C,
  0x07, 0x01, 0xC0, 0x70, 0x1E, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0,
  0x70, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x07, 0xC7, 0x80, 0x78, 0x78, 0x0F, 0x03,
  0xC1, 0xF0, 0x3C, 0x1E, 0x03, 0xC3, 0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x80,
  0x0E, 0xF0, 0x00, 0xF2, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x00, 0x33, 0xCF, 0x1E, 0x78, 0xE1, 0xC6, 0x03, 0xE1, 0xE1, 0xFF,
  0x3C, 0x7F, 0xFF, 0x9F, 0x87, 0xE3, 0xC0, 0x7C, 0xF8, 0x07, 0x9E, 0x00,
  0xF7, 0xC0, 0x1E, 0xF8, 0x07, 0xDE, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03,
  0xCF, 0x00, 0x79, 0xE0, 0x1F, 0x3C, 0x07, 0xE7, 0xC0, 0xF8, 0xF8, 0x6F,
  0x0F, 0xFD, 0xFC, 0xFF, 0x3F, 0x0F, 0x83, 0xE0, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x3F, 0x03, 0xCF, 0xF0, 0xFB, 0xFF, 0x1E, 0xC3,
  0xE3, 0xF0, 0x3E, 0x7C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x7C, 0x01,
  0xEF, 0x00, 0x3D, 0xE0, 0x0F, 0xBC, 0x01, 0xF7, 0x80, 0x3C, 0xF0, 0x07,
  0xBE, 0x01, 0xF7, 0xC0, 0x7C, 0xFC, 0x1F, 0x1E, 0xFF, 0xE3, 0xCF, 0xF0,
  0x78, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0xC7, 0xC1, 0xF3,
  0xC0, 0x7B, 0xC0, 0x11, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x47, 0x80, 0x3B, 0xC0, 0x3F, 0xE0,
  0x3E, 0x7C, 0x3E, 0x3F, 0xFE, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xF1, 0xE0, 0x7F, 0xCF,
  0x07, 0xFF, 0x78, 0x7E, 0x0B, 0xC3, 0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xE0,
  0x0F, 0x1F, 0x00, 0x78, 0xF8, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x01, 0xF1,
  0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x07, 0xC3, 0xC0, 0x3E, 0x1F, 0x02,
  0xF0, 0xF8, 0x7F, 0x83, 0xFF, 0x78, 0x0F, 0xF3, 0xC0, 0x3F, 0x1E, 0x00,
  0x01, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xF8, 0xFC, 0x3E, 0x3C, 0x07, 0x9E,
  0x01, 0xF7, 0x80, 0x7B, 0xC0, 0x3E, 0xF0, 0x7F, 0x3F, 0xFF, 0x8F, 0xFF,
  0x83, 0xFE, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x8F, 0x00, 0x73, 0xC0, 0x3E,
  0xFC, 0x1F, 0x1F, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x81, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0xF9, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0xF0, 0x7F, 0xCF, 0x0F,
  0xFE, 0xF1, 0xF8, 0x2F, 0x1E, 0x01, 0xF3, 0xE0, 0x1E, 0x3C, 0x01, 0xE3,
  0xC0, 0x1E, 0x7C, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x3C,
  0x78, 0x03, 0xC7, 0x80, 0x7C, 0x78, 0x07, 0xC7, 0xC0, 0xBC, 0x3E, 0x1B,
  0xC3, 0xFF, 0x78, 0x1F, 0xE7, 0x80, 0xFC, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x02, 0x01, 0xF0, 0x70, 0x3E, 0x0F, 0xFF, 0xC0, 0x7F,
  0xF8, 0x01, 0xFE, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x3E,
  0x07, 0x9F, 0xE1, 0xEF, 0xF8, 0xFE, 0x1F, 0x3D, 0x03, 0xCF, 0x80, 0xF3,
  0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xDF, 0x00, 0xF7, 0x80, 0x3D, 0xE0,
  0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x7B, 0xE0, 0x1E, 0xF0, 0x07,
  0xBC, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x81, 0x01, 0xE0, 0xE0, 0xF8, 0xFC, 0x3C,
  0x7C, 0x0F, 0x3E, 0x03, 0xDF, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0x03, 0xC1, 0xF0, 0x78,
  0x1F, 0x0F, 0x01, 0xE3, 0xC0, 0x1E, 0x78, 0x01, 0xEF, 0x00, 0x3F, 0xE0,
  0x03, 0xF8, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x1F, 0x01, 0xE7, 0xF8, 0x1E, 0xFF, 0xC3, 0xF8, 0x7C, 0x3D,
  0x03, 0xC3, 0xE0, 0x3C, 0x3E, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x07, 0x87,
  0xC1, 0xF0, 0x78, 0x7C, 0x07, 0xBF, 0x00, 0x79, 0xE0, 0x07, 0x9F, 0x04,
  0x78, 0xF0, 0xFF, 0x8F, 0x1E, 0xF0, 0x7B, 0xCF, 0x07, 0xF8, 0xF0, 0x3F,
  0x0F, 0x01, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x04, 0x1E, 0x0F, 0x1E, 0x1E, 0x3E,
  0x3C, 0x3C, 0x78, 0x3D, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0x00, 0x1E,
  0x78, 0x78, 0x7B, 0xE7, 0xF1, 0xDF, 0xDF, 0xC7, 0x4F, 0xCF, 0x1E, 0x3E,
  0x3C, 0xF0, 0xF0, 0xF3, 0xC3, 0xC3, 0xCF, 0x0F, 0x0F, 0x38, 0x38, 0x38,
  0xE0, 0xE0, 0xE3, 0x83, 0x83, 0x9E, 0x1E, 0x1E, 0x78, 0x78, 0x79, 0xE1,
  0xE1, 0xE7, 0x07, 0x07, 0x1C, 0x1C, 0x1C, 0x70, 0x70, 0x73, 0xC3, 0xC3,
  0xCF, 0x0F, 0x0F, 0x3C, 0x3C, 0x3C, 0x1E, 0x3E, 0x07, 0x9F, 0xE1, 0xEF,
  0xF8, 0xFE, 0x1F, 0x3D, 0x03, 0xCF, 0x80, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F,
  0x3C, 0x03, 0xDF, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x1E, 0x78, 0x07, 0x9E,
  0x01, 0xE7, 0x80, 0x7B, 0xE0, 0x1E, 0xF0, 0x07, 0xBC, 0x03, 0xCF, 0x00,
  0xF3, 0xC0, 0x3C, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0x83,
  0xE3, 0xE0, 0x3C, 0xF8, 0x07, 0x9E, 0x00, 0x7B, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x0F,
  0xBC, 0x01, 0xE3, 0xC0, 0x7C, 0x7C, 0x1F, 0x07, 0xFF, 0xC0, 0x7F, 0xF0,
  0x03, 0xF0, 0x00, 0x07, 0x8F, 0xC0, 0x3C, 0xFF, 0x03, 0xCF, 0xFC, 0x1E,
  0xC3, 0xE0, 0xFC, 0x0F, 0x87, 0xC0, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F,
  0x1F, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xF1, 0xE0,
  0x0F, 0x0F, 0x00, 0x78, 0xF8, 0x07, 0xC7, 0xC0, 0x7C, 0x3F, 0x07, 0xC1,
  0xEF, 0xFE, 0x0F, 0x3F, 0xC0, 0x78, 0xFC, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xF1, 0xE1, 0xFF, 0x3C, 0x7F, 0xF7,
  0x9F, 0x82, 0xF3, 0xC0, 0x3E, 0xF8, 0x07, 0x9E, 0x00, 0xF7, 0xC0, 0x1E,
  0xF8, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x1F, 0x78, 0x03, 0xCF, 0x00, 0x79,
  0xE0, 0x1F, 0x3C, 0x03, 0xE7, 0xC0, 0xBC, 0xF8, 0x7F, 0x8F, 0xFD, 0xE0,
  0xFF, 0x3C, 0x0F, 0x87, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0xFF, 0xC7, 0xFF, 0xF1, 0xFB, 0xFE, 0xFF, 0x03, 0xD8, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7C, 0x0F, 0x3E, 0x01, 0x8F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x80, 0x7F,
  0xF0, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xE4, 0x00, 0x79, 0x80, 0x1E,
  0xF8, 0x1F, 0x3F, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x0C, 0x1F, 0x07, 0x87, 0x87, 0xC1, 0xE3,
  0xE0, 0x7B, 0xF0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x03,
  0xCF, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x1F, 0x78, 0x07, 0x9E, 0x01, 0xE7,
  0x80, 0x79, 0xE0, 0x1E, 0xF0, 0x07, 0xBC, 0x03, 0xEF, 0x00, 0xF3, 0xC0,
  0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0xCF, 0x01, 0xF3, 0xC0, 0xFC, 0xF8, 0x7E,
  0x3F, 0xF7, 0x87, 0xF9, 0xE0, 0xF8, 0x78, 0xFF, 0x00, 0x9F, 0xE0, 0xFB,
  0xFC, 0x0F, 0x07, 0x81, 0xF0, 0xF0, 0x1E, 0x3E, 0x03, 0xC7, 0x80, 0x78,
  0xF0, 0x0F, 0x1E, 0x03, 0xE3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x03, 0xE3,
  0xC0, 0x78, 0x78, 0x1F, 0x0F, 0x07, 0xC1, 0xE1, 0xF0, 0x3C, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x1C, 0x3C, 0x31, 0xE1, 0xC3,
  0x8F, 0x0E, 0x1C, 0x70, 0x70, 0xF3, 0x83, 0x87, 0x9C, 0x3C, 0x3C, 0xE1,
  0xE1, 0xEF, 0x0F, 0x0F, 0x78, 0x70, 0x7B, 0x83, 0x83, 0x9C, 0x1C, 0x1C,
  0xE0, 0xE0, 0xE7, 0x0F, 0x07, 0x78, 0x78, 0x73, 0xC3, 0xC3, 0x9E, 0x2C,
  0x3C, 0xF3, 0x61, 0xC7, 0xF3, 0x9C, 0x1F, 0x9F, 0xC0, 0x78, 0x7C, 0x00,
  0x01, 0xE0, 0x78, 0x0F, 0xE3, 0xF8, 0x3F, 0xCF, 0xF0, 0xFB, 0xD8, 0xF7,
  0xC7, 0xA1, 0xE7, 0x07, 0xC3, 0xC8, 0x0F, 0x07, 0x80, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x1E, 0x1F, 0x02, 0x3C, 0x3E, 0x0E, 0x78, 0xDC, 0x7C, 0xF1, 0xBD,
  0xF1, 0xFE, 0x7F, 0xC1, 0xFC, 0x7F, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x00,
  0xF0, 0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x1F, 0x1E, 0x01, 0xE1, 0xE0,
  0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xC0, 0x1E, 0x3C,
  0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x7C, 0x3C, 0x07, 0xC3,
  0xC0, 0xBC, 0x3E, 0x1F, 0x83, 0xFF, 0x78, 0x1F, 0xE7, 0x80, 0x7C, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x02, 0x01, 0xF0, 0x70, 0x3E,
  0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x78, 0x7F,
  0xE3, 0x87, 0xFF, 0xFC, 0x3C, 0x3F, 0xE1, 0xC0, 0x7E, 0x1E, 0x03, 0xE0,
  0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x80, 0x7C, 0x1C, 0x07, 0xC0, 0xF0, 0x7C, 0x03, 0x87,
  0xF0, 0x1C, 0x7F, 0xF8, 0xE3, 0xFF, 0xFF, 0x1C, 0x3F, 0xF1, 0xE0, 0x7F,
  0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1F, 0x03, 0xFF,
  0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x78,
  0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x3C,
  0x1E, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x1E,
  0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x00, 0x03, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xC0, 0x1F, 0xF8, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x07, 0x80, 0x30, 0x7F, 0x03, 0xC7,
  0xF8, 0x1C, 0x79, 0xE0, 0xE3, 0x87, 0x0F, 0x3C, 0x3C, 0xF1, 0xC0, 0xFF,
  0x1E, 0x03, 0xF8, 0x60, 0x0F, 0x00,
};

const GFXglyph IBMPlexMono_MediumItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 9, 27, 23, 7, -27 },
  { 32, 13, 11, 23, 7, -28 },
  { 50, 24, 27, 23, 0, -27 },
  { 131, 21, 35, 23, 1, -31 },
  { 223, 26, 27, 23, -1, -27 },
  { 311, 23, 27, 23, 0, -27 },
  { 389, 5, 11, 23, 11, -28 },
  { 396, 15, 34, 23, 7, -29 },
  { 460, 15, 34, 23, 1, -29 },
  { 524, 20, 19, 23, 2, -21 },
  { 572, 19, 19, 23, 2, -21 },
  { 618, 9, 12, 23, 5, -6 },
  { 632, 12, 4, 23, 6, -14 },
  { 638, 7, 6, 23, 7, -6 },
  { 644, 22, 34, 23, 1, -29 },
  { 738, 20, 27, 23, 2, -27 },
  { 806, 18, 27, 23, 2, -27 },
  { 867, 20, 27, 23, 1, -27 },
  { 935, 20, 27, 23, 1, -27 },
  { 1003, 21, 27, 23, 0, -27 },
  { 1074, 21, 27, 23, 1, -27 },
  { 1145, 19, 27, 23, 2, -27 },
  { 1210, 20, 27, 23, 3, -27 },
  { 1278, 21, 27, 23, 1, -27 },
  { 1349, 19, 27, 23, 3, -27 },
  { 1414, 9, 20, 23, 7, -20 },
  { 1437, 11, 26, 23, 5, -20 },
  { 1473, 19, 22, 23, 3, -23 },
  { 1526, 20, 11, 23, 2, -17 },
  { 1554, 18, 22, 23, 2, -23 },
  { 1604, 16, 27, 23, 5, -27 },
  { 1658, 20, 31, 23, 2, -27 },
  { 1736, 21, 27, 23, -1, -27 },
  { 1807, 19, 27, 23, 2, -27 },
  { 1872, 19, 27, 23, 3, -27 },
  { 1937, 20, 27, 23, 2, -27 },
  { 2005, 21, 27, 23, 2, -27 },
  { 2076, 21, 27, 23, 2, -27 },
  { 2147, 20, 27, 23, 2, -27 },
  { 2215, 22, 27, 23, 1, -27 },
  { 2290, 22, 27, 23, 1, -27 },
  { 2365, 20, 27, 23, 2, -27 },
  { 2433, 24, 27, 23, 1, -27 },
  { 2514, 16, 27, 23, 3, -27 },
  { 2568, 22, 27, 23, 1, -27 },
  { 2643, 22, 27, 23, 1, -27 },
  { 2718, 20, 27, 23, 2, -27 },
  { 2786, 20, 27, 23, 2, -27 },
  { 2854, 20, 34, 23, 2, -27 },
  { 2939, 20, 27, 23, 2, -27 },
  { 3007, 21, 27, 23, 1, -27 },
  { 3078, 22, 27, 23, 3, -27 },
  { 3153, 21, 27, 23, 2, -27 },
  { 3224, 21, 27, 23, 4, -27 },
  { 3295, 24, 27, 23, 1, -27 },
  { 3376, 26, 27, 23, -1, -27 },
  { 3464, 22, 27, 23, 3, -27 },
  { 3539, 23, 27, 23, 0, -27 },
  { 3617, 17, 34, 23, 5, -29 },
  { 3690, 10, 34, 23, 7, -29 },
  { 3733, 17, 34, 23, 1, -29 },
  { 3806, 20, 16, 23, 2, -27 },
  { 3846, 19, 3, 23, 0, 4 },
  { 3854, 6, 8, 23, 8, -30 },
  { 3860, 19, 20, 23, 2, -20 },
  { 3908, 19, 28, 23, 2, -28 },
  { 3975, 17, 20, 23, 3, -20 },
  { 4018, 21, 28, 23, 2, -28 },
  { 4092, 18, 20, 23, 3, -20 },
  { 4137, 26, 36, 23, -1, -28 },
  { 4254, 20, 28, 23, 1, -20 },
  { 4324, 18, 28, 23, 2, -28 },
  { 4387, 18, 29, 23, 3, -29 },
  { 4453, 19, 37, 23, 1, -29 },
  { 4541, 20, 28, 23, 2, -28 },
  { 4611, 16, 28, 23, 4, -28 },
  { 4667, 22, 20, 23, 0, -20 },
  { 4722, 18, 20, 23, 2, -20 },
  { 4767, 19, 20, 23, 2, -20 },
  { 4815, 21, 28, 23, 0, -20 },
  { 4889, 19, 28, 23, 2, -20 },
  { 4956, 19, 20, 23, 4, -20 },
  { 5004, 18, 20, 23, 2, -20 },
  { 5049, 18, 27, 23, 3, -27 },
  { 5110, 18, 20, 23, 3, -20 },
  { 5155, 19, 20, 23, 2, -20 },
  { 5203, 21, 20, 23, 1, -20 },
  { 5256, 23, 20, 23, 0, -20 },
  { 5314, 20, 28, 23, 1, -20 },
  { 5384, 21, 20, 23, 1, -20 },
  { 5437, 18, 34, 23, 4, -29 },
  { 5514, 9, 34, 23, 7, -29 },
  { 5553, 19, 34, 23, 1, -29 },
  { 5634, 21, 9, 23, 1, -16 },
};

const GFXfont IBMPlexMono_MediumItalic38pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic38pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic38pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _IBMPLEXMONO_MEDIUMITALIC38PT7B_H_
