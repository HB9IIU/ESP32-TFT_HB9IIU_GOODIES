#ifndef _IBMPLEXMONO_MEDIUMITALIC48PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xE0, 0xFE, 0x07, 0xC0, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1F,
  0x3C, 0x1F, 0x7C, 0x1E, 0x7C, 0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x3E,
  0x78, 0x3E, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x78, 0x3C, 0x00, 0xFF, 0xE0,
  0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F,
  0xE0, 0x07, 0xC3, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x7F,
  0xF0, 0xFF, 0xE1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8,
  0x7F, 0xF0, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x7C, 0x3E,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0x39, 0xFC, 0x1F, 0x8F, 0x1F, 0x07, 0xE1, 0xE0, 0xC0, 0xF8, 0x3C, 0x10,
  0x1F, 0x07, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x7C, 0x1C, 0x00, 0x0F, 0x87,
  0x80, 0x01, 0xF8, 0xF0, 0x00, 0x3F, 0x9E, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xC7, 0xE0, 0x00, 0x38, 0x7E, 0x00,
  0x07, 0x07, 0xC0, 0x00, 0xE0, 0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0xF0, 0x7C, 0x10, 0x1C, 0x1F, 0x8F, 0x03, 0x83, 0xE3, 0xF0,
  0x70, 0xFC, 0x7F, 0x9E, 0x7F, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x7F, 0xC0, 0x07, 0x80, 0x7F, 0xF0, 0x07,
  0x80, 0x7F, 0xF8, 0x07, 0xC0, 0x7C, 0x3C, 0x03, 0xC0, 0x3C, 0x0F, 0x03,
  0xC0, 0x3C, 0x07, 0x83, 0xE0, 0x1E, 0x03, 0xC1, 0xE0, 0x0F, 0x01, 0xE1,
  0xE0, 0x07, 0x81, 0xE1, 0xF0, 0x03, 0xC0, 0xF0, 0xF0, 0x01, 0xE0, 0x78,
  0xF0, 0x00, 0xF8, 0xF8, 0xF8, 0x00, 0x7F, 0xFC, 0x78, 0x00, 0x1F, 0xFC,
  0x78, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x8F, 0xFC, 0x00, 0x0F,
  0x8F, 0xFF, 0x00, 0x07, 0x8F, 0x87, 0x80, 0x07, 0x87, 0x81, 0xC0, 0x07,
  0xC7, 0x80, 0xF0, 0x03, 0xC3, 0xC0, 0x78, 0x03, 0xC1, 0xE0, 0x7C, 0x03,
  0xE0, 0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x1E, 0x01, 0xE0, 0x3C, 0x0F, 0x00,
  0xF0, 0x1E, 0x0F, 0x80, 0xF0, 0x0F, 0x0F, 0x80, 0xF0, 0x07, 0xFF, 0xC0,
  0x78, 0x01, 0xFF, 0xC0, 0x78, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xF8,
  0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0xF0, 0x0F, 0x80, 0x0F, 0x00, 0xF8,
  0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0x00, 0x07,
  0x81, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x7C,
  0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0xC0, 0x7C,
  0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x7E, 0x04, 0xF8, 0x03, 0xE0, 0xFF,
  0x80, 0x3E, 0x0F, 0xFC, 0x07, 0xF1, 0xF7, 0xC0, 0x5F, 0x1E, 0x7E, 0x1C,
  0xFB, 0xC7, 0xFF, 0xCF, 0xFC, 0x3F, 0xF8, 0x7F, 0x81, 0xFF, 0x03, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x3E, 0x79, 0xF3, 0xE7, 0xCF, 0x9F, 0x3C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9E, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x70, 0x3E, 0x07, 0x7F, 0x1F, 0x1F, 0xBF,
  0xEF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x03, 0xF3, 0xE0, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x0F, 0x80, 0x70, 0x03, 0x80, 0x08, 0x01, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF0,
  0xFE, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07,
  0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xF8, 0x3F,
  0x01, 0xF8, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x80,
  0x0F, 0x87, 0xC0, 0x01, 0xF3, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E,
  0x00, 0x07, 0xCF, 0x80, 0x03, 0xF7, 0xE1, 0xF0, 0xFD, 0xF8, 0xFC, 0x3F,
  0x7E, 0x3F, 0x0F, 0xDF, 0x0F, 0xC3, 0xE7, 0xC3, 0xF0, 0xF9, 0xF0, 0x78,
  0x3E, 0x7C, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xF3, 0xF0,
  0x00, 0x7C, 0xFC, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1,
  0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x3F,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFB, 0xE0, 0x07, 0xF3, 0xE0, 0x0F,
  0xE3, 0xE0, 0x1F, 0xC3, 0xE0, 0x3F, 0x83, 0xE0, 0x1F, 0x07, 0xE0, 0x1E,
  0x07, 0xC0, 0x0C, 0x07, 0xC0, 0x08, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xF8, 0x3F,
  0x81, 0xF8, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x03, 0x80,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xF0, 0x07, 0xF0, 0x38, 0x00, 0xFC, 0x04, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x40, 0x00, 0xF8, 0x78, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x87, 0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x9F, 0x00, 0x07,
  0xCF, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00,
  0x7E, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x3E, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC3, 0xF0, 0x01, 0xF3, 0xFF, 0x00, 0x7D, 0xFF, 0xF0,
  0x1E, 0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0x83, 0xF0, 0x07, 0xE0, 0x18, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x40, 0x01, 0xF8, 0x78, 0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x0F, 0xF0, 0x3F,
  0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x1F, 0x1F, 0xF8, 0x3F,
  0x7F, 0xFC, 0x3E, 0xFF, 0xFE, 0x7F, 0xC0, 0xFE, 0x7F, 0x80, 0x3F, 0x7F,
  0x00, 0x3F, 0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x3F, 0x83, 0xF8, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF7,
  0xC0, 0x01, 0xF3, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xFC,
  0x78, 0x00, 0xFC, 0x7C, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07,
  0xF0, 0x3F, 0x81, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x3F,
  0x1F, 0x80, 0x0F, 0xC7, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x3E, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x01,
  0xF3, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xCF, 0x80,
  0x03, 0xF3, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x87,
  0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xC0, 0xFC, 0x3F, 0x00, 0x7E, 0x7E, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0xFE, 0x7F, 0x03, 0xFE, 0x7F, 0xFF, 0x7C, 0x3F, 0xFE,
  0xFC, 0x1F, 0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xC1,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF0, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x3F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFE, 0x0F, 0x80, 0x00, 0xF8,
  0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x3F,
  0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E,
  0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF0, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xE7,
  0xF0, 0x7F, 0x7E, 0x01, 0xFF, 0xE0, 0x07, 0xEF, 0x00, 0x3F, 0x10, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xC0,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xF0, 0x3F, 0x01,
  0xF0, 0x03, 0xE0, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x07,
  0x87, 0xC0, 0x01, 0xE1, 0xE0, 0x3C, 0x7C, 0xF8, 0x3F, 0xDE, 0x3E, 0x1F,
  0xF7, 0x8F, 0x07, 0xFF, 0xE3, 0xC3, 0xF1, 0xF9, 0xF0, 0xF8, 0x3E, 0x7C,
  0x7C, 0x0F, 0x9F, 0x1E, 0x03, 0xC7, 0x87, 0x80, 0xF1, 0xE3, 0xE0, 0x3C,
  0x78, 0xF8, 0x0F, 0x1E, 0x3E, 0x03, 0xCF, 0x8F, 0x81, 0xF3, 0xE3, 0xE0,
  0x78, 0xF8, 0xF8, 0x3E, 0x3E, 0x3E, 0x1F, 0x8F, 0x07, 0xFD, 0xE3, 0xC1,
  0xFF, 0x78, 0xF8, 0x7F, 0xBE, 0x3E, 0x0F, 0xCF, 0x07, 0x80, 0x40, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0xF8,
  0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x0F, 0x80,
  0x3F, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F,
  0x80, 0x0F, 0xC1, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0x80, 0x03,
  0xE3, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF3, 0xF0,
  0x00, 0x3F, 0x7C, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFC, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7C, 0x03,
  0xF0, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x0F, 0x80,
  0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xF1, 0xF8,
  0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x7C, 0x03, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x07, 0xE0, 0x0F, 0xC3,
  0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7E,
  0x3E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x00, 0x0F, 0x8F, 0x80, 0x0F,
  0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x0F, 0xE1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0x03, 0xF0,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x1C, 0x3F, 0x00, 0x0F, 0x8F, 0x80, 0x0F, 0xC7,
  0xC0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07,
  0xC0, 0x7F, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0x3E,
  0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x3E, 0x00,
  0x3F, 0x0F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0xFC, 0x7C,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF8,
  0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xE3, 0xE0, 0x01,
  0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x87, 0xE0,
  0x07, 0xE1, 0xF0, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x1F, 0x01, 0xFE, 0x07,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x3E, 0x00,
  0x7C, 0x3F, 0x00, 0x3F, 0x1F, 0x00, 0x0E, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xFF, 0x3F,
  0x03, 0xFF, 0x9F, 0x01, 0xFF, 0xCF, 0x81, 0xFF, 0xE7, 0xC0, 0x01, 0xF3,
  0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E,
  0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0x83, 0xF0, 0x0B,
  0xC1, 0xFC, 0x1F, 0xE0, 0x7F, 0xFD, 0xF0, 0x3F, 0xFC, 0xF8, 0x07, 0xFC,
  0x7C, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x3F,
  0x03, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x7C,
  0x00, 0x3E, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x07,
  0xC0, 0xFC, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0x7C, 0x0F,
  0x80, 0x07, 0xC0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x80, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81,
  0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x3F, 0x00,
  0x1F, 0x03, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xF0,
  0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xE0,
  0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x7C,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x06, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x0F, 0xC0,
  0x1F, 0x03, 0xE0, 0x1F, 0x81, 0xFC, 0x3F, 0x80, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x3E, 0x00, 0x1F, 0x81, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x80,
  0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x01, 0xF0,
  0x1F, 0xC0, 0x0F, 0x81, 0xFC, 0x00, 0x7C, 0x1F, 0xC0, 0x03, 0xE1, 0xFC,
  0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x00,
  0x7C, 0xFC, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xDF, 0x80, 0x03, 0xFC, 0x7C,
  0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0xC0, 0x7E, 0x00,
  0x7E, 0x03, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x01,
  0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0,
  0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x07, 0xBC, 0x0F, 0x78, 0x3D, 0xE0, 0x7B, 0xE3, 0xDF, 0x07,
  0xCF, 0x1E, 0xF8, 0x3E, 0x79, 0xE7, 0xC1, 0xF3, 0xCF, 0x3E, 0x0F, 0x9E,
  0xF1, 0xE0, 0x78, 0x7F, 0x8F, 0x03, 0xC3, 0xF8, 0xF8, 0x1E, 0x1F, 0x87,
  0xC1, 0xF0, 0xFC, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x1E, 0x0F, 0x03,
  0xE0, 0xE0, 0x78, 0x1E, 0x07, 0x07, 0xC0, 0xF0, 0x30, 0x3E, 0x0F, 0x81,
  0x81, 0xF0, 0x7C, 0x08, 0x0F, 0x83, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1E, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0xF0, 0x3F, 0x80, 0x1F, 0x03, 0xF8,
  0x01, 0xE0, 0x7F, 0xC0, 0x1E, 0x07, 0xFC, 0x03, 0xE0, 0x7F, 0xC0, 0x3E,
  0x07, 0xFC, 0x03, 0xE0, 0x7F, 0xC0, 0x3E, 0x07, 0xBE, 0x03, 0xC0, 0xFB,
  0xE0, 0x3C, 0x0F, 0x9E, 0x07, 0xC0, 0xF9, 0xE0, 0x7C, 0x0F, 0x9E, 0x07,
  0xC0, 0xF9, 0xF0, 0x7C, 0x0F, 0x1F, 0x07, 0x80, 0xF0, 0xF0, 0x78, 0x1F,
  0x0F, 0x0F, 0x81, 0xF0, 0xF0, 0xF8, 0x1F, 0x0F, 0x8F, 0x81, 0xF0, 0xF8,
  0xF8, 0x1E, 0x07, 0x8F, 0x01, 0xE0, 0x78, 0xF0, 0x3E, 0x07, 0xDF, 0x03,
  0xE0, 0x7D, 0xF0, 0x3E, 0x07, 0xDF, 0x03, 0xE0, 0x3D, 0xF0, 0x3C, 0x03,
  0xDE, 0x03, 0xC0, 0x3F, 0xE0, 0x7C, 0x03, 0xFE, 0x07, 0xC0, 0x3F, 0xE0,
  0x7C, 0x01, 0xFE, 0x07, 0xC0, 0x1F, 0xE0, 0x78, 0x01, 0xFC, 0x0F, 0x80,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x03, 0xF8, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0xFC, 0x00,
  0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xC7, 0xC0, 0x03, 0xF3, 0xF0,
  0x00, 0x7C, 0xFC, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xF7,
  0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03,
  0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0xBF, 0x00,
  0x07, 0xEF, 0xC0, 0x01, 0xF3, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x3F, 0x1F,
  0x00, 0x0F, 0x87, 0xC0, 0x07, 0xE1, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0xFC,
  0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x3F, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xC0, 0x1F,
  0xC1, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x0F,
  0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xE1, 0xF8, 0x01, 0xF8, 0x7C, 0x01, 0xFC,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x03, 0xF8, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x3E, 0x00,
  0x3E, 0x1F, 0x80, 0x0F, 0xC7, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC,
  0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD,
  0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x01,
  0xF9, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0,
  0x01, 0xF3, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x87,
  0xC0, 0x07, 0xE1, 0xF0, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x18, 0x00, 0x3F, 0x0F, 0x00,
  0x07, 0xC7, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xC0, 0x1F, 0xC1,
  0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x07,
  0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x0F, 0x80,
  0x0F, 0xC7, 0xE0, 0x03, 0xE1, 0xF8, 0x01, 0xF8, 0x7C, 0x01, 0xFC, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0x3E, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F,
  0x80, 0x3E, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF0,
  0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0x83,
  0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0x81, 0xFE, 0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x00, 0xE0, 0x7E, 0x00,
  0x08, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x08, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xF1,
  0xFC, 0x00, 0xFC, 0x3F, 0xE0, 0x7F, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xF1, 0xF8,
  0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1,
  0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07,
  0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80,
  0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x1F,
  0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7E,
  0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00,
  0x7C, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xFC,
  0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x07, 0xE0, 0x7F, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7C, 0xFC,
  0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF8,
  0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03,
  0xE0, 0x7C, 0x01, 0xF8, 0x1F, 0x00, 0x7C, 0x07, 0xE0, 0x3F, 0x00, 0xF8,
  0x0F, 0x80, 0x3E, 0x07, 0xE0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00,
  0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF0,
  0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF7,
  0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07,
  0x87, 0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3C, 0x1E, 0x07, 0xC0, 0xF0, 0x78,
  0x3F, 0x07, 0xC1, 0xE0, 0xFC, 0x1F, 0x07, 0x83, 0xF0, 0x78, 0x3E, 0x1F,
  0xC1, 0xE0, 0xF8, 0x7F, 0x0F, 0x83, 0xE1, 0xDC, 0x3E, 0x0F, 0x8F, 0x70,
  0xF0, 0x3E, 0x3D, 0xC3, 0xC0, 0xF0, 0xE7, 0x0F, 0x03, 0xC7, 0x9C, 0x7C,
  0x0F, 0x1E, 0x71, 0xE0, 0x3C, 0x71, 0xC7, 0x80, 0xF3, 0xC7, 0x1E, 0x03,
  0xCF, 0x1E, 0xF8, 0x1F, 0x38, 0x7B, 0xE0, 0x7D, 0xE1, 0xEF, 0x01, 0xF7,
  0x87, 0xBC, 0x07, 0xDC, 0x1E, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7B, 0xC1,
  0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F,
  0x80, 0x7F, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x0F,
  0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x07, 0xF7, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xC7,
  0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x3F, 0x00,
  0x7E, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x00, 0xF8, 0x1F, 0x80,
  0x0F, 0x81, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7C,
  0x7C, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x07, 0xFF, 0xF0, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xF8, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x20, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xCF, 0x80, 0x03,
  0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x3E, 0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x01,
  0xF0, 0xFC, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x7C, 0x60, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x78, 0xF8, 0x7C, 0x7C, 0x3C, 0x3E,
  0x1E, 0x0F, 0x0C, 0x00, 0x7E, 0x1F, 0x03, 0xFF, 0x1F, 0x07, 0xFF, 0x9F,
  0x0F, 0xFF, 0xDF, 0x1F, 0xC0, 0xDF, 0x1F, 0x80, 0x7F, 0x3F, 0x00, 0x3E,
  0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0x7C,
  0xFC, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xFC, 0x01, 0xF8,
  0x7C, 0x03, 0xF8, 0x7C, 0x07, 0xF8, 0x7F, 0x0E, 0xFF, 0x7F, 0xFC, 0xFF,
  0x3F, 0xF8, 0xFF, 0x1F, 0xF0, 0x3E, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0xF8,
  0xFF, 0xC0, 0x7C, 0xFF, 0xF0, 0x7E, 0xFF, 0xF8, 0x3F, 0xF0, 0xFE, 0x1F,
  0x60, 0x3F, 0x0F, 0xE0, 0x0F, 0x87, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE3,
  0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E,
  0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07,
  0xE7, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xF1, 0xF8, 0x01, 0xF0, 0xFC, 0x01,
  0xF8, 0xFF, 0x83, 0xF8, 0x7E, 0xFF, 0xF8, 0x3E, 0x7F, 0xF8, 0x1F, 0x1F,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xC0, 0xFC, 0x7E, 0x01, 0xF3, 0xF0, 0x03,
  0x8F, 0x80, 0x08, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x23, 0xE0, 0x00, 0xCF, 0xC0, 0x07, 0xDF, 0x00, 0x3E,
  0x7E, 0x01, 0xF0, 0xFC, 0x1F, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x1F, 0xF8,
  0xF8, 0x0F, 0xFF, 0xBE, 0x03, 0xFF, 0xF7, 0xC0, 0x7F, 0x07, 0xF8, 0x1F,
  0x80, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x1F,
  0x07, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0,
  0x01, 0xF0, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x83, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0x00,
  0x7F, 0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0x0E, 0xF8, 0x0F, 0xFF, 0xDF, 0x00,
  0xFF, 0xF3, 0xE0, 0x0F, 0xFC, 0x7C, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFE, 0x0F,
  0xE3, 0xF0, 0x0F, 0xCF, 0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0x7C, 0x00, 0x7E,
  0xF8, 0x01, 0xF9, 0xF0, 0x3F, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x63, 0xF0, 0x01, 0xE3, 0xE0, 0x03, 0xE7, 0xE0, 0x1F, 0x8F, 0xE0,
  0x7E, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x30, 0x0F, 0x80,
  0x00, 0x78, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7E, 0x1F, 0x00,
  0x00, 0x3F, 0x1F, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x3F, 0xF1, 0xF0,
  0x3F, 0xFE, 0xF8, 0x1F, 0xFF, 0xBE, 0x0F, 0xF0, 0x7F, 0x83, 0xF0, 0x07,
  0xE1, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x0F, 0xC0,
  0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F,
  0x80, 0x07, 0xC7, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x7E,
  0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x0F, 0xE0, 0xFC, 0x06, 0xF8, 0x3F, 0x87,
  0xFC, 0x07, 0xFF, 0xDF, 0x01, 0xFF, 0xE7, 0xC0, 0x3F, 0xF1, 0xF0, 0x03,
  0xF0, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x20, 0x01, 0xF8, 0x0C, 0x00, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xF0, 0x0F,
  0x8F, 0xF8, 0x0F, 0x9F, 0xFC, 0x0F, 0x9F, 0xFE, 0x0F, 0xB8, 0x7E, 0x1F,
  0xE0, 0x3E, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3E, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7E,
  0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x01, 0x00, 0xF8, 0x0E, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x3F,
  0x01, 0xF1, 0xF8, 0x07, 0xCF, 0xC0, 0x1F, 0x7E, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x80, 0x7C, 0x07, 0x00, 0xF8, 0x1F, 0x03, 0xF0, 0x3F, 0x07, 0xC0,
  0x3F, 0x0F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x7C, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x0F, 0xC0, 0x0F, 0x8F, 0xFC, 0x03, 0xE7, 0xFF, 0x80, 0xFB, 0xFF,
  0xE0, 0x3E, 0xE1, 0xF8, 0x1F, 0xE0, 0x3F, 0x07, 0xF0, 0x0F, 0xC1, 0xF8,
  0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x03,
  0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x0F, 0xE0, 0x0F, 0x9F, 0xE0,
  0x03, 0xE7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x7E, 0x3E, 0x03, 0x1F, 0x0F,
  0xC1, 0xE7, 0xC1, 0xF0, 0xFD, 0xF0, 0x7C, 0x7E, 0x7C, 0x0F, 0xBF, 0x1F,
  0x03, 0xFF, 0x8F, 0xC0, 0x7F, 0xC3, 0xE0, 0x1F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x04, 0x0F, 0x80, 0xE0, 0xF8, 0x1F, 0x1F,
  0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x1F, 0x81, 0xF3, 0xF0, 0x1F, 0x7E, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x9F,
  0x07, 0xC0, 0xF3, 0xF8, 0xFE, 0x0F, 0x7F, 0x9F, 0xE0, 0xF7, 0xFB, 0xFF,
  0x1F, 0xC7, 0xB1, 0xF1, 0xF8, 0x7E, 0x1F, 0x1F, 0x07, 0xC1, 0xF1, 0xF0,
  0x7C, 0x1F, 0x1E, 0x07, 0x81, 0xE1, 0xE0, 0x78, 0x1E, 0x3E, 0x07, 0x81,
  0xE3, 0xE0, 0xF8, 0x1E, 0x3E, 0x0F, 0x83, 0xE3, 0xC0, 0xF0, 0x3E, 0x3C,
  0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0x3C, 0x7C, 0x0F, 0x03, 0xC7, 0xC1, 0xF0,
  0x3C, 0x7C, 0x1F, 0x07, 0xC7, 0x81, 0xE0, 0x7C, 0x78, 0x1E, 0x07, 0x87,
  0x81, 0xE0, 0x78, 0xF8, 0x1E, 0x07, 0x8F, 0x83, 0xE0, 0xF8, 0xF8, 0x3E,
  0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x0F, 0x8F, 0xF8, 0x0F, 0x9F, 0xFC, 0x0F,
  0x9F, 0xFE, 0x0F, 0xB8, 0x7E, 0x1F, 0xE0, 0x3E, 0x1F, 0xC0, 0x3F, 0x1F,
  0x80, 0x3F, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x3F,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xFC,
  0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFC, 0x1F, 0xC7, 0xE0, 0x0F, 0x8F, 0x80,
  0x1F, 0xBF, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF7,
  0xC0, 0x0F, 0xC7, 0xC0, 0x3F, 0x0F, 0xE0, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x7C, 0x7F, 0xE0, 0x0F, 0x9F, 0xFE, 0x03, 0xF7, 0xFF, 0xC0, 0x7F, 0xE1,
  0xFC, 0x0F, 0xB0, 0x1F, 0x81, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0x3E, 0x07,
  0xE0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x03,
  0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C,
  0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7E,
  0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0xC1, 0xFC, 0x0F, 0xDF,
  0xFF, 0x01, 0xF3, 0xFF, 0xC0, 0x3E, 0x3F, 0xF0, 0x07, 0xC1, 0xF8, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0xFF,
  0xC7, 0xC1, 0xFF, 0xF7, 0xC1, 0xFF, 0xFB, 0xE0, 0xFE, 0x0F, 0xF0, 0xFC,
  0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x3F,
  0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE7,
  0xE0, 0x01, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C,
  0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x3F, 0x87, 0xE0, 0x3F,
  0xC3, 0xF8, 0x77, 0xC1, 0xFF, 0xFB, 0xE0, 0x7F, 0xF9, 0xF0, 0x1F, 0xF8,
  0xF8, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xF0, 0x3E, 0x7F, 0xE0,
  0x7D, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xE0, 0x7E,
  0x0F, 0x80, 0x1C, 0x1F, 0x80, 0x08, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x30, 0x00, 0x7C, 0x78, 0x00, 0xFC,
  0xFF, 0x03, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x10, 0x0F, 0x80, 0x70, 0x1F, 0x01, 0xF0, 0x3E, 0x0F, 0xF0,
  0x7C, 0x3F, 0x00, 0xF8, 0xFC, 0x01, 0xF7, 0xF0, 0x03, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3F, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x05, 0xF0, 0x7E,
  0x1D, 0xF0, 0x7F, 0xF9, 0xF0, 0x3F, 0xF9, 0xF0, 0x1F, 0xF3, 0xF0, 0x0F,
  0xC0, 0x00, 0xFF, 0xC0, 0x0D, 0xFF, 0x80, 0xFB, 0xFF, 0x01, 0xF7, 0xFE,
  0x03, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0,
  0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03,
  0xF1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x3F, 0x0F, 0x80, 0x7C,
  0x3F, 0x01, 0xF8, 0x7C, 0x07, 0xE0, 0xF8, 0x1F, 0x81, 0xF0, 0x7F, 0x03,
  0xE7, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x07, 0xC1, 0x87, 0xC1, 0xE1, 0xF1, 0xE0, 0x78, 0x3C,
  0x78, 0x1E, 0x0F, 0x1E, 0x07, 0x83, 0xC7, 0x81, 0xE0, 0xF3, 0xE0, 0xF8,
  0x3C, 0xF8, 0x3C, 0x0F, 0x3C, 0x0F, 0x03, 0xCF, 0x03, 0xC0, 0xF3, 0xC0,
  0xF0, 0x3C, 0xF0, 0x3C, 0x0F, 0x3C, 0x1F, 0x03, 0xDF, 0x07, 0xC0, 0xF7,
  0xC1, 0xE0, 0x7D, 0xE0, 0x78, 0x1E, 0x78, 0x1E, 0x07, 0x9E, 0x07, 0x81,
  0xE7, 0x83, 0xE0, 0xF3, 0xE0, 0xF8, 0x3C, 0xF8, 0x7E, 0x1F, 0x3E, 0x37,
  0x87, 0x87, 0xFD, 0xE3, 0xC1, 0xFE, 0x3F, 0xE0, 0x7F, 0x8F, 0xF0, 0x07,
  0x81, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0xFF,
  0x87, 0xFC, 0x0F, 0xFE, 0x7F, 0xE1, 0xFC, 0xF3, 0x8F, 0x9F, 0xC7, 0xB8,
  0x7C, 0xF8, 0x3D, 0x83, 0xE3, 0x81, 0xEC, 0x1F, 0x10, 0x0F, 0xC0, 0xF8,
  0x00, 0x7E, 0x08, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x08, 0x1F, 0x80, 0x07, 0xC0, 0xFC, 0x04, 0x3E, 0x0D, 0xE0, 0x71,
  0xF0, 0x6F, 0x0F, 0x8F, 0x87, 0x78, 0xFE, 0x7C, 0x73, 0xCF, 0xC3, 0xFF,
  0x9F, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0x83, 0xFC, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8,
  0x3F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x01,
  0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC1, 0xF8,
  0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x81,
  0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F,
  0x83, 0xF0, 0x0F, 0xE0, 0x7C, 0x07, 0xF0, 0x1F, 0x87, 0x7C, 0x07, 0xFF,
  0x9F, 0x00, 0xFF, 0xE7, 0xC0, 0x1F, 0xF1, 0xF0, 0x03, 0xF0, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x20, 0x01, 0xF0,
  0x0C, 0x00, 0xFC, 0x07, 0xC0, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x0F, 0x83,
  0xFF, 0xC7, 0xC3, 0xFF, 0xF3, 0xE3, 0xFF, 0xFF, 0xF1, 0xF0, 0x7F, 0xF8,
  0xF0, 0x0F, 0xF8, 0xF8, 0x01, 0xF8, 0x78, 0x01, 0xF8, 0x3C, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x20, 0x03, 0xF0, 0x38, 0x07, 0xF0,
  0x3C, 0x07, 0xE0, 0x0F, 0x07, 0xE0, 0x07, 0x87, 0xE0, 0x03, 0xC7, 0xFF,
  0x01, 0xF7, 0xFF, 0xFC, 0x7B, 0xE3, 0xFF, 0xF9, 0xF0, 0x7F, 0xFC, 0xF8,
  0x07, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF0,
  0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x03, 0x03, 0xFC,
  0x01, 0xF1, 0xFF, 0x80, 0x78, 0xFF, 0xF0, 0x1E, 0x3E, 0x7C, 0x0F, 0x1F,
  0x0F, 0x83, 0xC7, 0x81, 0xF1, 0xE3, 0xE0, 0x7F, 0xF8, 0xF0, 0x0F, 0xFC,
  0x3C, 0x01, 0xFE, 0x07, 0x00, 0x3E, 0x00,
};

const GFXglyph IBMPlexMono_MediumItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 12, 34, 29, 9, -34 },
  { 52, 16, 14, 29, 9, -36 },
  { 80, 30, 34, 29, 0, -34 },
  { 208, 27, 45, 29, 1, -39 },
  { 360, 33, 35, 29, -1, -34 },
  { 505, 28, 35, 29, 0, -34 },
  { 628, 7, 14, 29, 14, -36 },
  { 641, 19, 43, 29, 9, -36 },
  { 744, 19, 43, 29, 2, -36 },
  { 847, 25, 24, 29, 2, -26 },
  { 922, 24, 24, 29, 3, -27 },
  { 994, 12, 14, 29, 6, -7 },
  { 1015, 15, 5, 29, 7, -17 },
  { 1025, 8, 8, 29, 9, -8 },
  { 1033, 28, 43, 29, 1, -36 },
  { 1184, 26, 35, 29, 2, -34 },
  { 1298, 24, 34, 29, 2, -34 },
  { 1400, 26, 34, 29, 1, -34 },
  { 1511, 26, 35, 29, 1, -34 },
  { 1625, 26, 34, 29, 1, -34 },
  { 1736, 26, 35, 29, 2, -34 },
  { 1850, 24, 35, 29, 2, -34 },
  { 1955, 25, 34, 29, 4, -34 },
  { 2062, 26, 35, 29, 2, -34 },
  { 2176, 24, 34, 29, 4, -34 },
  { 2278, 11, 26, 29, 9, -26 },
  { 2314, 14, 33, 29, 6, -26 },
  { 2372, 23, 28, 29, 4, -29 },
  { 2453, 25, 14, 29, 2, -22 },
  { 2497, 24, 28, 29, 2, -29 },
  { 2581, 21, 34, 29, 6, -34 },
  { 2671, 26, 39, 29, 2, -34 },
  { 2798, 27, 34, 29, -1, -34 },
  { 2913, 25, 34, 29, 2, -34 },
  { 3020, 25, 35, 29, 3, -34 },
  { 3130, 26, 34, 29, 2, -34 },
  { 3241, 27, 34, 29, 2, -34 },
  { 3356, 27, 34, 29, 2, -34 },
  { 3471, 25, 35, 29, 3, -34 },
  { 3581, 28, 34, 29, 1, -34 },
  { 3700, 26, 34, 29, 2, -34 },
  { 3811, 25, 35, 29, 2, -34 },
  { 3921, 29, 34, 29, 2, -34 },
  { 4045, 22, 34, 29, 3, -34 },
  { 4139, 29, 34, 29, 1, -34 },
  { 4263, 28, 34, 29, 1, -34 },
  { 4382, 26, 35, 29, 2, -34 },
  { 4496, 26, 34, 29, 2, -34 },
  { 4607, 26, 43, 29, 2, -34 },
  { 4747, 26, 34, 29, 2, -34 },
  { 4858, 27, 35, 29, 1, -34 },
  { 4977, 27, 34, 29, 4, -34 },
  { 5092, 26, 35, 29, 3, -34 },
  { 5206, 26, 34, 29, 5, -34 },
  { 5317, 30, 34, 29, 1, -34 },
  { 5445, 32, 34, 29, -1, -34 },
  { 5581, 28, 34, 29, 4, -34 },
  { 5700, 29, 34, 29, 0, -34 },
  { 5824, 21, 43, 29, 7, -36 },
  { 5937, 13, 43, 29, 8, -36 },
  { 6007, 21, 43, 29, 1, -36 },
  { 6120, 26, 20, 29, 2, -34 },
  { 6185, 23, 4, 29, 0, 4 },
  { 6197, 8, 10, 29, 10, -38 },
  { 6207, 24, 26, 29, 2, -25 },
  { 6285, 25, 37, 29, 2, -36 },
  { 6401, 22, 26, 29, 3, -25 },
  { 6473, 27, 37, 29, 2, -36 },
  { 6598, 23, 26, 29, 3, -25 },
  { 6673, 32, 46, 29, -1, -36 },
  { 6857, 26, 35, 29, 1, -25 },
  { 6971, 24, 36, 29, 2, -36 },
  { 7079, 22, 38, 29, 4, -37 },
  { 7184, 23, 47, 29, 2, -37 },
  { 7320, 26, 37, 29, 2, -36 },
  { 7441, 20, 37, 29, 5, -36 },
  { 7534, 28, 25, 29, 0, -25 },
  { 7622, 24, 25, 29, 2, -25 },
  { 7697, 23, 26, 29, 3, -25 },
  { 7772, 27, 35, 29, 0, -25 },
  { 7891, 25, 35, 29, 2, -25 },
  { 8001, 23, 25, 29, 5, -25 },
  { 8073, 24, 26, 29, 2, -25 },
  { 8151, 23, 35, 29, 3, -34 },
  { 8252, 24, 26, 29, 3, -25 },
  { 8330, 23, 25, 29, 3, -25 },
  { 8402, 26, 26, 29, 1, -25 },
  { 8487, 29, 26, 29, 0, -25 },
  { 8582, 26, 35, 29, 1, -25 },
  { 8696, 25, 26, 29, 2, -25 },
  { 8778, 23, 43, 29, 5, -36 },
  { 8902, 12, 43, 29, 9, -36 },
  { 8967, 23, 43, 29, 2, -36 },
  { 9091, 26, 11, 29, 2, -20 },
};

const GFXfont IBMPlexMono_MediumItalic48pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic48pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic48pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _IBMPLEXMONO_MEDIUMITALIC48PT7B_H_
