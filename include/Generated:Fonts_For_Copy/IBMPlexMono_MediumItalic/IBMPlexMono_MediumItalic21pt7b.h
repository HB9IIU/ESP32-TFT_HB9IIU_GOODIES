#ifndef _IBMPLEXMONO_MEDIUMITALIC21PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x19, 0xCE, 0x63, 0x18, 0xC4, 0x21, 0x00, 0x0E, 0x73, 0x80, 0x66,
  0xCD, 0x9E, 0x7C, 0xD9, 0x80, 0x03, 0x30, 0x19, 0x01, 0x98, 0x0C, 0xC3,
  0xE7, 0x9E, 0x7C, 0x33, 0x01, 0x98, 0x19, 0x87, 0xCF, 0xBE, 0x78, 0x26,
  0x03, 0x30, 0x19, 0x81, 0x98, 0x00, 0x01, 0x80, 0x18, 0x07, 0xC1, 0xFF,
  0x39, 0x33, 0x12, 0x33, 0x03, 0xB0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x26,
  0x06, 0x64, 0x66, 0xF6, 0xE7, 0xFC, 0x1F, 0x80, 0xC0, 0x0C, 0x00, 0x0F,
  0x06, 0x3E, 0x18, 0x66, 0x61, 0x8C, 0x83, 0x1B, 0x06, 0x6C, 0x07, 0xC0,
  0x0F, 0x38, 0x01, 0xF8, 0x1F, 0x30, 0x24, 0x60, 0xC8, 0xC3, 0x11, 0x8C,
  0x3E, 0x38, 0x38, 0x00, 0x07, 0x80, 0xFC, 0x0C, 0x61, 0x86, 0x18, 0x60,
  0xCE, 0x0C, 0xC3, 0xF8, 0x66, 0x0E, 0x60, 0xC3, 0x0C, 0x33, 0xE5, 0xB7,
  0xDE, 0x38, 0xE0, 0x6D, 0xED, 0x80, 0x07, 0x0C, 0x18, 0x18, 0x30, 0x60,
  0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x30,
  0x18, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x06, 0x06, 0x06, 0x0C, 0x18, 0x18, 0x30, 0xE0, 0x06, 0x00, 0xC0, 0x18,
  0x33, 0x3F, 0xFE, 0x7F, 0x07, 0x81, 0xF8, 0x73, 0x0C, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x07, 0xFF, 0xFF, 0x83, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x3B, 0x99, 0xCC, 0x60, 0xFF, 0xFC, 0xFF, 0x80, 0x00, 0x38, 0x01, 0x80,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x38, 0x00, 0x0F, 0x83, 0xF8, 0xE3, 0xB8, 0x36, 0x06, 0xC0, 0xF9,
  0x9F, 0x73, 0xCE, 0xF8, 0x1F, 0x03, 0x60, 0xE6, 0x38, 0xFE, 0x0F, 0x80,
  0x07, 0x83, 0xE1, 0xF0, 0xEC, 0x73, 0x18, 0xC0, 0x70, 0x1C, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x0E, 0x3F, 0xFF, 0xFC, 0x07, 0xC1, 0xFE, 0x18, 0x73,
  0x87, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0x80, 0x70, 0x07, 0xFE, 0xFF, 0xE0, 0x07, 0xC1, 0xFE, 0x38, 0x71, 0x07,
  0x00, 0x70, 0x0E, 0x07, 0xC0, 0xFC, 0x00, 0xE0, 0x0E, 0x00, 0xE4, 0x0E,
  0xE1, 0xC7, 0xFC, 0x1F, 0x00, 0x00, 0xE0, 0x1E, 0x03, 0xE0, 0x36, 0x06,
  0xE0, 0xCC, 0x18, 0xC3, 0x8C, 0x30, 0xC6, 0x0C, 0xFF, 0xFF, 0xFF, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x1F, 0xE7, 0xFC, 0xC0, 0x18, 0x03, 0x00, 0xCF,
  0x1F, 0xF3, 0x8E, 0x00, 0xC0, 0x18, 0x03, 0x20, 0xEE, 0x18, 0xFF, 0x0F,
  0x80, 0x03, 0xC0, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xEF, 0x1B, 0xF3, 0x8E,
  0xE0, 0xDC, 0x1F, 0x03, 0x60, 0x6E, 0x1C, 0xFF, 0x0F, 0x80, 0x7F, 0xFF,
  0xFF, 0x03, 0x60, 0xEC, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80,
  0x70, 0x0C, 0x03, 0x80, 0xE0, 0x18, 0x00, 0x0F, 0x87, 0xFC, 0xE3, 0xB8,
  0x37, 0x06, 0x61, 0x87, 0xE1, 0xFC, 0x61, 0xD8, 0x1B, 0x03, 0x60, 0x6E,
  0x1D, 0xFF, 0x0F, 0x80, 0x1F, 0x1F, 0xE6, 0x1F, 0x83, 0xC0, 0xF0, 0x3C,
  0x1F, 0x8F, 0xFF, 0x9E, 0xE0, 0x30, 0x18, 0x0C, 0x0E, 0x0F, 0x00, 0x3B,
  0xDC, 0x00, 0x00, 0x00, 0xE7, 0x38, 0x1C, 0xF3, 0x80, 0x00, 0x00, 0x00,
  0x39, 0xC6, 0x38, 0xC3, 0x00, 0x00, 0x40, 0x70, 0x78, 0x78, 0x78, 0x38,
  0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x04, 0x7F, 0xEF, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x20, 0x0E, 0x03, 0xC0, 0x3C, 0x03,
  0x80, 0x70, 0x1C, 0x1E, 0x1E, 0x1E, 0x0E, 0x02, 0x00, 0x1F, 0x0F, 0xE7,
  0x1F, 0x87, 0x01, 0xC0, 0x60, 0x78, 0x78, 0x18, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x1E, 0x03, 0x80, 0x0F, 0x83, 0xF8, 0xE1, 0xB8, 0x36, 0x76, 0xCF,
  0xDB, 0x1E, 0x63, 0xCC, 0x5B, 0x1B, 0x63, 0x67, 0xEC, 0xED, 0x80, 0x18,
  0x03, 0xF8, 0x3F, 0x00, 0x03, 0xC0, 0x78, 0x1B, 0x03, 0x60, 0xCC, 0x19,
  0x87, 0x30, 0xC6, 0x38, 0xC7, 0xFC, 0xFF, 0xB8, 0x36, 0x07, 0xC0, 0xF0,
  0x18, 0x3F, 0x87, 0xF8, 0xC3, 0x98, 0x33, 0x0E, 0xE1, 0x9F, 0xE3, 0xFC,
  0x60, 0xCC, 0x19, 0x83, 0x70, 0x6E, 0x1D, 0xFF, 0x3F, 0xC0, 0x07, 0x83,
  0xFC, 0xE3, 0x98, 0x37, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03,
  0x82, 0x30, 0x67, 0x1C, 0xFF, 0x07, 0x80, 0x3F, 0x87, 0xF8, 0xC3, 0x98,
  0x33, 0x06, 0xE0, 0xDC, 0x1B, 0x07, 0x60, 0xEC, 0x1D, 0x83, 0x70, 0xEE,
  0x39, 0xFE, 0x3F, 0x80, 0x3F, 0xF3, 0xFE, 0x30, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x7F, 0xC7, 0xFC, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0F,
  0xF8, 0xFF, 0x80, 0x3F, 0xF3, 0xFE, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x7F, 0xC7, 0xFC, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x00, 0x0F, 0x83, 0xF8, 0xE3, 0x98, 0x37, 0x00, 0xC0, 0x18, 0x07,
  0x1F, 0xE7, 0xDC, 0x1B, 0x83, 0x70, 0xE6, 0x1C, 0xFF, 0x8F, 0x60, 0x30,
  0x73, 0x06, 0x30, 0x63, 0x06, 0x70, 0x66, 0x0E, 0x7F, 0xE7, 0xFC, 0x60,
  0xC6, 0x0C, 0xE0, 0xCE, 0x1C, 0xC1, 0xCC, 0x18, 0xC1, 0x80, 0x3F, 0xE7,
  0xFC, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC1, 0xFF, 0x3F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x60, 0xCE,
  0x38, 0xFE, 0x0F, 0x80, 0x38, 0x79, 0x83, 0x0C, 0x30, 0x63, 0x87, 0x38,
  0x3B, 0x81, 0xB8, 0x0F, 0xC0, 0x7F, 0x03, 0x98, 0x38, 0xE1, 0xC7, 0x0C,
  0x18, 0x60, 0xE3, 0x03, 0x00, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x1F, 0xFF, 0xF8,
  0x1C, 0x39, 0xE3, 0xCF, 0x1E, 0x79, 0xE3, 0x4F, 0x1B, 0xD8, 0xDC, 0xC6,
  0xE6, 0x62, 0x33, 0x13, 0x19, 0x18, 0xC0, 0xC6, 0x06, 0x30, 0x33, 0x03,
  0x80, 0x38, 0x73, 0x86, 0x3C, 0x63, 0xC6, 0x6C, 0x66, 0xC6, 0x6C, 0xE6,
  0x6C, 0x66, 0xC6, 0x6C, 0xC6, 0xCC, 0x6C, 0xC3, 0xCC, 0x38, 0xC3, 0x80,
  0x0F, 0x83, 0xF8, 0xE3, 0xB8, 0x36, 0x06, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0xF8, 0x1F, 0x03, 0x70, 0xE6, 0x38, 0xFE, 0x0F, 0x80, 0x3F, 0xC7, 0xFC,
  0xC1, 0x98, 0x33, 0x06, 0xE0, 0xDC, 0x3B, 0xFE, 0x7F, 0x8C, 0x01, 0x80,
  0x70, 0x0E, 0x01, 0x80, 0x30, 0x00, 0x0F, 0x83, 0xF8, 0xE3, 0xB8, 0x36,
  0x06, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0x70, 0xEE, 0x38,
  0xFE, 0x0F, 0x80, 0x62, 0x06, 0xE0, 0xF8, 0x0E, 0x00, 0x3F, 0xC7, 0xFC,
  0xC1, 0x98, 0x33, 0x06, 0xE0, 0xDC, 0x3B, 0xFE, 0x7F, 0x8C, 0xE1, 0x8C,
  0x71, 0x8E, 0x39, 0x83, 0x30, 0x70, 0x07, 0xC1, 0xFF, 0x18, 0x33, 0x82,
  0x38, 0x03, 0x80, 0x1F, 0x00, 0xFC, 0x01, 0xE0, 0x06, 0x00, 0x64, 0x06,
  0xF0, 0xE7, 0xFC, 0x1F, 0x00, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x03, 0x80, 0x38, 0x00, 0x30, 0x73, 0x06, 0x30, 0x67, 0x06, 0x70, 0x66,
  0x0E, 0x60, 0xE6, 0x0C, 0x60, 0xCE, 0x0C, 0xE0, 0xCE, 0x1C, 0xE1, 0x87,
  0xF8, 0x3E, 0x00, 0xC0, 0x7E, 0x0E, 0xE0, 0xCE, 0x0C, 0x61, 0xC6, 0x18,
  0x63, 0x86, 0x30, 0x63, 0x06, 0x60, 0x66, 0x07, 0xE0, 0x7C, 0x03, 0xC0,
  0x38, 0x00, 0x60, 0x3B, 0x01, 0x98, 0x0C, 0xC0, 0x66, 0x63, 0x23, 0x33,
  0x39, 0x99, 0x4C, 0xDB, 0x66, 0xDE, 0x34, 0xF1, 0xE7, 0x8F, 0x3C, 0x71,
  0xC3, 0x8E, 0x00, 0x38, 0x1C, 0x60, 0xC1, 0xC7, 0x03, 0x38, 0x0E, 0xC0,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x80, 0x36, 0x01, 0x98, 0x0E, 0x70,
  0x70, 0xC1, 0x83, 0x8C, 0x06, 0x00, 0xC0, 0x7E, 0x0E, 0x60, 0xC6, 0x18,
  0x73, 0x83, 0x30, 0x36, 0x01, 0xE0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x38, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x1C, 0x00, 0xC0,
  0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60,
  0x07, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x1F, 0x8F, 0xC6, 0x02, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80,
  0xC0, 0x7E, 0x3F, 0x00, 0xC6, 0x31, 0x84, 0x31, 0x8C, 0x61, 0x0C, 0x63,
  0x18, 0x43, 0x18, 0xC6, 0x1F, 0xC7, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18,
  0x06, 0x1F, 0x8F, 0xE0, 0x07, 0x00, 0xF0, 0x36, 0x0C, 0xC1, 0x8C, 0x61,
  0x98, 0x37, 0x03, 0x40, 0x40, 0xFF, 0xFF, 0xF0, 0xE6, 0x63, 0x1E, 0xE7,
  0xF9, 0xC7, 0x30, 0x6E, 0x0D, 0x83, 0xB0, 0x66, 0x0C, 0xE3, 0x8F, 0xB9,
  0xE7, 0x00, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x6F, 0x1F, 0xF3,
  0xC6, 0x70, 0xEC, 0x1D, 0x83, 0x30, 0x6E, 0x0D, 0xC3, 0xB7, 0xE6, 0x78,
  0x0F, 0x0F, 0xF3, 0x0D, 0x82, 0x60, 0x38, 0x0E, 0x13, 0x83, 0x61, 0x9F,
  0xC3, 0xE0, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x61, 0xEE, 0x3F,
  0xC7, 0x1C, 0x60, 0xCE, 0x0C, 0xC0, 0xCC, 0x1C, 0xC1, 0xCE, 0x38, 0x7D,
  0x87, 0x98, 0x0F, 0x8F, 0xF3, 0x0D, 0x87, 0x7F, 0xBF, 0x8E, 0x03, 0x83,
  0x61, 0x9F, 0xE3, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x18, 0x00, 0x60, 0x03,
  0x80, 0x7F, 0xE3, 0xFF, 0x80, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x31, 0x80, 0xCE, 0x01, 0xB8, 0x07,
  0xC0, 0x07, 0x00, 0x0F, 0x71, 0xFF, 0x38, 0xE3, 0x06, 0x70, 0x67, 0x06,
  0x60, 0xE6, 0x0C, 0x71, 0xC3, 0xEC, 0x3C, 0xC0, 0x1C, 0x61, 0x8F, 0xF8,
  0x3E, 0x00, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0D, 0xE7, 0xFD, 0xE3,
  0x70, 0xD8, 0x36, 0x0D, 0x83, 0x61, 0xF8, 0x6C, 0x1B, 0x06, 0x0E, 0x07,
  0x03, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x33,
  0x39, 0xB8, 0xF8, 0x78, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0x00, 0x0F, 0xE3,
  0xF8, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x63, 0x18,
  0xE6, 0x1D, 0x83, 0xE0, 0x70, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x67, 0x1D, 0xF3, 0xC6, 0x70, 0xCC, 0x39, 0x8C, 0x36, 0x06, 0xE5, 0xCD,
  0xF1, 0xF6, 0x1C, 0xFC, 0x7E, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30,
  0x38, 0x18, 0x0C, 0x06, 0x33, 0x33, 0xB1, 0xF0, 0x70, 0x36, 0x73, 0xFF,
  0x73, 0x36, 0x33, 0x62, 0x36, 0x63, 0x66, 0x36, 0x66, 0xC6, 0x6C, 0x66,
  0xCC, 0x60, 0x37, 0x8F, 0xF7, 0x8D, 0xC3, 0x60, 0xD8, 0x36, 0x0D, 0x87,
  0xE1, 0xB0, 0x6C, 0x18, 0x0F, 0x0F, 0xF7, 0x0D, 0x83, 0xE0, 0xF8, 0x3C,
  0x0F, 0x07, 0x61, 0x9F, 0xE3, 0xE0, 0x1B, 0xC3, 0xFE, 0x3C, 0x63, 0x87,
  0x30, 0x73, 0x06, 0x30, 0x67, 0x06, 0x70, 0xE6, 0xFC, 0x67, 0x86, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x00, 0x1E, 0xE7, 0xFD, 0xC7, 0x30, 0x6E, 0x0D,
  0x81, 0xB0, 0x76, 0x0E, 0xE3, 0x8F, 0xB1, 0xE6, 0x00, 0xC0, 0x38, 0x06,
  0x00, 0xC0, 0xFD, 0xFE, 0xF1, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x07, 0x00, 0x1F, 0x8F, 0xF7, 0x09, 0xC0, 0x7C, 0x0F, 0xE0,
  0x78, 0x07, 0x41, 0xBF, 0xE3, 0xE0, 0x0C, 0x0C, 0x06, 0x03, 0x0F, 0xFF,
  0xFC, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x46, 0x77, 0x73, 0xF0, 0xE0, 0x30,
  0xEE, 0x19, 0x83, 0x30, 0x66, 0x0C, 0xC3, 0x98, 0x77, 0x0C, 0xE3, 0x8F,
  0xB0, 0xE6, 0x00, 0xF8, 0xFC, 0x33, 0x0C, 0xC3, 0x30, 0xCC, 0x33, 0x1D,
  0xCE, 0x67, 0x9F, 0x83, 0xC0, 0x66, 0x6C, 0xCD, 0x19, 0xE3, 0x3C, 0x47,
  0x98, 0xF3, 0x1E, 0x62, 0xDC, 0xDF, 0x93, 0x9C, 0x00, 0x0C, 0x71, 0xF7,
  0x9D, 0xEE, 0x8E, 0x30, 0x70, 0x03, 0x00, 0x18, 0x18, 0xC4, 0xCA, 0x77,
  0xDE, 0x1C, 0xE0, 0x18, 0x73, 0x86, 0x30, 0x63, 0x06, 0x30, 0x63, 0x06,
  0x30, 0xE3, 0x0C, 0x31, 0xC3, 0xEC, 0x1C, 0xC0, 0x1C, 0x43, 0x8F, 0xF8,
  0x3E, 0x00, 0x3E, 0x6F, 0xFD, 0x8F, 0x30, 0xC0, 0x70, 0x1C, 0x06, 0x23,
  0x86, 0xFC, 0xDF, 0xFB, 0x1E, 0x00, 0x07, 0xC3, 0xF0, 0xC0, 0x30, 0x0C,
  0x01, 0x80, 0x60, 0x18, 0xFC, 0x3F, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x03,
  0x00, 0xC0, 0x30, 0x0F, 0x83, 0xE0, 0x18, 0xC6, 0x23, 0x18, 0xC6, 0x31,
  0x18, 0xC6, 0x31, 0x88, 0xC6, 0x30, 0x1F, 0x07, 0xC0, 0x30, 0x0C, 0x02,
  0x01, 0x00, 0xC0, 0x30, 0x0F, 0xC3, 0xF1, 0x80, 0x60, 0x18, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x3F, 0x0F, 0x80, 0x38, 0x6F, 0x8F, 0xBB, 0x63, 0xEC,
  0x38,
};

const GFXglyph IBMPlexMono_MediumItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 15, 13, 4, -15 },
  { 11, 7, 6, 13, 4, -16 },
  { 17, 13, 15, 13, 0, -15 },
  { 42, 12, 19, 13, 0, -17 },
  { 71, 15, 15, 13, -1, -15 },
  { 100, 12, 15, 13, 0, -15 },
  { 123, 3, 6, 13, 6, -16 },
  { 126, 8, 19, 13, 4, -16 },
  { 145, 8, 19, 13, 1, -16 },
  { 164, 11, 10, 13, 1, -12 },
  { 178, 11, 10, 13, 1, -11 },
  { 192, 5, 6, 13, 3, -3 },
  { 196, 7, 2, 13, 3, -7 },
  { 198, 3, 3, 13, 4, -3 },
  { 200, 13, 19, 13, 0, -16 },
  { 231, 11, 15, 13, 1, -15 },
  { 252, 10, 15, 13, 1, -15 },
  { 271, 12, 15, 13, 0, -15 },
  { 294, 12, 15, 13, 0, -15 },
  { 317, 12, 15, 13, 0, -15 },
  { 340, 11, 15, 13, 1, -15 },
  { 361, 11, 15, 13, 1, -15 },
  { 382, 11, 15, 13, 2, -15 },
  { 403, 11, 15, 13, 1, -15 },
  { 424, 10, 15, 13, 2, -15 },
  { 443, 5, 11, 13, 4, -11 },
  { 450, 6, 14, 13, 3, -11 },
  { 461, 10, 12, 13, 2, -12 },
  { 476, 11, 7, 13, 1, -10 },
  { 486, 10, 12, 13, 1, -12 },
  { 501, 10, 15, 13, 2, -15 },
  { 520, 11, 17, 13, 1, -15 },
  { 544, 11, 15, 13, 0, -15 },
  { 565, 11, 15, 13, 1, -15 },
  { 586, 11, 15, 13, 1, -15 },
  { 607, 11, 15, 13, 1, -15 },
  { 628, 12, 15, 13, 1, -15 },
  { 651, 12, 15, 13, 1, -15 },
  { 674, 11, 15, 13, 1, -15 },
  { 695, 12, 15, 13, 1, -15 },
  { 718, 11, 15, 13, 1, -15 },
  { 739, 11, 15, 13, 1, -15 },
  { 760, 13, 15, 13, 1, -15 },
  { 785, 10, 15, 13, 1, -15 },
  { 804, 13, 15, 13, 0, -15 },
  { 829, 12, 15, 13, 1, -15 },
  { 852, 11, 15, 13, 1, -15 },
  { 873, 11, 15, 13, 1, -15 },
  { 894, 11, 19, 13, 1, -15 },
  { 921, 11, 15, 13, 1, -15 },
  { 942, 12, 15, 13, 0, -15 },
  { 965, 12, 15, 13, 2, -15 },
  { 988, 12, 15, 13, 1, -15 },
  { 1011, 12, 15, 13, 2, -15 },
  { 1034, 13, 15, 13, 1, -15 },
  { 1059, 14, 15, 13, 0, -15 },
  { 1086, 12, 15, 13, 2, -15 },
  { 1109, 13, 15, 13, 0, -15 },
  { 1134, 9, 19, 13, 3, -16 },
  { 1156, 5, 19, 13, 4, -16 },
  { 1168, 10, 19, 13, 0, -16 },
  { 1192, 11, 9, 13, 1, -15 },
  { 1205, 10, 2, 13, 0, 2 },
  { 1208, 4, 4, 13, 4, -16 },
  { 1210, 11, 11, 13, 1, -11 },
  { 1226, 11, 16, 13, 1, -16 },
  { 1248, 10, 11, 13, 1, -11 },
  { 1262, 12, 16, 13, 1, -16 },
  { 1286, 10, 11, 13, 1, -11 },
  { 1300, 14, 20, 13, 0, -16 },
  { 1335, 12, 15, 13, 0, -11 },
  { 1358, 10, 16, 13, 1, -16 },
  { 1378, 9, 16, 13, 2, -16 },
  { 1396, 10, 20, 13, 1, -16 },
  { 1421, 11, 16, 13, 1, -16 },
  { 1443, 9, 16, 13, 2, -16 },
  { 1461, 12, 11, 13, 0, -11 },
  { 1478, 10, 11, 13, 1, -11 },
  { 1492, 10, 11, 13, 1, -11 },
  { 1506, 12, 15, 13, 0, -11 },
  { 1529, 11, 15, 13, 1, -11 },
  { 1550, 10, 11, 13, 2, -11 },
  { 1564, 10, 11, 13, 1, -11 },
  { 1578, 9, 15, 13, 2, -15 },
  { 1595, 11, 11, 13, 1, -11 },
  { 1611, 10, 11, 13, 1, -11 },
  { 1625, 11, 11, 13, 1, -11 },
  { 1641, 13, 11, 13, 0, -11 },
  { 1659, 12, 15, 13, 0, -11 },
  { 1682, 11, 11, 13, 1, -11 },
  { 1698, 10, 19, 13, 2, -16 },
  { 1722, 5, 19, 13, 4, -16 },
  { 1734, 10, 19, 13, 1, -16 },
  { 1758, 11, 5, 13, 1, -9 },
};

const GFXfont IBMPlexMono_MediumItalic21pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic21pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic21pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _IBMPLEXMONO_MEDIUMITALIC21PT7B_H_
