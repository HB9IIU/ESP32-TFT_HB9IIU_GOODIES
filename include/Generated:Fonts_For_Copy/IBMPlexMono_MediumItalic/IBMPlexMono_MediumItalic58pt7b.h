#ifndef _IBMPLEXMONO_MEDIUMITALIC58PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x83, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0x7E,
  0x00, 0x1F, 0x03, 0xF3, 0xF0, 0x3E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F,
  0x07, 0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xE7, 0xE0, 0x7C, 0x7E, 0x0F, 0xC7,
  0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xC0, 0xFC, 0x7C, 0x0F, 0xCF, 0xC0, 0xF8,
  0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07,
  0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00,
  0x7E, 0x0F, 0x80, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xE7, 0x9F, 0xF0, 0x3F, 0xC3,
  0xC3, 0xF0, 0x1F, 0x81, 0xE0, 0xF0, 0x1F, 0xC1, 0xF0, 0x30, 0x0F, 0xC0,
  0xF0, 0x10, 0x07, 0xE0, 0x78, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x01, 0xF8,
  0x1E, 0x00, 0x00, 0xFC, 0x0F, 0x00, 0x00, 0x7F, 0x0F, 0x80, 0x00, 0x3F,
  0x87, 0x80, 0x00, 0x1F, 0xF3, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x07, 0x9F, 0xF0, 0x00, 0x03, 0xC3, 0xF8, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x01, 0xE0, 0x7F, 0x00, 0x00, 0xF0, 0x3F, 0x80, 0x00, 0x78, 0x1F,
  0xC0, 0x00, 0x3C, 0x0F, 0xE0, 0x00, 0x1E, 0x07, 0xE0, 0x20, 0x1F, 0x03,
  0xF0, 0x78, 0x0F, 0x83, 0xF8, 0x7E, 0x07, 0x83, 0xF8, 0x7F, 0x83, 0xC3,
  0xFC, 0x1F, 0xF9, 0xE7, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0x00, 0x7F, 0xFC, 0x00, 0x3E, 0x00, 0xFF, 0xFC, 0x00, 0x3E, 0x00,
  0xF8, 0x7E, 0x00, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1E,
  0x01, 0xF8, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x03, 0xE0, 0x1E, 0x03, 0xE0,
  0x03, 0xE0, 0x1E, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x07, 0xC0,
  0x3E, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x1F,
  0x00, 0x07, 0xC0, 0x7C, 0x3E, 0x00, 0x03, 0xC0, 0x7C, 0x7C, 0x00, 0x03,
  0xE1, 0xF8, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0xF8, 0x00, 0x01, 0xFF, 0xF1,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0x8F, 0xFF, 0xC0, 0x00, 0x1F, 0x1F, 0x87,
  0xE0, 0x00, 0x3F, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x3E, 0x01, 0xE0, 0x00,
  0x7C, 0x3E, 0x01, 0xE0, 0x00, 0xF8, 0x3E, 0x01, 0xE0, 0x00, 0xF8, 0x3E,
  0x03, 0xE0, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x03, 0xE0,
  0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x1F, 0x80, 0x3C, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x1F,
  0x80, 0x3E, 0x00, 0x3F, 0xFF, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0x00, 0x7C,
  0x00, 0x0F, 0xFC, 0x00, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03,
  0xF0, 0x1F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xFF, 0x7F, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x3F, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x23, 0xF8, 0x01, 0xF8,
  0x0E, 0xFE, 0x00, 0x7E, 0x07, 0xFF, 0x80, 0x3F, 0xC3, 0xF7, 0xE0, 0x0F,
  0xF0, 0xF9, 0xFC, 0x06, 0x7E, 0x7E, 0x7F, 0x87, 0x9F, 0x9F, 0x0F, 0xFF,
  0xE3, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xF0, 0x0F,
  0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x1F, 0x8F, 0xC7, 0xC3,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x30, 0x07,
  0xC0, 0x19, 0xF8, 0x1F, 0x03, 0xE7, 0xF8, 0x7C, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x1F,
  0xC7, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC0,
  0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x1F, 0x87, 0xF9,
  0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xBF, 0xF3, 0xFE, 0x7F, 0x87, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xC0, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x0F,
  0x81, 0xF9, 0xFC, 0x3F, 0x83, 0xF3, 0xF0, 0x7F, 0x07, 0xEF, 0xE0, 0xFE,
  0x0F, 0xDF, 0xC3, 0xFC, 0x3F, 0xBF, 0x83, 0xF0, 0x7F, 0x7F, 0x07, 0xC0,
  0xFE, 0xFE, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F,
  0xE7, 0xE0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7E,
  0x3F, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x03,
  0xFC, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xF7, 0xE0, 0x01, 0xFE, 0x7E, 0x00,
  0x7F, 0xCF, 0xE0, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x0F, 0xC0, 0x3F, 0xC0,
  0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x00, 0xE0, 0x1F, 0xC0,
  0x04, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x01, 0xF0, 0x00, 0xFE, 0x00,
  0xE0, 0x00, 0x7F, 0x00, 0x40, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x08,
  0x00, 0x03, 0xF8, 0x3C, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x01, 0xFD, 0xF8, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F,
  0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC1, 0xFC, 0x00, 0x07,
  0xC7, 0xFF, 0x80, 0x0F, 0xCF, 0xFF, 0xC0, 0x0F, 0x9F, 0xFF, 0xE0, 0x0F,
  0xBF, 0xFF, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x0C,
  0x00, 0x07, 0xF0, 0x3C, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0xFF,
  0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x1F, 0xC7, 0xFF, 0x01, 0xFC, 0xFF, 0xFE, 0x0F, 0xEF, 0xFF, 0xF0,
  0x7E, 0xFF, 0xFF, 0xC7, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xF9, 0xFE,
  0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFE, 0xFE,
  0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x81,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFD, 0xF8, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x3F, 0x9F, 0x80,
  0x01, 0xFC, 0x7C, 0x00, 0x07, 0xF1, 0xF0, 0x00, 0x3F, 0x87, 0xC0, 0x00,
  0xFC, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFE,
  0x03, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xE0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFC,
  0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x7F, 0x80, 0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF9, 0xF8,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x03, 0xFE, 0xFF,
  0x00, 0x3F, 0xE7, 0xFE, 0x07, 0xFF, 0x1F, 0xFF, 0xFB, 0xF8, 0x7F, 0xFF,
  0x9F, 0x81, 0xFF, 0xF9, 0xFC, 0x07, 0xFF, 0x9F, 0xC0, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xF0, 0x7F,
  0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFE, 0x07, 0xF8, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x0F,
  0xF0, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x07,
  0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFC,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x20, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFE, 0x07, 0xFD, 0xFC,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0x9E, 0x00, 0x0F, 0xC2,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x1F, 0x1F, 0x00, 0xF8, 0x7C, 0x7C, 0x07, 0xF9, 0xF3, 0xF0, 0x3F, 0xF7,
  0xCF, 0x81, 0xFF, 0xDF, 0x3E, 0x0F, 0xFF, 0x7D, 0xF8, 0x7F, 0x07, 0xF7,
  0xE1, 0xF8, 0x0F, 0x9F, 0x87, 0xC0, 0x3E, 0x7C, 0x3F, 0x00, 0xF9, 0xF0,
  0xFC, 0x03, 0xE7, 0xC3, 0xE0, 0x0F, 0xBF, 0x0F, 0x80, 0x7E, 0xFC, 0x3E,
  0x01, 0xF3, 0xF1, 0xF8, 0x07, 0xCF, 0x87, 0xE0, 0x1F, 0x3E, 0x1F, 0x80,
  0xFC, 0xF8, 0x7E, 0x03, 0xF3, 0xE1, 0xF8, 0x1F, 0xCF, 0x83, 0xE0, 0xFE,
  0x3E, 0x0F, 0xC7, 0xF8, 0xF8, 0x3F, 0xFB, 0xE3, 0xE0, 0xFF, 0xCF, 0x8F,
  0x81, 0xFF, 0x3E, 0x3E, 0x03, 0xF9, 0xF8, 0xF8, 0x03, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xFC, 0x00, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE,
  0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E,
  0x1F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x7F,
  0x3F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xFC, 0x1F,
  0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xE0,
  0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x03,
  0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F,
  0x87, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x01, 0xF8,
  0x3F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0xFF, 0x83,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x0F,
  0x07, 0xE0, 0x00, 0x40, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x10, 0x0F,
  0xC0, 0x00, 0x38, 0x3F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0xFF,
  0x01, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xFC,
  0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x0F,
  0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0x7E,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x00,
  0x03, 0xF8, 0x7E, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x03,
  0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x7F, 0x81, 0xFC, 0x03, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xC0,
  0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x00,
  0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xE8, 0xFE, 0x00, 0x04,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xFF, 0x8F,
  0xE0, 0x3F, 0xFF, 0x3F, 0x80, 0x7F, 0xFC, 0x7F, 0x00, 0xFF, 0xF8, 0xFE,
  0x03, 0xFF, 0xF1, 0xFC, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x0F, 0xC7, 0xF0,
  0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x3E, 0x1F, 0xC0, 0x00, 0x7C, 0x3F, 0x80,
  0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xBE, 0x03, 0xFE, 0x0E,
  0xFC, 0x07, 0xFF, 0xFD, 0xF8, 0x07, 0xFF, 0xF3, 0xF0, 0x07, 0xFF, 0xC7,
  0xE0, 0x07, 0xFF, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0xC0,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x1F,
  0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x01, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x3F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xF0, 0x1F, 0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0x80,
  0x07, 0xF8, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x03,
  0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x0F, 0xF0,
  0x00, 0x7F, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0xC0, 0x00, 0x7E, 0x07,
  0xF8, 0x00, 0x07, 0xE0, 0xFF, 0x00, 0x00, 0x7E, 0x1F, 0xE0, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0x00, 0xFC, 0xFF, 0x00, 0x00, 0x0F, 0xDF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFD, 0xFC, 0x00, 0x01, 0xFF, 0x9F, 0xC0, 0x00, 0x1F, 0xF0, 0xFE, 0x00,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFB, 0xE0,
  0x7D, 0xF0, 0x1F, 0x7C, 0x1F, 0x3E, 0x03, 0xE7, 0xC7, 0xEF, 0xC0, 0xFC,
  0xF8, 0xF9, 0xF8, 0x1F, 0x9F, 0x3F, 0x3F, 0x03, 0xF3, 0xE7, 0xC7, 0xC0,
  0x7E, 0x3F, 0xF8, 0xF8, 0x0F, 0x87, 0xFE, 0x3F, 0x01, 0xF0, 0xFF, 0x87,
  0xE0, 0x7E, 0x1F, 0xF0, 0xFC, 0x0F, 0xC3, 0xFC, 0x1F, 0x81, 0xF8, 0x3F,
  0x83, 0xE0, 0x3F, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x80, 0xF8,
  0x1F, 0x03, 0xF0, 0x3F, 0x01, 0xC0, 0x7E, 0x07, 0xE0, 0x38, 0x0F, 0xC0,
  0xFC, 0x06, 0x01, 0xF0, 0x1F, 0x80, 0xC0, 0x7E, 0x03, 0xE0, 0x10, 0x0F,
  0xC0, 0x7C, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x03, 0xFE, 0x00, 0x1F, 0x81, 0xFF, 0x00, 0x0F, 0xC0, 0xFF, 0x80,
  0x07, 0xC0, 0x7F, 0xE0, 0x07, 0xE0, 0x3F, 0xF0, 0x03, 0xF0, 0x1F, 0xF8,
  0x01, 0xF8, 0x1F, 0xFC, 0x00, 0xFC, 0x0F, 0xFE, 0x00, 0x7E, 0x07, 0xFF,
  0x80, 0x3E, 0x03, 0xFF, 0xC0, 0x3F, 0x01, 0xFB, 0xE0, 0x1F, 0x80, 0xF9,
  0xF0, 0x0F, 0xC0, 0xFC, 0xF8, 0x07, 0xE0, 0x7E, 0x7E, 0x03, 0xF0, 0x3F,
  0x3F, 0x01, 0xF0, 0x1F, 0x8F, 0x81, 0xF8, 0x0F, 0x87, 0xC0, 0xFC, 0x07,
  0xC3, 0xF0, 0x7E, 0x07, 0xE1, 0xF8, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0x81,
  0xF8, 0x3E, 0x0F, 0x80, 0xFC, 0x1F, 0x0F, 0xC0, 0x7C, 0x0F, 0xC7, 0xE0,
  0x3E, 0x07, 0xE3, 0xF0, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x80, 0xF8, 0xFC,
  0x0F, 0xC0, 0x7C, 0x7C, 0x07, 0xE0, 0x3F, 0x7E, 0x03, 0xE0, 0x1F, 0xBF,
  0x01, 0xF0, 0x07, 0xDF, 0x81, 0xF8, 0x03, 0xEF, 0xC0, 0xFC, 0x01, 0xFF,
  0xE0, 0x7E, 0x00, 0xFF, 0xE0, 0x3F, 0x00, 0x7F, 0xF0, 0x1F, 0x00, 0x1F,
  0xF8, 0x0F, 0x80, 0x0F, 0xFC, 0x0F, 0xC0, 0x07, 0xFE, 0x07, 0xE0, 0x03,
  0xFF, 0x03, 0xF0, 0x01, 0xFF, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0xFE, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x01,
  0xF8, 0x7F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x07, 0xF3, 0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFE, 0x3F, 0x00, 0x01, 0xFC, 0x7F, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x7F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00,
  0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00,
  0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0xFE, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8,
  0x7F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x0F, 0xC7,
  0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x03, 0xF3, 0xF8,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x07, 0xF3, 0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x1F, 0xCF, 0xC0, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0xFE, 0x3F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x03,
  0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F,
  0x03, 0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x80, 0x00, 0xFE, 0x03, 0x80,
  0x00, 0xFC, 0x0F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x01, 0xFD, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F,
  0x81, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x3F,
  0x80, 0x7E, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3C, 0x07, 0xF0, 0x00, 0x0C,
  0x03, 0xF8, 0x00, 0x04, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x08,
  0x00, 0x01, 0xFC, 0x1E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x1F,
  0xF0, 0x00, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x00,
  0x03, 0xF8, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x01,
  0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFE,
  0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xE1,
  0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7F, 0x0F,
  0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x87, 0xE0,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F,
  0x9F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x00, 0x03, 0xF8,
  0x7E, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x83,
  0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x03, 0xF0,
  0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x1F,
  0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x07, 0xE7, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00,
  0x3E, 0x1F, 0x80, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x07, 0xC1, 0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00,
  0xF8, 0x1F, 0x01, 0xF8, 0x0F, 0x81, 0xF0, 0x3F, 0x81, 0xF8, 0x3F, 0x03,
  0xF8, 0x1F, 0x83, 0xF0, 0x7F, 0x81, 0xF0, 0x3F, 0x07, 0xF8, 0x1F, 0x03,
  0xF0, 0x7F, 0x83, 0xF0, 0x3E, 0x0F, 0xF8, 0x3F, 0x03, 0xE0, 0xF7, 0x83,
  0xE0, 0x3E, 0x0F, 0x78, 0x3E, 0x03, 0xE1, 0xF7, 0x83, 0xE0, 0x3E, 0x1E,
  0x78, 0x7E, 0x03, 0xE1, 0xE7, 0x87, 0xC0, 0x7E, 0x3E, 0x78, 0x7C, 0x07,
  0xE3, 0xC7, 0x87, 0xC0, 0x7E, 0x3C, 0x7C, 0xFC, 0x07, 0xE7, 0xC7, 0xCF,
  0x80, 0x7C, 0x78, 0x7C, 0xF8, 0x07, 0xCF, 0x87, 0xCF, 0x80, 0x7C, 0xF8,
  0x7D, 0xF8, 0x07, 0xCF, 0x07, 0xDF, 0x00, 0x7D, 0xF0, 0x7D, 0xF0, 0x07,
  0xDF, 0x07, 0xDF, 0x00, 0xFD, 0xE0, 0x7D, 0xF0, 0x0F, 0xFE, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x0F,
  0xF8, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF1, 0xFC, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7F,
  0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7F, 0x03,
  0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE3,
  0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x07, 0xC6, 0x00, 0x00, 0x18, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0C, 0x3E, 0x3F, 0x8F, 0xC7, 0xE1, 0xF8, 0xFC,
  0x3E, 0x1F, 0x87, 0xC1, 0xE0, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF,
  0x0F, 0xC0, 0xFF, 0xFC, 0xFE, 0x0F, 0xFF, 0xF7, 0xF0, 0xFF, 0xFF, 0xBF,
  0x07, 0xF8, 0x1D, 0xF8, 0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x00, 0xFE, 0x3F,
  0x80, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xF8, 0xFC, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x3F,
  0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3F,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xFC, 0x7E, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0xFF,
  0x87, 0xF0, 0x0E, 0xFC, 0x1F, 0xE0, 0xE7, 0xFE, 0xFF, 0xFF, 0x3F, 0xE3,
  0xFF, 0xF1, 0xFF, 0x1F, 0xFF, 0x0F, 0xF8, 0x7F, 0xF0, 0x1F, 0xC0, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x3F, 0x00, 0x1F, 0x83, 0xFF, 0x00, 0x7E, 0x3F, 0xFE, 0x01, 0xF9,
  0xFF, 0xFC, 0x07, 0xE7, 0xFF, 0xF8, 0x1F, 0xBC, 0x1F, 0xE0, 0xFF, 0xC0,
  0x3F, 0x83, 0xF6, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x03,
  0xF0, 0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0xFC,
  0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x7F, 0x1F,
  0x80, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x7F, 0x0F, 0xC0, 0x01, 0xFC, 0x7F, 0x80, 0x0F, 0xE1, 0xFE, 0x00, 0x7F,
  0x87, 0xEE, 0x07, 0xFC, 0x1F, 0xBF, 0xFF, 0xE0, 0x7E, 0x7F, 0xFF, 0x01,
  0xF8, 0xFF, 0xF8, 0x0F, 0xE1, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x03, 0xF8, 0xFE,
  0x00, 0x3E, 0x3F, 0x80, 0x07, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x21, 0xF8, 0x00,
  0x0E, 0x3F, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x8F,
  0xE0, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0xFF, 0xE1, 0xF8, 0x01, 0xFF, 0xF1, 0xF8, 0x07,
  0xFF, 0xF9, 0xF8, 0x07, 0xFF, 0xF9, 0xF8, 0x0F, 0xF8, 0x1D, 0xF8, 0x1F,
  0xE0, 0x0F, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x3F,
  0x00, 0x03, 0xF0, 0x7F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x07, 0xE0, 0xFE,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0xDF, 0x80, 0x7F, 0x83, 0xDF, 0x80, 0x7F,
  0xFF, 0x9F, 0x80, 0x3F, 0xFF, 0x1F, 0x80, 0x3F, 0xFE, 0x1F, 0x80, 0x0F,
  0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xF0, 0x3F, 0xC3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x3F, 0x80,
  0x07, 0xE7, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xF7,
  0xE0, 0x01, 0xFD, 0xFC, 0x00, 0xFF, 0xBF, 0x81, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x04, 0x3F, 0x00, 0x01,
  0xE7, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xCF, 0xE0, 0x07, 0xF1, 0xFF,
  0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x40, 0x0F,
  0xC0, 0x00, 0x03, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x7E,
  0x00, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x00,
  0x3F, 0x9F, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0xFC, 0x03, 0xFF, 0xF1, 0xF8, 0x0F, 0xFF, 0xF3, 0xF0, 0x3F, 0xFF, 0xF7,
  0xE0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFE, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x0F,
  0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x7E,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0,
  0x0D, 0xF8, 0x1F, 0xC0, 0x3F, 0xF0, 0x3F, 0xC1, 0xEF, 0xC0, 0x7F, 0xFF,
  0x9F, 0x80, 0x7F, 0xFF, 0x3F, 0x00, 0x7F, 0xFC, 0x7E, 0x00, 0x7F, 0xF0,
  0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x40, 0x01, 0xFC,
  0x01, 0xC0, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0xFE, 0x1F, 0xF8, 0x0F, 0xE7, 0xFF, 0xC0, 0xFC, 0x7F, 0xFE,
  0x0F, 0xCF, 0xFF, 0xE0, 0xFD, 0xE1, 0xFE, 0x0F, 0xD8, 0x07, 0xF1, 0xFF,
  0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF1, 0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x03,
  0xF1, 0xF8, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7E, 0x3F,
  0x80, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x7E, 0x3F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00,
  0x1F, 0xC7, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8,
  0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x01, 0x80,
  0x0F, 0xC0, 0x3C, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0xFF, 0x01, 0xFC,
  0x1F, 0xC0, 0x1F, 0x83, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0x8F, 0xE0,
  0x01, 0xFB, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x01, 0x80, 0x1F, 0x80,
  0x3C, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xF0, 0x07, 0xF8,
  0x3F, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x7F, 0x7E, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x3F,
  0x87, 0xFE, 0x00, 0xFE, 0x3F, 0xFC, 0x03, 0xF1, 0xFF, 0xF8, 0x0F, 0xCF,
  0xFF, 0xE0, 0x3F, 0x78, 0x3F, 0xC0, 0xFD, 0x80, 0x7F, 0x07, 0xFC, 0x01,
  0xFC, 0x1F, 0xE0, 0x03, 0xF0, 0x7F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x7F,
  0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x03,
  0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x01, 0xFC, 0x00, 0xFC,
  0x3F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x7F, 0x1F,
  0x80, 0x01, 0xF8, 0x7F, 0x00, 0x47, 0xE0, 0xFC, 0x07, 0x9F, 0x83, 0xF8,
  0x3F, 0x7E, 0x07, 0xE1, 0xFD, 0xF8, 0x1F, 0x8F, 0xEF, 0xE0, 0x3F, 0x7F,
  0x3F, 0x00, 0xFF, 0xF8, 0xFC, 0x03, 0xFF, 0xC3, 0xF0, 0x07, 0xFE, 0x0F,
  0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x0C, 0x07, 0xE0, 0x1E, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0,
  0x7F, 0x0F, 0xC0, 0xFE, 0x0F, 0xC3, 0xFC, 0x0F, 0xC7, 0xF8, 0x1F, 0xCF,
  0xF0, 0x1F, 0x9F, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x01,
  0xF1, 0xFC, 0x3F, 0xC0, 0x7C, 0xFF, 0x9F, 0xF8, 0x1F, 0x7F, 0xEF, 0xFE,
  0x07, 0xDF, 0xFB, 0xFF, 0x83, 0xFC, 0x7F, 0xC7, 0xF0, 0xFE, 0x0F, 0xE0,
  0xFC, 0x3F, 0x03, 0xF0, 0x3E, 0x0F, 0xC0, 0xFC, 0x0F, 0x83, 0xE0, 0x3E,
  0x03, 0xE0, 0xF8, 0x0F, 0x80, 0xF8, 0x7E, 0x07, 0xE0, 0x3E, 0x1F, 0x01,
  0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x07, 0xE1, 0xF0, 0x1F, 0x01, 0xF0, 0x7C,
  0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x1F, 0x0F, 0xC0, 0xFC, 0x07, 0xC3,
  0xE0, 0x3F, 0x01, 0xF0, 0xF8, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xE0, 0x3E,
  0x0F, 0x80, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x03, 0xE1, 0xF8, 0x1F, 0x80,
  0xF8, 0x7C, 0x07, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0x1F, 0x87, 0xC0, 0x7C,
  0x07, 0xE1, 0xF0, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0x7C, 0x3F, 0x03,
  0xF0, 0x1F, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0xFE,
  0x1F, 0xF8, 0x0F, 0xE7, 0xFF, 0xC0, 0xFC, 0x7F, 0xFE, 0x0F, 0xCF, 0xFF,
  0xE0, 0xFD, 0xE1, 0xFE, 0x0F, 0xD8, 0x07, 0xF1, 0xFF, 0x00, 0x7F, 0x1F,
  0xE0, 0x07, 0xF1, 0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xF1, 0xF8, 0x00,
  0x7F, 0x1F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xE3,
  0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC,
  0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0xC7, 0xE0,
  0x01, 0xF8, 0xFE, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F,
  0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0x83, 0xF8, 0x00,
  0xFE, 0x3F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC,
  0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x00, 0x01, 0xFD, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x1F, 0xBF, 0x80, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7F,
  0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xF8, 0x7E,
  0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0xF0,
  0x01, 0xF8, 0xFF, 0xF8, 0x01, 0xF9, 0xFF, 0xFC, 0x01, 0xF9, 0xFF, 0xFE,
  0x01, 0xFB, 0xC1, 0xFE, 0x03, 0xFF, 0x00, 0xFE, 0x03, 0xF6, 0x00, 0x7F,
  0x03, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xFC,
  0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF8,
  0x1F, 0xB8, 0x1F, 0xF0, 0x1F, 0xBF, 0xFF, 0xE0, 0x1F, 0x9F, 0xFF, 0xC0,
  0x1F, 0x8F, 0xFF, 0x80, 0x3F, 0x87, 0xFF, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xFF, 0x0F, 0xC0, 0x7F, 0xFC, 0x7E, 0x0F, 0xFF, 0xF3, 0xF0, 0x7F,
  0xFF, 0x9F, 0x87, 0xFC, 0x0E, 0xFC, 0x7F, 0x80, 0x3F, 0xE3, 0xF8, 0x00,
  0xFE, 0x3F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFC,
  0xFC, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xF3, 0xF8,
  0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x3F, 0x3F, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC,
  0x7E, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFF, 0x1F, 0x80, 0x07, 0xF8, 0xFE,
  0x00, 0x7F, 0xC7, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0xF7, 0xE0, 0xFF, 0xFF,
  0x3F, 0x03, 0xFF, 0xF1, 0xF8, 0x1F, 0xFF, 0x8F, 0xC0, 0x3F, 0xF0, 0xFE,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0xFE, 0x07, 0xF7,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC,
  0xFF, 0xF0, 0x0F, 0xDF, 0xFE, 0x01, 0xFD, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFB, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0x80, 0xFE, 0x0F, 0xE0, 0x03, 0xC0, 0xFC, 0x00, 0x08, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC1, 0x00, 0x00, 0xFC, 0x38, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xF8,
  0xFF, 0x80, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x01, 0x00, 0x3F, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01,
  0xFE, 0x03, 0xF0, 0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x07, 0xE1, 0xFE, 0x00,
  0x7F, 0x7F, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x03,
  0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x7F, 0x1F,
  0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00,
  0x0F, 0xC7, 0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xF8,
  0xFE, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xC0,
  0x07, 0xF8, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x0F, 0xF0, 0xFE, 0x01, 0xBF,
  0x0F, 0xF0, 0x7B, 0xF0, 0x7F, 0xFF, 0x3F, 0x07, 0xFF, 0xE7, 0xF0, 0x3F,
  0xFC, 0x7F, 0x01, 0xFF, 0x87, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x63, 0xFF, 0xC0, 0x1F, 0x1F, 0xFC, 0x01, 0xFD, 0xFF, 0xE0, 0x0F,
  0xEF, 0xFF, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0,
  0x7E, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01,
  0xF8, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xE0,
  0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x80, 0xFC,
  0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x1F,
  0xE0, 0x1F, 0x83, 0xFE, 0x00, 0xFC, 0x7F, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x0C, 0x3F, 0x03, 0xE0, 0xF8, 0x7C,
  0x07, 0xC1, 0xF0, 0xF8, 0x0F, 0x83, 0xF1, 0xF0, 0x1F, 0x03, 0xE3, 0xE0,
  0x7E, 0x07, 0xCF, 0xC0, 0xF8, 0x0F, 0x9F, 0x01, 0xF0, 0x1F, 0x3E, 0x03,
  0xE0, 0x3E, 0x7C, 0x07, 0xC0, 0x7C, 0xF8, 0x0F, 0x80, 0xF9, 0xF0, 0x1F,
  0x01, 0xF7, 0xE0, 0x7E, 0x03, 0xEF, 0x80, 0xF8, 0x07, 0xDF, 0x01, 0xF0,
  0x0F, 0xBE, 0x03, 0xE0, 0x3F, 0x7C, 0x07, 0xC0, 0x7C, 0xF8, 0x0F, 0x80,
  0xFB, 0xF0, 0x3F, 0x01, 0xF7, 0xC0, 0x7C, 0x03, 0xEF, 0x80, 0xF8, 0x0F,
  0x9F, 0x01, 0xF0, 0x1F, 0x3E, 0x07, 0xE0, 0x3E, 0x7C, 0x0F, 0xC0, 0xF8,
  0xF8, 0x37, 0x83, 0xF1, 0xF8, 0xEF, 0x07, 0xC3, 0xFF, 0x9F, 0x1F, 0x07,
  0xFF, 0x3F, 0xFE, 0x0F, 0xFC, 0x7F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xF8, 0x1F,
  0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x7F, 0xFE,
  0x3F, 0xFC, 0x1F, 0xF7, 0xCF, 0x1F, 0x87, 0xF8, 0xF9, 0xC1, 0xF9, 0xFC,
  0x1F, 0x30, 0x3F, 0x1F, 0x01, 0xFE, 0x07, 0xE1, 0x80, 0x3F, 0x80, 0xFC,
  0x20, 0x07, 0xF0, 0x1F, 0x80, 0x01, 0xFE, 0x03, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xC0, 0x7F, 0x00, 0x01,
  0xF8, 0x0F, 0xE0, 0x08, 0x3F, 0x01, 0xFC, 0x03, 0x87, 0xE0, 0x7F, 0x80,
  0xF8, 0xFC, 0x0D, 0xF0, 0x7F, 0x1F, 0x83, 0x9F, 0x1F, 0xC3, 0xF0, 0xF3,
  0xEF, 0xF0, 0x7F, 0xFC, 0x7F, 0xFC, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0xFF,
  0xE0, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8,
  0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F,
  0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0,
  0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x7F, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x01,
  0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x1B, 0xF0, 0x0F, 0xF0, 0xF7,
  0xE0, 0x1F, 0xFF, 0xCF, 0xC0, 0x3F, 0xFF, 0x1F, 0x80, 0x3F, 0xFE, 0x7F,
  0x00, 0x3F, 0xF0, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x40, 0x00, 0xFE, 0x01, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0xC1, 0xF8, 0x3F, 0xFF, 0xE3, 0xF0, 0xFF,
  0xFF, 0xE7, 0xC1, 0xF8, 0x1F, 0xFF, 0x83, 0xE0, 0x0F, 0xFF, 0x0F, 0xC0,
  0x07, 0xFC, 0x1F, 0x00, 0x0F, 0xF0, 0x3E, 0x00, 0x3F, 0x80, 0x7C, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x01, 0x80, 0x07, 0xF0, 0x1F,
  0x00, 0x1F, 0xC0, 0x1F, 0x00, 0x7F, 0x00, 0x3E, 0x01, 0xFC, 0x00, 0x7C,
  0x0F, 0xF0, 0x00, 0xFC, 0x3F, 0xF0, 0x00, 0xF8, 0xFF, 0xFF, 0x01, 0xF1,
  0xFF, 0xFF, 0xE3, 0xE3, 0xE3, 0xFF, 0xFF, 0xC7, 0xC1, 0xFF, 0xFF, 0x1F,
  0x80, 0x7F, 0xFE, 0x3F, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x18, 0x07, 0xFC, 0x00, 0x7C, 0x1F, 0xFC, 0x00, 0xF8, 0x7F, 0xFC,
  0x01, 0xF1, 0xFF, 0xF8, 0x07, 0xC3, 0xF1, 0xF8, 0x0F, 0x8F, 0xC1, 0xF8,
  0x3E, 0x1F, 0x03, 0xF8, 0xFC, 0x7C, 0x03, 0xFF, 0xF0, 0xF8, 0x03, 0xFF,
  0xE3, 0xE0, 0x07, 0xFF, 0x87, 0xC0, 0x07, 0xFC, 0x03, 0x80, 0x03, 0xF0,
  0x00,
};

const GFXglyph IBMPlexMono_MediumItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 14, 41, 35, 11, -40 },
  { 73, 20, 17, 35, 11, -43 },
  { 116, 36, 40, 35, 0, -40 },
  { 296, 33, 54, 35, 1, -47 },
  { 519, 40, 42, 35, -2, -41 },
  { 729, 34, 42, 35, 0, -41 },
  { 908, 9, 17, 35, 16, -43 },
  { 928, 23, 52, 35, 11, -44 },
  { 1078, 23, 52, 35, 2, -44 },
  { 1228, 30, 29, 35, 3, -32 },
  { 1337, 28, 29, 35, 4, -32 },
  { 1439, 15, 17, 35, 7, -9 },
  { 1471, 18, 6, 35, 9, -21 },
  { 1485, 11, 10, 35, 10, -9 },
  { 1499, 34, 52, 35, 1, -44 },
  { 1720, 31, 42, 35, 3, -41 },
  { 1883, 28, 40, 35, 3, -40 },
  { 2023, 32, 41, 35, 1, -41 },
  { 2187, 32, 42, 35, 1, -41 },
  { 2355, 32, 40, 35, 1, -40 },
  { 2515, 32, 41, 35, 2, -40 },
  { 2679, 29, 41, 35, 3, -40 },
  { 2828, 30, 40, 35, 5, -40 },
  { 2978, 32, 42, 35, 2, -41 },
  { 3146, 29, 41, 35, 4, -41 },
  { 3295, 14, 32, 35, 10, -31 },
  { 3351, 17, 39, 35, 7, -31 },
  { 3434, 28, 34, 35, 5, -35 },
  { 3553, 30, 17, 35, 3, -26 },
  { 3617, 28, 34, 35, 3, -35 },
  { 3736, 25, 42, 35, 7, -41 },
  { 3868, 30, 48, 35, 3, -41 },
  { 4048, 32, 40, 35, -1, -40 },
  { 4208, 31, 40, 35, 2, -40 },
  { 4363, 30, 42, 35, 4, -41 },
  { 4521, 31, 40, 35, 2, -40 },
  { 4676, 33, 40, 35, 2, -40 },
  { 4841, 33, 40, 35, 2, -40 },
  { 5006, 31, 42, 35, 3, -41 },
  { 5169, 33, 40, 35, 2, -40 },
  { 5334, 32, 40, 35, 2, -40 },
  { 5494, 30, 41, 35, 3, -40 },
  { 5648, 36, 40, 35, 2, -40 },
  { 5828, 26, 40, 35, 4, -40 },
  { 5958, 35, 40, 35, 1, -40 },
  { 6133, 33, 40, 35, 2, -40 },
  { 6298, 31, 42, 35, 3, -41 },
  { 6461, 32, 40, 35, 2, -40 },
  { 6621, 31, 52, 35, 3, -41 },
  { 6823, 32, 40, 35, 2, -40 },
  { 6983, 33, 42, 35, 1, -41 },
  { 7157, 33, 40, 35, 5, -40 },
  { 7322, 31, 41, 35, 4, -40 },
  { 7481, 31, 40, 35, 6, -40 },
  { 7636, 36, 40, 35, 2, -40 },
  { 7816, 38, 40, 35, -1, -40 },
  { 8006, 33, 40, 35, 5, -40 },
  { 8171, 35, 40, 35, 0, -40 },
  { 8346, 26, 52, 35, 8, -44 },
  { 8515, 16, 52, 35, 10, -44 },
  { 8619, 26, 52, 35, 1, -44 },
  { 8788, 30, 24, 35, 3, -40 },
  { 8878, 28, 5, 35, 0, 5 },
  { 8896, 9, 12, 35, 12, -46 },
  { 8910, 29, 32, 35, 3, -31 },
  { 9026, 30, 44, 35, 2, -43 },
  { 9191, 27, 32, 35, 4, -31 },
  { 9299, 32, 44, 35, 3, -43 },
  { 9475, 27, 32, 35, 4, -31 },
  { 9583, 38, 55, 35, -1, -43 },
  { 9845, 31, 43, 35, 1, -31 },
  { 10012, 28, 43, 35, 3, -43 },
  { 10163, 28, 44, 35, 4, -43 },
  { 10317, 28, 55, 35, 2, -43 },
  { 10510, 30, 44, 35, 3, -43 },
  { 10675, 24, 44, 35, 6, -43 },
  { 10807, 34, 31, 35, 0, -31 },
  { 10939, 28, 31, 35, 3, -31 },
  { 11048, 29, 32, 35, 3, -31 },
  { 11164, 32, 43, 35, 0, -31 },
  { 11336, 29, 43, 35, 3, -31 },
  { 11492, 28, 30, 35, 6, -30 },
  { 11597, 28, 32, 35, 3, -31 },
  { 11709, 28, 41, 35, 4, -40 },
  { 11853, 28, 31, 35, 4, -30 },
  { 11962, 29, 31, 35, 3, -30 },
  { 12075, 31, 31, 35, 2, -30 },
  { 12196, 35, 32, 35, 0, -31 },
  { 12336, 31, 42, 35, 1, -30 },
  { 12499, 31, 32, 35, 2, -31 },
  { 12623, 28, 52, 35, 6, -44 },
  { 12805, 14, 52, 35, 11, -44 },
  { 12896, 28, 52, 35, 2, -44 },
  { 13078, 31, 13, 35, 2, -24 },
};

const GFXfont IBMPlexMono_MediumItalic58pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic58pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic58pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _IBMPLEXMONO_MEDIUMITALIC58PT7B_H_
