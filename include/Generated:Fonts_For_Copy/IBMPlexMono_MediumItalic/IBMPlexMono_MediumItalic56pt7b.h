#ifndef _IBMPLEXMONO_MEDIUMITALIC56PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0x81, 0xFF,
  0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x07, 0xF0, 0x0F, 0x80, 0x1F,
  0x83, 0xF1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x7E, 0x3F, 0x07, 0xE3,
  0xF0, 0x7E, 0x3F, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0xFC,
  0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F,
  0x87, 0xC1, 0xF8, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x79, 0xFF, 0x03, 0xF8, 0x78,
  0x7E, 0x07, 0xF0, 0x78, 0x3C, 0x07, 0xE0, 0x78, 0x18, 0x07, 0xE0, 0x78,
  0x00, 0x07, 0xE0, 0xF0, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x0F, 0xE0, 0xF0,
  0x00, 0x07, 0xE0, 0xF0, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x07, 0xF0, 0xF0,
  0x00, 0x07, 0xFD, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xDF, 0xF8, 0x00, 0x03, 0xC7,
  0xF8, 0x00, 0x03, 0xC3, 0xF8, 0x00, 0x03, 0xC1, 0xF8, 0x00, 0x03, 0xC1,
  0xFC, 0x00, 0x07, 0xC1, 0xFC, 0x00, 0x07, 0x81, 0xFC, 0x00, 0x07, 0x81,
  0xF8, 0x08, 0x07, 0x81, 0xF8, 0x3C, 0x07, 0x83, 0xF8, 0x7E, 0x07, 0x83,
  0xF0, 0xFF, 0x0F, 0x8F, 0xF0, 0x7F, 0xCF, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x7C, 0x01, 0xFF, 0xE0, 0x01, 0xF0, 0x07, 0xFF, 0xE0, 0x07,
  0xC0, 0x1F, 0x87, 0xC0, 0x0F, 0x80, 0x3E, 0x07, 0x80, 0x3E, 0x00, 0xF8,
  0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x03, 0xC0, 0x3E, 0x07,
  0xC0, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x1F, 0x00, 0xF0, 0x3E, 0x00, 0x3E,
  0x01, 0xE0, 0xF8, 0x00, 0x7C, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x0F, 0x87,
  0xC0, 0x01, 0xF0, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x7C, 0x00, 0x03,
  0xFF, 0xF0, 0xF8, 0x00, 0x03, 0xFF, 0xC3, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xC7,
  0xFF, 0xC0, 0x00, 0x1F, 0x1F, 0xFF, 0x80, 0x00, 0x7C, 0x3E, 0x1F, 0x80,
  0x01, 0xF0, 0xF8, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x1E, 0x00, 0x0F, 0x87,
  0xC0, 0x3C, 0x00, 0x3E, 0x0F, 0x80, 0x78, 0x00, 0x7C, 0x1F, 0x01, 0xF0,
  0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x78, 0x07, 0xC0, 0x0F, 0x80,
  0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xE0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x7C,
  0x01, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0x00,
  0x0F, 0xFF, 0x80, 0x3E, 0x00, 0x0F, 0xFC, 0x00, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFC,
  0x3F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x0F,
  0xC0, 0x1F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x7F, 0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x07, 0xE0, 0x07, 0xE0, 0x23, 0xF0, 0x03, 0xF0, 0x19, 0xF8, 0x01, 0xF8,
  0x1F, 0xFC, 0x00, 0xFE, 0x1F, 0xFF, 0x00, 0xDF, 0x0F, 0x9F, 0x80, 0xEF,
  0xCF, 0x8F, 0xE0, 0xF7, 0xE7, 0xC7, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0xF8,
  0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xE0, 0x03, 0xF0,
  0x03, 0xE0, 0x00, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7E, 0x7E, 0x7E,
  0x7C, 0x7C, 0x7C, 0xFC, 0xFC, 0xFC, 0xF8, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x30, 0x0F, 0xC0, 0x33, 0xF0,
  0x7E, 0x1F, 0x9F, 0xF3, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x07,
  0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x03, 0xF8, 0x03, 0xE0,
  0x07, 0x80, 0x0E, 0x00, 0x08, 0x00, 0x40, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F,
  0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F,
  0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x7F, 0xFF, 0xDF, 0xFF,
  0xF7, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x1F, 0x1F, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E,
  0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x3C,
  0x0F, 0xDF, 0x83, 0xF0, 0x7F, 0xFC, 0x3F, 0x83, 0xFF, 0xE1, 0xFC, 0x1F,
  0xFF, 0x0F, 0xE1, 0xFF, 0xF0, 0x7F, 0x0F, 0xFF, 0x81, 0xF0, 0x7F, 0xFC,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F,
  0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFC, 0x1F,
  0xC0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xF7, 0xE0, 0x01, 0xFE,
  0x7E, 0x00, 0x3F, 0xC7, 0xE0, 0x07, 0xF8, 0x7E, 0x00, 0xFF, 0x0F, 0xC0,
  0x1F, 0xE0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x00, 0x70,
  0x0F, 0xC0, 0x04, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x03, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0x7F, 0x00, 0xF0, 0x00, 0xFE,
  0x00, 0xC0, 0x00, 0xFE, 0x00, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x08, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x04, 0x00, 0x03, 0xF8, 0x3C, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x03, 0xFE, 0x03, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E,
  0x3F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x1F,
  0x80, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x07, 0xE0,
  0x07, 0xE0, 0x1F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0xC0,
  0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7E, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xE3, 0xFF, 0xC0, 0x0F,
  0x9F, 0xFF, 0x80, 0x3E, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xC0, 0x0F, 0xF0, 0x3E, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x80, 0x00, 0x7E, 0x0F, 0x00, 0x03, 0xF8, 0x7E,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0xFF,
  0xE0, 0x1F, 0x9F, 0xFF, 0x83, 0xF3, 0xFF, 0xF8, 0x3F, 0x7F, 0xFF, 0xC7,
  0xEF, 0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x1F,
  0xC7, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0x00, 0x01, 0xF9, 0xF0,
  0x00, 0x1F, 0xCF, 0x80, 0x01, 0xFC, 0x7C, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0xFE, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0x80,
  0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x03,
  0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC,
  0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x03,
  0xF8, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0x01,
  0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0xFC, 0xFE, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFE, 0x1F, 0xF0,
  0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00,
  0x7E, 0x3F, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0xF7, 0xE3, 0xFF,
  0xFE, 0xFC, 0x3F, 0xFF, 0xCF, 0xC1, 0xFF, 0xF9, 0xF8, 0x07, 0xFF, 0x1F,
  0x80, 0x1F, 0xC3, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0xC3, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xFC, 0x7F, 0xE1, 0xFE, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x81, 0xFF, 0x0F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F,
  0xF1, 0xFF, 0x0F, 0xF8, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x04, 0x00,
  0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xC0, 0x04, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x7F, 0x81, 0xFE,
  0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x38, 0x00, 0x3F,
  0x08, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xC0, 0xFC,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x3E, 0x3E, 0x01, 0xF1, 0xF1, 0xF0, 0x3F, 0xCF, 0x9F, 0x03, 0xFF, 0x7C,
  0xF8, 0x3F, 0xFB, 0xE7, 0xC3, 0xF8, 0x7F, 0x7E, 0x1F, 0x81, 0xF3, 0xE0,
  0xF8, 0x0F, 0x9F, 0x0F, 0x80, 0x7C, 0xF8, 0x7C, 0x03, 0xE7, 0xC3, 0xE0,
  0x1F, 0x7E, 0x3F, 0x00, 0xFB, 0xF1, 0xF0, 0x0F, 0xDF, 0x0F, 0x80, 0x7C,
  0xF8, 0x7C, 0x03, 0xE7, 0xC3, 0xE0, 0x1F, 0x3E, 0x1F, 0x01, 0xF9, 0xF0,
  0xF8, 0x0F, 0xCF, 0x87, 0xC0, 0xFE, 0x7C, 0x3F, 0x0F, 0xE3, 0xE1, 0xFC,
  0xFF, 0x1F, 0x0F, 0xFE, 0xF8, 0xF8, 0x3F, 0xF7, 0xC7, 0xC1, 0xFF, 0x3E,
  0x3E, 0x07, 0xF1, 0xF1, 0xF0, 0x0E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0xC7, 0xC0, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0xFC, 0x7F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xC0, 0x1F, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x07, 0xE0,
  0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F,
  0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x01, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80,
  0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0xFC, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7F,
  0x0F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0xE1, 0xF8, 0x01, 0xFF, 0x07,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0x7F,
  0x0F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x70, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x03, 0x03, 0xF0, 0x00, 0x3F, 0x1F,
  0x80, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0x1F, 0xC0,
  0x1F, 0xC0, 0x7F, 0x83, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xC0, 0x3F,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0x80,
  0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0xFC, 0x1F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xF1, 0xF8,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF8, 0x7E, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0,
  0x7F, 0x00, 0x3F, 0x81, 0xF8, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC7,
  0xF0, 0x00, 0x78, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x3F, 0xFF, 0x7F, 0x01, 0xFF, 0xFB, 0xF8, 0x0F, 0xFF, 0x9F, 0xC0,
  0x7F, 0xFC, 0xFE, 0x03, 0xFF, 0xE7, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x01,
  0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7C, 0x7F, 0x00, 0x03, 0xE3,
  0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0xC3, 0xF8,
  0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x83, 0xDF, 0x03, 0xFF, 0xFD,
  0xF8, 0x0F, 0xFF, 0xEF, 0xC0, 0x3F, 0xFE, 0x7E, 0x00, 0xFF, 0xE3, 0xF0,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E,
  0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFC,
  0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xF8,
  0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x03, 0xF0,
  0x3F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0,
  0xFE, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x0C, 0x00, 0x1F,
  0x83, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x0F, 0xC0,
  0x01, 0xFC, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x7F, 0x80,
  0x07, 0xE0, 0x1F, 0xE0, 0x00, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0x81, 0xFE,
  0x00, 0x03, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x0F,
  0xCF, 0xE0, 0x00, 0x01, 0xFB, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x07, 0xFE, 0x7E, 0x00, 0x00, 0xFF, 0x8F, 0xE0, 0x00, 0x3F, 0xE0,
  0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x0F, 0xC0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x01, 0xF7, 0xC1, 0xF7,
  0xC0, 0x7D, 0xF0, 0xF9, 0xF0, 0x3F, 0x7C, 0x3E, 0xFC, 0x0F, 0xDF, 0x1F,
  0x3E, 0x03, 0xE3, 0xC7, 0xCF, 0x80, 0xF8, 0xFB, 0xE3, 0xE0, 0x3E, 0x3E,
  0xF8, 0xF8, 0x0F, 0x8F, 0xFC, 0x7E, 0x07, 0xE1, 0xFE, 0x1F, 0x81, 0xF8,
  0x7F, 0x87, 0xC0, 0x7E, 0x1F, 0xC1, 0xF0, 0x1F, 0x07, 0xF0, 0x7C, 0x07,
  0xC1, 0xF8, 0x3F, 0x01, 0xF0, 0x3E, 0x0F, 0xC0, 0xFC, 0x0F, 0x03, 0xF0,
  0x3F, 0x03, 0xC0, 0xF8, 0x0F, 0xC0, 0xE0, 0x3E, 0x03, 0xE0, 0x18, 0x0F,
  0x80, 0xF8, 0x04, 0x07, 0xE0, 0x3E, 0x02, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0x03, 0xFE, 0x00, 0x3E,
  0x03, 0xFE, 0x00, 0x3E, 0x03, 0xFE, 0x00, 0x3E, 0x07, 0xFE, 0x00, 0x7E,
  0x07, 0xFE, 0x00, 0x7E, 0x07, 0xFF, 0x00, 0x7E, 0x07, 0xFF, 0x00, 0x7C,
  0x07, 0xFF, 0x00, 0x7C, 0x07, 0xDF, 0x00, 0x7C, 0x0F, 0xDF, 0x00, 0xFC,
  0x0F, 0xDF, 0x80, 0xFC, 0x0F, 0xCF, 0x80, 0xFC, 0x0F, 0x8F, 0x80, 0xF8,
  0x0F, 0x8F, 0x80, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0x1F, 0x8F, 0xC1, 0xF8,
  0x1F, 0x87, 0xC1, 0xF8, 0x1F, 0x87, 0xC1, 0xF8, 0x1F, 0x07, 0xC1, 0xF0,
  0x1F, 0x07, 0xE1, 0xF0, 0x1F, 0x07, 0xE1, 0xF0, 0x3F, 0x03, 0xE3, 0xF0,
  0x3F, 0x03, 0xE3, 0xF0, 0x3F, 0x03, 0xE3, 0xF0, 0x3E, 0x03, 0xF3, 0xE0,
  0x3E, 0x03, 0xF3, 0xE0, 0x3E, 0x01, 0xF3, 0xE0, 0x7E, 0x01, 0xF7, 0xE0,
  0x7E, 0x01, 0xF7, 0xE0, 0x7E, 0x01, 0xFF, 0xE0, 0x7C, 0x01, 0xFF, 0xC0,
  0x7C, 0x00, 0xFF, 0xC0, 0x7C, 0x00, 0xFF, 0xC0, 0xFC, 0x00, 0xFF, 0xC0,
  0xFC, 0x00, 0xFF, 0xC0, 0xFC, 0x00, 0x7F, 0xC0, 0xF8, 0x00, 0x7F, 0x80,
  0xF8, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFE,
  0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x01,
  0xF8, 0xFE, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFD, 0xFC, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x3F, 0xBF, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x7E, 0x7E, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF8,
  0xFE, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F,
  0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC,
  0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFE, 0x0F,
  0xC0, 0x03, 0xFC, 0x1F, 0x80, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01,
  0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0x7E, 0x0F, 0xE0,
  0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x03,
  0xF8, 0xFE, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0,
  0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xF8,
  0x02, 0x00, 0x07, 0xE0, 0x38, 0x00, 0x3F, 0x83, 0xE0, 0x00, 0xFC, 0x3F,
  0x80, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x7F, 0x80, 0xFC, 0x00,
  0x3F, 0x81, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFE,
  0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0,
  0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x01,
  0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x01, 0xFE, 0x03, 0xFF, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x3C, 0x07, 0xF0, 0x00, 0x18, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x08, 0x00,
  0x03, 0xF8, 0x3C, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0xFF, 0x00,
  0x0F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00,
  0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xF8, 0x7E, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x03,
  0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC,
  0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7F, 0x0F,
  0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF8, 0x7E, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07,
  0xE0, 0x7E, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xF0,
  0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x03,
  0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC,
  0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x01,
  0xF8, 0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0xFC,
  0x07, 0xC3, 0xF0, 0x3F, 0x01, 0xF0, 0xFC, 0x1F, 0xC0, 0xFC, 0x3F, 0x07,
  0xF0, 0x3E, 0x0F, 0x81, 0xFE, 0x0F, 0x83, 0xE0, 0xFF, 0x83, 0xE0, 0xF8,
  0x3F, 0xE1, 0xF8, 0x3E, 0x0F, 0xF8, 0x7C, 0x0F, 0x87, 0xBE, 0x1F, 0x03,
  0xE1, 0xEF, 0x87, 0xC0, 0xF8, 0x7B, 0xE3, 0xF0, 0x7E, 0x3C, 0xF8, 0xF8,
  0x1F, 0x8F, 0x3E, 0x3E, 0x07, 0xC3, 0xCF, 0x8F, 0x81, 0xF1, 0xE3, 0xE3,
  0xE0, 0x7C, 0x78, 0xF9, 0xF0, 0x1F, 0x3E, 0x3E, 0x7C, 0x07, 0xCF, 0x0F,
  0x9F, 0x01, 0xF3, 0xC3, 0xE7, 0xC0, 0x7D, 0xF0, 0xFB, 0xE0, 0x1F, 0x78,
  0x3E, 0xF8, 0x07, 0xDE, 0x0F, 0xBE, 0x03, 0xFF, 0x83, 0xEF, 0x80, 0xFB,
  0xC0, 0x7B, 0xC0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0xFC, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFE, 0x7E, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00,
  0x03, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x1F, 0x80,
  0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0,
  0x3F, 0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x1F, 0x80,
  0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x03,
  0xEF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFC, 0xE0, 0x00, 0x03, 0x82,
  0x00, 0x00, 0x20, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x08, 0x1C, 0x3F, 0x1F,
  0x87, 0xC3, 0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xFC, 0x3F, 0x03, 0xFF, 0xE3, 0xF0, 0x7F, 0xFF, 0x7E,
  0x0F, 0xFF, 0xF7, 0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xC0, 0x1F, 0xE3, 0xF8,
  0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFC, 0xFC,
  0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01,
  0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x8F,
  0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xF0, 0xFE, 0x01,
  0xBF, 0x07, 0xF0, 0x7B, 0xFE, 0x7F, 0xFF, 0x3F, 0xE7, 0xFF, 0xE3, 0xFE,
  0x3F, 0xFC, 0x1F, 0xE1, 0xFF, 0x80, 0xFE, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x1F, 0xF8, 0x03, 0xF1,
  0xFF, 0xE0, 0x1F, 0x9F, 0xFF, 0x81, 0xF9, 0xFF, 0xFE, 0x0F, 0xDE, 0x0F,
  0xF0, 0x7E, 0xC0, 0x3F, 0x83, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x00,
  0xFE, 0x7F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8,
  0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xE3, 0xF8,
  0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xEE, 0x07,
  0xF8, 0x3F, 0x7F, 0xFF, 0x81, 0xFB, 0xFF, 0xFC, 0x1F, 0x8F, 0xFF, 0x80,
  0xFC, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x83, 0xFC, 0x0F, 0xE1, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x3F, 0x00,
  0x0E, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x20, 0xFC, 0x00, 0x0E, 0x3F, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF8,
  0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x1F, 0xE0, 0x7F, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0xFF,
  0xC3, 0xF0, 0x0F, 0xFF, 0x8F, 0xC0, 0x7F, 0xFF, 0x3F, 0x03, 0xFF, 0xFE,
  0xFC, 0x1F, 0xF0, 0x3B, 0xF0, 0x7F, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFE,
  0x0F, 0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xFE, 0x0F, 0xC0, 0x0D, 0xF8,
  0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0x07, 0xBF, 0x01, 0xFF, 0xFC, 0xFC, 0x07,
  0xFF, 0xF3, 0xF0, 0x0F, 0xFF, 0x8F, 0xC0, 0x1F, 0xFC, 0x3F, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFC, 0x0F, 0xF1, 0xFC,
  0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xDF, 0xC0, 0x03, 0xF7,
  0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xBF, 0x03, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x04, 0x3F,
  0x00, 0x03, 0xCF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x7F,
  0x1F, 0xE0, 0x7F, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x08, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x02, 0x00, 0xFC, 0x00,
  0x00, 0x18, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x01, 0xFD, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xC3, 0xF0, 0x0F, 0xFF,
  0x8F, 0xC0, 0x7F, 0xFF, 0x3F, 0x03, 0xFF, 0xFE, 0xFC, 0x1F, 0xF0, 0x3B,
  0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xF8,
  0x7F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x3F,
  0x80, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x7F,
  0x83, 0xF8, 0x03, 0xFE, 0x0F, 0xE0, 0x1D, 0xF8, 0x1F, 0xE0, 0xEF, 0xC0,
  0x7F, 0xFF, 0xBF, 0x00, 0xFF, 0xFC, 0xFC, 0x03, 0xFF, 0xE3, 0xF0, 0x07,
  0xFF, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x80, 0x07,
  0xF0, 0x07, 0x00, 0x3F, 0xC0, 0x3F, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x3F, 0xF0,
  0x1F, 0x8F, 0xFF, 0x03, 0xF3, 0xFF, 0xF0, 0x7E, 0xFF, 0xFE, 0x0F, 0xDC,
  0x1F, 0xC3, 0xF7, 0x01, 0xFC, 0x7E, 0xC0, 0x3F, 0x8F, 0xF0, 0x03, 0xF1,
  0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F,
  0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07,
  0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8,
  0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E,
  0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0xC0, 0x0F, 0xC0, 0x78, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0x7E,
  0x0F, 0xE0, 0x1F, 0x87, 0xF0, 0x07, 0xE3, 0xF8, 0x01, 0xF1, 0xFC, 0x00,
  0xFC, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x18, 0x03,
  0xF0, 0x07, 0x00, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x07,
  0xF0, 0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0x7F, 0x3F,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x3F, 0xF0, 0x07, 0xE3, 0xFF,
  0xC0, 0x3F, 0x3F, 0xFF, 0x01, 0xFB, 0xFF, 0xF8, 0x0F, 0xDC, 0x1F, 0xE0,
  0xFD, 0x80, 0x7F, 0x07, 0xE8, 0x01, 0xF8, 0x3F, 0xC0, 0x0F, 0xC1, 0xFC,
  0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xF0, 0x03,
  0xF0, 0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x00,
  0x7E, 0x1F, 0xE0, 0x03, 0xF7, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8,
  0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x04, 0x7E, 0x1F, 0x80, 0x73, 0xF0, 0x7E,
  0x07, 0xDF, 0x83, 0xF0, 0x7F, 0xF8, 0x1F, 0xC7, 0xEF, 0xC0, 0x7E, 0x7E,
  0x7E, 0x03, 0xFF, 0xE3, 0xF0, 0x0F, 0xFE, 0x1F, 0x80, 0x7F, 0xE0, 0xFC,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x81, 0xF8, 0x07, 0x83, 0xF0, 0x1F,
  0x87, 0xE0, 0x7F, 0x0F, 0xC1, 0xFC, 0x1F, 0x87, 0xF0, 0x7E, 0x1F, 0xC0,
  0xFC, 0x7F, 0x01, 0xF9, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x7C,
  0x07, 0xCF, 0xE1, 0xFE, 0x07, 0xDF, 0xF3, 0xFF, 0x0F, 0xDF, 0xF3, 0xFF,
  0x0F, 0xBF, 0xF7, 0xFF, 0x0F, 0xB1, 0xF6, 0x3F, 0x0F, 0xC1, 0xFC, 0x1F,
  0x0F, 0xC1, 0xFC, 0x1F, 0x0F, 0x81, 0xF8, 0x1F, 0x1F, 0x81, 0xF8, 0x1F,
  0x1F, 0x81, 0xF0, 0x1F, 0x1F, 0x01, 0xF0, 0x1F, 0x1F, 0x01, 0xF0, 0x1F,
  0x1F, 0x01, 0xF0, 0x3E, 0x1F, 0x03, 0xE0, 0x3E, 0x3F, 0x03, 0xE0, 0x3E,
  0x3E, 0x03, 0xE0, 0x3E, 0x3E, 0x03, 0xE0, 0x3E, 0x3E, 0x03, 0xE0, 0x3E,
  0x3E, 0x03, 0xE0, 0x7C, 0x3E, 0x07, 0xC0, 0x7C, 0x7E, 0x07, 0xC0, 0x7C,
  0x7C, 0x07, 0xC0, 0x7C, 0x7C, 0x07, 0xC0, 0x7C, 0x7C, 0x07, 0xC0, 0x7C,
  0x7C, 0x07, 0xC0, 0xF8, 0x7C, 0x0F, 0x80, 0xF8, 0x7C, 0x0F, 0x80, 0xF8,
  0xF8, 0x0F, 0x80, 0xF8, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xFC, 0x01,
  0xF8, 0x7F, 0xE0, 0x3F, 0x1F, 0xFE, 0x07, 0xE7, 0xFF, 0xE0, 0xFD, 0xFF,
  0xFC, 0x1F, 0xB8, 0x3F, 0x87, 0xEE, 0x03, 0xF8, 0xFD, 0x80, 0x7F, 0x1F,
  0xE0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03,
  0xF3, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8,
  0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E,
  0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80,
  0x07, 0xE3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xE3,
  0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0x03, 0xFC, 0x1F,
  0xE0, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xE3, 0xF0, 0x00,
  0x7E, 0x7F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE,
  0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0x87, 0xE0,
  0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x1F, 0xF0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0xFF, 0xC0, 0x07,
  0xE3, 0xFF, 0xC0, 0x0F, 0xCF, 0xFF, 0xC0, 0x3F, 0x3F, 0xFF, 0xC0, 0x7E,
  0xF0, 0x7F, 0x80, 0xFD, 0x80, 0x7F, 0x01, 0xFE, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x80,
  0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x01,
  0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8,
  0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0x70, 0x3F, 0xC0, 0x7E, 0xFF, 0xFF, 0x00,
  0xFD, 0xFF, 0xFE, 0x03, 0xF1, 0xFF, 0xF0, 0x07, 0xE1, 0xFF, 0xC0, 0x0F,
  0xC0, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFC,
  0x3F, 0x03, 0xFF, 0xE3, 0xF0, 0x7F, 0xFF, 0x3F, 0x0F, 0xFF, 0xFB, 0xF1,
  0xFF, 0x03, 0xBF, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E,
  0xFE, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F,
  0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF8, 0xFC,
  0x00, 0x7F, 0x8F, 0xC0, 0x0D, 0xF8, 0xFE, 0x01, 0xFF, 0x07, 0xF0, 0x7B,
  0xF0, 0x7F, 0xFF, 0xBF, 0x07, 0xFF, 0xF3, 0xF0, 0x3F, 0xFE, 0x3F, 0x01,
  0xFF, 0xC3, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x9F, 0xFC, 0x03,
  0xF7, 0x80, 0x00, 0x7E, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x1F, 0xE0, 0x3F, 0x83, 0xF0, 0x01, 0xE0, 0xFC, 0x00, 0x08, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x04, 0x00,
  0x07, 0xE1, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x3F, 0x9F, 0xE0, 0x1F, 0xE3,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x08,
  0x03, 0xF0, 0x07, 0x00, 0xFC, 0x03, 0xE0, 0x7E, 0x03, 0xFC, 0x1F, 0x81,
  0xFE, 0x07, 0xE1, 0xFE, 0x01, 0xF8, 0xFF, 0x00, 0x7E, 0x7F, 0x80, 0x1F,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00,
  0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F,
  0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xCF, 0xE0, 0x01,
  0xF9, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC,
  0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F,
  0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xC0,
  0x07, 0xF1, 0xF8, 0x01, 0xFE, 0x3F, 0x00, 0x7F, 0x87, 0xF0, 0x1B, 0xF0,
  0xFF, 0x07, 0x7E, 0x0F, 0xFF, 0xCF, 0xC1, 0xFF, 0xF9, 0xF8, 0x1F, 0xFE,
  0x3F, 0x01, 0xFF, 0x8F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0xC7, 0xFF, 0x00, 0x7C, 0xFF, 0xF0, 0x0F, 0xEF, 0xFF, 0x00, 0x7E, 0xFF,
  0xF0, 0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0x7F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xF0,
  0x7E, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0,
  0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x01, 0xFC,
  0x0F, 0x80, 0x1F, 0x81, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x7F, 0x01, 0xF8,
  0x0F, 0xF0, 0x1F, 0x81, 0xFE, 0x01, 0xF8, 0x7F, 0xC0, 0x1F, 0x9F, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x18, 0x7C, 0x07,
  0x83, 0xE1, 0xF0, 0x3E, 0x0F, 0x87, 0xC0, 0xF8, 0x3F, 0x1F, 0x03, 0xE0,
  0x7C, 0xF8, 0x0F, 0x81, 0xF3, 0xE0, 0x3E, 0x07, 0xCF, 0x80, 0xF8, 0x1F,
  0x3E, 0x07, 0xC0, 0x7C, 0xF8, 0x1F, 0x01, 0xF3, 0xE0, 0x7C, 0x07, 0xDF,
  0x01, 0xF0, 0x1F, 0x7C, 0x07, 0xC0, 0x7D, 0xF0, 0x1F, 0x01, 0xF7, 0xC0,
  0xF8, 0x07, 0xDF, 0x03, 0xE0, 0x3E, 0x7C, 0x0F, 0x80, 0xFB, 0xE0, 0x3E,
  0x03, 0xEF, 0x80, 0xF8, 0x0F, 0xBE, 0x03, 0xE0, 0x7C, 0xF8, 0x1F, 0x81,
  0xF3, 0xE0, 0x7C, 0x07, 0xCF, 0x83, 0xF0, 0x3E, 0x3E, 0x0F, 0xC0, 0xF8,
  0xFC, 0x6F, 0x07, 0xC3, 0xFF, 0xBE, 0x3E, 0x0F, 0xFC, 0x7F, 0xF8, 0x3F,
  0xF1, 0xFF, 0xC0, 0x7F, 0x83, 0xFC, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0,
  0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xFC, 0x7F, 0xF8, 0x7F, 0x9F, 0x38, 0xFC,
  0x7F, 0x8F, 0xB8, 0x3E, 0x7F, 0x07, 0xD8, 0x1F, 0x1E, 0x03, 0xEC, 0x0F,
  0x86, 0x01, 0xFC, 0x07, 0xC0, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x7F,
  0x00, 0x87, 0xC0, 0x6F, 0x80, 0xE3, 0xE0, 0x37, 0xC0, 0xF1, 0xF0, 0x3B,
  0xE1, 0xFC, 0xFC, 0x1D, 0xF1, 0xFC, 0x7E, 0x3C, 0xF9, 0xFC, 0x3F, 0xFE,
  0x7F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x0F,
  0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0,
  0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x7E,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0x80,
  0x1F, 0xE0, 0x7E, 0x00, 0xDF, 0x81, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x3B,
  0xF0, 0x0F, 0xFF, 0xEF, 0xC0, 0x3F, 0xFF, 0x3F, 0x00, 0x7F, 0xF8, 0xFC,
  0x00, 0xFF, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x40,
  0x01, 0xFC, 0x03, 0x80, 0x0F, 0xE0, 0x1F, 0x80, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0x03,
  0xF0, 0x3F, 0xFF, 0x0F, 0xC1, 0xFF, 0xFE, 0x3E, 0x0F, 0xFF, 0xFE, 0xF8,
  0x3F, 0x07, 0xFF, 0xE1, 0xF8, 0x03, 0xFF, 0x87, 0xC0, 0x03, 0xF8, 0x1F,
  0x00, 0x1F, 0xC0, 0x7C, 0x00, 0xFE, 0x01, 0xF0, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x01,
  0x00, 0x0F, 0xE0, 0x3C, 0x00, 0x7F, 0x00, 0xF0, 0x03, 0xF8, 0x03, 0xE0,
  0x1F, 0xC0, 0x0F, 0x81, 0xFE, 0x00, 0x3E, 0x0F, 0xF8, 0x00, 0x7C, 0x7F,
  0xFF, 0x01, 0xF1, 0xFF, 0xFF, 0xC7, 0xC7, 0xCF, 0xFF, 0xFF, 0x3F, 0x0F,
  0xFF, 0xF8, 0xFC, 0x07, 0xFF, 0xE3, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x30, 0x0F, 0xF0, 0x01, 0xF0, 0x7F, 0xE0, 0x07, 0xC3, 0xFF,
  0xC0, 0x1F, 0x1F, 0xFF, 0x80, 0xF8, 0xFC, 0x7E, 0x03, 0xE3, 0xE0, 0xFC,
  0x1F, 0x1F, 0x81, 0xF8, 0xFC, 0x7C, 0x07, 0xFF, 0xE1, 0xF0, 0x0F, 0xFF,
  0x8F, 0x80, 0x1F, 0xFC, 0x3E, 0x00, 0x3F, 0xE0, 0x38, 0x00, 0x7E, 0x00,
};

const GFXglyph IBMPlexMono_MediumItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 14, 40, 34, 10, -39 },
  { 71, 20, 17, 34, 10, -41 },
  { 114, 35, 39, 34, 0, -39 },
  { 285, 32, 53, 34, 1, -46 },
  { 497, 39, 41, 34, -2, -40 },
  { 697, 33, 41, 34, 0, -40 },
  { 867, 8, 17, 34, 16, -41 },
  { 884, 22, 51, 34, 11, -43 },
  { 1025, 22, 51, 34, 2, -43 },
  { 1166, 29, 28, 34, 3, -31 },
  { 1268, 27, 27, 34, 4, -31 },
  { 1360, 14, 16, 34, 7, -8 },
  { 1388, 18, 5, 34, 8, -20 },
  { 1400, 10, 9, 34, 10, -8 },
  { 1412, 32, 51, 34, 1, -43 },
  { 1616, 29, 41, 34, 3, -40 },
  { 1765, 28, 39, 34, 2, -39 },
  { 1902, 31, 40, 34, 1, -40 },
  { 2057, 31, 41, 34, 1, -40 },
  { 2216, 30, 39, 34, 1, -39 },
  { 2363, 30, 40, 34, 2, -39 },
  { 2513, 28, 40, 34, 3, -39 },
  { 2653, 29, 39, 34, 5, -39 },
  { 2795, 30, 41, 34, 2, -40 },
  { 2949, 28, 40, 34, 4, -40 },
  { 3089, 13, 30, 34, 10, -29 },
  { 3138, 16, 37, 34, 7, -29 },
  { 3212, 27, 33, 34, 5, -34 },
  { 3324, 29, 17, 34, 3, -26 },
  { 3386, 27, 33, 34, 3, -34 },
  { 3498, 24, 41, 34, 7, -40 },
  { 3621, 29, 46, 34, 3, -40 },
  { 3788, 31, 39, 34, -1, -39 },
  { 3940, 30, 39, 34, 2, -39 },
  { 4087, 29, 41, 34, 4, -40 },
  { 4236, 30, 39, 34, 2, -39 },
  { 4383, 31, 39, 34, 2, -39 },
  { 4535, 32, 39, 34, 2, -39 },
  { 4691, 29, 41, 34, 3, -40 },
  { 4840, 32, 39, 34, 2, -39 },
  { 4996, 31, 39, 34, 2, -39 },
  { 5148, 29, 40, 34, 3, -39 },
  { 5293, 35, 39, 34, 2, -39 },
  { 5464, 25, 39, 34, 4, -39 },
  { 5586, 34, 39, 34, 1, -39 },
  { 5752, 32, 39, 34, 2, -39 },
  { 5908, 29, 41, 34, 3, -40 },
  { 6057, 31, 39, 34, 2, -39 },
  { 6209, 29, 51, 34, 3, -40 },
  { 6394, 31, 39, 34, 2, -39 },
  { 6546, 32, 41, 34, 1, -40 },
  { 6710, 31, 39, 34, 5, -39 },
  { 6862, 30, 40, 34, 4, -39 },
  { 7012, 30, 39, 34, 6, -39 },
  { 7159, 34, 39, 34, 2, -39 },
  { 7325, 37, 39, 34, -1, -39 },
  { 7506, 32, 39, 34, 5, -39 },
  { 7662, 34, 39, 34, 0, -39 },
  { 7828, 25, 51, 34, 8, -43 },
  { 7988, 15, 51, 34, 10, -43 },
  { 8084, 25, 51, 34, 1, -43 },
  { 8244, 29, 24, 34, 3, -39 },
  { 8331, 27, 5, 34, 0, 5 },
  { 8348, 9, 12, 34, 12, -44 },
  { 8362, 28, 31, 34, 3, -30 },
  { 8471, 29, 42, 34, 2, -41 },
  { 8624, 26, 31, 34, 4, -30 },
  { 8725, 30, 42, 34, 3, -41 },
  { 8883, 26, 31, 34, 4, -30 },
  { 8984, 37, 53, 34, -1, -41 },
  { 9230, 30, 42, 34, 1, -30 },
  { 9388, 27, 41, 34, 3, -41 },
  { 9527, 26, 43, 34, 4, -42 },
  { 9667, 27, 54, 34, 2, -42 },
  { 9850, 29, 42, 34, 3, -41 },
  { 10003, 23, 42, 34, 6, -41 },
  { 10124, 32, 30, 34, 0, -30 },
  { 10244, 27, 30, 34, 3, -30 },
  { 10346, 28, 31, 34, 3, -30 },
  { 10455, 31, 41, 34, 0, -30 },
  { 10614, 28, 41, 34, 3, -30 },
  { 10758, 27, 29, 34, 6, -29 },
  { 10856, 27, 31, 34, 3, -30 },
  { 10961, 26, 40, 34, 4, -39 },
  { 11091, 27, 30, 34, 4, -29 },
  { 11193, 28, 30, 34, 3, -29 },
  { 11298, 30, 30, 34, 2, -29 },
  { 11411, 33, 31, 34, 0, -30 },
  { 11539, 30, 41, 34, 1, -29 },
  { 11693, 30, 31, 34, 2, -30 },
  { 11810, 27, 51, 34, 6, -43 },
  { 11983, 13, 51, 34, 11, -43 },
  { 12066, 27, 51, 34, 2, -43 },
  { 12239, 30, 13, 34, 2, -24 },
};

const GFXfont IBMPlexMono_MediumItalic56pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic56pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic56pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _IBMPLEXMONO_MEDIUMITALIC56PT7B_H_
