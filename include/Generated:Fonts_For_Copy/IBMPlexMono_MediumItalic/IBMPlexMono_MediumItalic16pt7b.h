#ifndef _IBMPLEXMONO_MEDIUMITALIC16PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x26, 0x64, 0x00, 0xEE, 0xC0, 0x4A, 0x77, 0xBD, 0x80, 0x04,
  0x83, 0x60, 0x91, 0xE7, 0x1A, 0x04, 0x81, 0x63, 0xDE, 0x24, 0x1B, 0x06,
  0xC0, 0x02, 0x03, 0x07, 0xC6, 0x92, 0x41, 0x20, 0xD0, 0x3C, 0x0B, 0x04,
  0xC2, 0x79, 0x67, 0xE0, 0xC0, 0x60, 0x38, 0x6C, 0x91, 0x16, 0x27, 0x84,
  0x80, 0x77, 0x01, 0x21, 0xE4, 0x2C, 0x89, 0xB2, 0x1C, 0x00, 0x0E, 0x08,
  0x84, 0x42, 0x21, 0xB1, 0xE1, 0x31, 0x98, 0xC4, 0xE7, 0x5C, 0xC0, 0xFA,
  0x80, 0x0C, 0x63, 0x18, 0x41, 0x0C, 0x30, 0xC3, 0x0C, 0x10, 0x60, 0xC0,
  0x30, 0x60, 0x83, 0x0C, 0x30, 0xC3, 0x08, 0x21, 0x8C, 0x63, 0x00, 0x08,
  0x08, 0x99, 0xFF, 0x38, 0x38, 0x6C, 0xC4, 0x08, 0x08, 0x18, 0xFF, 0x10,
  0x10, 0x10, 0x76, 0x4C, 0xF8, 0xFF, 0x00, 0x00, 0xC0, 0x60, 0x10, 0x0C,
  0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x30,
  0x00, 0x1E, 0x23, 0x61, 0xC1, 0xDB, 0xDB, 0xC3, 0xC3, 0xC2, 0xC6, 0x78,
  0x1C, 0x3C, 0x6C, 0xCC, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0xFF, 0x1F,
  0x18, 0xC8, 0x60, 0x30, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x3F, 0xC0,
  0x1F, 0x18, 0xC0, 0x60, 0x30, 0x30, 0xE0, 0x0C, 0x06, 0x03, 0x61, 0x9F,
  0x00, 0x03, 0x83, 0x83, 0x41, 0x61, 0xB1, 0x99, 0x8D, 0x84, 0xFF, 0x83,
  0x01, 0x80, 0x3F, 0x60, 0x60, 0x40, 0x5C, 0xE6, 0x03, 0x03, 0x02, 0xC6,
  0x78, 0x0E, 0x18, 0x30, 0x60, 0x7E, 0xE6, 0xC3, 0xC3, 0xC2, 0xC6, 0x7C,
  0x7F, 0xA1, 0x90, 0xD0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x30, 0x18, 0x18,
  0x00, 0x1E, 0x63, 0x63, 0x43, 0x62, 0x3C, 0xC6, 0xC3, 0x83, 0xC6, 0x7C,
  0x3E, 0x63, 0x43, 0xC3, 0xC3, 0x67, 0x7E, 0x06, 0x0C, 0x18, 0x70, 0x77,
  0x60, 0x00, 0xEE, 0xC0, 0x39, 0xCC, 0x00, 0x00, 0x0E, 0x62, 0x30, 0x01,
  0x07, 0x1C, 0x70, 0xC0, 0x70, 0x38, 0x0E, 0x02, 0xFF, 0x00, 0x00, 0xFF,
  0x40, 0x70, 0x1C, 0x0E, 0x03, 0x0E, 0x38, 0xE0, 0x80, 0x7D, 0x8E, 0x18,
  0x31, 0xC6, 0x08, 0x20, 0x60, 0xC1, 0x80, 0x1E, 0x23, 0x41, 0x4D, 0xDB,
  0xD3, 0xB3, 0xB3, 0xB2, 0x9E, 0x80, 0xC0, 0x7C, 0x06, 0x07, 0x02, 0xC3,
  0x61, 0xB1, 0x98, 0xCC, 0xFE, 0x61, 0x60, 0xB0, 0x60, 0x7E, 0x63, 0x63,
  0x63, 0x62, 0x7C, 0xC2, 0xC3, 0xC2, 0xC6, 0xFC, 0x1E, 0x33, 0x61, 0x40,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC3, 0x46, 0x3C, 0x7E, 0x63, 0x63, 0x63, 0x63,
  0x43, 0xC3, 0xC3, 0xC6, 0xC6, 0xF8, 0x7F, 0xB0, 0x18, 0x0C, 0x06, 0x03,
  0xFB, 0x01, 0x80, 0xC0, 0x60, 0x3F, 0x80, 0x7F, 0xB0, 0x18, 0x0C, 0x06,
  0x03, 0xF3, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x00, 0x1E, 0x23, 0x61, 0xC0,
  0xC0, 0xCF, 0xC3, 0xC2, 0xC6, 0xC6, 0x7E, 0x30, 0xCC, 0x23, 0x18, 0xC6,
  0x21, 0x9F, 0xE6, 0x19, 0x84, 0x63, 0x10, 0xCC, 0x30, 0x7F, 0x0C, 0x08,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x10, 0xFE, 0x3F, 0x03, 0x03, 0x02,
  0x06, 0x06, 0x06, 0x06, 0x86, 0xCC, 0x78, 0x61, 0xB1, 0x99, 0x8D, 0x85,
  0x83, 0xC3, 0xB1, 0x98, 0xC6, 0x63, 0x20, 0xC0, 0x30, 0x40, 0x83, 0x06,
  0x0C, 0x18, 0x20, 0xC1, 0x83, 0xF8, 0x31, 0xCE, 0x73, 0xB9, 0xAA, 0x6E,
  0x9B, 0x66, 0x99, 0x26, 0x41, 0x30, 0x4C, 0x30, 0x38, 0xCE, 0x23, 0x88,
  0xA6, 0x2D, 0x9B, 0x66, 0xD9, 0x94, 0x45, 0x11, 0xCC, 0x70, 0x1E, 0x23,
  0x63, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0xC6, 0x78, 0x7E, 0x63, 0x61,
  0x63, 0x63, 0x7E, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x1E, 0x23, 0x63, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0xC6, 0x78, 0x18, 0x0B, 0x0E, 0x7E, 0x63,
  0x61, 0x63, 0x63, 0x7E, 0xCC, 0xCC, 0xCC, 0xC6, 0xC6, 0x1F, 0x18, 0xC8,
  0x04, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0x01, 0x71, 0x9F, 0x80, 0xFF, 0x86,
  0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x00, 0x61,
  0xB0, 0x98, 0xC8, 0x64, 0x36, 0x1B, 0x0D, 0x84, 0xC6, 0x63, 0x1F, 0x00,
  0x83, 0xC3, 0xC6, 0xC6, 0xC4, 0xCC, 0xC8, 0xD8, 0x50, 0x70, 0x70, 0x60,
  0x58, 0x36, 0x0D, 0xB3, 0x6C, 0x9B, 0x25, 0xD9, 0x5E, 0x57, 0x19, 0xCE,
  0x70, 0x30, 0xCC, 0x61, 0xB0, 0x6C, 0x0E, 0x03, 0x01, 0xE0, 0xD8, 0x33,
  0x18, 0xCC, 0x18, 0xC1, 0xD8, 0x66, 0x30, 0x98, 0x34, 0x0F, 0x01, 0x80,
  0x60, 0x10, 0x04, 0x03, 0x00, 0x3F, 0xC0, 0x60, 0x30, 0x1C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x70, 0x18, 0x0F, 0xF0, 0x1E, 0x60, 0xC1, 0x02, 0x04,
  0x08, 0x30, 0x60, 0x81, 0x02, 0x04, 0x1F, 0x00, 0x88, 0xC4, 0x44, 0x66,
  0x22, 0x23, 0x31, 0x1E, 0x44, 0x08, 0x30, 0x60, 0x81, 0x02, 0x04, 0x18,
  0x30, 0x40, 0x9F, 0x00, 0x0C, 0x1C, 0x36, 0x22, 0x63, 0xC3, 0x82, 0xFF,
  0xC8, 0x80, 0x3B, 0x67, 0xC2, 0xC2, 0xC6, 0xC6, 0xCE, 0x77, 0x20, 0x60,
  0x60, 0x60, 0x6E, 0x73, 0x63, 0xC3, 0xC3, 0xC2, 0xC6, 0xBC, 0x3E, 0xC5,
  0x06, 0x0C, 0x18, 0x71, 0xBE, 0x01, 0x80, 0x80, 0xC0, 0x63, 0xB3, 0x3B,
  0x09, 0x84, 0xC6, 0x63, 0x33, 0x8E, 0xC0, 0x1E, 0x63, 0x43, 0xC6, 0xF8,
  0xC4, 0xC6, 0x7C, 0x03, 0xC1, 0x80, 0x60, 0x18, 0x3F, 0xC1, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0xD8, 0x16, 0x03, 0x00, 0x1D, 0x99,
  0xD8, 0x6C, 0x26, 0x13, 0x19, 0x9C, 0x76, 0x02, 0x23, 0x3F, 0x00, 0x20,
  0x60, 0x60, 0x60, 0x6E, 0x72, 0x63, 0xC2, 0xC6, 0xC6, 0xC6, 0xC6, 0x0C,
  0x1C, 0x00, 0x00, 0xF8, 0x18, 0x10, 0x10, 0x32, 0x33, 0x3C, 0x38, 0x06,
  0x0C, 0x00, 0x03, 0xE8, 0x83, 0x06, 0x0C, 0x18, 0x24, 0x4D, 0x8F, 0x0C,
  0x00, 0x20, 0x60, 0x60, 0x60, 0x6E, 0x73, 0x62, 0xC6, 0xD8, 0xD9, 0xDB,
  0xCC, 0xF0, 0xC3, 0x0C, 0x21, 0x86, 0x18, 0x65, 0xB5, 0x9C, 0x7D, 0xB7,
  0x53, 0x29, 0x94, 0x9E, 0x4F, 0x25, 0xB2, 0x6E, 0x72, 0x63, 0xC2, 0xC6,
  0xC6, 0xC6, 0xC6, 0x3C, 0x62, 0xC3, 0xC3, 0xC3, 0xC2, 0xC6, 0x78, 0x37,
  0x1C, 0xCC, 0x6C, 0x36, 0x1B, 0x09, 0x8C, 0xBC, 0x40, 0x60, 0x30, 0x00,
  0x3B, 0x67, 0xC3, 0xC2, 0xC6, 0xC6, 0xCE, 0x76, 0x04, 0x04, 0x0C, 0xF6,
  0x70, 0x83, 0x06, 0x0C, 0x18, 0x20, 0x3E, 0x63, 0x40, 0x78, 0x0E, 0x06,
  0xC6, 0x7C, 0x18, 0x18, 0x10, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x23, 0x2C,
  0x38, 0x63, 0x43, 0x42, 0xC2, 0xC6, 0xC6, 0xCE, 0x76, 0xE2, 0x63, 0x63,
  0x63, 0x62, 0x66, 0x4C, 0x70, 0x65, 0xB2, 0x5B, 0x29, 0x94, 0xCA, 0x4F,
  0x64, 0xDC, 0x39, 0x9A, 0xB8, 0xCC, 0x30, 0x0C, 0x33, 0x4D, 0xDB, 0x98,
  0x31, 0x90, 0xC8, 0x4C, 0x26, 0x33, 0x19, 0x9C, 0x76, 0x02, 0x23, 0x3F,
  0x00, 0x7B, 0x47, 0xC6, 0x18, 0x32, 0x62, 0xF3, 0x9E, 0x1E, 0x20, 0x40,
  0x81, 0x83, 0x38, 0x08, 0x10, 0x61, 0x82, 0x04, 0x0F, 0x00, 0x33, 0x22,
  0x26, 0x66, 0x44, 0x4C, 0xCC, 0x3C, 0x08, 0x30, 0x41, 0x02, 0x03, 0x98,
  0x30, 0x60, 0x40, 0x81, 0x1E, 0x00, 0x71, 0xDB, 0x8E,
};

const GFXglyph IBMPlexMono_MediumItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 11, 10, 3, -11 },
  { 7, 5, 5, 10, 3, -12 },
  { 11, 10, 11, 10, 0, -11 },
  { 25, 9, 15, 10, 0, -13 },
  { 42, 11, 11, 10, 0, -11 },
  { 58, 9, 11, 10, 0, -11 },
  { 71, 2, 5, 10, 5, -12 },
  { 73, 6, 14, 10, 3, -12 },
  { 84, 6, 14, 10, 1, -12 },
  { 95, 8, 8, 10, 1, -9 },
  { 103, 8, 7, 10, 1, -8 },
  { 110, 4, 4, 10, 2, -2 },
  { 112, 5, 1, 10, 2, -5 },
  { 113, 3, 3, 10, 3, -3 },
  { 115, 10, 14, 10, 0, -12 },
  { 133, 8, 11, 10, 1, -11 },
  { 144, 8, 11, 10, 1, -11 },
  { 155, 9, 11, 10, 0, -11 },
  { 168, 9, 11, 10, 0, -11 },
  { 181, 9, 11, 10, 0, -11 },
  { 194, 8, 11, 10, 1, -11 },
  { 205, 8, 11, 10, 1, -11 },
  { 216, 9, 11, 10, 1, -11 },
  { 229, 8, 11, 10, 1, -11 },
  { 240, 8, 11, 10, 1, -11 },
  { 251, 4, 9, 10, 3, -9 },
  { 256, 5, 11, 10, 2, -9 },
  { 263, 8, 9, 10, 1, -9 },
  { 272, 8, 4, 10, 1, -7 },
  { 276, 8, 9, 10, 1, -9 },
  { 285, 7, 11, 10, 2, -11 },
  { 295, 8, 13, 10, 1, -11 },
  { 308, 9, 11, 10, 0, -11 },
  { 321, 8, 11, 10, 1, -11 },
  { 332, 8, 11, 10, 1, -11 },
  { 343, 8, 11, 10, 1, -11 },
  { 354, 9, 11, 10, 1, -11 },
  { 367, 9, 11, 10, 1, -11 },
  { 380, 8, 11, 10, 1, -11 },
  { 391, 10, 11, 10, 0, -11 },
  { 405, 8, 11, 10, 1, -11 },
  { 416, 8, 11, 10, 1, -11 },
  { 427, 9, 11, 10, 1, -11 },
  { 440, 7, 11, 10, 1, -11 },
  { 450, 10, 11, 10, 0, -11 },
  { 464, 10, 11, 10, 0, -11 },
  { 478, 8, 11, 10, 1, -11 },
  { 489, 8, 11, 10, 1, -11 },
  { 500, 8, 14, 10, 1, -11 },
  { 514, 8, 11, 10, 1, -11 },
  { 525, 9, 11, 10, 0, -11 },
  { 538, 9, 11, 10, 1, -11 },
  { 551, 9, 11, 10, 1, -11 },
  { 564, 8, 11, 10, 2, -11 },
  { 575, 10, 11, 10, 0, -11 },
  { 589, 10, 11, 10, 0, -11 },
  { 603, 10, 11, 10, 1, -11 },
  { 617, 10, 11, 10, 0, -11 },
  { 631, 7, 14, 10, 2, -12 },
  { 644, 4, 14, 10, 3, -12 },
  { 651, 7, 14, 10, 0, -12 },
  { 664, 8, 7, 10, 1, -11 },
  { 671, 8, 1, 10, 0, 2 },
  { 672, 3, 3, 10, 3, -12 },
  { 674, 8, 8, 10, 1, -8 },
  { 682, 8, 12, 10, 1, -12 },
  { 694, 7, 8, 10, 1, -8 },
  { 701, 9, 12, 10, 1, -12 },
  { 715, 8, 8, 10, 1, -8 },
  { 723, 10, 15, 10, 0, -12 },
  { 742, 9, 11, 10, 0, -8 },
  { 755, 8, 12, 10, 1, -12 },
  { 767, 8, 12, 10, 1, -12 },
  { 779, 7, 15, 10, 1, -12 },
  { 793, 8, 12, 10, 1, -12 },
  { 805, 6, 12, 10, 2, -12 },
  { 814, 9, 8, 10, 0, -8 },
  { 823, 8, 8, 10, 1, -8 },
  { 831, 8, 8, 10, 1, -8 },
  { 839, 9, 11, 10, 0, -8 },
  { 852, 8, 11, 10, 1, -8 },
  { 863, 7, 8, 10, 2, -8 },
  { 870, 8, 8, 10, 1, -8 },
  { 878, 8, 11, 10, 1, -11 },
  { 889, 8, 8, 10, 1, -8 },
  { 897, 8, 8, 10, 1, -8 },
  { 905, 9, 8, 10, 0, -8 },
  { 914, 10, 8, 10, 0, -8 },
  { 924, 9, 11, 10, 0, -8 },
  { 937, 8, 8, 10, 1, -8 },
  { 945, 7, 14, 10, 2, -12 },
  { 958, 4, 14, 10, 3, -12 },
  { 965, 7, 14, 10, 1, -12 },
  { 978, 8, 3, 10, 1, -7 },
};

const GFXfont IBMPlexMono_MediumItalic16pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic16pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _IBMPLEXMONO_MEDIUMITALIC16PT7B_H_
