#ifndef _IBMPLEXMONO_MEDIUMITALIC35PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x07,
  0x03, 0x81, 0x80, 0xC0, 0x60, 0x20, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0x87,
  0xC7, 0xE3, 0xF0, 0xF0, 0x78, 0xEE, 0x1D, 0xC3, 0xB8, 0xFF, 0x1F, 0xE3,
  0xFC, 0x77, 0x0E, 0xE1, 0xDC, 0x78, 0x00, 0x3C, 0x70, 0x00, 0xE3, 0xC0,
  0x07, 0x8E, 0x00, 0x1C, 0x38, 0x00, 0x71, 0xE0, 0x03, 0xC7, 0x00, 0x0E,
  0x1C, 0x07, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE0, 0x1C, 0x70,
  0x00, 0xF1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x38, 0x07, 0xF8, 0xFE, 0x3F,
  0xC3, 0xF8, 0xFF, 0x1F, 0xE0, 0x38, 0x70, 0x00, 0xE3, 0xC0, 0x03, 0x8E,
  0x00, 0x1C, 0x38, 0x00, 0x71, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0xFE,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xE1, 0xF3, 0xBF, 0x1E, 0x38, 0xC1, 0xC3,
  0x88, 0x3C, 0x30, 0x03, 0xC3, 0x00, 0x1E, 0x70, 0x01, 0xF7, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0xE7, 0xC0,
  0x0E, 0x3C, 0x00, 0xE3, 0xC0, 0x0C, 0x3C, 0x20, 0xC3, 0xCF, 0x0C, 0x78,
  0xFD, 0xCF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x07, 0x07,
  0xF8, 0x0E, 0x0F, 0xFC, 0x1C, 0x0E, 0x1C, 0x1C, 0x1E, 0x1C, 0x38, 0x1C,
  0x1C, 0x70, 0x1C, 0x1C, 0xF0, 0x1C, 0x3C, 0xE0, 0x1C, 0x39, 0xC0, 0x1F,
  0xFB, 0x80, 0x0F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xF0, 0x01, 0xCF, 0xF8, 0x03, 0x9E, 0x38, 0x07, 0x1C, 0x38, 0x07,
  0x38, 0x38, 0x0E, 0x38, 0x38, 0x1C, 0x38, 0x38, 0x3C, 0x38, 0x70, 0x38,
  0x1F, 0xF0, 0x70, 0x1F, 0xE0, 0xE0, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x07, 0x87, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0xE0,
  0x0E, 0x07, 0x00, 0x70, 0x38, 0x03, 0x83, 0xC0, 0x1E, 0x1C, 0x00, 0x71,
  0xE0, 0x3F, 0xFC, 0x03, 0xEF, 0x80, 0x3C, 0x78, 0x01, 0xC3, 0xC0, 0x1E,
  0x0F, 0x00, 0xF0, 0x78, 0x07, 0x81, 0xE1, 0x3C, 0x0F, 0x1F, 0xE0, 0x7C,
  0xE7, 0x85, 0xEF, 0x3F, 0xE7, 0xF0, 0xFE, 0x3F, 0x03, 0xE0, 0xF0, 0x7B,
  0xDE, 0xE7, 0x3B, 0xDE, 0xF7, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x18, 0x38, 0x7F,
  0xDE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0xC0, 0x0F, 0x70, 0x07, 0x9E, 0x03, 0xC3, 0xC1, 0xE0, 0xF0, 0x30, 0x18,
  0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x8F, 0x87, 0xC3, 0xC3, 0xE1, 0xE0, 0xE0, 0xF0, 0x70,
  0x78, 0x00, 0x7F, 0xEF, 0xFF, 0xFF, 0x80, 0x3D, 0xFF, 0xFF, 0xFD, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0xC0, 0xFF, 0xF8, 0x7C, 0x1E, 0x1E, 0x03, 0xCF, 0x00, 0xF3, 0x80, 0x1D,
  0xE0, 0x07, 0x78, 0x03, 0xDE, 0x38, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF1,
  0xE3, 0xFC, 0x70, 0xFF, 0x00, 0x7F, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01,
  0xCF, 0x00, 0xF3, 0xC0, 0x78, 0x78, 0x3E, 0x1F, 0xFF, 0x03, 0xFF, 0x80,
  0x3F, 0x80, 0x00, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xF7, 0x81, 0xF3,
  0xC1, 0xF1, 0xC1, 0xF1, 0xE0, 0x70, 0xF0, 0x10, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x07, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xFE,
  0x07, 0xC3, 0xE1, 0xE0, 0x3C, 0x7C, 0x03, 0xC1, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x0F, 0x83, 0xE0,
  0xE0, 0x3E, 0x08, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x80, 0x1E, 0x78,
  0x07, 0xCF, 0x81, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3D, 0xC0,
  0x07, 0xBC, 0x00, 0x73, 0xC0, 0x0F, 0x3C, 0x01, 0xE3, 0xC0, 0x3C, 0x38,
  0x07, 0x87, 0x80, 0xF0, 0x78, 0x0E, 0x07, 0x81, 0xC0, 0x78, 0x3C, 0x07,
  0x07, 0x80, 0x70, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x8F, 0x80, 0x77,
  0xFC, 0x0F, 0xFF, 0xC3, 0xE0, 0xF8, 0x78, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0xC0, 0x1E, 0x3C, 0x07, 0xCF, 0xC1,
  0xF0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x7E, 0x1E, 0xFF, 0x8F, 0xFF, 0xEF, 0xE0, 0xFF,
  0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03,
  0xFE, 0x01, 0xE7, 0x83, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xC0, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xC0, 0x1F, 0x70, 0x07, 0xBC, 0x03,
  0xCF, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0x07, 0xC1, 0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F,
  0x1E, 0x03, 0xC1, 0xE0, 0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xF0,
  0x7C, 0x1F, 0x1E, 0x00, 0xF3, 0xC0, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B,
  0xC0, 0x1F, 0x7C, 0x03, 0xC7, 0xC1, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0xC7, 0xC1, 0xE7, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x03, 0xFF, 0x07, 0xF7, 0xFF, 0xF1, 0xFF, 0x78, 0x7E, 0x78, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0x01, 0xFC, 0x00, 0x0F, 0x0F, 0xC7, 0xE7, 0xE3, 0xF0, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE1, 0xF1, 0xF8, 0xFC,
  0x7E, 0x1E, 0x00, 0x03, 0xC0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80,
  0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x07, 0x00, 0x00, 0x80, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xF0, 0x10, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x38, 0x00,
  0x10, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7C, 0x3E, 0xF8,
  0x1F, 0x70, 0x0F, 0x20, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x0F,
  0xF8, 0x0F, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C, 0x1E,
  0x1E, 0x03, 0xCF, 0x00, 0x73, 0x80, 0x1D, 0xE1, 0xE7, 0x70, 0xFD, 0xDC,
  0x7F, 0x77, 0x1E, 0x3F, 0xCF, 0x0E, 0xF3, 0x83, 0xB8, 0xE0, 0xEE, 0x38,
  0x3B, 0x9E, 0x0E, 0xE7, 0x87, 0xB8, 0xE3, 0xCE, 0x3F, 0xF3, 0x8F, 0xDC,
  0xE1, 0xE7, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7B, 0x80, 0x07, 0xB8, 0x00, 0xF3, 0xC0,
  0x0F, 0x3C, 0x00, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xC3, 0xC0, 0x3C, 0x1C,
  0x03, 0x81, 0xC0, 0x78, 0x1C, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE7, 0x80,
  0x0F, 0x78, 0x00, 0xFF, 0x80, 0x0F, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F,
  0xFF, 0x07, 0x81, 0xE0, 0xF0, 0x1E, 0x1C, 0x03, 0xC7, 0x80, 0x78, 0xF0,
  0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x1E, 0x38, 0x03, 0xC7, 0x00,
  0x79, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF,
  0x87, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xC3,
  0xE1, 0xE0, 0x3C, 0x3C, 0x03, 0xCF, 0x00, 0x61, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x04, 0x1E, 0x00, 0xF1, 0xC0, 0x1E,
  0x3C, 0x07, 0x87, 0xC3, 0xE0, 0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0x83, 0xE0, 0xF0, 0x3C,
  0x1C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C,
  0x78, 0x07, 0x8E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0xF1,
  0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x00, 0xF9, 0xE0, 0x1E, 0x3C, 0x07, 0x87,
  0x81, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFF,
  0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0xC0, 0x7F, 0xF8, 0x3C, 0x1F, 0x1E, 0x03, 0xCF, 0x00, 0xF3, 0xC0,
  0x11, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE1, 0xFE,
  0xF0, 0x7F, 0xBC, 0x1F, 0xEF, 0x08, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0x3C,
  0x01, 0xCF, 0x00, 0xF3, 0xE0, 0x7C, 0x7C, 0x3F, 0x1F, 0xFB, 0xC3, 0xFC,
  0xE0, 0x3E, 0x38, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xE0,
  0x0E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E,
  0x01, 0xE1, 0xC0, 0x1C, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3,
  0xC0, 0x3C, 0x38, 0x03, 0xC7, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78,
  0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x8F, 0x00, 0xF0, 0xF0, 0x0F,
  0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x08, 0x07, 0x8E, 0x01, 0xE3, 0xC0, 0xF0,
  0xF8, 0x7C, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x7C,
  0x3C, 0x03, 0xC0, 0xF0, 0x1F, 0x03, 0xC0, 0xF8, 0x0E, 0x07, 0xC0, 0x78,
  0x3E, 0x01, 0xE1, 0xF0, 0x07, 0x8F, 0x80, 0x1E, 0x7C, 0x00, 0x7B, 0xE0,
  0x01, 0xDF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xF3, 0xC0, 0x0F, 0x8F, 0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x81,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x0F, 0x00, 0x78,
  0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFE, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x3F, 0x0F, 0xE1, 0xEE, 0x77, 0x87, 0xBB,
  0xDC, 0x1C, 0xEE, 0x70, 0x73, 0xF9, 0xC1, 0xC7, 0xCF, 0x07, 0x1E, 0x3C,
  0x3C, 0x78, 0xE0, 0xF1, 0xC3, 0x83, 0xC7, 0x0E, 0x0E, 0x08, 0x38, 0x38,
  0x41, 0xE0, 0xE0, 0x07, 0x87, 0x80, 0x1C, 0x1E, 0x00, 0x70, 0x78, 0x01,
  0xC1, 0xC0, 0x07, 0x07, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x0F, 0x80, 0xF0,
  0xFC, 0x0F, 0x0F, 0xC0, 0xF0, 0xFC, 0x0E, 0x1F, 0xC0, 0xE1, 0xFC, 0x0E,
  0x1F, 0xE1, 0xE1, 0xDE, 0x1E, 0x1C, 0xE1, 0xE1, 0xCE, 0x1C, 0x3C, 0xE1,
  0xC3, 0xCF, 0x1C, 0x38, 0xF3, 0xC3, 0x87, 0x3C, 0x38, 0x73, 0xC7, 0x87,
  0x38, 0x78, 0x7B, 0x87, 0x83, 0xB8, 0x70, 0x3F, 0x87, 0x03, 0xF8, 0x70,
  0x3F, 0x8F, 0x03, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0x01, 0xFC, 0x01,
  0xFF, 0xC0, 0xFF, 0xF8, 0x7C, 0x1E, 0x1E, 0x03, 0xCF, 0x00, 0xF3, 0xC0,
  0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1E, 0xF0, 0x07, 0xBC,
  0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x78, 0x78, 0x3E, 0x1F, 0xFF, 0x03, 0xFF,
  0x80, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xF0,
  0x1E, 0x0F, 0x01, 0xE0, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x1E, 0x1E,
  0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x03, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0x83,
  0xFF, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C, 0x1E,
  0x1E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xDE,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x03, 0xEF, 0x00, 0xF3, 0xC0, 0x78,
  0x78, 0x3E, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0x03, 0xC0, 0x00,
  0x78, 0x40, 0x1E, 0x38, 0x03, 0xDF, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03,
  0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xF0, 0x1E, 0x0F,
  0x01, 0xE0, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1,
  0xE0, 0x1E, 0x1E, 0x03, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0,
  0x3C, 0x78, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0x83, 0xC0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x0F, 0x00,
  0x78, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xE0, 0xF8, 0x3F, 0x1E,
  0x00, 0xE1, 0xE0, 0x08, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x20, 0x07,
  0xCF, 0x00, 0x78, 0xFC, 0x1F, 0x87, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x70, 0x07, 0x9E, 0x00, 0xF3, 0xC0,
  0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x38, 0x03, 0xCF, 0x00,
  0x71, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x3C, 0x01,
  0xE7, 0x80, 0x38, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x0F,
  0x07, 0x83, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0xF0, 0x01,
  0xF7, 0x80, 0x1E, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80,
  0x78, 0x78, 0x07, 0x87, 0x80, 0xF0, 0x78, 0x0F, 0x03, 0x81, 0xE0, 0x38,
  0x1E, 0x03, 0xC1, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0x80, 0x3C, 0x78, 0x03,
  0xC7, 0x80, 0x3C, 0xF0, 0x01, 0xCF, 0x00, 0x1D, 0xE0, 0x01, 0xDE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3C, 0x00,
  0x3C, 0xF0, 0x00, 0xE3, 0xC0, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x78,
  0xE0, 0x01, 0xC3, 0x87, 0x87, 0x0E, 0x1E, 0x1C, 0x38, 0xF8, 0xF1, 0xE3,
  0xE3, 0x87, 0x9D, 0x8E, 0x1E, 0x76, 0x38, 0x71, 0x99, 0xE1, 0xCE, 0x67,
  0x07, 0x39, 0x9C, 0x1C, 0xC6, 0x70, 0x77, 0x1B, 0xC1, 0xDC, 0x6E, 0x07,
  0x61, 0xB8, 0x3F, 0x86, 0xE0, 0xFE, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0xC1,
  0xF0, 0x3F, 0x07, 0xC0, 0x07, 0x80, 0x1F, 0x07, 0xC0, 0x3C, 0x03, 0xC0,
  0x7C, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0xF0, 0x01, 0xE1, 0xE0, 0x00, 0xF3,
  0xE0, 0x00, 0xF3, 0xC0, 0x00, 0xF7, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xEF, 0x00, 0x03, 0xC7, 0x80, 0x07, 0x87, 0x80, 0x0F, 0x87,
  0x80, 0x0F, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x7C, 0x01,
  0xE0, 0xF8, 0x01, 0xF0, 0xF0, 0x01, 0xF7, 0x80, 0x1E, 0x78, 0x03, 0xC7,
  0x80, 0x7C, 0x3C, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x1F, 0x01, 0xE1, 0xE0,
  0x1E, 0x3C, 0x00, 0xE7, 0x80, 0x0F, 0x78, 0x00, 0xFF, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0x07, 0xFE, 0x07,
  0xFE, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xE0,
  0x38, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0F, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0x70,
  0x03, 0xDE, 0x01, 0xE7, 0x80, 0x70, 0xF0, 0x3C, 0x3C, 0x1E, 0x07, 0x0F,
  0x01, 0xE3, 0xC0, 0x79, 0xE0, 0x0E, 0xF0, 0x03, 0xFC, 0x00, 0x72, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x73, 0xC7, 0x8E, 0x38,
  0x71, 0x80, 0x07, 0xC7, 0x87, 0xFB, 0xCF, 0xFD, 0xE7, 0xC3, 0xF7, 0x80,
  0xFB, 0xC0, 0x3B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC,
  0x03, 0xDC, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xF3, 0xE1, 0xF9, 0xFF, 0xBF,
  0x7F, 0x9F, 0x9F, 0x07, 0xC0, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x3E, 0x07, 0x9F, 0xE1, 0xEF, 0xF8, 0x7E, 0x1F, 0x1D, 0x03, 0xCF, 0x80,
  0xF3, 0xC0, 0x1C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0x80, 0x3D,
  0xE0, 0x0F, 0x78, 0x07, 0x9E, 0x03, 0xE7, 0xC1, 0xF1, 0xFF, 0xF8, 0x73,
  0xFC, 0x3C, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xC1,
  0xE3, 0xC0, 0x7B, 0xC0, 0x21, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0xCF, 0x00, 0xF3, 0xC0, 0xF1, 0xF0, 0xF8,
  0x7F, 0xF8, 0x1F, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x07, 0xE3, 0xC1, 0xFE, 0x70, 0x7F, 0xFE, 0x1F, 0x07, 0xC7,
  0xC0, 0x78, 0xF0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x38, 0xF0, 0x0F, 0x1E,
  0x01, 0xE3, 0xC0, 0x3C, 0x70, 0x07, 0x8F, 0x01, 0xF1, 0xE0, 0x7C, 0x3E,
  0x1F, 0x83, 0xFE, 0xF0, 0x7F, 0x9E, 0x03, 0xE3, 0xC0, 0x01, 0xFC, 0x03,
  0xFF, 0x03, 0xFF, 0xC3, 0xE1, 0xF3, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x3E,
  0xF0, 0x7E, 0xFF, 0xFE, 0x7F, 0xFC, 0x3F, 0xE0, 0x1E, 0x00, 0x0F, 0x00,
  0x63, 0xC0, 0x79, 0xF0, 0x78, 0x7F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x20, 0x70, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xF1, 0xE0, 0xFF, 0x38, 0x3F, 0xFF, 0x0F, 0x83,
  0xE3, 0xE0, 0x3C, 0x78, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1C, 0x78, 0x07,
  0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0xF0, 0xF0, 0x2E,
  0x1F, 0x0F, 0xC1, 0xFF, 0x78, 0x3F, 0xCF, 0x01, 0xF1, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x02, 0x01, 0xE0, 0xE0, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80,
  0x1F, 0xC0, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x7C, 0x1E, 0x7F,
  0x0F, 0x7F, 0xC7, 0xE1, 0xE3, 0xE0, 0x79, 0xE0, 0x3D, 0xF0, 0x1E, 0xF0,
  0x0E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCE, 0x01, 0xEF, 0x00, 0xF7,
  0x80, 0x73, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x70, 0x0F, 0x00, 0x00,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F,
  0x06, 0x0F, 0x0F, 0x0F, 0x1E, 0x0E, 0x7C, 0x0E, 0xF8, 0x0F, 0xF0, 0x0F,
  0xE0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x20, 0x78, 0x38, 0x3C, 0x3E, 0x1E,
  0x0F, 0x0E, 0x03, 0xCF, 0x00, 0xF7, 0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x3C, 0x0F, 0x3F,
  0xC3, 0xDF, 0xF0, 0xFC, 0x3E, 0x3E, 0x07, 0x8F, 0x01, 0xE7, 0xC0, 0x71,
  0xE0, 0x38, 0x78, 0x3C, 0x1E, 0x3E, 0x07, 0xBC, 0x01, 0xCF, 0x00, 0xF1,
  0xE1, 0xBC, 0x78, 0xFF, 0x0F, 0x7B, 0xC3, 0xFC, 0xF0, 0x7E, 0x38, 0x0F,
  0x00, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x04, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x10, 0x78,
  0x30, 0xF0, 0xF1, 0xE3, 0xC3, 0xCF, 0x07, 0x3C, 0x0F, 0xF0, 0x1F, 0xC0,
  0x1E, 0x00, 0x1C, 0xF1, 0xE1, 0xDF, 0x3F, 0x1D, 0xFF, 0xF3, 0xE7, 0xC7,
  0x3C, 0x38, 0x73, 0xC3, 0x87, 0x38, 0x78, 0x73, 0x87, 0x07, 0x38, 0x70,
  0xF7, 0x87, 0x0E, 0x78, 0x70, 0xE7, 0x07, 0x0E, 0x70, 0xF0, 0xE7, 0x0E,
  0x0E, 0x70, 0xE1, 0xEF, 0x0E, 0x1C, 0xF0, 0xE1, 0xCE, 0x1E, 0x1C, 0x3C,
  0x7C, 0x1E, 0x7F, 0x0F, 0x7F, 0xC7, 0xE1, 0xE3, 0xE0, 0x79, 0xE0, 0x3D,
  0xF0, 0x1E, 0xF0, 0x0E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCE, 0x01,
  0xEF, 0x00, 0xF7, 0x80, 0x73, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x70,
  0x0F, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xC1, 0xE7, 0xC0,
  0x7B, 0xC0, 0x3D, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0xF9, 0xE0, 0xF8, 0xFF, 0xF8,
  0x3F, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0x1F, 0x01, 0xE7, 0xF8, 0x3D, 0xFF,
  0x07, 0xE1, 0xF0, 0xE8, 0x1E, 0x3E, 0x03, 0xC7, 0x80, 0x38, 0xF0, 0x0F,
  0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x70, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x3C,
  0x78, 0x0F, 0x8F, 0x83, 0xE1, 0xFF, 0xF8, 0x39, 0xFE, 0x0F, 0x1F, 0x81,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xE3, 0xC3, 0xFC, 0xE1, 0xFF, 0xF8,
  0xF8, 0x3E, 0x7C, 0x07, 0x9E, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1C, 0xF0,
  0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0x80, 0x3C, 0xF0, 0x1F, 0x3C, 0x0B,
  0x8F, 0x87, 0xE1, 0xFF, 0x78, 0x7F, 0x9E, 0x07, 0xC7, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0xFF, 0x8F, 0xFF, 0x9F, 0xBF, 0xDF, 0xC1, 0xE8, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0x87, 0xFF, 0xE7,
  0xC0, 0xE3, 0xC0, 0x21, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xFC,
  0x07, 0xFF, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0xF3, 0x00, 0x73, 0xC0,
  0xF9, 0xFF, 0xF8, 0x7F, 0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x04, 0x1E, 0x0E, 0x1E, 0x1F, 0x1C, 0x7C,
  0x1C, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0x0F, 0x00, 0x3C, 0x03, 0x9E, 0x03,
  0xCF, 0x01, 0xE7, 0x80, 0xF3, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1C, 0xF0,
  0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9C, 0x03, 0xDE, 0x03, 0xEF, 0x01, 0xE7,
  0x81, 0xF1, 0xE1, 0xF8, 0xFF, 0xBC, 0x3F, 0x9E, 0x0F, 0x8F, 0x00, 0xFF,
  0x03, 0x7F, 0x07, 0xBF, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C,
  0x78, 0x1E, 0x38, 0x0F, 0x1C, 0x07, 0x9E, 0x07, 0x8F, 0x03, 0xC7, 0x83,
  0xE3, 0xC3, 0xE1, 0xC3, 0xE0, 0xE7, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F,
  0x80, 0x00, 0x38, 0x78, 0xC7, 0x0E, 0x3C, 0xE1, 0xC3, 0x9C, 0x38, 0x73,
  0x87, 0x0E, 0xF0, 0xE1, 0xDC, 0x3C, 0x3B, 0x87, 0x07, 0x70, 0xE0, 0xEE,
  0x1C, 0x3D, 0xC3, 0x87, 0x70, 0xF0, 0xEE, 0x1E, 0x1D, 0xC3, 0x87, 0x3C,
  0xF0, 0xE7, 0xF7, 0x38, 0xFC, 0xFE, 0x0F, 0x0F, 0x80, 0x01, 0xC1, 0xE0,
  0x3F, 0x1F, 0x83, 0xFD, 0xFE, 0x7C, 0xEC, 0xF7, 0xC7, 0xC3, 0x98, 0x3C,
  0x1C, 0x01, 0xE0, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x01, 0xC1, 0xE0, 0x8E, 0x0F, 0x06, 0x70, 0xF8, 0xFB, 0xCD, 0xEF,
  0x9F, 0xE7, 0xF0, 0x7E, 0x3F, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x01, 0xC7,
  0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1C, 0x03, 0xCF, 0x00, 0xF3, 0xC0,
  0x38, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0x80, 0x78, 0xE0, 0x3E,
  0x38, 0x0F, 0x0F, 0x07, 0xC3, 0xC3, 0xF0, 0xFF, 0xBC, 0x1F, 0xCF, 0x03,
  0xE3, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x40, 0x3E, 0x1C, 0x1F, 0x0F, 0xFF,
  0x81, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x07, 0xE1, 0xE1, 0xFF, 0x3C, 0x7F,
  0xFF, 0x9E, 0x1F, 0xE3, 0x80, 0x78, 0x70, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x04, 0x07, 0xC1, 0xC1, 0xE0,
  0x38, 0x7C, 0x07, 0x9F, 0xFC, 0x73, 0xFF, 0xFC, 0xF1, 0xFF, 0x9E, 0x07,
  0xE0, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x03, 0xC0, 0xFF, 0x80, 0xFC, 0x00, 0xFF, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0x07, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38,
  0x38, 0x78, 0x78, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0x01,
  0xFF, 0x81, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1C, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0x80, 0xE3,
  0xF8, 0x1C, 0xFF, 0x87, 0x9C, 0xF0, 0xE7, 0x0F, 0x3C, 0xE0, 0xFF, 0x38,
  0x0F, 0xC3, 0x00, 0xF0,
};

const GFXglyph IBMPlexMono_MediumItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 9, 24, 21, 6, -24 },
  { 28, 11, 10, 21, 7, -26 },
  { 42, 22, 24, 21, 0, -24 },
  { 108, 20, 32, 21, 1, -28 },
  { 188, 24, 24, 21, -1, -24 },
  { 260, 21, 24, 21, 0, -24 },
  { 323, 5, 10, 21, 10, -26 },
  { 330, 14, 32, 21, 7, -27 },
  { 386, 14, 32, 21, 1, -27 },
  { 442, 18, 17, 21, 2, -19 },
  { 481, 17, 17, 21, 2, -19 },
  { 518, 9, 10, 21, 4, -5 },
  { 530, 11, 3, 21, 5, -12 },
  { 535, 6, 6, 21, 6, -6 },
  { 540, 20, 32, 21, 1, -27 },
  { 620, 18, 24, 21, 2, -24 },
  { 674, 17, 24, 21, 2, -24 },
  { 725, 19, 24, 21, 1, -24 },
  { 782, 19, 24, 21, 1, -24 },
  { 839, 20, 24, 21, 0, -24 },
  { 899, 19, 24, 21, 1, -24 },
  { 956, 17, 24, 21, 2, -24 },
  { 1007, 18, 24, 21, 3, -24 },
  { 1061, 19, 24, 21, 1, -24 },
  { 1118, 17, 24, 21, 3, -24 },
  { 1169, 9, 19, 21, 6, -19 },
  { 1191, 11, 24, 21, 4, -19 },
  { 1224, 17, 20, 21, 3, -21 },
  { 1267, 18, 11, 21, 2, -16 },
  { 1292, 17, 20, 21, 2, -21 },
  { 1335, 16, 24, 21, 4, -24 },
  { 1383, 18, 28, 21, 2, -24 },
  { 1446, 20, 24, 21, -1, -24 },
  { 1506, 19, 24, 21, 1, -24 },
  { 1563, 19, 24, 21, 2, -24 },
  { 1620, 19, 24, 21, 1, -24 },
  { 1677, 20, 24, 21, 1, -24 },
  { 1737, 20, 24, 21, 1, -24 },
  { 1797, 18, 24, 21, 2, -24 },
  { 1851, 20, 24, 21, 1, -24 },
  { 1911, 20, 24, 21, 1, -24 },
  { 1971, 18, 24, 21, 2, -24 },
  { 2025, 22, 24, 21, 1, -24 },
  { 2091, 16, 24, 21, 2, -24 },
  { 2139, 22, 24, 21, 0, -24 },
  { 2205, 20, 24, 21, 1, -24 },
  { 2265, 18, 24, 21, 2, -24 },
  { 2319, 20, 24, 21, 1, -24 },
  { 2379, 18, 31, 21, 2, -24 },
  { 2449, 20, 24, 21, 1, -24 },
  { 2509, 20, 24, 21, 1, -24 },
  { 2569, 20, 24, 21, 3, -24 },
  { 2629, 19, 24, 21, 2, -24 },
  { 2686, 20, 24, 21, 3, -24 },
  { 2746, 22, 24, 21, 1, -24 },
  { 2812, 24, 24, 21, -1, -24 },
  { 2884, 20, 24, 21, 3, -24 },
  { 2944, 21, 24, 21, 0, -24 },
  { 3007, 16, 32, 21, 5, -27 },
  { 3071, 10, 32, 21, 6, -27 },
  { 3111, 15, 32, 21, 1, -27 },
  { 3171, 18, 15, 21, 2, -24 },
  { 3205, 17, 3, 21, 0, 3 },
  { 3212, 6, 7, 21, 7, -27 },
  { 3218, 17, 18, 21, 2, -18 },
  { 3257, 18, 26, 21, 1, -26 },
  { 3316, 17, 18, 21, 2, -18 },
  { 3355, 19, 26, 21, 2, -26 },
  { 3417, 17, 18, 21, 2, -18 },
  { 3456, 24, 33, 21, -1, -26 },
  { 3555, 19, 25, 21, 1, -18 },
  { 3615, 17, 26, 21, 2, -26 },
  { 3671, 16, 26, 21, 3, -26 },
  { 3723, 17, 33, 21, 1, -26 },
  { 3794, 18, 26, 21, 2, -26 },
  { 3853, 15, 26, 21, 3, -26 },
  { 3902, 20, 18, 21, 0, -18 },
  { 3947, 17, 18, 21, 2, -18 },
  { 3986, 17, 18, 21, 2, -18 },
  { 4025, 19, 25, 21, 0, -18 },
  { 4085, 18, 25, 21, 2, -18 },
  { 4142, 17, 18, 21, 4, -18 },
  { 4181, 17, 18, 21, 2, -18 },
  { 4220, 16, 24, 21, 3, -24 },
  { 4268, 17, 18, 21, 2, -18 },
  { 4307, 17, 18, 21, 2, -18 },
  { 4346, 19, 18, 21, 1, -18 },
  { 4389, 21, 18, 21, 0, -18 },
  { 4437, 18, 25, 21, 1, -18 },
  { 4494, 19, 18, 21, 1, -18 },
  { 4537, 16, 32, 21, 4, -27 },
  { 4601, 8, 32, 21, 7, -27 },
  { 4633, 17, 32, 21, 1, -27 },
  { 4701, 19, 8, 21, 1, -15 },
};

const GFXfont IBMPlexMono_MediumItalic35pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic35pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _IBMPLEXMONO_MEDIUMITALIC35PT7B_H_
