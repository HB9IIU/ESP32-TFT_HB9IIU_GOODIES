#ifndef _IBMPLEXMONO_MEDIUMITALIC40PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x07, 0xE1, 0xF8, 0xFE, 0x3F, 0x8F, 0xC1, 0xF0,
  0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x79, 0xE1, 0xE7, 0x87,
  0x9E, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x8F, 0x3C, 0x3C, 0x00, 0x0E, 0x1E,
  0x00, 0x0F, 0x0E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0x87, 0x80, 0x03, 0xC3,
  0x80, 0x01, 0xE3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xE0, 0x1F, 0xF8,
  0xFF, 0x8F, 0xF8, 0x7F, 0xC7, 0xFC, 0x3F, 0xE3, 0xFE, 0x3F, 0xE0, 0x0E,
  0x1E, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x87, 0x80, 0x7F,
  0xC3, 0xFC, 0x3F, 0xE3, 0xFE, 0x3F, 0xE1, 0xFF, 0x1F, 0xF0, 0xFF, 0x80,
  0x70, 0xF0, 0x00, 0x38, 0x78, 0x00, 0x3C, 0x38, 0x00, 0x1C, 0x3C, 0x00,
  0x0E, 0x1E, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x0F, 0xCE, 0xFC, 0x3E, 0x1C, 0x74, 0x7C, 0x30, 0x40, 0xF0, 0xE0, 0x01,
  0xE1, 0xC0, 0x03, 0xE3, 0x80, 0x07, 0xE7, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03,
  0xBF, 0x00, 0x07, 0x1F, 0x00, 0x1C, 0x3E, 0x00, 0x38, 0x7C, 0x20, 0x70,
  0xF8, 0xE0, 0xE1, 0xF3, 0xE1, 0xC7, 0xC7, 0xF3, 0xBF, 0x87, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0xF0, 0x3F, 0xC0, 0x1E, 0x07, 0xFE, 0x03, 0xC0, 0x70, 0xE0, 0x38, 0x0F,
  0x0F, 0x07, 0x00, 0xE0, 0x70, 0xF0, 0x1E, 0x0F, 0x0E, 0x01, 0xE0, 0xF1,
  0xC0, 0x1E, 0x0E, 0x3C, 0x01, 0xE0, 0xE7, 0x80, 0x0E, 0x1E, 0x70, 0x00,
  0xFF, 0xCF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xF7, 0xFE, 0x00, 0x1E, 0x78, 0xF0,
  0x03, 0xCF, 0x07, 0x00, 0x38, 0xE0, 0x70, 0x07, 0x0E, 0x07, 0x00, 0xF0,
  0xE0, 0xF0, 0x0E, 0x0E, 0x0F, 0x01, 0xC0, 0xE0, 0xE0, 0x3C, 0x0E, 0x1E,
  0x03, 0x80, 0xFF, 0xC0, 0x70, 0x07, 0xF8, 0x0F, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01,
  0xF0, 0xF8, 0x03, 0xE0, 0x78, 0x03, 0xE0, 0x78, 0x03, 0xC0, 0x78, 0x01,
  0xC0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0xF0, 0x01, 0xF1, 0xF0, 0x03,
  0xF7, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3C, 0x78, 0x00, 0x78,
  0x7C, 0x00, 0x78, 0x3C, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x1E, 0x00, 0xF8,
  0x1F, 0x0C, 0xF8, 0x1F, 0x0F, 0xF8, 0x17, 0x9E, 0x7C, 0x37, 0xBE, 0x7F,
  0xF7, 0xFC, 0x7F, 0xE3, 0xF8, 0x3F, 0xC3, 0xF8, 0x0F, 0x80, 0xE0, 0x3C,
  0xF3, 0xCF, 0x79, 0xE7, 0x9E, 0x79, 0xEF, 0x3C, 0x00, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x3E, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x20, 0x3C, 0x09, 0xE1, 0xE1, 0xCF, 0xCF,
  0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xFE, 0x00, 0x3E, 0xF8, 0x03, 0xE3, 0xC0, 0x3E, 0x1F,
  0x03, 0xE0, 0x78, 0x0E, 0x01, 0xE0, 0x20, 0x08, 0x00, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC3, 0xE1,
  0xF8, 0x7C, 0x3F, 0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC0,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFD, 0xFF, 0xE0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFC, 0x1F, 0x0F,
  0x80, 0x7C, 0x78, 0x01, 0xE7, 0xC0, 0x0F, 0x3C, 0x00, 0x7B, 0xE0, 0x03,
  0xDF, 0x00, 0x1E, 0xF0, 0xF0, 0xF7, 0x8F, 0x8F, 0xFC, 0x7C, 0x7F, 0xE3,
  0xE3, 0xFF, 0x1E, 0x1F, 0xF8, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x7D,
  0xE0, 0x03, 0xCF, 0x00, 0x3E, 0x7C, 0x01, 0xF1, 0xE0, 0x1F, 0x0F, 0x83,
  0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7E, 0xF0,
  0x1F, 0xBE, 0x07, 0xE7, 0xC1, 0xF0, 0xF0, 0x7C, 0x1E, 0x03, 0x03, 0xC0,
  0x40, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xC1, 0xF8, 0x3E, 0x03, 0xE1,
  0xF0, 0x07, 0x83, 0x80, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F,
  0xC1, 0xF8, 0x3C, 0x03, 0xE0, 0x60, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x20, 0x01, 0xF1, 0xC0, 0x0F,
  0x8F, 0x80, 0x3E, 0x3F, 0x03, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01,
  0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3D, 0xE0, 0x01, 0xEF,
  0x80, 0x0F, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x0F, 0x00,
  0x78, 0x3C, 0x03, 0xC1, 0xF0, 0x1E, 0x07, 0x80, 0x78, 0x1E, 0x03, 0xC0,
  0x78, 0x1E, 0x01, 0xE0, 0xF0, 0x07, 0x87, 0x80, 0x3E, 0x1F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE3, 0xF0, 0x03, 0x9F, 0xF0, 0x1E, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC1, 0xF8, 0x3F, 0x07, 0x80, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x10, 0x01, 0xF0, 0xE0, 0x07, 0xC7, 0xC0,
  0x3E, 0x3F, 0x81, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xF0,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x3F, 0x03, 0xCF, 0xF8, 0x7D, 0xFF, 0xC7,
  0xBF, 0xFE, 0x7F, 0x07, 0xEF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xEF, 0x80, 0x3E, 0xF8, 0x07,
  0xE7, 0xC0, 0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xF0,
  0x01, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xC0,
  0xFC, 0x3E, 0x01, 0xF0, 0xF0, 0x03, 0xC7, 0xC0, 0x0F, 0x0F, 0x00, 0x7C,
  0x3C, 0x01, 0xE0, 0xF8, 0x1F, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xC0, 0xFC, 0x3E, 0x00, 0xF1, 0xF0, 0x03,
  0xE7, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xCF,
  0xC0, 0x1F, 0x1F, 0x81, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x3F, 0x03, 0xE7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03,
  0xF7, 0xE0, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xBC, 0x1F, 0xF7, 0xC0, 0xFC,
  0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0x0F, 0x87, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xE0, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x7E, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFE, 0x1E, 0x00, 0x03, 0xE0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xE0, 0x7E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0,
  0x3F, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x01, 0x00, 0x3F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x08, 0x00, 0x01, 0x80, 0x00, 0x7C,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0x00,
  0x00, 0x03, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xF7, 0xC1, 0xFF,
  0xC0, 0x7F, 0xC0, 0x1E, 0x60, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0xFC, 0x1F, 0x0F, 0x80, 0x3C, 0x78, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x1E,
  0x79, 0xC1, 0xFB, 0xDE, 0x1F, 0xFE, 0xF1, 0xE1, 0xE7, 0x8F, 0x07, 0x3C,
  0xF0, 0x39, 0xC7, 0x83, 0xDE, 0x3C, 0x1E, 0xF1, 0xC0, 0xF7, 0x8E, 0x07,
  0x3C, 0x70, 0x39, 0xC3, 0x83, 0xCE, 0x1C, 0x3E, 0x70, 0xFF, 0xF3, 0x87,
  0xF7, 0x9E, 0x1F, 0x38, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78,
  0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xE3, 0xC0, 0x07, 0x87, 0x80,
  0x1F, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0xF8, 0x1E, 0x01, 0xE0, 0x3C, 0x07,
  0xC0, 0x78, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC3, 0xE0, 0x0F, 0x87, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3C, 0x00,
  0x3C, 0xF8, 0x00, 0x79, 0xF0, 0x00, 0xF7, 0xC0, 0x01, 0xF0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xF0, 0x1F, 0x0F,
  0x80, 0x78, 0x7C, 0x03, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF0, 0xF0, 0x07,
  0x87, 0x80, 0x7C, 0x7C, 0x07, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x3C, 0x03, 0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0x78,
  0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x9F, 0x01,
  0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFC,
  0x3F, 0x0F, 0x80, 0x78, 0xF8, 0x03, 0xC7, 0x80, 0x1F, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x03, 0x0F, 0x00, 0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x1F,
  0x0F, 0x83, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xF0, 0x3F, 0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1E,
  0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F,
  0x9E, 0x00, 0x7C, 0xF0, 0x03, 0xE7, 0x80, 0x1F, 0x3C, 0x00, 0xF3, 0xE0,
  0x0F, 0x9F, 0x00, 0x7C, 0xF0, 0x03, 0xE7, 0x80, 0x3E, 0x3C, 0x01, 0xF1,
  0xE0, 0x1F, 0x1F, 0x03, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0xFC, 0x1F, 0x0F, 0xC0, 0x7C, 0x7C, 0x03, 0xE7, 0xC0, 0x0F, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x1F, 0xFB, 0xE0, 0xFF, 0xDF, 0x07, 0xFE, 0xF8, 0x3F, 0xE7, 0xC0,
  0x0F, 0x3E, 0x00, 0x79, 0xF0, 0x03, 0xCF, 0x80, 0x1E, 0x3C, 0x01, 0xF1,
  0xF0, 0x1F, 0x0F, 0xC1, 0xF8, 0x7F, 0xFB, 0xC1, 0xFF, 0xDE, 0x07, 0xFC,
  0xF0, 0x0F, 0x87, 0x80, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x7C, 0x3E, 0x00,
  0xF8, 0x7C, 0x01, 0xE0, 0xF8, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F,
  0x07, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF0, 0x7C, 0x01, 0xE0,
  0xF0, 0x03, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x3E, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0,
  0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x78, 0x3C, 0x00,
  0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1E,
  0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x0F, 0x00,
  0x78, 0x78, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x87, 0xE0, 0x7F, 0xFF, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x80, 0x1F, 0x83,
  0xC0, 0x1F, 0x81, 0xE0, 0x1F, 0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0x7C, 0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x0F, 0x0F, 0x80,
  0x0F, 0x8F, 0x80, 0x07, 0xCF, 0x80, 0x03, 0xEF, 0x80, 0x01, 0xEF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xBC, 0x00, 0x3F, 0x9F,
  0x00, 0x1F, 0x8F, 0x80, 0x0F, 0x83, 0xE0, 0x07, 0x81, 0xF0, 0x03, 0xC0,
  0x78, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x78,
  0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0xFE,
  0x1F, 0xC0, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xDE, 0x1E, 0xE3, 0xDC,
  0x1E, 0xE3, 0xBC, 0x1C, 0xE7, 0xBC, 0x3C, 0xF7, 0x3C, 0x3C, 0xFF, 0x3C,
  0x3C, 0x7E, 0x3C, 0x3C, 0x7E, 0x38, 0x3C, 0x7C, 0x78, 0x3C, 0x7C, 0x78,
  0x78, 0x38, 0x78, 0x78, 0x30, 0x78, 0x78, 0x30, 0x78, 0x78, 0x20, 0x70,
  0x78, 0x20, 0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0,
  0x07, 0xE0, 0x1E, 0x0F, 0xC0, 0x3C, 0x3F, 0x80, 0x78, 0x7F, 0x01, 0xE0,
  0xFF, 0x03, 0xC1, 0xFE, 0x07, 0x83, 0xFC, 0x0F, 0x07, 0xF8, 0x1E, 0x1E,
  0x70, 0x3C, 0x3C, 0xF0, 0xF0, 0x79, 0xE1, 0xE0, 0xF3, 0xC3, 0xC1, 0xE7,
  0x87, 0x83, 0xC7, 0x0F, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x78, 0x3C, 0x3C,
  0xF0, 0x78, 0x79, 0xE0, 0xF0, 0x73, 0xC1, 0xE0, 0xF7, 0x87, 0x81, 0xEF,
  0x0F, 0x03, 0xFC, 0x1E, 0x07, 0xF8, 0x3C, 0x07, 0xF0, 0x78, 0x0F, 0xE0,
  0xF0, 0x1F, 0xC3, 0xC0, 0x3F, 0x87, 0x80, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFC, 0x1F, 0x0F, 0x80,
  0x7C, 0x78, 0x03, 0xE7, 0xC0, 0x0F, 0x3C, 0x00, 0x7B, 0xE0, 0x03, 0xDF,
  0x00, 0x1E, 0xF8, 0x00, 0xF7, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xF7, 0xC0, 0x0F, 0xBC, 0x00, 0x7D, 0xE0,
  0x03, 0xEF, 0x80, 0x3E, 0x7C, 0x01, 0xF1, 0xE0, 0x1F, 0x0F, 0xC3, 0xF0,
  0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0x00,
  0xF8, 0x7C, 0x01, 0xE1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1E, 0x00, 0x78,
  0x78, 0x01, 0xE1, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x01, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0xFC, 0x1F, 0x0F, 0x80, 0x7C, 0x78, 0x03, 0xE7, 0xC0,
  0x0F, 0x3C, 0x00, 0x7B, 0xE0, 0x03, 0xDF, 0x00, 0x1E, 0xF8, 0x00, 0xF7,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xF7, 0xC0, 0x0F, 0xBC, 0x00, 0x7D, 0xE0, 0x03, 0xEF, 0x80, 0x3E, 0x7C,
  0x01, 0xF1, 0xE0, 0x1F, 0x0F, 0xC3, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xF8,
  0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x30, 0x03,
  0xE3, 0xC0, 0x0F, 0xBF, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x0F, 0x00, 0xF8, 0x7C, 0x01, 0xE1, 0xF0, 0x07, 0xC7, 0xC0,
  0x1F, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x0F, 0x8F, 0x80, 0x3E,
  0x3E, 0x01, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFE, 0x01, 0xF0, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x07, 0x80, 0x78, 0x1E,
  0x01, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x83,
  0xE0, 0x1E, 0x0F, 0x00, 0x7C, 0x3C, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFC, 0x0F, 0xC1, 0xF0,
  0x07, 0xC7, 0xC0, 0x04, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC2, 0x00, 0x0F, 0x0E, 0x00, 0x3E, 0x3E,
  0x00, 0x7C, 0x7F, 0x03, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x79, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01,
  0xF3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x80, 0x3E, 0x7C,
  0x01, 0xF3, 0xC0, 0x0F, 0x9E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E,
  0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9E, 0x00, 0x7C, 0xF0, 0x03, 0xC7, 0x80,
  0x1E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x8F, 0x00, 0x78, 0x78, 0x03, 0xC3,
  0xC0, 0x3E, 0x1F, 0x03, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x1F, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xEF, 0x80, 0x0F,
  0xBE, 0x00, 0x3C, 0xF8, 0x01, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x1E,
  0x00, 0xF8, 0x78, 0x03, 0xC1, 0xE0, 0x1F, 0x07, 0x80, 0x78, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x00, 0xF0, 0x7C, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80,
  0x3C, 0x3E, 0x00, 0xF0, 0xF0, 0x03, 0xC7, 0xC0, 0x0F, 0x1E, 0x00, 0x3C,
  0xF8, 0x00, 0xFB, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0x8F, 0x00, 0x03, 0xC7, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xE3, 0xC0, 0x00,
  0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x38, 0x78, 0x7C, 0x3C, 0x3C, 0x3E,
  0x1E, 0x1E, 0x1F, 0x0F, 0x0F, 0x1F, 0x87, 0x07, 0x8F, 0xC7, 0x83, 0x87,
  0xE3, 0xC1, 0xC7, 0x71, 0xE1, 0xE3, 0xB8, 0xE0, 0xF1, 0xDC, 0x70, 0x79,
  0xCE, 0x78, 0x3C, 0xE7, 0x3C, 0x1E, 0xF3, 0x9C, 0x0F, 0x71, 0xCE, 0x07,
  0xB8, 0xEF, 0x03, 0xF8, 0x77, 0x81, 0xDC, 0x3B, 0xC0, 0xEE, 0x1D, 0xC0,
  0x7E, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xF8,
  0x00, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x3E, 0x1F,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF1, 0xF0, 0x00, 0x3E, 0x1E, 0x00,
  0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF1, 0xE0, 0x07, 0xC3,
  0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x07, 0x80, 0xF8, 0x0F, 0x83, 0xE0, 0x0F,
  0x07, 0x80, 0x1E, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0xF0, 0x00, 0x7B,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1E, 0x03,
  0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xF0,
  0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0,
  0x38, 0x07, 0x80, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00,
  0x1F, 0x78, 0x00, 0xF3, 0xC0, 0x0F, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0x83,
  0xC0, 0x78, 0x0F, 0x07, 0xC0, 0x78, 0x3C, 0x03, 0xE3, 0xC0, 0x0F, 0x3E,
  0x00, 0x79, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0x10, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x31, 0xF1, 0xE1, 0xC3,
  0xC3, 0x87, 0x84, 0x03, 0xF0, 0xF0, 0x7F, 0x8F, 0x0F, 0xFD, 0xF1, 0xFF,
  0xFE, 0x3F, 0x07, 0xE7, 0xE0, 0x3E, 0x7C, 0x01, 0xE7, 0x80, 0x1E, 0xF8,
  0x03, 0xEF, 0x80, 0x3C, 0xF8, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF,
  0x00, 0x7C, 0xF0, 0x0F, 0xCF, 0x81, 0xF8, 0xFC, 0x37, 0x87, 0xFF, 0x7F,
  0x7F, 0xE7, 0xF3, 0xFC, 0x7E, 0x1F, 0x83, 0xE0, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE1, 0xF8, 0x1E, 0x3F, 0xC1,
  0xE7, 0xFE, 0x3E, 0xFF, 0xE3, 0xFC, 0x3F, 0x3F, 0x01, 0xF3, 0xE0, 0x0F,
  0x3E, 0x00, 0xF3, 0xC0, 0x0F, 0x7C, 0x00, 0xF7, 0xC0, 0x1F, 0x78, 0x01,
  0xF7, 0x80, 0x1F, 0x78, 0x01, 0xE7, 0x80, 0x3E, 0xF8, 0x07, 0xCF, 0xE0,
  0xFC, 0xF7, 0xFF, 0x8F, 0x7F, 0xF0, 0xF3, 0xFE, 0x0F, 0x0F, 0x80, 0x01,
  0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x07, 0xDF, 0x00,
  0xF7, 0xC0, 0x33, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x02, 0x3C, 0x00, 0xEF, 0x00, 0x7F, 0xE0, 0x3E, 0xFC,
  0x1F, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x07, 0xC3, 0xC0, 0x7F, 0xCF, 0x03, 0xFF, 0xBC, 0x1F, 0xFE, 0xF0, 0xFC,
  0x1F, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xE0, 0x07,
  0x8F, 0x80, 0x1E, 0x3E, 0x00, 0xF8, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x0F,
  0x00, 0x7C, 0x3C, 0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xF0, 0xFF, 0x07, 0xFF,
  0x7C, 0x1F, 0xF9, 0xE0, 0x3F, 0xC7, 0x80, 0x7E, 0x1E, 0x00, 0x00, 0xFE,
  0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xF0, 0x7E, 0xF8, 0x07,
  0xDE, 0x00, 0xF7, 0xC0, 0x3E, 0xF0, 0x3F, 0x9F, 0xFF, 0xE3, 0xFF, 0xF0,
  0x7F, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x04, 0x3C, 0x00, 0xE7, 0xC0, 0x3E,
  0xFC, 0x1F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x02, 0x03,
  0xC0, 0x00, 0x60, 0x78, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x3E, 0x7C, 0x00, 0x07, 0xEF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x78,
  0x1F, 0xF3, 0xC1, 0xFF, 0x9E, 0x1F, 0xFE, 0xF1, 0xF8, 0x37, 0x8F, 0x80,
  0x7C, 0xF8, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF3, 0xE0, 0x07, 0x9F,
  0x00, 0x7C, 0xF8, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x01, 0xF1, 0xF0, 0x0F,
  0x8F, 0x80, 0xBC, 0x7E, 0x1F, 0xE1, 0xFF, 0xDE, 0x0F, 0xFC, 0xF0, 0x3F,
  0xE7, 0x80, 0x7C, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x04, 0x01, 0xF0,
  0x78, 0x1F, 0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE3, 0xE0, 0x78, 0xFF, 0x0F, 0x3F, 0xE1, 0xEF, 0xFE, 0x7D, 0x87, 0xCF,
  0xE0, 0x79, 0xF8, 0x0F, 0x3E, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E,
  0x00, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78,
  0x03, 0xCF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xCF, 0x00, 0x79, 0xE0,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x81, 0x01, 0xE0, 0xF0, 0x3C, 0x3F, 0x07,
  0x8F, 0xC0, 0xF3, 0xF0, 0x1E, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x0F,
  0xE0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x03, 0x03, 0xE0, 0x78, 0x3E, 0x0F, 0xC3, 0xC0,
  0x7E, 0x3C, 0x03, 0xF3, 0xC0, 0x1F, 0x3C, 0x00, 0xFF, 0xC0, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0xFC, 0x07, 0x8F, 0xF0, 0x3C,
  0xFF, 0xC1, 0xEF, 0xFE, 0x1F, 0x61, 0xF0, 0xFE, 0x07, 0x87, 0xE0, 0x3C,
  0x3E, 0x01, 0xE1, 0xE0, 0x1E, 0x0F, 0x01, 0xE0, 0x78, 0x3E, 0x07, 0xCF,
  0xC0, 0x3E, 0xF8, 0x01, 0xE3, 0xC0, 0x8F, 0x1F, 0x0E, 0x78, 0x78, 0xFB,
  0xC3, 0xEF, 0xBE, 0x1F, 0xF9, 0xF0, 0x7F, 0x8F, 0x03, 0xF8, 0x78, 0x0F,
  0x80, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x20, 0xF0, 0x38,
  0x78, 0x7E, 0x3C, 0x7E, 0x1E, 0x7E, 0x0F, 0x7E, 0x07, 0xFE, 0x03, 0xFE,
  0x01, 0xFC, 0x00, 0x7C, 0x00, 0x1E, 0x78, 0x7C, 0x3D, 0xF9, 0xFC, 0x7B,
  0xF7, 0xF8, 0xFF, 0xFF, 0xF1, 0xF1, 0xF1, 0xE3, 0xC3, 0xE3, 0xCF, 0x87,
  0x87, 0x9E, 0x0F, 0x0F, 0x3C, 0x1C, 0x1E, 0x78, 0x78, 0x38, 0xF0, 0xF0,
  0x71, 0xC1, 0xE0, 0xE7, 0x83, 0xC3, 0xCF, 0x07, 0x07, 0x9E, 0x0E, 0x0F,
  0x3C, 0x3C, 0x1C, 0x78, 0x78, 0x38, 0xE0, 0xF0, 0xF3, 0xC1, 0xE1, 0xE7,
  0x83, 0x83, 0xCF, 0x0F, 0x07, 0x80, 0x1F, 0x1F, 0x03, 0xC7, 0xF8, 0x79,
  0xFF, 0x0F, 0x7F, 0xF3, 0xEC, 0x3E, 0x7F, 0x03, 0xCF, 0xC0, 0x79, 0xF0,
  0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3D, 0xF0, 0x07, 0xBE, 0x01, 0xF7, 0xC0,
  0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0xDF, 0x00,
  0xFB, 0xE0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x3F,
  0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0x03, 0xE3, 0xE0, 0x1E, 0x7C,
  0x01, 0xF7, 0xC0, 0x1F, 0x78, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xEF, 0x00, 0x3E, 0xF8, 0x03, 0xE7, 0x80, 0x7C,
  0x7C, 0x0F, 0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xF0,
  0x00, 0x07, 0x87, 0xE0, 0x1E, 0x3F, 0xC0, 0x79, 0xFF, 0x83, 0xEF, 0xFE,
  0x0F, 0xF0, 0xFC, 0x3F, 0x01, 0xF0, 0xF8, 0x03, 0xC3, 0xE0, 0x0F, 0x0F,
  0x00, 0x3C, 0x7C, 0x00, 0xF1, 0xF0, 0x07, 0xC7, 0x80, 0x1F, 0x1E, 0x00,
  0x7C, 0x78, 0x01, 0xE1, 0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x3F, 0x83, 0xF0,
  0xF7, 0xFF, 0x83, 0xDF, 0xFC, 0x0F, 0x3F, 0xE0, 0x3C, 0x3E, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0xF0,
  0x7F, 0xCF, 0x0F, 0xFE, 0xF1, 0xFF, 0xEF, 0x3F, 0x07, 0xF3, 0xE0, 0x1F,
  0x7C, 0x01, 0xE7, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x03,
  0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x80,
  0xFC, 0xFC, 0x3F, 0xC7, 0xFF, 0x7C, 0x7F, 0xE7, 0x83, 0xFC, 0x78, 0x1F,
  0x87, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x7F, 0xC3,
  0xFF, 0xFC, 0x7E, 0xFF, 0xCF, 0xEF, 0xFD, 0xFE, 0x07, 0xF8, 0x00, 0x7A,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF,
  0xF1, 0xF0, 0x1C, 0x3C, 0x01, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0xF1, 0x00, 0x1E, 0x78, 0x0F, 0xDF, 0xFF, 0xF1, 0xFF, 0xFC,
  0x1F, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0xC0, 0xF0, 0x7C, 0x1E, 0x1F, 0x83, 0xC7, 0xE0,
  0xFB, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xE0, 0x00,
  0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0xBE, 0x01, 0xF7, 0xC0, 0x3E,
  0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0xDF, 0x00, 0xFB,
  0xE0, 0x1F, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x1F, 0x3C, 0x07, 0xE7,
  0x81, 0xFC, 0xF8, 0x6F, 0x9F, 0xFD, 0xE1, 0xFF, 0x3C, 0x3F, 0xC7, 0x81,
  0xF0, 0xF0, 0x7F, 0x80, 0x47, 0xF8, 0x3E, 0xFF, 0x81, 0xEF, 0xF0, 0x1F,
  0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x1F, 0x01,
  0xF1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x3E, 0x1E, 0x03, 0xE1, 0xE0,
  0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xF8, 0x3C, 0x7F, 0x03, 0xFF, 0xE0, 0x3F,
  0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x1C, 0x1C, 0x18, 0x70, 0x71,
  0xE3, 0xC1, 0xC3, 0xCF, 0x0F, 0x0F, 0x3C, 0x3C, 0x3C, 0xE0, 0xF0, 0xF3,
  0x83, 0x83, 0xCE, 0x0E, 0x0F, 0x78, 0x38, 0x3D, 0xE1, 0xE0, 0xF7, 0x87,
  0x83, 0xDC, 0x1E, 0x0E, 0x70, 0x78, 0x79, 0xC1, 0xC1, 0xEF, 0x0F, 0x07,
  0x3C, 0x3C, 0x3C, 0xF1, 0xF0, 0xE3, 0xFD, 0xC7, 0x8F, 0xF7, 0xFC, 0x1F,
  0x8F, 0xE0, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x7C, 0x03, 0xF8, 0xFE, 0x07,
  0xF9, 0xFE, 0x0F, 0xF9, 0xFF, 0x1F, 0x3B, 0x8F, 0x3E, 0x3B, 0x0F, 0x38,
  0x3E, 0x0F, 0x10, 0x3E, 0x0F, 0x00, 0x3E, 0x08, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x10, 0x7C, 0x00, 0xF0, 0x7C, 0x08, 0xF0,
  0x7C, 0x3C, 0xF0, 0xDC, 0x7C, 0xF1, 0xDC, 0xF8, 0xFF, 0x9F, 0xF0, 0x7F,
  0x9F, 0xE0, 0x7F, 0x0F, 0xC0, 0x3E, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x78,
  0x03, 0xC3, 0xC0, 0x1E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x0F, 0x00, 0x78,
  0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x8F, 0x80,
  0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x01, 0xF0, 0xF0, 0x1F, 0x87,
  0xC0, 0xFC, 0x3E, 0x1F, 0xC1, 0xFF, 0xDE, 0x07, 0xFC, 0xF0, 0x3F, 0xC7,
  0x80, 0x7C, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x04, 0x01, 0xF0, 0x78,
  0x3F, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x3C, 0x1F, 0xF8, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE,
  0x1E, 0x0F, 0xF8, 0x70, 0x0F, 0xC1, 0xC0, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0xE0, 0x1F, 0x03, 0x81, 0xF0, 0x0F, 0x0F, 0xE0, 0x1C, 0x7F, 0xFC, 0x71,
  0xFF, 0xFF, 0xC7, 0xBF, 0xFF, 0x1E, 0x1F, 0xF8, 0xF0, 0x1F, 0xC0, 0x00,
  0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x7F, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFC,
  0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0x03, 0xC0, 0x18, 0x3F, 0x80, 0xF1, 0xFF, 0x03, 0xC7, 0xFC, 0x0E, 0x3C,
  0x78, 0x78, 0xE1, 0xF3, 0xC7, 0x83, 0xFF, 0x1C, 0x07, 0xF8, 0x70, 0x1F,
  0xC2, 0xC0, 0x1E, 0x00,
};

const GFXglyph IBMPlexMono_MediumItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 10, 28, 24, 7, -28 },
  { 36, 14, 12, 24, 7, -30 },
  { 57, 25, 28, 24, 0, -28 },
  { 145, 23, 36, 24, 1, -32 },
  { 249, 28, 28, 24, -1, -28 },
  { 347, 24, 28, 24, 0, -28 },
  { 431, 6, 12, 24, 11, -30 },
  { 440, 15, 36, 24, 8, -30 },
  { 508, 16, 36, 24, 1, -30 },
  { 580, 21, 20, 24, 2, -22 },
  { 633, 19, 20, 24, 3, -22 },
  { 681, 10, 12, 24, 5, -6 },
  { 696, 13, 4, 24, 6, -14 },
  { 703, 7, 7, 24, 7, -7 },
  { 710, 23, 36, 24, 1, -30 },
  { 814, 21, 28, 24, 2, -28 },
  { 888, 19, 28, 24, 2, -28 },
  { 955, 22, 28, 24, 1, -28 },
  { 1032, 22, 28, 24, 1, -28 },
  { 1109, 22, 28, 24, 0, -28 },
  { 1186, 22, 28, 24, 1, -28 },
  { 1263, 20, 28, 24, 2, -28 },
  { 1333, 20, 28, 24, 4, -28 },
  { 1403, 22, 28, 24, 1, -28 },
  { 1480, 20, 28, 24, 3, -28 },
  { 1550, 10, 22, 24, 7, -22 },
  { 1578, 12, 28, 24, 5, -22 },
  { 1620, 20, 23, 24, 3, -24 },
  { 1678, 21, 12, 24, 2, -18 },
  { 1710, 19, 23, 24, 2, -24 },
  { 1765, 17, 28, 24, 5, -28 },
  { 1825, 21, 32, 24, 2, -28 },
  { 1909, 23, 28, 24, -1, -28 },
  { 1990, 21, 28, 24, 2, -28 },
  { 2064, 21, 28, 24, 3, -28 },
  { 2138, 21, 28, 24, 2, -28 },
  { 2212, 22, 28, 24, 2, -28 },
  { 2289, 22, 28, 24, 2, -28 },
  { 2366, 21, 28, 24, 2, -28 },
  { 2440, 23, 28, 24, 1, -28 },
  { 2521, 22, 28, 24, 2, -28 },
  { 2598, 21, 28, 24, 2, -28 },
  { 2672, 25, 28, 24, 1, -28 },
  { 2760, 17, 28, 24, 3, -28 },
  { 2820, 24, 28, 24, 1, -28 },
  { 2904, 23, 28, 24, 1, -28 },
  { 2985, 21, 28, 24, 2, -28 },
  { 3059, 22, 28, 24, 2, -28 },
  { 3136, 21, 36, 24, 2, -28 },
  { 3231, 22, 28, 24, 2, -28 },
  { 3308, 23, 28, 24, 1, -28 },
  { 3389, 23, 28, 24, 3, -28 },
  { 3470, 21, 28, 24, 3, -28 },
  { 3544, 22, 28, 24, 4, -28 },
  { 3621, 25, 28, 24, 1, -28 },
  { 3709, 27, 28, 24, -1, -28 },
  { 3804, 23, 28, 24, 3, -28 },
  { 3885, 24, 28, 24, 0, -28 },
  { 3969, 17, 36, 24, 6, -30 },
  { 4046, 11, 36, 24, 7, -30 },
  { 4096, 18, 36, 24, 1, -30 },
  { 4177, 21, 17, 24, 2, -28 },
  { 4222, 19, 4, 24, 0, 3 },
  { 4232, 7, 8, 24, 8, -31 },
  { 4239, 20, 21, 24, 2, -21 },
  { 4292, 20, 30, 24, 2, -30 },
  { 4367, 18, 21, 24, 3, -21 },
  { 4415, 22, 30, 24, 2, -30 },
  { 4498, 19, 21, 24, 3, -21 },
  { 4548, 27, 38, 24, -1, -30 },
  { 4677, 21, 29, 24, 1, -21 },
  { 4754, 19, 30, 24, 2, -30 },
  { 4826, 19, 31, 24, 3, -31 },
  { 4900, 20, 39, 24, 1, -31 },
  { 4998, 21, 30, 24, 2, -30 },
  { 5077, 17, 30, 24, 4, -30 },
  { 5141, 23, 21, 24, 0, -21 },
  { 5202, 19, 21, 24, 2, -21 },
  { 5252, 20, 21, 24, 2, -21 },
  { 5305, 22, 29, 24, 0, -21 },
  { 5385, 20, 29, 24, 2, -21 },
  { 5458, 20, 21, 24, 4, -21 },
  { 5511, 19, 21, 24, 2, -21 },
  { 5561, 19, 28, 24, 3, -28 },
  { 5628, 19, 21, 24, 3, -21 },
  { 5678, 20, 21, 24, 2, -21 },
  { 5731, 22, 21, 24, 1, -21 },
  { 5789, 24, 21, 24, 0, -21 },
  { 5852, 21, 29, 24, 1, -21 },
  { 5929, 22, 21, 24, 1, -21 },
  { 5987, 19, 36, 24, 4, -30 },
  { 6073, 9, 36, 24, 8, -30 },
  { 6114, 20, 36, 24, 1, -30 },
  { 6204, 22, 10, 24, 1, -17 },
};

const GFXfont IBMPlexMono_MediumItalic40pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic40pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic40pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _IBMPLEXMONO_MEDIUMITALIC40PT7B_H_
