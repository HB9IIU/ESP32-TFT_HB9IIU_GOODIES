#ifndef _IBMPLEXMONO_MEDIUMITALIC36PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x00, 0x00, 0x00, 0x0F, 0x0F,
  0xC7, 0xE3, 0xF1, 0xF0, 0xF0, 0x00, 0x78, 0xF7, 0x8F, 0x78, 0xF7, 0x0E,
  0x70, 0xE7, 0x0E, 0xF1, 0xEF, 0x1E, 0xF1, 0xEE, 0x1C, 0xE1, 0xC0, 0x00,
  0x3C, 0x78, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x1E, 0x38, 0x00, 0x70,
  0xE0, 0x01, 0xC3, 0x80, 0x0F, 0x1C, 0x07, 0xF8, 0x7F, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xF0, 0x1C, 0x38, 0x00, 0x71, 0xE0, 0x03, 0xC7, 0x00, 0x0E,
  0x1C, 0x00, 0x38, 0xF0, 0x1F, 0xE3, 0xFC, 0xFF, 0x0F, 0xF3, 0xFC, 0x7F,
  0xC0, 0xF1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x3C, 0x00, 0x78, 0xE0, 0x01,
  0xC3, 0x80, 0x07, 0x1E, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x0F,
  0xFF, 0xE0, 0xF9, 0x9F, 0x1E, 0x38, 0xE1, 0xE3, 0x84, 0x1C, 0x38, 0x03,
  0xC3, 0x80, 0x1E, 0x30, 0x01, 0xF3, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x6F, 0xC0, 0x06, 0x3C, 0x00, 0xE1,
  0xE0, 0x0E, 0x1E, 0x00, 0xE1, 0xE2, 0x0E, 0x3C, 0xF0, 0xC3, 0xCF, 0xCC,
  0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF0, 0x07, 0x81, 0xFC,
  0x03, 0x81, 0xFF, 0x03, 0x81, 0xE3, 0x83, 0x80, 0xE1, 0xC3, 0xC0, 0xE0,
  0xE1, 0xC0, 0x70, 0x71, 0xC0, 0x38, 0x39, 0xC0, 0x1C, 0x1D, 0xE0, 0x0E,
  0x1C, 0xE0, 0x03, 0xFE, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x78, 0x03, 0x9C, 0x1C,
  0x03, 0xCE, 0x0E, 0x01, 0xC7, 0x07, 0x01, 0xC7, 0x07, 0x01, 0xC1, 0x83,
  0x80, 0xE0, 0xE3, 0xC0, 0xE0, 0x7F, 0xC0, 0xE0, 0x1F, 0xC0, 0xE0, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xC7,
  0x80, 0x3C, 0x1E, 0x01, 0xC0, 0xF0, 0x0E, 0x07, 0x80, 0x70, 0x3C, 0x03,
  0xC1, 0xC0, 0x1E, 0x1E, 0x00, 0x70, 0xE0, 0x0F, 0xDE, 0x01, 0xFF, 0xE0,
  0x1E, 0x78, 0x01, 0xE3, 0xC0, 0x0E, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x81,
  0xE0, 0x3C, 0x0F, 0x05, 0xE0, 0x7C, 0x7F, 0x03, 0xE7, 0xBC, 0x37, 0x39,
  0xFF, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0x03, 0xC0, 0x39, 0xDE, 0xF7, 0xBD,
  0xCE, 0x77, 0xBC, 0x00, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x18, 0x38, 0x3F, 0xCE, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0x83, 0xFF, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0x78,
  0x07, 0x9E, 0x03, 0xC3, 0xC1, 0xF0, 0xF0, 0x78, 0x1E, 0x04, 0x02, 0x00,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x03, 0xC1,
  0xE0, 0x70, 0x3C, 0x00, 0x7F, 0xF7, 0xFE, 0xFF, 0xE0, 0x3C, 0xFD, 0xFF,
  0xF7, 0xCF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xC3, 0xE1, 0xE0, 0x3C, 0x78,
  0x03, 0xCF, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x1C, 0x3F, 0xE7,
  0xC7, 0xF8, 0xF8, 0xFF, 0x1E, 0x3F, 0xE3, 0xC7, 0xBC, 0x00, 0xF7, 0x80,
  0x1E, 0xF0, 0x03, 0xDE, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0x8F, 0x00,
  0xF0, 0xF8, 0x7C, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xF7, 0x80, 0xFB, 0xC1, 0xF9, 0xE1,
  0xF8, 0xF0, 0x78, 0x78, 0x38, 0x78, 0x08, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0x07, 0xC3, 0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xC9, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xF7,
  0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFF,
  0x0F, 0xC3, 0xF0, 0xE0, 0x1E, 0x08, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0xFF, 0x80, 0x1F, 0x80,
  0x07, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x1F, 0x30, 0x03, 0xCF, 0x00, 0xF9, 0xF0, 0x3E, 0x1F, 0xFF, 0x81,
  0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xDE, 0x00, 0x79, 0xC0, 0x0F,
  0x3C, 0x00, 0xE3, 0xC0, 0x1E, 0x3C, 0x03, 0xC3, 0xC0, 0x78, 0x3C, 0x0F,
  0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x83, 0xC0, 0x78, 0x78, 0x07, 0x87,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xE0, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC7, 0xE0, 0x1C, 0xFF, 0x01,
  0xDF, 0xF8, 0x3F, 0x0F, 0xC3, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC3, 0x00, 0x7C, 0x78, 0x07,
  0x8F, 0xC1, 0xF8, 0x7F, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x1F, 0x07, 0xDF, 0xF1,
  0xEF, 0xFE, 0x7E, 0x0F, 0xBE, 0x01, 0xEF, 0x80, 0x7F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x0F, 0x1F, 0x0F,
  0xC7, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0x38, 0x01, 0xE7, 0x00, 0x7C, 0xE0, 0x0F, 0x1C, 0x03,
  0xE7, 0x80, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0xE0, 0xF8, 0x3E, 0x0F, 0x01, 0xF1, 0xE0, 0x0F, 0x1E,
  0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x0F, 0x07, 0xC0,
  0x7F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x3E, 0x07, 0xC7, 0xC0, 0x3C,
  0x78, 0x03, 0xCF, 0x80, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF8, 0x07,
  0xC7, 0xC0, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xF8, 0x3E, 0x7C, 0x07, 0x9E, 0x00,
  0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7B,
  0xC0, 0x3E, 0xFC, 0x17, 0x9F, 0xFF, 0xC3, 0xFC, 0xF0, 0x7E, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x0F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE1,
  0xF8, 0xFC, 0xFE, 0x3E, 0x1E, 0x00, 0x03, 0xC0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1E, 0x03, 0xC0, 0xF0,
  0x1C, 0x07, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x78, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xC0, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF,
  0xFF, 0xE0, 0x10, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x00, 0x07,
  0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7C, 0x1F, 0x78, 0x0F, 0xF0, 0x0F, 0x10,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF8, 0x0F,
  0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1E,
  0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0x81, 0xE1, 0xE0,
  0x1C, 0x78, 0x03, 0x8E, 0x00, 0x79, 0xC1, 0xEF, 0x78, 0xFF, 0xEE, 0x1F,
  0xF9, 0xC7, 0x8F, 0x38, 0xE0, 0xEF, 0x3C, 0x1D, 0xE7, 0x03, 0xB8, 0xE0,
  0xF7, 0x1C, 0x1C, 0xE3, 0x83, 0x9C, 0x70, 0xF3, 0x8E, 0x1E, 0x71, 0xFF,
  0xCE, 0x3F, 0xF9, 0xC3, 0xEE, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x80, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3B, 0xC0, 0x07,
  0xBC, 0x00, 0x7B, 0xC0, 0x0F, 0x3C, 0x00, 0xF1, 0xC0, 0x1E, 0x1C, 0x01,
  0xE1, 0xE0, 0x3C, 0x1E, 0x03, 0xC1, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1E, 0x00, 0xF1, 0xE0, 0x0F,
  0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0xF8, 0x00,
  0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0x81, 0xF0, 0xF0,
  0x1E, 0x1E, 0x03, 0xC3, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0,
  0x78, 0x78, 0x1F, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xFF, 0x0F, 0x01,
  0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xE0, 0x0F, 0x3C, 0x01,
  0xE7, 0x80, 0x7C, 0xF0, 0x1F, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x07, 0xC1, 0xF1, 0xF0,
  0x1E, 0x3C, 0x03, 0xCF, 0x00, 0x71, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x41, 0xC0, 0x0E, 0x3C, 0x03,
  0xE7, 0x80, 0xF8, 0xF8, 0x3E, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xF0,
  0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0x07, 0xC1, 0xE0,
  0x3C, 0x3C, 0x07, 0x87, 0x80, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80,
  0x3C, 0xF0, 0x07, 0x9E, 0x01, 0xF3, 0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x00,
  0xF3, 0xC0, 0x1E, 0x78, 0x07, 0xCF, 0x00, 0xF1, 0xE0, 0x1E, 0x78, 0x07,
  0x8F, 0x01, 0xF1, 0xE0, 0x7C, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xF8,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x07,
  0xC3, 0xE1, 0xE0, 0x3C, 0x7C, 0x03, 0xCF, 0x00, 0x61, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x87, 0xFD, 0xE0,
  0xFF, 0xBC, 0x1F, 0xE7, 0x80, 0x1C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0,
  0x1E, 0x78, 0x07, 0xC7, 0x80, 0xF0, 0xF8, 0x6E, 0x0F, 0xFB, 0xC1, 0xFF,
  0x78, 0x0F, 0x8F, 0x00, 0x0F, 0x00, 0x78, 0x78, 0x07, 0x83, 0xC0, 0x3C,
  0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0,
  0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03,
  0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C,
  0x03, 0xC1, 0xE0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x80, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0x82, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x3E,
  0x3E, 0x1F, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0x00,
  0x7E, 0x1E, 0x01, 0xF0, 0x3C, 0x07, 0xC0, 0x78, 0x1F, 0x00, 0xF0, 0x7C,
  0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x0F, 0x80, 0x1E, 0x3E, 0x00,
  0x3C, 0xF8, 0x00, 0x7B, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x0F, 0xCF, 0x00, 0x1F, 0x9E, 0x00, 0x3E, 0x1E, 0x00, 0x78,
  0x3C, 0x01, 0xE0, 0x7C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00,
  0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x07, 0x80, 0x7C, 0x3F, 0x01, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x7F, 0x0F,
  0xC1, 0xF8, 0x3F, 0x8F, 0xE0, 0xEE, 0x3B, 0x87, 0xB9, 0xCE, 0x1E, 0xEF,
  0x78, 0x7B, 0xF9, 0xE1, 0xC7, 0xE7, 0x07, 0x1F, 0x1C, 0x1C, 0x7C, 0x70,
  0xF1, 0xE3, 0xC3, 0xC3, 0x0F, 0x0F, 0x0C, 0x3C, 0x38, 0x20, 0xE0, 0xE0,
  0x83, 0x83, 0x80, 0x0E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07,
  0x87, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0xF0, 0x01, 0xC0, 0x0F, 0xC0, 0x78,
  0x7E, 0x03, 0x83, 0xF0, 0x1C, 0x1F, 0x81, 0xE0, 0xFC, 0x0F, 0x0F, 0xF0,
  0x78, 0x7F, 0x83, 0xC3, 0xDC, 0x1C, 0x1C, 0xE0, 0xE0, 0xE7, 0x0F, 0x07,
  0x3C, 0x78, 0x79, 0xE3, 0xC3, 0xC7, 0x1E, 0x1E, 0x38, 0xE0, 0xE1, 0xC7,
  0x07, 0x0F, 0x78, 0x38, 0x7B, 0xC3, 0xC1, 0xDE, 0x1E, 0x0E, 0xF0, 0xF0,
  0x7F, 0x07, 0x03, 0xF8, 0x38, 0x0F, 0xC1, 0xC0, 0x7E, 0x1E, 0x03, 0xF0,
  0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xC3,
  0xE1, 0xE0, 0x3C, 0x78, 0x03, 0xCF, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01,
  0xEF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x07, 0xDE, 0x00, 0xF3, 0xC0, 0x1E,
  0x78, 0x07, 0x8F, 0x81, 0xF0, 0xF8, 0x7C, 0x1F, 0xFF, 0x01, 0xFF, 0xC0,
  0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0x01,
  0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x79, 0xE0, 0x0F, 0x3C, 0x01,
  0xE7, 0x80, 0x3C, 0xF0, 0x0F, 0x1E, 0x03, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE,
  0x1F, 0xFF, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xC3,
  0xE1, 0xE0, 0x3C, 0x78, 0x03, 0xCF, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01,
  0xEF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x07, 0xDE, 0x00, 0xF3, 0xC0, 0x1E,
  0x78, 0x07, 0x8F, 0x81, 0xF0, 0xF8, 0x7C, 0x1F, 0xFF, 0x01, 0xFF, 0xC0,
  0x0F, 0xE0, 0x00, 0x78, 0x00, 0x07, 0x82, 0x00, 0x79, 0xE0, 0x0F, 0x78,
  0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0,
  0x7F, 0xFF, 0x0F, 0x01, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x79,
  0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x0F, 0x1E, 0x03, 0xE3,
  0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F,
  0x0F, 0x01, 0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C,
  0x07, 0x87, 0x80, 0x78, 0xF0, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC,
  0x07, 0xFF, 0xE0, 0xF8, 0x1F, 0x1F, 0x00, 0xE1, 0xE0, 0x04, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC6, 0x00, 0x3C, 0xF0, 0x07, 0xCF,
  0xC0, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0xF1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x3C,
  0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3,
  0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x78,
  0x78, 0x07, 0x87, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x0F,
  0x0F, 0x00, 0xF0, 0xF8, 0x0F, 0x07, 0x83, 0xE0, 0x7F, 0xFE, 0x03, 0xFF,
  0xC0, 0x0F, 0xE0, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0x78,
  0x01, 0xEF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0x70,
  0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0,
  0xF0, 0x1E, 0x1E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x07, 0x1C, 0x00, 0xE7,
  0x80, 0x1E, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x1C, 0xF0, 0x00, 0x73, 0xC0, 0x03,
  0xCF, 0x00, 0x0E, 0x3C, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x87, 0x87, 0x8E,
  0x1E, 0x1E, 0x38, 0xF8, 0x70, 0xE3, 0xE1, 0xC7, 0x8D, 0xCF, 0x1E, 0x77,
  0x3C, 0x79, 0xDC, 0xE1, 0xE6, 0x73, 0x87, 0x39, 0xCE, 0x1C, 0xE7, 0x78,
  0x73, 0x1D, 0xC1, 0xDC, 0x77, 0x07, 0x71, 0xDC, 0x1D, 0x87, 0xF0, 0x7E,
  0x1F, 0x83, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x00, 0x07, 0x80, 0x1F, 0x07, 0xC0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xE0,
  0x7C, 0x01, 0xE0, 0xF8, 0x01, 0xE0, 0xF0, 0x00, 0xF1, 0xE0, 0x00, 0xF3,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xE7, 0x80, 0x03, 0xC7, 0x80, 0x07, 0xC7, 0xC0, 0x0F, 0x83,
  0xC0, 0x0F, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x3E, 0x01, 0xE0, 0x7C, 0x01,
  0xF0, 0xF8, 0x00, 0xF0, 0xF0, 0x00, 0xFB, 0xC0, 0x0F, 0x9E, 0x00, 0x78,
  0xF8, 0x07, 0x83, 0xC0, 0x7C, 0x1E, 0x03, 0xC0, 0xF8, 0x3C, 0x03, 0xC3,
  0xE0, 0x1E, 0x1E, 0x00, 0x79, 0xE0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xE0,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xF0, 0x1C, 0x07, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3D, 0xE0, 0x07, 0x1E, 0x01, 0xE3, 0xC0,
  0x78, 0x38, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0xF0, 0x0E, 0x3C, 0x01, 0xE7,
  0x80, 0x1D, 0xE0, 0x03, 0xD8, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xF8, 0x11, 0xCF, 0x9E, 0x38, 0xF1, 0xC6, 0x03, 0xE3, 0xC3, 0xFC,
  0xF1, 0xFF, 0xB8, 0xF8, 0x3E, 0x7C, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x7B,
  0xC0, 0x1E, 0xF0, 0x07, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0,
  0x0F, 0x3C, 0x07, 0xCF, 0x02, 0xF3, 0xE1, 0xF8, 0x7F, 0xDF, 0xDF, 0xE3,
  0xE1, 0xF0, 0x78, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x1F,
  0x03, 0xCF, 0xF0, 0x7B, 0xFF, 0x0F, 0xE1, 0xE1, 0xF0, 0x3E, 0x3C, 0x03,
  0xCF, 0x80, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x0F,
  0x9E, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x0F, 0x9F, 0x01, 0xE3, 0xF0, 0xFC,
  0x7F, 0xFF, 0x0F, 0x7F, 0xC3, 0xC3, 0xE0, 0x00, 0x01, 0xFC, 0x03, 0xFF,
  0x03, 0xFF, 0xC3, 0xE1, 0xF3, 0xC0, 0x79, 0xE0, 0x21, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x23,
  0xC0, 0x3D, 0xE0, 0x3C, 0xF8, 0x7C, 0x3F, 0xFC, 0x0F, 0xFC, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x03, 0xE3, 0xC1, 0xFE,
  0x78, 0x7F, 0xEF, 0x1F, 0x07, 0xE7, 0xC0, 0x78, 0xF0, 0x0F, 0x1E, 0x01,
  0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1C, 0x78, 0x07,
  0x8F, 0x00, 0xF1, 0xE0, 0x3E, 0x3C, 0x0F, 0xC7, 0xC3, 0x78, 0x7F, 0xCE,
  0x0F, 0xF3, 0xC0, 0x7C, 0x78, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0x83, 0xFF,
  0xE3, 0xE0, 0xF3, 0xC0, 0x39, 0xC0, 0x1D, 0xE0, 0x1E, 0xF0, 0x7F, 0x7F,
  0xFF, 0x7F, 0xFE, 0x3F, 0xF0, 0x1E, 0x00, 0x0F, 0x00, 0x23, 0x80, 0x39,
  0xE0, 0x3E, 0xF8, 0x3E, 0x3F, 0xFE, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x70, 0x78, 0x00, 0xF8, 0x78, 0x00, 0x78,
  0x70, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF1, 0xE0, 0xFF, 0x3C, 0x3F, 0xF7,
  0x8F, 0x83, 0xF3, 0xE0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF3, 0xC0, 0x1E,
  0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0E, 0x3C, 0x03, 0xC7, 0x80, 0x78,
  0xF0, 0x1F, 0x1E, 0x07, 0xE3, 0xE1, 0xBC, 0x3F, 0xF7, 0x03, 0xFD, 0xE0,
  0x3E, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x40, 0x3C, 0x1C, 0x0F, 0x07,
  0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x3E, 0x1E, 0x7F, 0x8F, 0x7F, 0xE7, 0xB1, 0xF3, 0xE0, 0x79, 0xF0,
  0x3C, 0xF0, 0x1E, 0xF8, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xEF,
  0x01, 0xE7, 0x80, 0xF3, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F,
  0x78, 0x0F, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x81, 0xE0, 0xE0,
  0xF0, 0xF8, 0x78, 0xF0, 0x3C, 0xF0, 0x1C, 0xF0, 0x0F, 0xF0, 0x07, 0xF0,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x20, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x08,
  0x1E, 0x07, 0x07, 0x83, 0xE1, 0xE0, 0x7C, 0x78, 0x0F, 0x9E, 0x01, 0xF7,
  0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x3E, 0x07, 0x9F, 0xE0, 0xF7, 0xFE, 0x1E, 0xC7,
  0xC3, 0xE0, 0x78, 0x7C, 0x0F, 0x0F, 0x01, 0xE3, 0xE0, 0x38, 0x78, 0x1E,
  0x0F, 0x07, 0x81, 0xE7, 0xC0, 0x3D, 0xE0, 0x07, 0x9E, 0x08, 0xE3, 0xC3,
  0xBC, 0x3C, 0xFF, 0x87, 0xBC, 0xF0, 0x7F, 0x1E, 0x0F, 0xC3, 0xC0, 0xF0,
  0x00, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x20, 0xE0, 0xE3, 0xC3, 0xE7, 0x8F, 0x0F, 0x3C, 0x1E, 0xF0, 0x3F, 0xC0,
  0x7F, 0x00, 0x78, 0x00, 0x1C, 0xF0, 0xF0, 0xEF, 0xCF, 0x87, 0x7E, 0xFE,
  0x3C, 0x7C, 0xF3, 0xC3, 0xC7, 0x9E, 0x1C, 0x3C, 0xE0, 0xE1, 0xE7, 0x07,
  0x0E, 0x38, 0x78, 0x71, 0xC3, 0x83, 0x9E, 0x1C, 0x1C, 0xF0, 0xE1, 0xE7,
  0x07, 0x0F, 0x38, 0x38, 0x71, 0xC3, 0xC3, 0x8E, 0x1C, 0x1C, 0xF0, 0xE0,
  0xE7, 0x87, 0x0F, 0x38, 0x38, 0x78, 0x1E, 0x3E, 0x1E, 0x7F, 0x8F, 0x7F,
  0xE7, 0xB1, 0xF3, 0xE0, 0x79, 0xF0, 0x3C, 0xF0, 0x1E, 0xF8, 0x0F, 0x78,
  0x07, 0xBC, 0x03, 0xDE, 0x01, 0xEF, 0x01, 0xE7, 0x80, 0xF3, 0x80, 0x7B,
  0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x0F, 0x3C, 0x07, 0x80, 0x01,
  0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xF0, 0xF8, 0x3E, 0x3C, 0x07, 0x9E, 0x00,
  0xE7, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7B,
  0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x03, 0xCF, 0x00, 0xF1, 0xF0, 0xF8, 0x3F,
  0xFC, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0x0F, 0x80, 0xF3, 0xFC, 0x0F,
  0x7F, 0xE0, 0xFE, 0x1E, 0x0F, 0x81, 0xF0, 0xF0, 0x0F, 0x1F, 0x00, 0xF1,
  0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x01, 0xF1, 0xE0, 0x1E,
  0x3C, 0x01, 0xE3, 0xC0, 0x3E, 0x3E, 0x03, 0xC3, 0xF0, 0xFC, 0x3F, 0xFF,
  0x83, 0x9F, 0xF0, 0x78, 0x7C, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE3, 0xC3, 0xFC, 0xF1, 0xFF, 0xBC, 0xF8, 0x3F, 0x7C, 0x07, 0x9E, 0x01,
  0xE7, 0x80, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x73,
  0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0xCF, 0x03, 0xF3, 0xE1, 0xBC, 0x7F,
  0xCE, 0x1F, 0xF7, 0x81, 0xF1, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0xFF, 0x8F,
  0xFF, 0xCF, 0xFF, 0xCF, 0xE1, 0xEC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xC0, 0xE3,
  0xC0, 0x21, 0xE0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x79, 0x80, 0x3D, 0xF0,
  0x3C, 0xFF, 0xFE, 0x3F, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x03, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x03, 0x07, 0x83,
  0xC3, 0xC3, 0xE1, 0xE7, 0xC0, 0xF7, 0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0x0F,
  0x00, 0x00, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0E, 0x3C,
  0x07, 0x8F, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01,
  0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0xC7, 0x82, 0xF1,
  0xE1, 0xBC, 0x7F, 0xDE, 0x0F, 0xE7, 0x81, 0xF1, 0xE0, 0xFF, 0x01, 0x3F,
  0xC1, 0xEF, 0xE0, 0x78, 0x78, 0x0E, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0,
  0x3C, 0x78, 0x0F, 0x1E, 0x07, 0x87, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x3C,
  0x3C, 0x0F, 0x0F, 0x07, 0x83, 0xC7, 0xC0, 0xE3, 0xF0, 0x3F, 0xF0, 0x0F,
  0xF8, 0x01, 0xF8, 0x00, 0x3C, 0x38, 0x63, 0x83, 0x8E, 0x38, 0x78, 0xE3,
  0x87, 0x0E, 0x38, 0x70, 0xF7, 0x87, 0x0F, 0x78, 0x70, 0xF7, 0x07, 0x0F,
  0x70, 0xF0, 0xE7, 0x0F, 0x0E, 0x70, 0xE0, 0xE7, 0x0E, 0x0E, 0xF0, 0xE1,
  0xCE, 0x1E, 0x1C, 0xE1, 0xE1, 0xCF, 0x3E, 0x38, 0xFE, 0xE7, 0x07, 0xE7,
  0xE0, 0x78, 0x7C, 0x00, 0x01, 0xE0, 0xF0, 0x1F, 0x8F, 0xE0, 0xFF, 0x3F,
  0x8F, 0x9D, 0x8E, 0x7C, 0x74, 0x3C, 0xC1, 0xF0, 0xF0, 0x07, 0xC3, 0x80,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0xE0, 0xF8, 0x23, 0x82, 0xE1, 0x8F, 0x1B, 0x8F, 0x3C, 0xEE, 0xF8,
  0xFF, 0x3F, 0xC1, 0xF8, 0xFE, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x01, 0xE3,
  0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x8F,
  0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x70, 0xF0, 0x1E, 0x1E,
  0x03, 0xC3, 0xC0, 0x78, 0x78, 0x1F, 0x0F, 0x07, 0xE1, 0xE1, 0xB8, 0x3F,
  0xEF, 0x03, 0xF9, 0xE0, 0x3E, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x80,
  0x3C, 0x1C, 0x1F, 0x07, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0xE1, 0xFF, 0x9C, 0x7F, 0xFF, 0x8E, 0x0F, 0xF3, 0xC0, 0x7C, 0x70,
  0x1F, 0x0E, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xE1, 0xC0, 0xF8, 0x38, 0x3C, 0x03, 0x8F, 0xC0, 0x73, 0xFF,
  0xCE, 0x77, 0xFF, 0xCE, 0x3F, 0xF3, 0xC0, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0F, 0x03, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0F, 0x0E,
  0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x38,
  0x38, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xE0,
  0xE0, 0x03, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0x00,
  0xFF, 0x80, 0xF0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0x80, 0x61,
  0xFC, 0x0E, 0x3F, 0xE0, 0xE3, 0x8F, 0x1E, 0x78, 0xF1, 0xC7, 0x07, 0xFC,
  0xF0, 0x3F, 0x86, 0x01, 0xE0,
};

const GFXglyph IBMPlexMono_MediumItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 9, 25, 22, 7, -25 },
  { 30, 12, 11, 22, 7, -27 },
  { 47, 22, 25, 22, 0, -25 },
  { 116, 20, 33, 22, 1, -29 },
  { 199, 25, 25, 22, -1, -25 },
  { 278, 21, 25, 22, 0, -25 },
  { 344, 5, 11, 22, 10, -27 },
  { 351, 14, 32, 22, 7, -27 },
  { 407, 14, 32, 22, 1, -27 },
  { 463, 18, 18, 22, 2, -20 },
  { 504, 18, 17, 22, 2, -19 },
  { 543, 10, 10, 22, 4, -5 },
  { 556, 12, 3, 22, 5, -12 },
  { 561, 7, 6, 22, 6, -6 },
  { 567, 20, 32, 22, 1, -27 },
  { 647, 19, 25, 22, 2, -25 },
  { 707, 17, 25, 22, 2, -25 },
  { 761, 19, 25, 22, 1, -25 },
  { 821, 19, 25, 22, 1, -25 },
  { 881, 20, 25, 22, 0, -25 },
  { 944, 20, 25, 22, 1, -25 },
  { 1007, 18, 25, 22, 2, -25 },
  { 1064, 19, 25, 22, 3, -25 },
  { 1124, 20, 25, 22, 1, -25 },
  { 1187, 18, 25, 22, 3, -25 },
  { 1244, 9, 19, 22, 6, -19 },
  { 1266, 11, 24, 22, 4, -19 },
  { 1299, 18, 21, 22, 3, -22 },
  { 1347, 18, 10, 22, 2, -16 },
  { 1370, 17, 21, 22, 2, -22 },
  { 1415, 16, 25, 22, 4, -25 },
  { 1465, 19, 29, 22, 2, -25 },
  { 1534, 20, 25, 22, -1, -25 },
  { 1597, 19, 25, 22, 1, -25 },
  { 1657, 19, 25, 22, 2, -25 },
  { 1717, 19, 25, 22, 2, -25 },
  { 1777, 19, 25, 22, 2, -25 },
  { 1837, 20, 25, 22, 2, -25 },
  { 1900, 19, 25, 22, 2, -25 },
  { 1960, 21, 25, 22, 1, -25 },
  { 2026, 20, 25, 22, 1, -25 },
  { 2089, 18, 25, 22, 2, -25 },
  { 2146, 23, 25, 22, 1, -25 },
  { 2218, 16, 25, 22, 2, -25 },
  { 2268, 22, 25, 22, 0, -25 },
  { 2337, 21, 25, 22, 1, -25 },
  { 2403, 19, 25, 22, 2, -25 },
  { 2463, 19, 25, 22, 2, -25 },
  { 2523, 19, 32, 22, 2, -25 },
  { 2599, 19, 25, 22, 2, -25 },
  { 2659, 20, 25, 22, 1, -25 },
  { 2722, 20, 25, 22, 3, -25 },
  { 2785, 20, 25, 22, 2, -25 },
  { 2848, 19, 25, 22, 4, -25 },
  { 2908, 22, 25, 22, 1, -25 },
  { 2977, 24, 25, 22, -1, -25 },
  { 3052, 21, 25, 22, 3, -25 },
  { 3118, 22, 25, 22, 0, -25 },
  { 3187, 16, 32, 22, 5, -27 },
  { 3251, 10, 32, 22, 6, -27 },
  { 3291, 16, 32, 22, 1, -27 },
  { 3355, 19, 15, 22, 2, -25 },
  { 3391, 18, 3, 22, 0, 3 },
  { 3398, 6, 8, 22, 7, -29 },
  { 3404, 18, 19, 22, 2, -19 },
  { 3447, 19, 27, 22, 1, -27 },
  { 3512, 17, 19, 22, 2, -19 },
  { 3553, 19, 27, 22, 2, -27 },
  { 3618, 17, 19, 22, 2, -19 },
  { 3659, 24, 34, 22, -1, -27 },
  { 3761, 19, 26, 22, 1, -19 },
  { 3823, 17, 27, 22, 2, -27 },
  { 3881, 17, 27, 22, 3, -27 },
  { 3939, 18, 34, 22, 1, -27 },
  { 4016, 19, 27, 22, 2, -27 },
  { 4081, 15, 27, 22, 4, -27 },
  { 4132, 21, 19, 22, 0, -19 },
  { 4182, 17, 19, 22, 2, -19 },
  { 4223, 18, 19, 22, 2, -19 },
  { 4266, 20, 26, 22, 0, -19 },
  { 4331, 18, 26, 22, 2, -19 },
  { 4390, 17, 19, 22, 4, -19 },
  { 4431, 17, 19, 22, 2, -19 },
  { 4472, 17, 25, 22, 3, -25 },
  { 4526, 18, 19, 22, 2, -19 },
  { 4569, 18, 19, 22, 2, -19 },
  { 4612, 20, 19, 22, 1, -19 },
  { 4660, 22, 19, 22, 0, -19 },
  { 4713, 19, 26, 22, 1, -19 },
  { 4775, 19, 19, 22, 1, -19 },
  { 4821, 17, 32, 22, 4, -27 },
  { 4889, 8, 32, 22, 7, -27 },
  { 4921, 17, 32, 22, 1, -27 },
  { 4989, 20, 8, 22, 1, -15 },
};

const GFXfont IBMPlexMono_MediumItalic36pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic36pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic36pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _IBMPLEXMONO_MEDIUMITALIC36PT7B_H_
