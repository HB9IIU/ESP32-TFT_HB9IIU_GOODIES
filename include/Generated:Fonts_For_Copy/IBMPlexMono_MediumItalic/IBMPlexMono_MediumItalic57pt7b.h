#ifndef _IBMPLEXMONO_MEDIUMITALIC57PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF8,
  0x3F, 0xE0, 0x3F, 0xC0, 0x3E, 0x00, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC,
  0x1F, 0x9F, 0x03, 0xE3, 0xE0, 0x7C, 0xFC, 0x0F, 0x9F, 0x83, 0xF3, 0xF0,
  0x7E, 0x7E, 0x0F, 0xCF, 0x81, 0xF1, 0xF0, 0x3E, 0x7E, 0x07, 0xCF, 0xC1,
  0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xC0, 0xFC, 0xF8, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8,
  0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0x03, 0xFF, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F,
  0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x00, 0x7C, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xCF, 0xBF,
  0xE0, 0x3F, 0x87, 0x87, 0xF8, 0x3F, 0x83, 0xC0, 0xF0, 0x1F, 0x81, 0xE0,
  0x20, 0x0F, 0xC0, 0xF0, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x03, 0xF0, 0x3C,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x1E, 0x00, 0x00, 0x7F, 0x0F,
  0x00, 0x00, 0x3F, 0xC7, 0x80, 0x00, 0x0F, 0xFB, 0xC0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0x0F, 0xF0, 0x00, 0x07, 0x83, 0xF8, 0x00,
  0x03, 0xC1, 0xFC, 0x00, 0x01, 0xE0, 0x7E, 0x00, 0x00, 0xF0, 0x3F, 0x00,
  0x00, 0x78, 0x1F, 0x80, 0x00, 0x7C, 0x0F, 0xC0, 0x40, 0x3C, 0x0F, 0xE0,
  0xF0, 0x1E, 0x07, 0xE0, 0xFC, 0x0F, 0x07, 0xF0, 0xFF, 0x07, 0x87, 0xF0,
  0x3F, 0xE3, 0xCF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0xF0, 0x00, 0x3E,
  0x00, 0x7F, 0xF8, 0x00, 0x7C, 0x00, 0xFF, 0xFC, 0x00, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x07,
  0xC0, 0x3E, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x07, 0xC0, 0x3E,
  0x1F, 0x00, 0x07, 0xC0, 0x3C, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x7C, 0x00,
  0x03, 0xC0, 0x7C, 0x7C, 0x00, 0x03, 0xE1, 0xF8, 0xF8, 0x00, 0x03, 0xFF,
  0xF1, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0x8F,
  0xFF, 0xC0, 0x00, 0x1F, 0x1F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x03, 0xC0,
  0x00, 0x3E, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x3E, 0x03, 0xE0, 0x00, 0xF8,
  0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x7C, 0x03,
  0xE0, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x1F, 0x80, 0x3E, 0x00, 0x3F, 0xFF, 0x00,
  0x7C, 0x00, 0x1F, 0xFE, 0x00, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xF9, 0xFC, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xF3, 0xFE, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x01, 0x0F, 0xC0,
  0x0F, 0xC0, 0x73, 0xF0, 0x03, 0xF8, 0x1F, 0xFE, 0x00, 0xFE, 0x0F, 0xBF,
  0x80, 0x6F, 0xC7, 0xE7, 0xE0, 0x1B, 0xF1, 0xF1, 0xFE, 0x1E, 0x7E, 0xF8,
  0x7F, 0xFF, 0x1F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0xE0, 0xFF,
  0xC0, 0x3F, 0xF0, 0x1F, 0xE0, 0x03, 0xF0, 0x01, 0xE0, 0x00, 0x1F, 0x1F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C,
  0xFC, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x30, 0x07, 0xC0, 0x1B, 0xF0, 0x3E, 0x0F, 0xDF, 0xF3, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xBF,
  0x80, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x03, 0xF8, 0x1F, 0x80,
  0x3F, 0x80, 0x7E, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0x80, 0x0F, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x1F, 0x8F,
  0xF7, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0x81, 0xF8, 0x00, 0x7E, 0x0F,
  0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x3F, 0x3F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0xFD, 0xF8, 0x1F, 0x07,
  0xF7, 0xE0, 0xFC, 0x1F, 0xFF, 0x83, 0xF8, 0x7F, 0xFE, 0x1F, 0xE1, 0xFF,
  0xF8, 0x7F, 0x07, 0xEF, 0xE1, 0xFC, 0x1F, 0xBF, 0x03, 0xE0, 0xFE, 0xFC,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x7E, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7E,
  0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFD, 0xFC, 0x00,
  0x7F, 0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x1F,
  0x80, 0x7F, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x01, 0xF0, 0x1F, 0x80, 0x1C,
  0x03, 0xF0, 0x01, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xFC, 0x03, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0x7F, 0x80, 0xF8, 0x00, 0x7F,
  0x00, 0xE0, 0x00, 0xFE, 0x00, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x04, 0x00, 0x03, 0xF8, 0x3C, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x03, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E,
  0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0xFE, 0x00, 0x0F, 0xC7, 0xFF,
  0x00, 0x1F, 0x3F, 0xFF, 0x80, 0x3E, 0xFF, 0xFF, 0x80, 0x7D, 0xFF, 0xFF,
  0x00, 0xFF, 0x01, 0xFF, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xE0, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x04, 0x00, 0x03, 0xF8, 0x3C,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x03, 0xFE,
  0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0x8F, 0xFF, 0x03, 0xF9, 0xFF,
  0xF8, 0x3F, 0x3F, 0xFF, 0xC7, 0xF7, 0xFF, 0xFE, 0x7F, 0xF0, 0x3F, 0xE7,
  0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xE7, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x3F,
  0xC3, 0xFC, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xF8, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7F,
  0x1F, 0x00, 0x01, 0xFC, 0x7C, 0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x3F, 0x0F,
  0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xC0, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x7E,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x7E, 0x03, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x03,
  0xF8, 0x3F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F,
  0x3F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x03, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xC7, 0xF0, 0x00, 0x7E,
  0x3F, 0x80, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFE, 0xFC,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x3F,
  0x9F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x07, 0xFE, 0x1F,
  0xFF, 0xFB, 0xF0, 0x7F, 0xFF, 0xBF, 0x01, 0xFF, 0xF9, 0xF8, 0x07, 0xFF,
  0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xE0,
  0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x03, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0x80, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x04, 0x00,
  0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xE0, 0x04, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE3, 0xFE, 0x0F,
  0xF9, 0xFC, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x9E, 0x00,
  0x1F, 0xC2, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0,
  0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0xF8, 0x3E, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x3E, 0x1F,
  0x1F, 0x03, 0xFE, 0x7C, 0xFC, 0x1F, 0xFB, 0xF3, 0xE0, 0xFF, 0xFF, 0x8F,
  0x83, 0xFF, 0xFE, 0x7E, 0x1F, 0xC3, 0xF9, 0xF8, 0x7E, 0x07, 0xE7, 0xC3,
  0xF0, 0x0F, 0x9F, 0x0F, 0xC0, 0x3E, 0x7C, 0x3E, 0x01, 0xF1, 0xF0, 0xF8,
  0x07, 0xCF, 0xC7, 0xE0, 0x1F, 0x3F, 0x1F, 0x80, 0x7C, 0xF8, 0x7E, 0x01,
  0xF3, 0xE1, 0xF0, 0x0F, 0xCF, 0x87, 0xC0, 0x3E, 0x3E, 0x1F, 0x00, 0xF8,
  0xF8, 0x7C, 0x07, 0xE3, 0xE1, 0xF8, 0x3F, 0x8F, 0x87, 0xF3, 0xBE, 0x3E,
  0x0F, 0xFF, 0xF8, 0xF8, 0x3F, 0xF7, 0xC3, 0xE0, 0x7F, 0x9F, 0x0F, 0x80,
  0xFE, 0x7C, 0x3E, 0x01, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFB, 0xE0,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0xC1, 0xF0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0xFC, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7E,
  0x3F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7F,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x0F, 0xF0, 0x3F,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x1F, 0xC0,
  0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01,
  0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFC,
  0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xF8,
  0x00, 0xFE, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x03,
  0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xFC,
  0x3F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xFE, 0x1F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0x81, 0xF8, 0x00, 0x7E,
  0x0F, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x0E, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1C, 0x0F, 0xC0,
  0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x7E, 0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x7E, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x3F,
  0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0x80,
  0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x00,
  0xFE, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFE,
  0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x7F, 0x81, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x00, 0x7E, 0x0F, 0xE0,
  0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x0F, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x01, 0xFF, 0xF3, 0xF8,
  0x07, 0xFF, 0xCF, 0xE0, 0x3F, 0xFF, 0x3F, 0x80, 0xFF, 0xFC, 0xFE, 0x03,
  0xFF, 0xF3, 0xF8, 0x00, 0x0F, 0x8F, 0xE0, 0x00, 0x3E, 0x3F, 0x80, 0x01,
  0xF8, 0xFE, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7E,
  0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x7F, 0x07,
  0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x3B, 0xF0, 0x3F, 0xFF, 0xEF, 0xC0, 0x7F,
  0xFF, 0x3E, 0x00, 0xFF, 0xF8, 0xF8, 0x01, 0xFF, 0xC7, 0xE0, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xE0,
  0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x80,
  0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x70,
  0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x03,
  0xF0, 0x3F, 0x80, 0x3F, 0x80, 0xFF, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x07, 0xF8,
  0x0F, 0xE0, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x1F,
  0xE0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0xFF, 0x00, 0x03, 0xF0, 0x3F, 0xC0, 0x00, 0x7E, 0x0F, 0xF0, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x7E, 0x3F, 0xC0,
  0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0x7F,
  0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x7E, 0x00, 0x00, 0xFF, 0xCF, 0xE0, 0x00,
  0x1F, 0xF0, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x3F, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF,
  0x81, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xF7, 0xC1, 0xF7, 0xE0, 0x7D, 0xF0,
  0x7D, 0xF0, 0x3F, 0x7C, 0x3E, 0x7C, 0x0F, 0xCF, 0x8F, 0x9F, 0x03, 0xF3,
  0xE7, 0xCF, 0xC0, 0xF8, 0xFB, 0xF3, 0xF0, 0x3E, 0x3E, 0xF8, 0xFC, 0x0F,
  0x87, 0xFE, 0x3E, 0x07, 0xE1, 0xFF, 0x0F, 0x81, 0xF8, 0x7F, 0x83, 0xE0,
  0x7E, 0x1F, 0xE1, 0xF8, 0x1F, 0x87, 0xF0, 0x7E, 0x07, 0xC0, 0xFC, 0x1F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x03, 0xC0,
  0x7C, 0x0F, 0xC0, 0x60, 0x3F, 0x03, 0xF0, 0x18, 0x0F, 0xC0, 0xF8, 0x04,
  0x03, 0xF0, 0x3E, 0x01, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F,
  0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0x03, 0xFE, 0x00,
  0x3F, 0x03, 0xFE, 0x00, 0x3F, 0x03, 0xFE, 0x00, 0x3F, 0x03, 0xFF, 0x00,
  0x3E, 0x07, 0xFF, 0x00, 0x3E, 0x07, 0xFF, 0x00, 0x3E, 0x07, 0xFF, 0x00,
  0x7E, 0x07, 0xFF, 0x00, 0x7E, 0x07, 0xDF, 0x80, 0x7E, 0x07, 0xDF, 0x80,
  0x7C, 0x0F, 0xCF, 0x80, 0x7C, 0x0F, 0xCF, 0x80, 0x7C, 0x0F, 0xCF, 0x80,
  0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0x0F, 0x8F, 0xC0, 0xFC, 0x0F, 0x87, 0xC0,
  0xF8, 0x1F, 0x87, 0xC0, 0xF8, 0x1F, 0x87, 0xC0, 0xF8, 0x1F, 0x87, 0xE1,
  0xF8, 0x1F, 0x87, 0xE1, 0xF8, 0x1F, 0x03, 0xE1, 0xF8, 0x1F, 0x03, 0xE1,
  0xF8, 0x3F, 0x03, 0xE1, 0xF0, 0x3F, 0x03, 0xF1, 0xF0, 0x3F, 0x03, 0xF3,
  0xF0, 0x3F, 0x01, 0xF3, 0xF0, 0x3E, 0x01, 0xF3, 0xF0, 0x3E, 0x01, 0xF3,
  0xF0, 0x7E, 0x01, 0xFB, 0xE0, 0x7E, 0x01, 0xFB, 0xE0, 0x7E, 0x00, 0xFF,
  0xE0, 0x7E, 0x00, 0xFF, 0xE0, 0x7C, 0x00, 0xFF, 0xE0, 0x7C, 0x00, 0xFF,
  0xE0, 0xFC, 0x00, 0xFF, 0xC0, 0xFC, 0x00, 0x7F, 0xC0, 0xFC, 0x00, 0x7F,
  0xC0, 0xFC, 0x00, 0x7F, 0xC0, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0x81,
  0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0xFC, 0xFC, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0x7F, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x07, 0xF3, 0xF0, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0xC0,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0x80,
  0x3F, 0x81, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0xFC,
  0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0x7F,
  0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF0, 0xFE,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xF0,
  0x7F, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x01,
  0x00, 0x01, 0xF8, 0x0E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x01, 0xFE, 0x03,
  0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x07,
  0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F,
  0xC0, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x7C,
  0x07, 0xF0, 0x00, 0x18, 0x03, 0xF8, 0x00, 0x08, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x10,
  0x00, 0x03, 0xF0, 0x3C, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x3F,
  0xC0, 0x03, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F,
  0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE3, 0xF8,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x7F, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8,
  0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F,
  0x80, 0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x80,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7E, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00,
  0x03, 0xF8, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x07,
  0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x07, 0xE0,
  0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x7F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x03, 0xE1,
  0xF8, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x03, 0xF0, 0x7C, 0x0F, 0xE0, 0x7C, 0x1F, 0x81, 0xFC, 0x0F, 0x83, 0xF0,
  0x3F, 0x81, 0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F, 0xC1, 0xFE, 0x0F, 0x81,
  0xF0, 0x7F, 0xC1, 0xF0, 0x3E, 0x0F, 0xF8, 0x3E, 0x07, 0xC1, 0xEF, 0x07,
  0xC0, 0xF8, 0x7D, 0xE1, 0xF8, 0x1F, 0x0F, 0x3C, 0x3E, 0x03, 0xE1, 0xE7,
  0x87, 0xC0, 0xFC, 0x7C, 0xF0, 0xF8, 0x1F, 0x8F, 0x1E, 0x3F, 0x03, 0xF1,
  0xE3, 0xC7, 0xC0, 0x7C, 0x7C, 0x78, 0xF8, 0x0F, 0x8F, 0x0F, 0x1F, 0x01,
  0xF1, 0xE1, 0xE7, 0xE0, 0x3E, 0x7C, 0x3C, 0xF8, 0x07, 0xCF, 0x07, 0x9F,
  0x00, 0xF9, 0xE0, 0xF3, 0xE0, 0x1F, 0x7C, 0x1E, 0x7C, 0x03, 0xEF, 0x03,
  0xDF, 0x00, 0xFD, 0xE0, 0x7B, 0xE0, 0x1F, 0xFC, 0x0F, 0x7C, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xFC, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00,
  0x00, 0x7E, 0x7F, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0x9F, 0x80, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0xC1, 0xF8, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x01, 0xF8, 0x07, 0xF0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFB,
  0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF8, 0x7E,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F,
  0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x1F, 0xC0,
  0x00, 0x7E, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF3, 0xC0, 0x00,
  0x0F, 0x06, 0x00, 0x00, 0x10, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x08,
  0x1E, 0x3F, 0x0F, 0x87, 0xE1, 0xF0, 0xFC, 0x3E, 0x1F, 0x07, 0xC3, 0xE0,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0x03, 0xFF, 0xE3, 0xF0,
  0x7F, 0xFF, 0x3F, 0x0F, 0xFF, 0xFB, 0xF1, 0xFF, 0x03, 0xBF, 0x1F, 0xC0,
  0x0F, 0xF3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xE7, 0xF0, 0x00, 0x7E,
  0x7F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F,
  0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC,
  0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x0F,
  0xF8, 0xFE, 0x01, 0xFF, 0x07, 0xF0, 0x7B, 0xFF, 0x7F, 0xFF, 0x3F, 0xF7,
  0xFF, 0xF3, 0xFF, 0x3F, 0xFE, 0x1F, 0xE1, 0xFF, 0xC0, 0xFE, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x07,
  0xF0, 0x03, 0xF0, 0xFF, 0xE0, 0x1F, 0x8F, 0xFF, 0x80, 0xFC, 0xFF, 0xFE,
  0x07, 0xEF, 0xFF, 0xF0, 0x7F, 0x78, 0x3F, 0xC3, 0xF7, 0x00, 0xFE, 0x1F,
  0xF0, 0x03, 0xF0, 0xFF, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFC, 0x3F, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x9F,
  0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7E, 0x3F, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x1F,
  0xC7, 0xF8, 0x01, 0xFC, 0x3F, 0x70, 0x3F, 0xE1, 0xFB, 0xFF, 0xFE, 0x0F,
  0xCF, 0xFF, 0xE0, 0x7E, 0x7F, 0xFE, 0x07, 0xE1, 0xFF, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFC, 0x0F, 0xF1, 0xFC, 0x00,
  0xFC, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x06, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x10, 0xFC, 0x00, 0x07, 0x3F, 0x00,
  0x03, 0xEF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x7F, 0x1F,
  0xE0, 0x7F, 0x83, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xFC,
  0x3F, 0x00, 0xFF, 0xFC, 0x7E, 0x03, 0xFF, 0xFD, 0xF8, 0x0F, 0xFF, 0xFB,
  0xF0, 0x1F, 0xE0, 0x7F, 0xE0, 0x7F, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xF8,
  0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F,
  0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xFE, 0x07, 0xF0,
  0x03, 0xFC, 0x0F, 0xE0, 0x1D, 0xF8, 0x0F, 0xF0, 0x73, 0xF0, 0x1F, 0xFF,
  0xEF, 0xE0, 0x1F, 0xFF, 0x9F, 0x80, 0x3F, 0xFE, 0x3F, 0x00, 0x3F, 0xF8,
  0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x1F,
  0xF0, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x07,
  0xE7, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xEF, 0xE0,
  0x07, 0xF9, 0xFC, 0x1F, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x61, 0xF8, 0x00, 0x0E, 0x3F, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x10, 0x03, 0xF0, 0x00, 0x00, 0x60, 0x1F, 0xC0, 0x00, 0x07, 0xC0,
  0x7E, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0xFC, 0x03, 0xFF, 0xF1, 0xF8, 0x0F, 0xFF, 0xF7, 0xF0,
  0x3F, 0xFF, 0xEF, 0xC0, 0xFF, 0x81, 0xFF, 0x81, 0xFC, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0xFF, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x07,
  0xF8, 0x1F, 0xC0, 0x1B, 0xF0, 0x1F, 0xE0, 0xF7, 0xE0, 0x3F, 0xFF, 0xCF,
  0xC0, 0x3F, 0xFF, 0x1F, 0x80, 0x7F, 0xFC, 0x7E, 0x00, 0x3F, 0xF0, 0xFC,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x20, 0x00, 0xFE, 0x00,
  0xE0, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x1F,
  0x87, 0xFE, 0x03, 0xF1, 0xFF, 0xE0, 0x7E, 0x7F, 0xFE, 0x0F, 0xCF, 0xFF,
  0xE1, 0xFB, 0x83, 0xFC, 0x7F, 0xE0, 0x3F, 0x8F, 0xD8, 0x03, 0xF1, 0xFE,
  0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x3F,
  0x3F, 0x80, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80,
  0x07, 0xF3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x03, 0xF3,
  0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF9, 0xF8, 0x00,
  0x7E, 0x3F, 0x00, 0x0F, 0xCF, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F,
  0x00, 0x07, 0xE7, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x02, 0x00, 0x3F, 0x00, 0xE0, 0x07, 0xE0,
  0x3E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x03, 0xF8, 0x07, 0xE1, 0xFE, 0x00,
  0xFC, 0x7F, 0x80, 0x1F, 0x9F, 0xE0, 0x03, 0xE7, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x18,
  0x03, 0xF8, 0x03, 0xC0, 0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xE0, 0x3F,
  0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x00,
  0xFE, 0x7E, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x3F, 0x07, 0xFE, 0x00, 0xFC, 0x7F, 0xFC, 0x03, 0xF3, 0xFF, 0xF8,
  0x0F, 0xCF, 0xFF, 0xE0, 0x3F, 0x70, 0x7F, 0x81, 0xFF, 0x80, 0x7E, 0x07,
  0xEC, 0x01, 0xF8, 0x1F, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0xFC, 0x00,
  0x7E, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x80, 0x3F, 0x07, 0xF8,
  0x00, 0xFC, 0xFF, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x7E, 0x1F, 0x80, 0x21, 0xF8, 0x7F, 0x01, 0xC7, 0xE0, 0xFC, 0x0F, 0x9F,
  0x83, 0xF8, 0x7F, 0xFE, 0x07, 0xE3, 0xFB, 0xF0, 0x1F, 0x9F, 0xCF, 0xC0,
  0x3F, 0xFE, 0x3F, 0x00, 0xFF, 0xF0, 0xFC, 0x01, 0xFF, 0x83, 0xF0, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x08,
  0x0F, 0xE0, 0x1C, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0xFF, 0x0F, 0xC1, 0xFC,
  0x0F, 0xC3, 0xF8, 0x1F, 0xC7, 0xF0, 0x1F, 0x8F, 0xE0, 0x1F, 0x9F, 0xC0,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x7C, 0x03, 0xE7, 0xF8, 0x7F, 0x81,
  0xF3, 0xFC, 0x7F, 0xC0, 0xFB, 0xFE, 0x7F, 0xF0, 0xFF, 0xFF, 0xBF, 0xF8,
  0x7F, 0x8F, 0xF8, 0xFC, 0x3F, 0x87, 0xF8, 0x7E, 0x1F, 0x81, 0xF8, 0x1F,
  0x0F, 0x80, 0xF8, 0x0F, 0x87, 0xC0, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x07,
  0xE3, 0xE0, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x80,
  0xF8, 0x7C, 0x07, 0xC0, 0x7C, 0x3E, 0x07, 0xE0, 0x7E, 0x3F, 0x03, 0xF0,
  0x3F, 0x1F, 0x01, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x0F, 0x87, 0xC0, 0x7C,
  0x07, 0xC3, 0xE0, 0x3E, 0x03, 0xE1, 0xF0, 0x3F, 0x03, 0xF1, 0xF8, 0x1F,
  0x01, 0xF8, 0xF8, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC0, 0x7C, 0x3E, 0x03,
  0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0x1F, 0x0F, 0x81, 0xF8, 0x1F, 0x8F, 0xC0,
  0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x07, 0xC0, 0x00, 0x00, 0xFE, 0x01, 0xFC,
  0x7F, 0xE0, 0x3F, 0x1F, 0xFE, 0x07, 0xE7, 0xFF, 0xE0, 0xFC, 0xFF, 0xFE,
  0x1F, 0xB8, 0x3F, 0xC3, 0xFE, 0x03, 0xF8, 0xFD, 0x80, 0x3F, 0x1F, 0xE0,
  0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1,
  0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00,
  0x7F, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x3F, 0x3F,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x07,
  0xE3, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF0,
  0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0x81, 0xFC, 0x1F, 0xE0,
  0x0F, 0xE1, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x3F,
  0x7F, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0xC7, 0xE0, 0x01,
  0xF8, 0x7F, 0x00, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0xFF, 0xE0, 0x07, 0xE3,
  0xFF, 0xE0, 0x0F, 0xCF, 0xFF, 0xE0, 0x1F, 0xBF, 0xFF, 0xC0, 0x7F, 0x78,
  0x3F, 0xC0, 0xFD, 0xC0, 0x3F, 0x81, 0xFF, 0x00, 0x3F, 0x03, 0xFC, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x03,
  0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xFC,
  0x3F, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xFC, 0x1F,
  0xE0, 0x07, 0xF0, 0x3F, 0x70, 0x3F, 0xE0, 0x7E, 0xFF, 0xFF, 0x80, 0xFC,
  0xFF, 0xFE, 0x01, 0xF9, 0xFF, 0xF8, 0x07, 0xE1, 0xFF, 0xC0, 0x0F, 0xC0,
  0xFE, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0x0F,
  0xC0, 0xFF, 0xFC, 0x7E, 0x0F, 0xFF, 0xF7, 0xF0, 0xFF, 0xFF, 0xBF, 0x07,
  0xF8, 0x1F, 0xF8, 0x7F, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80,
  0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0x9F,
  0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x1F,
  0xC3, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xF0, 0xFE, 0x01, 0xDF, 0x83,
  0xFC, 0x1E, 0xFC, 0x1F, 0xFF, 0xEF, 0xE0, 0x7F, 0xFE, 0x7E, 0x03, 0xFF,
  0xE3, 0xF0, 0x0F, 0xFE, 0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x7F, 0xEF, 0xFF, 0xC7, 0xFE,
  0xFF, 0xFC, 0xFF, 0xE0, 0x1F, 0xDF, 0xFE, 0x01, 0xFB, 0xC0, 0x00, 0x1F,
  0xB0, 0x00, 0x01, 0xFA, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0x00,
  0xFC, 0x0F, 0xC0, 0x03, 0x80, 0xFC, 0x00, 0x10, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x10, 0x00, 0x0F,
  0xC3, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x10, 0x07, 0xE0, 0x0F, 0x00, 0xFC,
  0x03, 0xE0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x7F, 0x80, 0xFC, 0x1F, 0xE0,
  0x1F, 0x8F, 0xF8, 0x03, 0xF3, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8,
  0x00, 0x7E, 0x3F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F,
  0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x7F,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0xC7, 0xE0, 0x01,
  0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0x8F,
  0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x7F, 0x0F, 0xC0, 0x0F, 0xF0, 0xFC, 0x01, 0xBF, 0x0F, 0xE0, 0x3B, 0xF0,
  0xFF, 0x07, 0x7F, 0x07, 0xFF, 0xF7, 0xE0, 0x7F, 0xFE, 0x7E, 0x03, 0xFF,
  0xC7, 0xE0, 0x1F, 0xF8, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC7, 0xFF, 0x80, 0x7E, 0x7F, 0xF0, 0x0F, 0xEF, 0xFF, 0x00, 0x7E, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xC0,
  0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFE,
  0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x81, 0xF8,
  0x07, 0xF8, 0x1F, 0x80, 0xFF, 0x01, 0xF8, 0x1F, 0xE0, 0x1F, 0x83, 0xFC,
  0x01, 0xF9, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x3F, 0x03, 0xE1, 0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0xF8, 0x0F,
  0x83, 0xE1, 0xF0, 0x3F, 0x07, 0xC3, 0xE0, 0x7C, 0x0F, 0x8F, 0xC0, 0xF8,
  0x1F, 0x1F, 0x01, 0xF0, 0x3F, 0x3E, 0x03, 0xE0, 0x7E, 0x7C, 0x07, 0xC0,
  0xFC, 0xF8, 0x1F, 0x81, 0xF9, 0xF0, 0x3E, 0x03, 0xF7, 0xE0, 0x7C, 0x07,
  0xCF, 0x80, 0xF8, 0x0F, 0x9F, 0x01, 0xF0, 0x1F, 0x3E, 0x03, 0xE0, 0x3E,
  0x7C, 0x07, 0xC0, 0x7C, 0xF8, 0x1F, 0x00, 0xFB, 0xF0, 0x3E, 0x03, 0xE7,
  0xC0, 0x7C, 0x07, 0xCF, 0x80, 0xF8, 0x0F, 0x9F, 0x03, 0xF0, 0x3F, 0x3E,
  0x07, 0xE0, 0x7C, 0x7C, 0x0F, 0xC0, 0xF8, 0xF8, 0x3F, 0x83, 0xE1, 0xF8,
  0xEF, 0x0F, 0xC3, 0xFF, 0x9E, 0x3F, 0x07, 0xFF, 0x3F, 0xFC, 0x0F, 0xFC,
  0x7F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8,
  0x07, 0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0xE7, 0xFF, 0xC3, 0xFC, 0xF9, 0xE3,
  0xF1, 0xFE, 0x3E, 0xF0, 0xFC, 0xFE, 0x0F, 0xB8, 0x1F, 0x1F, 0x03, 0xEC,
  0x07, 0xC3, 0x00, 0xFB, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x0F,
  0xE0, 0x20, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x10, 0x1F, 0xC0, 0x00,
  0xF8, 0x07, 0xF0, 0x04, 0x3E, 0x03, 0xFC, 0x03, 0x0F, 0x80, 0xDF, 0x03,
  0xE3, 0xF0, 0x77, 0xC1, 0xFC, 0xFC, 0x1D, 0xF1, 0xFE, 0x3F, 0x0E, 0x7C,
  0xFF, 0x0F, 0xFF, 0x8F, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xF0,
  0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F,
  0x80, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0,
  0x03, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x3F, 0x81, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01,
  0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xFC,
  0x07, 0xF0, 0x0D, 0xF8, 0x0F, 0xF0, 0x73, 0xF0, 0x0F, 0xFF, 0xEF, 0xE0,
  0x1F, 0xFF, 0x9F, 0x80, 0x1F, 0xFE, 0x3F, 0x00, 0x1F, 0xF8, 0x7E, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x20, 0x00, 0x7E, 0x00, 0xF0,
  0x03, 0xFC, 0x03, 0xF8, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0x01, 0xF0, 0x3F, 0xFF,
  0x07, 0xC1, 0xFF, 0xFF, 0x3F, 0x0F, 0xFF, 0xFE, 0xFC, 0x3F, 0x07, 0xFF,
  0xF0, 0xF8, 0x03, 0xFF, 0x87, 0xC0, 0x03, 0xFC, 0x1F, 0x00, 0x0F, 0xE0,
  0x7C, 0x00, 0xFF, 0x01, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x01, 0x00, 0x0F, 0xE0,
  0x1C, 0x00, 0x7F, 0x00, 0xF8, 0x03, 0xF8, 0x03, 0xE0, 0x1F, 0xC0, 0x07,
  0xC1, 0xFE, 0x00, 0x1F, 0x0F, 0xFC, 0x00, 0x7C, 0x7F, 0xFF, 0x01, 0xF1,
  0xFF, 0xFF, 0xE3, 0xC7, 0xCF, 0xFF, 0xFF, 0x3F, 0x07, 0xFF, 0xFC, 0xFC,
  0x07, 0xFF, 0xE3, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x30, 0x07, 0xFC, 0x00, 0x7C, 0x1F,
  0xFC, 0x01, 0xF0, 0x7F, 0xF8, 0x03, 0xE1, 0xFF, 0xF8, 0x07, 0xC7, 0xE3,
  0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x7C, 0x03,
  0xFF, 0xF0, 0xF8, 0x07, 0xFF, 0xC3, 0xE0, 0x07, 0xFF, 0x07, 0xC0, 0x07,
  0xFC, 0x03, 0x80, 0x03, 0xE0, 0x00,
};

const GFXglyph IBMPlexMono_MediumItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 15, 41, 34, 10, -40 },
  { 78, 19, 17, 34, 11, -42 },
  { 119, 36, 40, 34, 0, -40 },
  { 299, 33, 53, 34, 1, -46 },
  { 518, 40, 41, 34, -2, -40 },
  { 723, 34, 41, 34, 0, -40 },
  { 898, 8, 17, 34, 16, -42 },
  { 915, 22, 51, 34, 11, -43 },
  { 1056, 22, 51, 34, 2, -43 },
  { 1197, 29, 28, 34, 3, -31 },
  { 1299, 27, 27, 34, 4, -31 },
  { 1391, 15, 17, 34, 7, -9 },
  { 1423, 19, 6, 34, 8, -20 },
  { 1438, 10, 9, 34, 10, -8 },
  { 1450, 33, 51, 34, 1, -43 },
  { 1661, 30, 41, 34, 3, -40 },
  { 1815, 27, 40, 34, 3, -40 },
  { 1950, 31, 40, 34, 1, -40 },
  { 2105, 31, 41, 34, 1, -40 },
  { 2264, 31, 40, 34, 1, -40 },
  { 2419, 31, 41, 34, 2, -40 },
  { 2578, 28, 41, 34, 3, -40 },
  { 2722, 30, 40, 34, 5, -40 },
  { 2872, 31, 41, 34, 2, -40 },
  { 3031, 29, 40, 34, 4, -40 },
  { 3176, 14, 30, 34, 10, -29 },
  { 3229, 17, 37, 34, 7, -29 },
  { 3308, 27, 33, 34, 5, -34 },
  { 3420, 29, 17, 34, 3, -26 },
  { 3482, 27, 33, 34, 3, -34 },
  { 3594, 25, 41, 34, 7, -40 },
  { 3723, 30, 46, 34, 3, -40 },
  { 3896, 32, 40, 34, -1, -40 },
  { 4056, 30, 40, 34, 2, -40 },
  { 4206, 30, 41, 34, 4, -40 },
  { 4360, 31, 40, 34, 2, -40 },
  { 4515, 32, 40, 34, 2, -40 },
  { 4675, 33, 40, 34, 2, -40 },
  { 4840, 30, 41, 34, 3, -40 },
  { 4994, 32, 40, 34, 2, -40 },
  { 5154, 32, 40, 34, 2, -40 },
  { 5314, 29, 41, 34, 3, -40 },
  { 5463, 35, 40, 34, 2, -40 },
  { 5638, 25, 40, 34, 4, -40 },
  { 5763, 34, 40, 34, 1, -40 },
  { 5933, 32, 40, 34, 2, -40 },
  { 6093, 30, 41, 34, 3, -40 },
  { 6247, 32, 40, 34, 2, -40 },
  { 6407, 30, 51, 34, 3, -40 },
  { 6599, 32, 40, 34, 2, -40 },
  { 6759, 33, 41, 34, 1, -40 },
  { 6929, 32, 40, 34, 5, -40 },
  { 7089, 30, 41, 34, 4, -40 },
  { 7243, 31, 40, 34, 6, -40 },
  { 7398, 35, 40, 34, 2, -40 },
  { 7573, 38, 40, 34, -1, -40 },
  { 7763, 33, 40, 34, 5, -40 },
  { 7928, 35, 40, 34, 0, -40 },
  { 8103, 25, 51, 34, 8, -43 },
  { 8263, 15, 51, 34, 10, -43 },
  { 8359, 25, 51, 34, 1, -43 },
  { 8519, 30, 24, 34, 3, -40 },
  { 8609, 28, 5, 34, 0, 5 },
  { 8627, 9, 12, 34, 12, -45 },
  { 8641, 28, 31, 34, 3, -30 },
  { 8750, 29, 43, 34, 2, -42 },
  { 8906, 26, 31, 34, 4, -30 },
  { 9007, 31, 43, 34, 3, -42 },
  { 9174, 27, 31, 34, 4, -30 },
  { 9279, 38, 54, 34, -1, -42 },
  { 9536, 31, 42, 34, 1, -30 },
  { 9699, 27, 42, 34, 3, -42 },
  { 9841, 27, 43, 34, 4, -42 },
  { 9987, 28, 54, 34, 2, -42 },
  { 10176, 30, 43, 34, 3, -42 },
  { 10338, 24, 43, 34, 6, -42 },
  { 10467, 33, 30, 34, 0, -30 },
  { 10591, 27, 30, 34, 3, -30 },
  { 10693, 28, 31, 34, 3, -30 },
  { 10802, 31, 41, 34, 0, -30 },
  { 10961, 29, 41, 34, 3, -30 },
  { 11110, 28, 29, 34, 6, -29 },
  { 11212, 28, 31, 34, 3, -30 },
  { 11321, 27, 41, 34, 4, -40 },
  { 11460, 28, 30, 34, 4, -29 },
  { 11565, 28, 31, 34, 3, -30 },
  { 11674, 31, 31, 34, 2, -30 },
  { 11795, 34, 31, 34, 0, -30 },
  { 11927, 31, 41, 34, 1, -29 },
  { 12086, 30, 31, 34, 2, -30 },
  { 12203, 27, 51, 34, 6, -43 },
  { 12376, 14, 51, 34, 11, -43 },
  { 12466, 27, 51, 34, 2, -43 },
  { 12639, 31, 13, 34, 2, -24 },
};

const GFXfont IBMPlexMono_MediumItalic57pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic57pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic57pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _IBMPLEXMONO_MEDIUMITALIC57PT7B_H_
