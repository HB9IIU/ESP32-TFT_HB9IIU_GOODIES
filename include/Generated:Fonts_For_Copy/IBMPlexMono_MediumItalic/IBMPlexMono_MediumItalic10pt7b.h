#ifndef _IBMPLEXMONO_MEDIUMITALIC10PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x38, 0xB6, 0x80, 0x14, 0xA6, 0xCA, 0xDD, 0x47, 0x00, 0x10,
  0xE5, 0xD4, 0x38, 0xAA, 0x9E, 0x20, 0x66, 0xB2, 0x43, 0xC1, 0x4C, 0xA6,
  0x00, 0x38, 0xA2, 0x9C, 0x92, 0x5E, 0x80, 0xE0, 0x34, 0x48, 0x88, 0x88,
  0x40, 0x21, 0x11, 0x11, 0x12, 0xC0, 0x12, 0x57, 0x8C, 0x48, 0x21, 0x3E,
  0x84, 0x00, 0x6A, 0x00, 0xF0, 0xE0, 0x04, 0x20, 0x84, 0x10, 0x84, 0x10,
  0x80, 0x74, 0x63, 0x5D, 0x4B, 0x80, 0x3B, 0x94, 0x21, 0x0B, 0xE0, 0x39,
  0x30, 0xC2, 0x31, 0x0F, 0x80, 0x39, 0x30, 0x8C, 0x0A, 0x27, 0x00, 0x08,
  0x62, 0x92, 0x4B, 0xF1, 0x00, 0x3D, 0x07, 0x92, 0x09, 0x2F, 0x00, 0x34,
  0xF9, 0x99, 0xE0, 0xFC, 0xC4, 0x42, 0x23, 0x00, 0x39, 0x14, 0xCC, 0x4B,
  0x27, 0x80, 0x74, 0x63, 0x3F, 0x13, 0x00, 0x70, 0xE0, 0x2C, 0x06, 0xA0,
  0x09, 0xB1, 0x86, 0x08, 0x7C, 0x0F, 0x80, 0x41, 0x82, 0x36, 0x40, 0x74,
  0xC4, 0xC0, 0x21, 0x00, 0x39, 0x15, 0xD9, 0xAA, 0xE4, 0x1C, 0x19, 0x4A,
  0x97, 0xE6, 0x20, 0x79, 0x14, 0x9C, 0x49, 0x2F, 0x80, 0x76, 0x61, 0x08,
  0x4B, 0x80, 0x39, 0x34, 0x51, 0x4D, 0x2F, 0x00, 0x3D, 0x04, 0x1E, 0x41,
  0x0F, 0x80, 0x3D, 0x04, 0x1E, 0x41, 0x0C, 0x00, 0x76, 0x61, 0x69, 0x4B,
  0xC0, 0x65, 0x14, 0xDE, 0x49, 0x28, 0x80, 0x7C, 0x41, 0x04, 0x30, 0x8F,
  0x80, 0x3C, 0x20, 0x82, 0x0B, 0x67, 0x00, 0x66, 0x91, 0x43, 0x85, 0x09,
  0x32, 0x00, 0x44, 0xC8, 0x88, 0xF0, 0x65, 0xB7, 0x55, 0x6A, 0x28, 0x80,
  0x65, 0x96, 0x56, 0x59, 0x69, 0x80, 0x74, 0x63, 0x19, 0xCB, 0x80, 0x39,
  0x14, 0x5E, 0x41, 0x0C, 0x00, 0x74, 0x63, 0x19, 0xCB, 0x86, 0x38, 0x39,
  0x14, 0x5E, 0x51, 0x6C, 0x80, 0x39, 0x34, 0x0E, 0x0A, 0x27, 0x00, 0xF9,
  0x08, 0x46, 0x21, 0x00, 0xCC, 0x63, 0x29, 0x4B, 0x80, 0x8C, 0x65, 0x26,
  0x31, 0x80, 0x45, 0x15, 0x5D, 0xBB, 0x6D, 0x80, 0x44, 0xA3, 0x8C, 0x31,
  0x28, 0x80, 0x8F, 0x65, 0x18, 0x61, 0x04, 0x00, 0x7C, 0x31, 0x8C, 0x21,
  0x0F, 0x80, 0x39, 0x10, 0x84, 0x21, 0x08, 0xF0, 0xAA, 0x55, 0x40, 0x38,
  0x84, 0x21, 0x08, 0x44, 0xE0, 0x22, 0xB5, 0x10, 0xF8, 0x90, 0x7D, 0x24,
  0xB2, 0x78, 0x21, 0x05, 0x9A, 0x4D, 0x2F, 0x00, 0x79, 0x89, 0xE0, 0x04,
  0x13, 0xD2, 0x4B, 0x27, 0x80, 0x79, 0xF9, 0xE0, 0x1C, 0x47, 0xC4, 0x10,
  0xC2, 0x28, 0x60, 0x3D, 0x24, 0xB2, 0x7A, 0x67, 0x00, 0x23, 0x16, 0xD4,
  0xA7, 0x20, 0x20, 0xE4, 0x45, 0x60, 0x08, 0x0E, 0x31, 0x0A, 0x4A, 0x20,
  0x21, 0x05, 0x9A, 0x51, 0xDD, 0x80, 0xE2, 0x44, 0x47, 0x60, 0x7D, 0x5A,
  0x6A, 0xA8, 0x5B, 0x52, 0x9C, 0x80, 0x79, 0x99, 0xE0, 0x59, 0xA4, 0xD2,
  0xF2, 0x08, 0x00, 0x3D, 0x24, 0xB2, 0x78, 0x21, 0x00, 0xFB, 0x10, 0x84,
  0x00, 0x3A, 0x1E, 0x1F, 0x00, 0x24, 0xF4, 0x45, 0x60, 0x9C, 0xA5, 0x2F,
  0x00, 0xD9, 0x9B, 0xE0, 0x55, 0x59, 0x7A, 0xF8, 0x6F, 0x53, 0x2F, 0xD8,
  0x4D, 0x24, 0x92, 0x7A, 0x6F, 0x00, 0x75, 0x23, 0x12, 0xB8, 0x39, 0x08,
  0x4C, 0x11, 0x08, 0x60, 0x55, 0x6A, 0x80, 0x30, 0x84, 0x41, 0x90, 0x84,
  0xE0, 0x66, 0x60,
};

const GFXglyph IBMPlexMono_MediumItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 3, 3, 6, 2, -7 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 6, 9, 6, 0, -8 },
  { 18, 7, 7, 6, 0, -7 },
  { 25, 6, 7, 6, 0, -7 },
  { 31, 1, 3, 6, 3, -7 },
  { 32, 4, 9, 6, 2, -8 },
  { 37, 4, 9, 6, 0, -8 },
  { 42, 6, 5, 6, 0, -5 },
  { 46, 5, 5, 6, 1, -6 },
  { 50, 3, 3, 6, 1, -2 },
  { 52, 4, 1, 6, 1, -4 },
  { 53, 2, 2, 6, 2, -2 },
  { 54, 6, 9, 6, 0, -8 },
  { 61, 5, 7, 6, 1, -7 },
  { 66, 5, 7, 6, 0, -7 },
  { 71, 6, 7, 6, 0, -7 },
  { 77, 6, 7, 6, 0, -7 },
  { 83, 6, 7, 6, 0, -7 },
  { 89, 6, 7, 6, 0, -7 },
  { 95, 4, 7, 6, 1, -7 },
  { 99, 5, 7, 6, 1, -7 },
  { 104, 6, 7, 6, 0, -7 },
  { 110, 5, 7, 6, 1, -7 },
  { 115, 2, 6, 6, 2, -6 },
  { 117, 3, 7, 6, 1, -6 },
  { 120, 5, 6, 6, 1, -6 },
  { 124, 6, 3, 6, 0, -5 },
  { 127, 5, 6, 6, 0, -6 },
  { 131, 5, 7, 6, 1, -7 },
  { 136, 6, 8, 6, 0, -7 },
  { 142, 5, 7, 6, 0, -7 },
  { 147, 6, 7, 6, 0, -7 },
  { 153, 5, 7, 6, 1, -7 },
  { 158, 6, 7, 6, 0, -7 },
  { 164, 6, 7, 6, 0, -7 },
  { 170, 6, 7, 6, 0, -7 },
  { 176, 5, 7, 6, 1, -7 },
  { 181, 6, 7, 6, 0, -7 },
  { 187, 6, 7, 6, 0, -7 },
  { 193, 6, 7, 6, 0, -7 },
  { 199, 7, 7, 6, 0, -7 },
  { 206, 4, 7, 6, 1, -7 },
  { 210, 6, 7, 6, 0, -7 },
  { 216, 6, 7, 6, 0, -7 },
  { 222, 5, 7, 6, 1, -7 },
  { 227, 6, 7, 6, 0, -7 },
  { 233, 5, 9, 6, 1, -7 },
  { 239, 6, 7, 6, 0, -7 },
  { 245, 6, 7, 6, 0, -7 },
  { 251, 5, 7, 6, 1, -7 },
  { 256, 5, 7, 6, 1, -7 },
  { 261, 5, 7, 6, 1, -7 },
  { 266, 6, 7, 6, 0, -7 },
  { 272, 6, 7, 6, 0, -7 },
  { 278, 6, 7, 6, 1, -7 },
  { 284, 6, 7, 6, 0, -7 },
  { 290, 5, 9, 6, 1, -8 },
  { 296, 2, 9, 6, 2, -8 },
  { 299, 5, 9, 6, 0, -8 },
  { 305, 5, 4, 6, 1, -7 },
  { 308, 5, 1, 6, 0, 1 },
  { 309, 2, 2, 6, 2, -8 },
  { 310, 6, 5, 6, 0, -5 },
  { 314, 6, 7, 6, 0, -7 },
  { 320, 4, 5, 6, 1, -5 },
  { 323, 6, 7, 6, 0, -7 },
  { 329, 4, 5, 6, 1, -5 },
  { 332, 6, 9, 6, 0, -7 },
  { 339, 6, 7, 6, 0, -5 },
  { 345, 5, 7, 6, 0, -7 },
  { 350, 4, 7, 6, 1, -7 },
  { 354, 5, 9, 6, 0, -7 },
  { 360, 6, 7, 6, 0, -7 },
  { 366, 4, 7, 6, 1, -7 },
  { 370, 6, 5, 6, 0, -5 },
  { 374, 5, 5, 6, 0, -5 },
  { 378, 4, 5, 6, 1, -5 },
  { 381, 6, 7, 6, 0, -5 },
  { 387, 6, 7, 6, 0, -5 },
  { 393, 5, 5, 6, 1, -5 },
  { 397, 5, 5, 6, 0, -5 },
  { 401, 4, 7, 6, 1, -7 },
  { 405, 5, 5, 6, 1, -5 },
  { 409, 4, 5, 6, 1, -5 },
  { 412, 6, 5, 6, 0, -5 },
  { 416, 6, 5, 6, 0, -5 },
  { 420, 6, 7, 6, 0, -5 },
  { 426, 6, 5, 6, 0, -5 },
  { 430, 5, 9, 6, 1, -8 },
  { 436, 2, 9, 6, 2, -8 },
  { 439, 5, 9, 6, 0, -8 },
  { 445, 6, 2, 6, 0, -4 },
};

const GFXfont IBMPlexMono_MediumItalic10pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic10pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _IBMPLEXMONO_MEDIUMITALIC10PT7B_H_
