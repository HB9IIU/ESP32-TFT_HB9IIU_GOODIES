#ifndef _IBMPLEXMONO_MEDIUMITALIC59PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xFE,
  0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x01, 0xF8, 0x00, 0x1F, 0x83, 0xF1, 0xF0, 0x3F, 0x3F, 0x03, 0xF3, 0xF0,
  0x3F, 0x3F, 0x03, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xE0, 0x7E, 0x7E,
  0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7,
  0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0x8F, 0xC1, 0xF8,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7F, 0xFE, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0xF3,
  0xFE, 0x03, 0xFC, 0x3C, 0x3F, 0xC0, 0xFE, 0x0F, 0x07, 0xC0, 0x7F, 0x03,
  0xC0, 0xE0, 0x1F, 0xC0, 0xF0, 0x20, 0x07, 0xE0, 0x7C, 0x00, 0x01, 0xF8,
  0x1F, 0x00, 0x00, 0x7E, 0x07, 0x80, 0x00, 0x1F, 0x81, 0xE0, 0x00, 0x07,
  0xF0, 0x78, 0x00, 0x01, 0xFC, 0x1E, 0x00, 0x00, 0x7F, 0x8F, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1E, 0xFF, 0xC0, 0x00, 0x07,
  0x8F, 0xF0, 0x00, 0x01, 0xE0, 0xFE, 0x00, 0x00, 0x78, 0x3F, 0x80, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x03, 0xC0, 0x7E, 0x00,
  0x00, 0xF0, 0x1F, 0x80, 0x00, 0x3C, 0x0F, 0xE0, 0x20, 0x0F, 0x03, 0xF8,
  0x3C, 0x03, 0xC1, 0xFC, 0x1F, 0x81, 0xF0, 0x7F, 0x0F, 0xF8, 0x7C, 0x7F,
  0x81, 0xFF, 0x9E, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0xC0, 0x07,
  0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x07, 0xC1, 0xF8,
  0x00, 0xF8, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0xF8, 0x00, 0x3E,
  0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x01, 0xF8, 0x7C, 0x00, 0x07, 0xC1, 0xF8,
  0x7C, 0x00, 0x03, 0xFF, 0xFC, 0x7E, 0x00, 0x01, 0xFF, 0xFC, 0x3E, 0x00,
  0x00, 0x7F, 0xFC, 0x3E, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xC3, 0xFF, 0xC0,
  0x00, 0x0F, 0xC3, 0xFF, 0xF0, 0x00, 0x07, 0xC3, 0xFF, 0xF8, 0x00, 0x07,
  0xC3, 0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xF0, 0x1F, 0x00, 0x03, 0xE1, 0xF8,
  0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x03, 0xE0,
  0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0xF8, 0x01, 0xF0,
  0x0F, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0x00,
  0x7C, 0x00, 0x3F, 0xFF, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0x00, 0x3E, 0x00,
  0x07, 0xFF, 0x00, 0x20, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0xE7, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xF9, 0xFE,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x00,
  0x07, 0xF0, 0x03, 0xF0, 0x08, 0xFE, 0x00, 0x7E, 0x03, 0xDF, 0xC0, 0x0F,
  0xE0, 0xFF, 0xF8, 0x03, 0xFC, 0x1F, 0x3F, 0x00, 0x6F, 0xC7, 0xE7, 0xF0,
  0x1D, 0xF8, 0xF8, 0xFF, 0x07, 0x3F, 0xBE, 0x0F, 0xFF, 0xE3, 0xFF, 0xC1,
  0xFF, 0xF8, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x30, 0x07, 0xE0, 0x0C, 0x78,
  0x0F, 0xC0, 0xF9, 0xFE, 0x1F, 0x8F, 0xF3, 0xFF, 0xBE, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x43, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x7F, 0x3F,
  0x80, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC0, 0x7E,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7E, 0x01,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8,
  0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0x80, 0x1F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xC0, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7E, 0x0F, 0xE0,
  0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xF8, 0xFE, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0xFD, 0xFC, 0x0F, 0x03, 0xFB, 0xF8, 0x7F, 0x07, 0xF7, 0xE0, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFC, 0x1F, 0xFF, 0x83, 0xF8, 0x3F, 0xFF, 0x07, 0xF0, 0x7E,
  0xFE, 0x07, 0xC1, 0xFD, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7F, 0x3F,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x03, 0xF0,
  0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xF7, 0xF0, 0x01,
  0xFE, 0x7E, 0x00, 0x3F, 0xC7, 0xE0, 0x07, 0xF8, 0x7E, 0x00, 0xFF, 0x0F,
  0xE0, 0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0x80, 0xFC, 0x00,
  0xE0, 0x0F, 0xC0, 0x04, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0x03, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x40,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0x03, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0xE0,
  0x00, 0x7F, 0x00, 0x40, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x0C, 0x00, 0x03, 0xF8, 0x3C, 0x00, 0x07, 0xF8, 0x7E, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xC1, 0xFE, 0x00, 0x07, 0xC7, 0xFF, 0x80, 0x0F, 0xCF,
  0xFF, 0xC0, 0x0F, 0xDF, 0xFF, 0xE0, 0x0F, 0xBF, 0xFF, 0xF0, 0x0F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x0C, 0x00,
  0x03, 0xF8, 0x3C, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x1F, 0xC7, 0xFF, 0x80, 0xFC, 0x7F, 0xFE, 0x0F, 0xEF, 0xFF, 0xF8, 0x7E,
  0xFF, 0xFF, 0xE7, 0xF7, 0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xFD, 0xFE, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7E, 0xFE, 0x00,
  0x07, 0xF3, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x3F,
  0x83, 0xFC, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xC0, 0x00, 0x3F, 0x9F, 0x80,
  0x00, 0xFE, 0x3F, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x0F, 0xE1, 0xF0, 0x00, 0x3F, 0x83, 0xE0, 0x00, 0xFF, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0x03, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xFC,
  0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x00,
  0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFF, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0xFE, 0x7F,
  0x00, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xBF,
  0x80, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x03, 0xFF, 0x3F, 0xE0,
  0x7B, 0xF1, 0xFF, 0xFF, 0xBF, 0x87, 0xFF, 0xFD, 0xFC, 0x1F, 0xFF, 0x9F,
  0xC0, 0x7F, 0xF8, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0x83, 0xFF, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xF0,
  0x3F, 0xE7, 0xF8, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xDF,
  0x00, 0x07, 0xF0, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xC0,
  0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0x7C, 0x1F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01,
  0xF1, 0xF8, 0x07, 0xC3, 0xE3, 0xE0, 0x3F, 0xC7, 0xCF, 0xC0, 0xFF, 0xDF,
  0x9F, 0x83, 0xFF, 0xFE, 0x3E, 0x0F, 0xFF, 0xFC, 0x7C, 0x1F, 0xC3, 0xF9,
  0xF8, 0x7F, 0x03, 0xF3, 0xF0, 0xFC, 0x07, 0xE7, 0xE1, 0xF0, 0x07, 0xCF,
  0x87, 0xE0, 0x1F, 0x9F, 0x0F, 0xC0, 0x3E, 0x3E, 0x1F, 0x80, 0x7C, 0xFC,
  0x3E, 0x00, 0xF9, 0xF8, 0x7C, 0x01, 0xF3, 0xF0, 0xF8, 0x07, 0xE7, 0xC1,
  0xF0, 0x0F, 0xCF, 0x83, 0xE0, 0x1F, 0x1F, 0x07, 0xC0, 0x7E, 0x3E, 0x0F,
  0x80, 0xFC, 0x7C, 0x1F, 0x82, 0xF8, 0xF8, 0x3F, 0x9F, 0xF1, 0xF0, 0x7F,
  0xF7, 0xE3, 0xE0, 0x7F, 0xEF, 0x87, 0xC0, 0xFF, 0x9F, 0x0F, 0x80, 0xFE,
  0x3E, 0x1F, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFE,
  0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x07,
  0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xF8, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xFE,
  0x0F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x01,
  0xF9, 0xFC, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0x00,
  0x7F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x07,
  0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0,
  0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x1F,
  0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x7E, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0x7E, 0x00,
  0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0xC3, 0xF8, 0x01, 0xFF, 0x87, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xE0,
  0xFE, 0x00, 0x04, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x80, 0x7F, 0x00, 0x01, 0xE0, 0xFE, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE,
  0x07, 0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xF8, 0x07, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F,
  0x0F, 0xC0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE,
  0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC,
  0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xE0,
  0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x00, 0x7F,
  0x03, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC,
  0x3F, 0x80, 0x01, 0xE0, 0xFE, 0x00, 0x04, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xFF, 0x1F, 0xC0,
  0x7F, 0xFE, 0x3F, 0x00, 0xFF, 0xFC, 0xFE, 0x01, 0xFF, 0xF9, 0xFC, 0x03,
  0xFF, 0xF3, 0xF8, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x0F, 0x8F, 0xE0, 0x00,
  0x3F, 0x1F, 0xC0, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0x7E, 0x07, 0xFC, 0x1E, 0xFC,
  0x07, 0xFF, 0xF9, 0xF8, 0x0F, 0xFF, 0xE7, 0xE0, 0x0F, 0xFF, 0xCF, 0xC0,
  0x07, 0xFE, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x81, 0xFC, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07,
  0xF0, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xC0, 0x00,
  0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0x3F, 0x81, 0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0xC0,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x7F, 0x03, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x03, 0xF8, 0x1F,
  0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x07,
  0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x02, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xC0, 0x00, 0xFF, 0x00,
  0x7E, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x00, 0x7E,
  0x00, 0x7F, 0x80, 0x03, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x80,
  0x01, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x7E, 0x07,
  0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0x87, 0xF8, 0x00, 0x01,
  0xFC, 0x7F, 0x80, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x80,
  0x00, 0x03, 0xF3, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xBF, 0x80, 0x00, 0x1F, 0xF8, 0xFE, 0x00, 0x00, 0xFF, 0x87,
  0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x03, 0xFC, 0x0F,
  0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFE,
  0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xBE,
  0x0F, 0xBF, 0x03, 0xE7, 0xC3, 0xE7, 0xE0, 0x7C, 0xF8, 0x7C, 0xF8, 0x1F,
  0x9F, 0x1F, 0x1F, 0x03, 0xF3, 0xF7, 0xE7, 0xE0, 0x7E, 0x3E, 0xF8, 0xFC,
  0x0F, 0xC7, 0xFF, 0x1F, 0x81, 0xF0, 0xFF, 0xC3, 0xF0, 0x3E, 0x1F, 0xF8,
  0x7C, 0x0F, 0xC1, 0xFE, 0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x07,
  0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F,
  0x01, 0xE0, 0x3E, 0x07, 0xE0, 0x3C, 0x0F, 0xC0, 0xFC, 0x07, 0x01, 0xF8,
  0x1F, 0x80, 0xC0, 0x3F, 0x03, 0xF0, 0x08, 0x07, 0xE0, 0x7E, 0x02, 0x00,
  0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0x81, 0xFF, 0x00, 0x0F, 0xC0, 0xFF,
  0xC0, 0x07, 0xE0, 0x7F, 0xE0, 0x03, 0xF0, 0x3F, 0xF0, 0x01, 0xF8, 0x1F,
  0xF8, 0x00, 0xFC, 0x0F, 0xFE, 0x00, 0x7C, 0x0F, 0xFF, 0x00, 0x7E, 0x07,
  0xFF, 0x80, 0x3F, 0x03, 0xF7, 0xC0, 0x1F, 0x81, 0xFB, 0xE0, 0x0F, 0xC0,
  0xFD, 0xF8, 0x07, 0xE0, 0x7C, 0xFC, 0x03, 0xE0, 0x7E, 0x7E, 0x03, 0xF0,
  0x3F, 0x1F, 0x01, 0xF8, 0x1F, 0x8F, 0x80, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E,
  0x07, 0xE3, 0xF0, 0x3F, 0x03, 0xE1, 0xF8, 0x1F, 0x03, 0xF0, 0x7C, 0x1F,
  0x81, 0xF8, 0x3E, 0x0F, 0xC0, 0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x0F, 0xC3,
  0xF0, 0x3F, 0x07, 0xE1, 0xF8, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x80, 0xF8,
  0xFC, 0x0F, 0xC0, 0x7E, 0x7E, 0x07, 0xE0, 0x3F, 0x3F, 0x03, 0xF0, 0x1F,
  0x9F, 0x81, 0xF8, 0x07, 0xCF, 0xC0, 0xF8, 0x03, 0xEF, 0xC0, 0xFC, 0x01,
  0xFF, 0xE0, 0x7E, 0x00, 0xFF, 0xF0, 0x3F, 0x00, 0x3F, 0xF8, 0x1F, 0x80,
  0x1F, 0xFC, 0x0F, 0xC0, 0x0F, 0xFE, 0x07, 0xC0, 0x07, 0xFE, 0x07, 0xE0,
  0x03, 0xFF, 0x03, 0xF0, 0x00, 0xFF, 0x81, 0xF8, 0x00, 0x7F, 0xC0, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0xC0, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x07,
  0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xF0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xFE, 0x1F,
  0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0xFE,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0xC0,
  0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0x3F, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFE, 0x7F,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x07, 0xF8,
  0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFC,
  0x01, 0x80, 0x01, 0xFC, 0x07, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC,
  0x7E, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x01,
  0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00,
  0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0xFE, 0x0F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xFE, 0x1F, 0xC0, 0x03,
  0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x7C, 0x03, 0xF8, 0x00, 0x0E, 0x01,
  0xFC, 0x00, 0x02, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x02, 0x00, 0x00, 0x7F, 0x03, 0xC0, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x1F, 0xF8,
  0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xE0,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0xC0,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x1F, 0x80,
  0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x80,
  0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x3F, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0x7F, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x7F, 0x80, 0x7F, 0x81, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x01, 0xFC, 0x7E, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF8, 0x7E, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0x7F, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x0F, 0xDF,
  0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x80,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x01, 0xFC, 0x0F, 0xC1,
  0xF0, 0x3F, 0xC0, 0xF8, 0x1F, 0x03, 0xFC, 0x0F, 0x83, 0xF0, 0x3F, 0xC1,
  0xF8, 0x3F, 0x07, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0xC1, 0xF0, 0x3F, 0x07,
  0xFC, 0x1F, 0x03, 0xF0, 0xFF, 0xC1, 0xF0, 0x3E, 0x0F, 0x7C, 0x3F, 0x03,
  0xE0, 0xF7, 0xC3, 0xF0, 0x3E, 0x1F, 0x7C, 0x3E, 0x03, 0xE1, 0xE7, 0xC3,
  0xE0, 0x3E, 0x1E, 0x7C, 0x7E, 0x07, 0xE3, 0xE7, 0xC7, 0xE0, 0x7E, 0x3C,
  0x7C, 0x7C, 0x07, 0xE3, 0xC7, 0xC7, 0xC0, 0x7E, 0x7C, 0x7C, 0x7C, 0x07,
  0xE7, 0x87, 0xCF, 0xC0, 0x7C, 0x78, 0x7C, 0xF8, 0x07, 0xCF, 0x87, 0xCF,
  0x80, 0x7C, 0xF0, 0x7C, 0xF8, 0x07, 0xDF, 0x07, 0xDF, 0x80, 0x7D, 0xF0,
  0x7D, 0xF0, 0x07, 0xDE, 0x07, 0xDF, 0x00, 0xFF, 0xE0, 0x7D, 0xF0, 0x0F,
  0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x00, 0xFD, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x00, 0x3F, 0xDF, 0x80, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x03,
  0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x7E,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0x9E, 0x00, 0x00, 0x3C, 0x08, 0x00,
  0x00, 0x20, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x1F, 0x8F,
  0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xE0, 0x7C, 0x18,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0x87, 0xF0, 0x1F, 0xFF, 0x1F, 0x81,
  0xFF, 0xFE, 0x7E, 0x07, 0xFF, 0xF9, 0xF8, 0x3F, 0xE0, 0x7F, 0xE1, 0xFE,
  0x00, 0xFF, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00,
  0x0F, 0xC7, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x01, 0xF8,
  0xFE, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0xFE, 0x3F,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7F, 0x0F, 0xC0,
  0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0xC3, 0xFC, 0x03,
  0x7E, 0x07, 0xF8, 0x3D, 0xFF, 0x9F, 0xFF, 0xE7, 0xFE, 0x3F, 0xFF, 0x1F,
  0xF8, 0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0xC0, 0x7F, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0xF8, 0x03, 0xF0,
  0xFF, 0xF8, 0x07, 0xE3, 0xFF, 0xF8, 0x0F, 0xCF, 0xFF, 0xF0, 0x1F, 0xBC,
  0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0xE0, 0xFF, 0x80, 0x1F, 0xC1, 0xFE, 0x00,
  0x1F, 0x83, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x00,
  0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7F, 0x0F,
  0xF0, 0x01, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0x70, 0x3F, 0xE0, 0x7E,
  0xFF, 0xFF, 0xC0, 0xFC, 0xFF, 0xFF, 0x01, 0xF8, 0xFF, 0xFC, 0x07, 0xF0,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xF0, 0x3F, 0xC3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x3F, 0x80,
  0x03, 0x07, 0xE0, 0x00, 0x81, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x21, 0xF8, 0x00, 0x0F, 0x3F, 0x80, 0x03,
  0xF7, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x8F, 0xE0, 0x0F, 0xF0, 0xFF,
  0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0xFF, 0xF0, 0xFC, 0x01, 0xFF, 0xF9, 0xFC, 0x03,
  0xFF, 0xF9, 0xFC, 0x07, 0xFF, 0xFD, 0xF8, 0x0F, 0xF8, 0x1D, 0xF8, 0x1F,
  0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F,
  0x80, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x6F, 0xC0, 0xFF, 0x00, 0xEF, 0xC0, 0x7F, 0x83, 0xDF, 0xC0, 0x7F,
  0xFF, 0xDF, 0xC0, 0x3F, 0xFF, 0x9F, 0x80, 0x1F, 0xFF, 0x1F, 0x80, 0x0F,
  0xFE, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0x80, 0xFE, 0x0F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x3F,
  0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0xFE, 0x7E, 0x00, 0x3F, 0xEF, 0xE0, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x20,
  0xFE, 0x00, 0x07, 0x8F, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xC7, 0xF0,
  0x03, 0xF8, 0x7F, 0xC0, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x80, 0x1F, 0x80, 0x00, 0x03, 0x80, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x00, 0x7F, 0x8F,
  0xC0, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x3F, 0x00, 0x7F, 0xFE,
  0x7F, 0x01, 0xFF, 0xFE, 0x7F, 0x01, 0xFF, 0xFF, 0x7E, 0x03, 0xFE, 0x07,
  0x7E, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0xC0, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01,
  0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0x80, 0x1F,
  0xF0, 0x1F, 0xC0, 0x3B, 0xF0, 0x1F, 0xE0, 0xF3, 0xF0, 0x1F, 0xFF, 0xF7,
  0xF0, 0x0F, 0xFF, 0xE7, 0xF0, 0x07, 0xFF, 0xC7, 0xE0, 0x03, 0xFF, 0x87,
  0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x08, 0x00, 0x3F, 0x80, 0x1C, 0x00, 0x7F, 0x80, 0x3F, 0x01, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE1,
  0xFF, 0x80, 0xFE, 0x3F, 0xFC, 0x0F, 0xE7, 0xFF, 0xE0, 0xFC, 0xFF, 0xFF,
  0x0F, 0xDE, 0x0F, 0xF0, 0xFD, 0x80, 0x7F, 0x0F, 0xF0, 0x03, 0xF1, 0xFF,
  0x00, 0x3F, 0x1F, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x03,
  0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF3, 0xF8, 0x00, 0x7F, 0x3F,
  0x80, 0x07, 0xF3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x7E, 0x3F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00,
  0x0F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xF8,
  0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x08, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x18, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC1,
  0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0x87, 0xF0, 0x01, 0xF8, 0xFE, 0x00,
  0x1F, 0x9F, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x02, 0x00, 0x7E, 0x00, 0x30, 0x03, 0xF0,
  0x03, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07,
  0xF0, 0x7F, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFF, 0x1F, 0x80, 0x03, 0xF8,
  0xFC, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0xF0, 0x07, 0xF1,
  0xFF, 0xF0, 0x0F, 0xE7, 0xFF, 0xE0, 0x1F, 0x9F, 0xFF, 0xE0, 0x3F, 0x78,
  0x3F, 0xC0, 0x7E, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x7E, 0x07, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x03,
  0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0xC0, 0x0F, 0xC3, 0xFE, 0x00,
  0x1F, 0x9F, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x01,
  0xFC, 0x3F, 0x00, 0x63, 0xF0, 0x7F, 0x01, 0xE7, 0xE0, 0x7E, 0x07, 0xEF,
  0xC0, 0xFC, 0x1F, 0x9F, 0x81, 0xFC, 0x7E, 0x7F, 0x01, 0xF9, 0xF8, 0xFE,
  0x03, 0xFF, 0xF1, 0xF8, 0x03, 0xFF, 0x83, 0xF0, 0x07, 0xFE, 0x07, 0xE0,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x10, 0x0F, 0xC0, 0x1C, 0x07,
  0xE0, 0x1F, 0x07, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xC1, 0xF8, 0x1F, 0xC0,
  0xFC, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x1F, 0xBF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x01, 0xF9, 0xFC, 0x1F,
  0xE0, 0x7C, 0xFF, 0x8F, 0xF8, 0x1F, 0x7F, 0xE7, 0xFF, 0x07, 0xDF, 0xFB,
  0xFF, 0xC3, 0xFC, 0x7E, 0xE3, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC, 0x3F, 0x03,
  0xF8, 0x1F, 0x0F, 0xC0, 0xFC, 0x07, 0xC3, 0xE0, 0x3F, 0x03, 0xF0, 0xF8,
  0x0F, 0x80, 0xFC, 0x7E, 0x03, 0xE0, 0x3F, 0x1F, 0x80, 0xF8, 0x0F, 0x87,
  0xC0, 0x7E, 0x03, 0xE1, 0xF0, 0x1F, 0x80, 0xF8, 0x7C, 0x07, 0xC0, 0x3E,
  0x1F, 0x01, 0xF0, 0x1F, 0x8F, 0xC0, 0x7C, 0x07, 0xE3, 0xF0, 0x1F, 0x01,
  0xF0, 0xF8, 0x0F, 0xC0, 0x7C, 0x3E, 0x03, 0xF0, 0x1F, 0x0F, 0x80, 0xF8,
  0x0F, 0xC3, 0xE0, 0x3E, 0x03, 0xF1, 0xF8, 0x0F, 0x80, 0xFC, 0x7E, 0x03,
  0xE0, 0x3E, 0x1F, 0x01, 0xF8, 0x0F, 0x87, 0xC0, 0x7E, 0x03, 0xE1, 0xF0,
  0x1F, 0x01, 0xF8, 0x7C, 0x07, 0xC0, 0x7E, 0x3F, 0x01, 0xF0, 0x1F, 0x8F,
  0xC0, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x1F, 0xF8, 0x0F,
  0xE3, 0xFF, 0xC0, 0xFE, 0x7F, 0xFE, 0x0F, 0xCF, 0xFF, 0xF0, 0xFD, 0xE0,
  0xFF, 0x0F, 0xD8, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0x1F, 0xF0, 0x03, 0xF1,
  0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0x80,
  0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F,
  0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0xFE,
  0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01,
  0xF8, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0x80,
  0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03,
  0xF9, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC1,
  0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xFC, 0x00, 0x7E, 0x1F,
  0xFF, 0x00, 0x3F, 0x1F, 0xFF, 0xC0, 0x1F, 0x9F, 0xFF, 0xE0, 0x0F, 0xDE,
  0x0F, 0xF8, 0x0F, 0xFC, 0x01, 0xFC, 0x07, 0xFC, 0x00, 0xFE, 0x03, 0xFC,
  0x00, 0x3F, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F,
  0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x03, 0xFC,
  0x07, 0xEE, 0x07, 0xFC, 0x03, 0xF7, 0xFF, 0xFE, 0x01, 0xF9, 0xFF, 0xFE,
  0x00, 0xFC, 0x7F, 0xFE, 0x00, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xC3, 0xF0, 0x1F, 0xFF, 0x9F, 0xC0, 0xFF,
  0xFE, 0x7F, 0x07, 0xFF, 0xFD, 0xF8, 0x3F, 0xE0, 0x77, 0xE1, 0xFE, 0x00,
  0x7F, 0x87, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0xFE,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x00,
  0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x7F, 0x8F, 0xC0, 0x01,
  0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x6F, 0xC3, 0xFC, 0x03, 0xBF,
  0x07, 0xF8, 0x3D, 0xFC, 0x1F, 0xFF, 0xF7, 0xF0, 0x3F, 0xFF, 0x9F, 0x80,
  0x7F, 0xFC, 0x7E, 0x00, 0xFF, 0xE1, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFE, 0x03, 0xFB, 0xFF, 0xF0, 0x7F,
  0xDF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xEF, 0xFF, 0xCF, 0xFF, 0x00,
  0x7E, 0x7F, 0xF8, 0x03, 0xF7, 0x80, 0x00, 0x3F, 0xB0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x83, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0x81, 0xF8, 0x00, 0x18, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x82, 0x00, 0x01, 0xFC, 0x38, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0xFE, 0x3F, 0xE0, 0x1F, 0xE1, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x18, 0x03,
  0xF8, 0x03, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0xE0, 0x3F, 0x03,
  0xFC, 0x03, 0xF0, 0xFF, 0x80, 0x7F, 0x1F, 0xE0, 0x07, 0xF7, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F,
  0xC7, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F,
  0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x0F,
  0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFE, 0x3F, 0x80,
  0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x1F,
  0xC3, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x1B, 0xF0, 0xFE, 0x01, 0xFF, 0x87,
  0xFC, 0x3D, 0xFC, 0x1F, 0xFF, 0xCF, 0xC0, 0xFF, 0xFE, 0x7E, 0x03, 0xFF,
  0xE3, 0xF0, 0x0F, 0xFE, 0x1F, 0x80, 0x1F, 0xC1, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x63, 0xFF, 0xC0, 0x1F, 0x9F, 0xFE, 0x01, 0xFC, 0xFF, 0xF0, 0x07,
  0xEF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xE0,
  0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC1, 0xFC,
  0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x01,
  0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0,
  0x7F, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0xFC,
  0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x0F,
  0xF0, 0x1F, 0x80, 0xFF, 0x00, 0xFC, 0x1F, 0xF0, 0x07, 0xE3, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0F, 0x80,
  0xF8, 0x7E, 0x1F, 0x81, 0xF8, 0x3E, 0x1F, 0x01, 0xF0, 0x3E, 0x1F, 0x01,
  0xF0, 0x3E, 0x1F, 0x01, 0xF0, 0x3E, 0x1F, 0x01, 0xF0, 0x3F, 0x1F, 0x01,
  0xF0, 0x3F, 0x3F, 0x03, 0xF0, 0x3F, 0x3E, 0x03, 0xF0, 0x3F, 0x3E, 0x03,
  0xE0, 0x3F, 0x3E, 0x03, 0xE0, 0x3F, 0x3E, 0x03, 0xE0, 0x3F, 0x7E, 0x03,
  0xE0, 0x3F, 0x7E, 0x07, 0xE0, 0x3E, 0x7C, 0x07, 0xE0, 0x3E, 0x7C, 0x07,
  0xC0, 0x3E, 0x7C, 0x07, 0xC0, 0x3E, 0x7C, 0x07, 0xC0, 0x7E, 0xFC, 0x07,
  0xC0, 0x7C, 0xFC, 0x0F, 0xC0, 0x7C, 0xF8, 0x0F, 0xC0, 0x7C, 0xF8, 0x0F,
  0xC0, 0xF8, 0xF8, 0x0F, 0x80, 0xF8, 0xF8, 0x1F, 0x81, 0xF8, 0xF8, 0x3F,
  0x81, 0xF0, 0xFC, 0x77, 0x83, 0xE0, 0xFF, 0xF7, 0xC7, 0xE0, 0xFF, 0xE7,
  0xFF, 0xC0, 0x7F, 0xC3, 0xFF, 0x80, 0x7F, 0x83, 0xFE, 0x00, 0x1F, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x03,
  0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xFE, 0x3F, 0xFE,
  0x1F, 0xF7, 0xE7, 0x8F, 0xC7, 0xF8, 0x7D, 0xC1, 0xF9, 0xFE, 0x0F, 0xB8,
  0x1F, 0x1F, 0x01, 0xF6, 0x03, 0xE1, 0xC0, 0x3F, 0xC0, 0x7C, 0x20, 0x07,
  0xF0, 0x0F, 0x80, 0x00, 0xFE, 0x01, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xC0, 0x7F, 0x80, 0x01, 0xF8, 0x0F,
  0xF0, 0x04, 0x3F, 0x01, 0xBE, 0x03, 0x87, 0xE0, 0x77, 0xC0, 0xF8, 0xFC,
  0x0E, 0xF8, 0x3F, 0x9F, 0x83, 0x9F, 0x1F, 0xE3, 0xF8, 0xF3, 0xE7, 0xF8,
  0x3F, 0xFC, 0x7F, 0xFE, 0x07, 0xFF, 0x8F, 0xFF, 0x80, 0xFF, 0xE0, 0xFF,
  0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xE0,
  0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0,
  0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0,
  0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0,
  0x0F, 0xF0, 0x1F, 0xC0, 0x1B, 0xF0, 0x1F, 0xE0, 0x3B, 0xF0, 0x0F, 0xF0,
  0x77, 0xF0, 0x0F, 0xFF, 0xF7, 0xF0, 0x07, 0xFF, 0xE7, 0xE0, 0x07, 0xFF,
  0xC7, 0xE0, 0x03, 0xFF, 0x87, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x18, 0x00, 0x3F, 0x80, 0x3C, 0x00,
  0x7F, 0x80, 0x7F, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0x03, 0xFF,
  0xF8, 0x7E, 0x07, 0xFF, 0xFC, 0x7E, 0x07, 0xFF, 0xFF, 0x7E, 0x0F, 0xE0,
  0xFF, 0xFE, 0x0F, 0x80, 0x1F, 0xFC, 0x0F, 0x80, 0x0F, 0xF8, 0x1F, 0x00,
  0x07, 0xF0, 0x1F, 0x00, 0x1F, 0xE0, 0x1F, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x60, 0x00, 0xFF, 0x01, 0xF0, 0x01, 0xFC,
  0x01, 0xF0, 0x03, 0xF8, 0x01, 0xF0, 0x07, 0xF0, 0x00, 0xF8, 0x1F, 0xE0,
  0x00, 0xF8, 0x3F, 0xF8, 0x00, 0xF8, 0x7F, 0xFF, 0x80, 0xF8, 0x7F, 0xFF,
  0xFC, 0xF8, 0x7E, 0x7F, 0xFF, 0xF8, 0x7C, 0x1F, 0xFF, 0xF8, 0xFC, 0x03,
  0xFF, 0xF0, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x18, 0x03,
  0xFE, 0x00, 0x1F, 0x07, 0xFF, 0x00, 0x1F, 0x0F, 0xFF, 0x80, 0x3E, 0x1F,
  0xFF, 0x80, 0x3E, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x07, 0xE0, 0x7C, 0x3E,
  0x07, 0xE0, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x7C, 0x01, 0xFF, 0xF8, 0x7C,
  0x01, 0xFF, 0xF0, 0xF8, 0x00, 0xFF, 0xE0, 0xF8, 0x00, 0x7F, 0xC0, 0x18,
  0x00, 0x1F, 0x00,
};

const GFXglyph IBMPlexMono_MediumItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 14, 42, 35, 11, -41 },
  { 75, 20, 18, 35, 11, -44 },
  { 120, 37, 41, 35, 0, -41 },
  { 310, 34, 55, 35, 1, -48 },
  { 544, 41, 43, 35, -2, -42 },
  { 765, 35, 43, 35, 0, -42 },
  { 954, 8, 18, 35, 17, -44 },
  { 972, 24, 53, 35, 11, -45 },
  { 1131, 23, 53, 35, 2, -45 },
  { 1284, 31, 29, 35, 3, -32 },
  { 1397, 29, 29, 35, 4, -33 },
  { 1503, 15, 18, 35, 7, -9 },
  { 1537, 19, 6, 35, 9, -21 },
  { 1552, 10, 10, 35, 11, -9 },
  { 1565, 34, 53, 35, 1, -45 },
  { 1791, 31, 43, 35, 3, -42 },
  { 1958, 28, 41, 35, 3, -41 },
  { 2102, 32, 42, 35, 1, -42 },
  { 2270, 32, 43, 35, 1, -42 },
  { 2442, 32, 41, 35, 1, -41 },
  { 2606, 32, 42, 35, 2, -41 },
  { 2774, 29, 42, 35, 3, -41 },
  { 2927, 31, 41, 35, 5, -41 },
  { 3086, 32, 43, 35, 2, -42 },
  { 3258, 29, 42, 35, 5, -42 },
  { 3411, 14, 32, 35, 11, -31 },
  { 3467, 18, 40, 35, 7, -31 },
  { 3557, 29, 34, 35, 5, -35 },
  { 3681, 31, 18, 35, 3, -27 },
  { 3751, 28, 34, 35, 3, -35 },
  { 3870, 26, 43, 35, 7, -42 },
  { 4010, 31, 49, 35, 3, -42 },
  { 4200, 33, 41, 35, -1, -41 },
  { 4370, 31, 41, 35, 2, -41 },
  { 4529, 31, 43, 35, 4, -42 },
  { 4696, 32, 41, 35, 2, -41 },
  { 4860, 33, 41, 35, 2, -41 },
  { 5030, 34, 41, 35, 2, -41 },
  { 5205, 31, 43, 35, 3, -42 },
  { 5372, 33, 41, 35, 2, -41 },
  { 5542, 33, 41, 35, 2, -41 },
  { 5712, 30, 42, 35, 3, -41 },
  { 5870, 37, 41, 35, 2, -41 },
  { 6060, 26, 41, 35, 4, -41 },
  { 6194, 35, 41, 35, 1, -41 },
  { 6374, 33, 41, 35, 2, -41 },
  { 6544, 31, 43, 35, 3, -42 },
  { 6711, 32, 41, 35, 3, -41 },
  { 6875, 31, 53, 35, 3, -42 },
  { 7081, 32, 41, 35, 3, -41 },
  { 7245, 34, 43, 35, 1, -42 },
  { 7428, 33, 41, 35, 5, -41 },
  { 7598, 32, 42, 35, 4, -41 },
  { 7766, 32, 41, 35, 6, -41 },
  { 7930, 36, 41, 35, 2, -41 },
  { 8115, 39, 41, 35, -1, -41 },
  { 8315, 34, 41, 35, 5, -41 },
  { 8490, 36, 41, 35, 0, -41 },
  { 8675, 27, 53, 35, 8, -45 },
  { 8854, 16, 53, 35, 10, -45 },
  { 8960, 26, 53, 35, 1, -45 },
  { 9133, 31, 25, 35, 3, -41 },
  { 9230, 29, 5, 35, 0, 5 },
  { 9249, 10, 12, 35, 12, -46 },
  { 9264, 30, 32, 35, 3, -31 },
  { 9384, 31, 45, 35, 2, -44 },
  { 9559, 27, 32, 35, 4, -31 },
  { 9667, 32, 45, 35, 3, -44 },
  { 9847, 28, 32, 35, 4, -31 },
  { 9959, 39, 57, 35, -1, -44 },
  { 10237, 32, 44, 35, 1, -31 },
  { 10413, 28, 44, 35, 3, -44 },
  { 10567, 28, 45, 35, 4, -44 },
  { 10725, 29, 57, 35, 2, -44 },
  { 10932, 31, 45, 35, 3, -44 },
  { 11107, 25, 45, 35, 6, -44 },
  { 11248, 34, 31, 35, 0, -31 },
  { 11380, 28, 31, 35, 3, -31 },
  { 11489, 29, 32, 35, 3, -31 },
  { 11605, 33, 43, 35, 0, -31 },
  { 11783, 30, 43, 35, 3, -31 },
  { 11945, 29, 30, 35, 6, -30 },
  { 12054, 29, 32, 35, 3, -31 },
  { 12170, 28, 42, 35, 4, -41 },
  { 12317, 29, 31, 35, 4, -30 },
  { 12430, 29, 32, 35, 3, -31 },
  { 12546, 32, 32, 35, 2, -31 },
  { 12674, 35, 32, 35, 0, -31 },
  { 12814, 32, 43, 35, 1, -30 },
  { 12986, 32, 32, 35, 2, -31 },
  { 13114, 28, 53, 35, 6, -45 },
  { 13300, 14, 53, 35, 11, -45 },
  { 13393, 28, 53, 35, 2, -45 },
  { 13579, 32, 14, 35, 2, -25 },
};

const GFXfont IBMPlexMono_MediumItalic59pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic59pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic59pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _IBMPLEXMONO_MEDIUMITALIC59PT7B_H_
