#ifndef _IBMPLEXMONO_MEDIUMITALIC67PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x3F, 0x81,
  0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF0, 0x1F,
  0x87, 0xE0, 0x3F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8,
  0xFE, 0x07, 0xF1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x8F, 0xE0, 0x7F, 0x1F,
  0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFC, 0x07, 0xE1, 0xF8,
  0x0F, 0xC7, 0xF0, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x20, 0x3F,
  0x81, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0x1F, 0x7F, 0xF0, 0x1F, 0xF0, 0x78, 0x7F, 0xC0,
  0x7F, 0x83, 0xE0, 0x7E, 0x03, 0xFC, 0x0F, 0x80, 0xE0, 0x0F, 0xE0, 0x3E,
  0x01, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0x03,
  0xF8, 0x0F, 0x80, 0x00, 0x1F, 0xE0, 0x7C, 0x00, 0x00, 0x3F, 0x81, 0xF0,
  0x00, 0x00, 0xFE, 0x07, 0xC0, 0x00, 0x03, 0xFC, 0x1F, 0x00, 0x00, 0x0F,
  0xF8, 0x7C, 0x00, 0x00, 0x1F, 0xF9, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0x3F, 0xF8, 0x00, 0x00, 0x7C, 0x3F, 0xE0, 0x00, 0x01, 0xF0, 0x7F,
  0x80, 0x00, 0x07, 0xC0, 0xFE, 0x00, 0x00, 0x1E, 0x03, 0xFC, 0x00, 0x00,
  0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xE0, 0x3F, 0xC0, 0x00, 0x0F, 0x80, 0xFE,
  0x00, 0x00, 0x3E, 0x03, 0xF8, 0x04, 0x00, 0xF8, 0x0F, 0xE0, 0x38, 0x03,
  0xC0, 0x7F, 0x83, 0xF0, 0x1F, 0x01, 0xFC, 0x1F, 0xE0, 0x7C, 0x0F, 0xF0,
  0xFF, 0xC1, 0xF0, 0xFF, 0x81, 0xFF, 0xE7, 0xCF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x7E, 0x00,
  0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x07,
  0xE0, 0x7E, 0x00, 0x0F, 0x80, 0x1F, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0x0F, 0x83,
  0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x7E,
  0x00, 0x00, 0x7E, 0x1F, 0xC3, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x0F, 0xC0,
  0x00, 0x03, 0xFF, 0xF0, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFC, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x87, 0xF0, 0x00, 0x07,
  0xE1, 0xFC, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x03,
  0xF0, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x1F,
  0x00, 0x3F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0xF3, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFB, 0xFF, 0x80, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x10, 0xFF, 0x00, 0x1F, 0xC0, 0x3C, 0xFF,
  0x00, 0x1F, 0xE0, 0x3F, 0xFF, 0x00, 0x1F, 0xE0, 0x7E, 0x7F, 0x00, 0x3F,
  0xF0, 0xFE, 0x7F, 0x00, 0x37, 0xF0, 0xFC, 0x7F, 0x80, 0x73, 0xF9, 0xFC,
  0x7F, 0xC1, 0xF3, 0xF9, 0xF8, 0x3F, 0xFF, 0xE3, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE1, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x1F,
  0xC7, 0xF1, 0xF8, 0x7E, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x02, 0x00, 0x1F, 0x80, 0x08, 0xF8, 0x07,
  0xF0, 0x0F, 0x1F, 0xE0, 0xFE, 0x0F, 0xF7, 0xFF, 0x1F, 0x8F, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x01,
  0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x0F, 0xC3, 0xFE, 0x7F, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE7, 0xFC, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F,
  0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0x7F,
  0x3F, 0xC0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0xF8,
  0x0F, 0xF7, 0xF8, 0x1F, 0xC0, 0xFF, 0x7F, 0x83, 0xFC, 0x0F, 0xF7, 0xF8,
  0x3F, 0xC0, 0xFE, 0x7F, 0x83, 0xFC, 0x0F, 0xE7, 0xF8, 0x3F, 0xC1, 0xFE,
  0x7F, 0x03, 0xF8, 0x1F, 0xE7, 0xF0, 0x1F, 0x01, 0xFE, 0x7F, 0x00, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x03, 0xF8,
  0xFF, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x1F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xBF,
  0x80, 0x00, 0xFF, 0x9F, 0xC0, 0x00, 0xFF, 0x9F, 0xE0, 0x01, 0xFF, 0x0F,
  0xF0, 0x01, 0xFF, 0x07, 0xF0, 0x01, 0xFF, 0x03, 0xF8, 0x01, 0xFF, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0x0F, 0x00,
  0x7F, 0x80, 0x03, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01,
  0xFE, 0x0B, 0xF0, 0x00, 0x0F, 0xF0, 0x07, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xC0,
  0x00, 0x7F, 0xC0, 0x0C, 0x00, 0x01, 0xFE, 0x00, 0x20, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x02, 0x00, 0x00, 0x3F, 0xC0,
  0x78, 0x00, 0x01, 0xFE, 0x07, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x81, 0xFE, 0x00, 0x00, 0xFC, 0x3F, 0xFC, 0x00, 0x07, 0xE7, 0xFF,
  0xF8, 0x00, 0x7E, 0x7F, 0xFF, 0xE0, 0x03, 0xF7, 0xFF, 0xFF, 0x80, 0x1F,
  0xBF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x10, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x60, 0x00, 0x07, 0xF8, 0x07, 0x00, 0x00, 0x3F,
  0xC0, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0xC0,
  0x03, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0x8F, 0xFF, 0xE0,
  0x1F, 0xE7, 0xFF, 0xFE, 0x07, 0xF3, 0xFF, 0xFF, 0x83, 0xFD, 0xFF, 0xFF,
  0xF0, 0xFE, 0xF8, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0x9F, 0xF8, 0x00,
  0x1F, 0xE7, 0xFC, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0x9F, 0xC0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x00,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0xE1, 0xF8, 0x00, 0x07, 0xF8, 0x3F,
  0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF8,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x01, 0xFF, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00, 0x7F,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x01,
  0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x7F, 0x1F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0x07, 0xF7, 0xF8, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x07, 0xFC, 0xFF,
  0x80, 0x0F, 0xFE, 0x7F, 0xF0, 0x1F, 0xFF, 0x1F, 0xFF, 0xFF, 0x7F, 0x07,
  0xFF, 0xFF, 0x3F, 0x83, 0xFF, 0xFF, 0x3F, 0xC0, 0xFF, 0xFF, 0x3F, 0xC0,
  0x1F, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xFE, 0x07, 0xFF,
  0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE,
  0x07, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0xE0,
  0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0,
  0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFE, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0x88, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF,
  0x03, 0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0x3F, 0x8F, 0x80, 0x00, 0xFF, 0x04, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFC,
  0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x7E, 0x1F, 0xC0, 0x00, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF8, 0xFE, 0x01,
  0xFF, 0x3F, 0x1F, 0x80, 0x7F, 0xF7, 0xE3, 0xF0, 0x1F, 0xFE, 0xFC, 0x7E,
  0x07, 0xFF, 0xDF, 0x9F, 0xC1, 0xFE, 0x1F, 0xF3, 0xF0, 0x3F, 0x80, 0xFE,
  0x7E, 0x0F, 0xE0, 0x1F, 0x8F, 0xC1, 0xF8, 0x03, 0xF1, 0xF8, 0x7F, 0x00,
  0x7E, 0x7F, 0x0F, 0xE0, 0x0F, 0xCF, 0xE1, 0xF8, 0x01, 0xF9, 0xF8, 0x3F,
  0x00, 0x3F, 0x3F, 0x07, 0xE0, 0x07, 0xC7, 0xE1, 0xFC, 0x01, 0xF8, 0xFC,
  0x3F, 0x80, 0x3F, 0x1F, 0x87, 0xF0, 0x07, 0xE3, 0xF0, 0xFC, 0x00, 0xFC,
  0xFC, 0x1F, 0x80, 0x3F, 0x9F, 0x83, 0xF0, 0x07, 0xE3, 0xF0, 0x7E, 0x01,
  0xFC, 0x7E, 0x0F, 0xE0, 0x3F, 0x8F, 0xC0, 0xFC, 0x0F, 0xF1, 0xF8, 0x1F,
  0xC7, 0x7E, 0x3F, 0x03, 0xFF, 0xEF, 0xC7, 0xE0, 0x3F, 0xF9, 0xF0, 0xFC,
  0x07, 0xFE, 0x7E, 0x1F, 0x80, 0x7F, 0x8F, 0xC1, 0xF0, 0x03, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x3F, 0x8F, 0xC0,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xC3, 0xFC, 0x00,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x81,
  0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F,
  0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF0,
  0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x0F, 0xF8, 0x0F, 0xE0, 0x00,
  0x7F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x87,
  0xF0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00,
  0x7F, 0xC3, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x00, 0x0F, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF0, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0x80,
  0xFE, 0x00, 0x00, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x20, 0x07, 0xF0, 0x00, 0x03, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F,
  0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0xFE, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0xFE,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x01, 0xFE,
  0x1F, 0xC0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xF8,
  0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x3F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03,
  0xFC, 0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x7F,
  0x07, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0xF0, 0x3F, 0xC0, 0x00,
  0x20, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F,
  0xFF, 0x9F, 0xE0, 0x0F, 0xFF, 0xF3, 0xFC, 0x01, 0xFF, 0xFC, 0x7F, 0x80,
  0x7F, 0xFF, 0x8F, 0xF0, 0x0F, 0xFF, 0xF1, 0xFE, 0x01, 0xFF, 0xFE, 0x3F,
  0x80, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x7E,
  0x1F, 0xC0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00,
  0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x0F,
  0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xF7, 0xF0, 0x1F, 0xFF, 0xFE, 0xFE,
  0x01, 0xFF, 0xFF, 0x9F, 0x80, 0x1F, 0xFF, 0xE3, 0xF0, 0x01, 0xFF, 0xF8,
  0xFE, 0x00, 0x1F, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00,
  0xFF, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x08,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0x00, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x7F, 0x81, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0x80, 0x00,
  0x7F, 0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xF8,
  0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xFC, 0x00, 0x00,
  0xFE, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x81, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x00, 0x1F, 0xC7, 0xFC, 0x00, 0x00,
  0x07, 0xF3, 0xFE, 0x00, 0x00, 0x01, 0xFD, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF3, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x1F, 0xC0, 0x00, 0x07,
  0xFE, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xF7, 0xE0,
  0x7F, 0xFE, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0xFE, 0xFC,
  0x07, 0xF3, 0xE0, 0xFC, 0xFC, 0x07, 0xF3, 0xF1, 0xF8, 0xFC, 0x07, 0xF3,
  0xF1, 0xF9, 0xFC, 0x07, 0xE3, 0xF3, 0xF1, 0xFC, 0x07, 0xE1, 0xF3, 0xF1,
  0xF8, 0x07, 0xE1, 0xFF, 0xE1, 0xF8, 0x0F, 0xE1, 0xFF, 0xE1, 0xF8, 0x0F,
  0xE1, 0xFF, 0xC3, 0xF8, 0x0F, 0xE1, 0xFF, 0x83, 0xF8, 0x0F, 0xE0, 0xFF,
  0x83, 0xF8, 0x0F, 0xC0, 0xFF, 0x03, 0xF0, 0x0F, 0xC0, 0xFF, 0x03, 0xF0,
  0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x07, 0xF0, 0x1F, 0xC0,
  0x7C, 0x07, 0xF0, 0x1F, 0xC0, 0x78, 0x07, 0xF0, 0x1F, 0x80, 0x78, 0x07,
  0xE0, 0x1F, 0x80, 0x70, 0x07, 0xE0, 0x3F, 0x80, 0x30, 0x07, 0xE0, 0x3F,
  0x80, 0x20, 0x0F, 0xE0, 0x3F, 0x80, 0x20, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xF0,
  0x1F, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0xF0, 0x00, 0x7F, 0x01, 0xFF, 0xC0,
  0x01, 0xF8, 0x07, 0xFF, 0x80, 0x07, 0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0x80,
  0x7F, 0xF8, 0x00, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xF8, 0x0F, 0xFF, 0x80,
  0x0F, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0x03,
  0xF3, 0xF0, 0x03, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0xC0, 0x7F, 0x3F, 0x00,
  0x7F, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0x07, 0xF1, 0xF8, 0x07, 0xE0, 0x1F,
  0xC7, 0xE0, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x7E, 0x03,
  0xF8, 0x0F, 0xE1, 0xFC, 0x0F, 0xE0, 0x3F, 0x83, 0xF0, 0x3F, 0x80, 0xFE,
  0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0x3F, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x07, 0xE1, 0xFC, 0x07, 0xF0,
  0x1F, 0x87, 0xF0, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x7E,
  0x01, 0xF8, 0x07, 0xF1, 0xF8, 0x07, 0xE0, 0x0F, 0xCF, 0xE0, 0x3F, 0x80,
  0x3F, 0x3F, 0x80, 0xFE, 0x00, 0xFC, 0xFE, 0x03, 0xF8, 0x03, 0xFB, 0xF8,
  0x0F, 0xE0, 0x0F, 0xEF, 0xC0, 0x3F, 0x00, 0x1F, 0xBF, 0x00, 0xFC, 0x00,
  0x7F, 0xFC, 0x07, 0xF0, 0x01, 0xFF, 0xF0, 0x1F, 0xC0, 0x07, 0xFF, 0xC0,
  0x7F, 0x00, 0x1F, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xE0, 0x00,
  0xFF, 0xE0, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0xFE, 0x00, 0x0F, 0xFE, 0x03,
  0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xC0,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xE7,
  0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x87,
  0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0x80,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x3F,
  0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x1F,
  0xC0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x1F,
  0xE7, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x7F,
  0x87, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F,
  0x80, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x20, 0x00, 0x07, 0xF8, 0x07,
  0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00,
  0x7F, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x01,
  0xF8, 0x07, 0xF8, 0x00, 0x03, 0xC0, 0x3F, 0xC0, 0x00, 0x04, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x10, 0x00, 0x00, 0x7F, 0x80, 0xE0, 0x00, 0x03, 0xFC, 0x0F,
  0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x83, 0xFF, 0x80, 0x03,
  0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x7F, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xC1,
  0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03,
  0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0x3F, 0x83, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x07,
  0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x00,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFE, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x7F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x0F, 0xF0, 0x1F, 0xC1, 0xFC,
  0x07, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xFE,
  0x03, 0xF0, 0x3F, 0x01, 0xFF, 0x03, 0xF8, 0x1F, 0x81, 0xFF, 0x81, 0xF8,
  0x0F, 0xC0, 0xFF, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0xE0, 0x7E, 0x03, 0xF0,
  0x7D, 0xF0, 0x3F, 0x01, 0xF8, 0x3E, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0x7C,
  0x1F, 0x80, 0xFE, 0x1F, 0x3E, 0x0F, 0xC0, 0x7F, 0x0F, 0x9F, 0x07, 0xE0,
  0x3F, 0x07, 0xCF, 0x87, 0xF0, 0x1F, 0x87, 0xC7, 0xC3, 0xF0, 0x0F, 0xC3,
  0xE3, 0xE1, 0xF8, 0x07, 0xE1, 0xF1, 0xF0, 0xFC, 0x03, 0xF1, 0xF0, 0xF8,
  0x7E, 0x01, 0xF8, 0xF8, 0x7C, 0x7E, 0x00, 0xFC, 0x7C, 0x3E, 0x3F, 0x00,
  0x7E, 0x7C, 0x1F, 0x1F, 0x80, 0x7F, 0x3E, 0x0F, 0x8F, 0xC0, 0x3F, 0x9F,
  0x07, 0xCF, 0xC0, 0x1F, 0x9F, 0x03, 0xE7, 0xE0, 0x0F, 0xCF, 0x81, 0xF3,
  0xF0, 0x07, 0xE7, 0xC0, 0xF9, 0xF8, 0x03, 0xF7, 0xC0, 0x7C, 0xF8, 0x01,
  0xFB, 0xE0, 0x3E, 0xFC, 0x00, 0xFD, 0xF0, 0x1F, 0x7E, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xEF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x00,
  0xFF, 0x9F, 0xE0, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0xFE,
  0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFC,
  0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0xFF, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x1F, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xF8, 0x06, 0x07, 0xC3, 0xF8, 0x7F, 0x87, 0xF0, 0x7E, 0x0F, 0xE0,
  0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x7E, 0x04, 0x00, 0x00, 0x0F,
  0xF0, 0x1F, 0xC0, 0x0F, 0xFF, 0x07, 0xF0, 0x0F, 0xFF, 0xE3, 0xFC, 0x07,
  0xFF, 0xFC, 0xFE, 0x03, 0xFF, 0xFF, 0x3F, 0x81, 0xFF, 0xFF, 0xEF, 0xE0,
  0xFF, 0xE0, 0x7B, 0xF8, 0x3F, 0xE0, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0xFF,
  0x87, 0xF8, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x1F, 0xC7, 0xF8, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x03, 0xF8, 0xFF,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFF,
  0x0F, 0xF0, 0x00, 0xFF, 0xC1, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0x80, 0x3B,
  0xF8, 0x1F, 0xF8, 0x3E, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0xF8, 0xFF, 0xFF,
  0x8F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0xF8, 0x01, 0xFC, 0x3F, 0xFF, 0x80,
  0x7F, 0x1F, 0xFF, 0xE0, 0x1F, 0xCF, 0xFF, 0xFC, 0x07, 0xF3, 0xFF, 0xFF,
  0x83, 0xFD, 0xF0, 0x7F, 0xE0, 0xFF, 0xF0, 0x07, 0xF8, 0x3F, 0xB0, 0x00,
  0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x01, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x1F, 0xC7, 0xF8,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFF, 0x1F,
  0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x1F,
  0xE3, 0xF8, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x1F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x3F, 0xDF, 0xFF, 0xFE, 0x0F, 0xE7,
  0xFF, 0xFF, 0x03, 0xF8, 0xFF, 0xFF, 0x80, 0xFE, 0x1F, 0xFF, 0xC0, 0x3F,
  0x83, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x03, 0xFE,
  0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x78,
  0x1F, 0xC0, 0x00, 0x60, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x20, 0x7F, 0x00, 0x00, 0x70, 0x7F, 0x00, 0x00, 0xFC,
  0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8,
  0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F,
  0xFC, 0x1F, 0xC0, 0x07, 0xFF, 0xF8, 0xFE, 0x00, 0x7F, 0xFF, 0xC7, 0xF0,
  0x07, 0xFF, 0xFF, 0x3F, 0x80, 0x7F, 0xFF, 0xFD, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0xC0,
  0x00, 0x3F, 0x81, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xE0,
  0x03, 0x7F, 0x00, 0xFF, 0x00, 0x7B, 0xF8, 0x07, 0xFE, 0x0F, 0xBF, 0xC0,
  0x1F, 0xFF, 0xFD, 0xFE, 0x00, 0xFF, 0xFF, 0xCF, 0xE0, 0x03, 0xFF, 0xFC,
  0x7F, 0x00, 0x0F, 0xFF, 0xC3, 0xF8, 0x00, 0x3F, 0xFC, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F,
  0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFF, 0x3F, 0x80, 0x01, 0xFE,
  0x7F, 0x80, 0x0F, 0xFE, 0x7F, 0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x20, 0x7F, 0x00, 0x00, 0x70, 0x7F, 0x00, 0x00, 0xFC,
  0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8,
  0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x18, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x0F,
  0xE0, 0x00, 0x00, 0x7E, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xBF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x7F, 0xF8, 0x3F, 0x80, 0x0F, 0xFF, 0xE1, 0xFC, 0x00, 0xFF,
  0xFF, 0x8F, 0xE0, 0x0F, 0xFF, 0xFE, 0x7F, 0x00, 0xFF, 0xFF, 0xF3, 0xF8,
  0x07, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x7F, 0x80, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0xFF,
  0xC0, 0x3F, 0xC0, 0x0E, 0xFE, 0x01, 0xFF, 0x81, 0xE7, 0xF0, 0x07, 0xFF,
  0xFF, 0x3F, 0x80, 0x3F, 0xFF, 0xF3, 0xF8, 0x00, 0xFF, 0xFF, 0x1F, 0xC0,
  0x03, 0xFF, 0xF0, 0xFE, 0x00, 0x0F, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0x00, 0x00, 0x7F,
  0x00, 0x0C, 0x00, 0x07, 0xF8, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x03, 0xF8, 0x3F, 0xF8, 0x03, 0xFC, 0x3F, 0xFE, 0x01, 0xFE, 0x3F,
  0xFF, 0x80, 0xFE, 0x3F, 0xFF, 0xC0, 0x7F, 0x3F, 0xFF, 0xF0, 0x3F, 0x9E,
  0x0F, 0xF8, 0x1F, 0xDC, 0x03, 0xFC, 0x1F, 0xEC, 0x00, 0xFF, 0x0F, 0xFC,
  0x00, 0x7F, 0x87, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xF8, 0x7F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x40, 0x03, 0xF8, 0x01, 0xC0, 0x07, 0xF0, 0x07, 0xC0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x01, 0xFE, 0x00, 0xFE, 0x07,
  0xF8, 0x01, 0xFC, 0x3F, 0xE0, 0x03, 0xF8, 0xFF, 0x80, 0x07, 0xF3, 0xFE,
  0x00, 0x1F, 0xCF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x08, 0x00, 0xFF, 0x00, 0x1C, 0x00,
  0x7F, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F,
  0xC3, 0xF8, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x01,
  0xFE, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0x87, 0xFF,
  0xE0, 0x07, 0xF0, 0xFF, 0xFE, 0x00, 0x7F, 0x1F, 0xFF, 0xF0, 0x07, 0xF3,
  0xFF, 0xFF, 0x00, 0x7F, 0x7C, 0x1F, 0xF8, 0x07, 0xF7, 0x00, 0x7F, 0x80,
  0xFF, 0xE0, 0x07, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x03,
  0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xE0,
  0x00, 0x7F, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x07, 0xFC,
  0x00, 0x1F, 0xC3, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0x01, 0x03,
  0xF8, 0x3F, 0x80, 0x38, 0x3F, 0x83, 0xFC, 0x07, 0xC7, 0xF8, 0x1F, 0xC0,
  0xFE, 0x7F, 0x01, 0xFE, 0x1F, 0xF7, 0xF0, 0x0F, 0xE3, 0xFC, 0x7F, 0x00,
  0xFE, 0x7F, 0x87, 0xF0, 0x0F, 0xFF, 0xF0, 0x7F, 0x00, 0x7F, 0xFE, 0x0F,
  0xF0, 0x07, 0xFF, 0xC0, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xE0, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x80, 0x7F, 0x80, 0x1C,
  0x07, 0xF0, 0x03, 0xE0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x1F, 0xF0, 0x7F,
  0x03, 0xFE, 0x0F, 0xF0, 0x7F, 0xC0, 0xFE, 0x0F, 0xF8, 0x0F, 0xE1, 0xFF,
  0x00, 0xFE, 0x3F, 0xE0, 0x0F, 0xE7, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0x07, 0xE3,
  0xFC, 0x1F, 0xF0, 0x1F, 0xCF, 0xFC, 0x7F, 0xF0, 0x3F, 0xBF, 0xF9, 0xFF,
  0xE0, 0x7E, 0x7F, 0xF3, 0xFF, 0xE0, 0xFD, 0xFF, 0xEF, 0xFF, 0xC1, 0xFB,
  0x1F, 0xDC, 0x3F, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFE, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x7E,
  0x01, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0,
  0x1F, 0x87, 0xF0, 0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x1F,
  0x80, 0x7E, 0x01, 0xFC, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x1F, 0x87,
  0xF0, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0xFC, 0x03, 0xF0, 0x0F, 0xC3, 0xF8, 0x0F, 0xE0, 0x1F, 0x87, 0xE0, 0x1F,
  0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x07, 0xE1, 0xFC, 0x07,
  0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x01, 0xFC, 0x1F, 0xFC, 0x01, 0xFE, 0x1F, 0xFF, 0x00, 0xFE, 0x1F, 0xFF,
  0xC0, 0x7F, 0x1F, 0xFF, 0xE0, 0x3F, 0x9F, 0xFF, 0xF8, 0x1F, 0xCF, 0x07,
  0xFC, 0x0F, 0xEE, 0x01, 0xFE, 0x0F, 0xF6, 0x00, 0x7F, 0x87, 0xFE, 0x00,
  0x3F, 0xC3, 0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x07, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0xC0,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x0F, 0xE7, 0xF8,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x03, 0xFC,
  0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xF8, 0x00,
  0x3F, 0x87, 0xFF, 0xF0, 0x01, 0xFC, 0x7F, 0xFF, 0x80, 0x0F, 0xE7, 0xFF,
  0xFE, 0x00, 0x7F, 0x3F, 0xFF, 0xF8, 0x07, 0xFB, 0xE0, 0xFF, 0xC0, 0x3F,
  0xFC, 0x01, 0xFE, 0x01, 0xFD, 0x80, 0x07, 0xF8, 0x0F, 0xFC, 0x00, 0x3F,
  0xC0, 0x7F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xC0,
  0x00, 0x3F, 0x81, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xBF, 0xFF,
  0xFC, 0x03, 0xF9, 0xFF, 0xFF, 0xC0, 0x1F, 0xC7, 0xFF, 0xFC, 0x00, 0xFE,
  0x1F, 0xFF, 0xC0, 0x07, 0xF0, 0x7F, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x1F,
  0xE0, 0x07, 0xFF, 0x83, 0xF8, 0x03, 0xFF, 0xFC, 0x7F, 0x00, 0xFF, 0xFF,
  0x8F, 0xE0, 0x3F, 0xFF, 0xF9, 0xFC, 0x0F, 0xFF, 0xFF, 0xBF, 0x81, 0xFF,
  0x80, 0xFF, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F,
  0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x0F,
  0xF0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F,
  0x87, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0xFF, 0x83, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x06, 0xFE, 0x07, 0xF8,
  0x03, 0xDF, 0xC0, 0xFF, 0xC1, 0xF7, 0xF8, 0x0F, 0xFF, 0xFE, 0xFE, 0x01,
  0xFF, 0xFF, 0x9F, 0xC0, 0x1F, 0xFF, 0xE3, 0xF8, 0x01, 0xFF, 0xF8, 0x7F,
  0x00, 0x1F, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xBF, 0xFF, 0xC1, 0xFF, 0xBF, 0xFF,
  0xE1, 0xFF, 0xDF, 0xFF, 0xE1, 0xFF, 0xEF, 0xFF, 0xF1, 0xFF, 0xF7, 0xFF,
  0xF9, 0xFF, 0xF8, 0x01, 0xFC, 0xFF, 0xFC, 0x00, 0xFE, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x60, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x7C,
  0x07, 0xF0, 0x00, 0x18, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x02, 0x00, 0x00, 0x7F, 0x83, 0xC0, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x3F, 0xC7, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x20, 0x03, 0xF8, 0x00, 0x60, 0x07, 0xF0, 0x03, 0xE0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x01, 0xFF, 0xC0,
  0xFE, 0x07, 0xFE, 0x01, 0xFC, 0x3F, 0xF0, 0x03, 0xF8, 0xFF, 0xC0, 0x07,
  0xF3, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0xFF, 0x1F, 0xC0,
  0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFE, 0x3F, 0x80,
  0x01, 0xFC, 0x7F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00,
  0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xFC, 0x7F, 0x00,
  0x03, 0xF8, 0xFF, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00,
  0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xF0, 0xFE, 0x00,
  0x37, 0xF0, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0x00, 0xEF, 0xF0, 0xFF, 0x81,
  0xEF, 0xE0, 0xFF, 0xFF, 0xCF, 0xE0, 0x7F, 0xFF, 0x8F, 0xE0, 0x7F, 0xFF,
  0x8F, 0xE0, 0x3F, 0xFF, 0x0F, 0xE0, 0x1F, 0xFC, 0x1F, 0xE0, 0x03, 0xF0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0C, 0x7F, 0xFE, 0x00, 0x3F, 0x3F, 0xFF,
  0x00, 0x7F, 0x9F, 0xFF, 0x80, 0x1F, 0xCF, 0xFF, 0xC0, 0x0F, 0xF7, 0xFF,
  0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0,
  0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x0F,
  0xF0, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xF8, 0x0F, 0xE0, 0x0F,
  0xF8, 0x07, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x0F, 0xFC, 0x01, 0xFC, 0x1F,
  0xFC, 0x00, 0xFE, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x60,
  0xFC, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0xFC, 0x03, 0xE0,
  0x3F, 0x0F, 0xC0, 0x7E, 0x03, 0xF1, 0xF8, 0x07, 0xE0, 0x3F, 0x1F, 0x80,
  0x7E, 0x03, 0xF1, 0xF8, 0x07, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x03, 0xF1,
  0xF8, 0x07, 0xC0, 0x3F, 0x1F, 0x80, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xC0,
  0x3F, 0x3F, 0x00, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xC0, 0x3F, 0x3F, 0x00,
  0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xC0, 0x3F, 0x3F, 0x01, 0xF8, 0x03, 0xF3,
  0xE0, 0x1F, 0x80, 0x3F, 0x7E, 0x01, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0x80,
  0x7E, 0x7E, 0x01, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x80, 0x7E, 0x7E, 0x03,
  0xF0, 0x07, 0xE7, 0xC0, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF0, 0x0F, 0xCF,
  0xC0, 0x3F, 0x00, 0xFC, 0xFC, 0x07, 0xF0, 0x1F, 0x8F, 0xC0, 0xFF, 0x01,
  0xF8, 0xFC, 0x0F, 0xF0, 0x3F, 0x0F, 0xE1, 0xDF, 0x07, 0xF0, 0xFF, 0xFD,
  0xF8, 0xFE, 0x0F, 0xFF, 0x9F, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xF8, 0x07,
  0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00,
  0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x01, 0xFF, 0xFC,
  0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xFE, 0xFC, 0xF8, 0x7F,
  0x0F, 0xF8, 0x7C, 0xF0, 0x7F, 0x1F, 0xE0, 0x7C, 0xE0, 0x3F, 0x1F, 0xC0,
  0x7F, 0xC0, 0x3F, 0x0F, 0x00, 0x7F, 0xC0, 0x3F, 0x06, 0x00, 0x7F, 0x80,
  0x3F, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x30, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0E, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x01, 0xFE, 0x00,
  0x20, 0xFC, 0x01, 0xFE, 0x00, 0x60, 0xFC, 0x03, 0xBE, 0x01, 0xF0, 0xFC,
  0x03, 0xBF, 0x03, 0xF8, 0xFE, 0x07, 0xBF, 0x07, 0xFC, 0xFE, 0x0F, 0x3F,
  0x1F, 0xF0, 0xFF, 0x1F, 0x3F, 0x3F, 0xE0, 0x7F, 0xFE, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x3F, 0xF8,
  0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x0F,
  0xF0, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x17, 0xF0, 0x0F, 0xF0,
  0x03, 0x7F, 0x00, 0xFF, 0x00, 0xEF, 0xF0, 0x0F, 0xFC, 0x1E, 0xFF, 0x00,
  0x7F, 0xFF, 0xCF, 0xE0, 0x07, 0xFF, 0xFC, 0xFE, 0x00, 0x3F, 0xFF, 0x8F,
  0xE0, 0x03, 0xFF, 0xF0, 0xFE, 0x00, 0x0F, 0xFE, 0x1F, 0xE0, 0x00, 0x3F,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x80, 0x00, 0x7F,
  0x80, 0x0C, 0x00, 0x0F, 0xF8, 0x01, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0x80,
  0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xF0, 0x07,
  0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0xFF, 0x87, 0xF0, 0x1F, 0xFF, 0xFC, 0x7F,
  0x03, 0xFF, 0xFF, 0xF7, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x3F,
  0xFF, 0xE0, 0x7E, 0x00, 0x7F, 0xFE, 0x0F, 0xC0, 0x01, 0xFF, 0xC0, 0xFC,
  0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x06, 0x00, 0x03, 0xFC, 0x01, 0xE0, 0x00, 0x7F, 0x80,
  0x3F, 0x00, 0x1F, 0xF0, 0x01, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0x7F,
  0xC0, 0x01, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0x81, 0xFF, 0xF0, 0x00, 0xFC,
  0x7F, 0xFF, 0xF0, 0x0F, 0xC7, 0xFF, 0xFF, 0xF8, 0xFC, 0x7F, 0x7F, 0xFF,
  0xFF, 0xC7, 0xF0, 0xFF, 0xFF, 0xF8, 0x7E, 0x03, 0xFF, 0xFF, 0x87, 0xE0,
  0x07, 0xFF, 0xF0, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x01, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xC0, 0xFF, 0xF0,
  0x00, 0x7C, 0x0F, 0xFF, 0xC0, 0x07, 0xE0, 0x7F, 0xFF, 0x00, 0x3F, 0x07,
  0xFF, 0xF8, 0x03, 0xF0, 0x7F, 0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x3F, 0x81,
  0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xC1, 0xF8, 0x07, 0xF1, 0xFE, 0x0F, 0xC0,
  0x1F, 0xFF, 0xE0, 0xFC, 0x00, 0xFF, 0xFE, 0x07, 0xE0, 0x03, 0xFF, 0xE0,
  0x3E, 0x00, 0x0F, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0x80, 0x00,
  0x7C, 0x00,
};

const GFXglyph IBMPlexMono_MediumItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 17, 48, 40, 12, -47 },
  { 103, 23, 20, 40, 12, -50 },
  { 161, 42, 47, 40, 0, -47 },
  { 408, 38, 63, 40, 1, -55 },
  { 708, 46, 49, 40, -2, -48 },
  { 990, 40, 49, 40, 0, -48 },
  { 1235, 10, 20, 40, 19, -50 },
  { 1260, 26, 60, 40, 13, -51 },
  { 1455, 27, 60, 40, 2, -51 },
  { 1658, 35, 33, 40, 3, -37 },
  { 1803, 33, 32, 40, 4, -36 },
  { 1935, 17, 20, 40, 8, -10 },
  { 1978, 21, 7, 40, 10, -24 },
  { 1997, 12, 11, 40, 12, -10 },
  { 2014, 39, 60, 40, 1, -51 },
  { 2307, 36, 49, 40, 3, -48 },
  { 2528, 33, 47, 40, 3, -47 },
  { 2722, 37, 48, 40, 1, -48 },
  { 2944, 37, 49, 40, 1, -48 },
  { 3171, 37, 47, 40, 1, -47 },
  { 3389, 37, 48, 40, 2, -47 },
  { 3611, 34, 48, 40, 3, -47 },
  { 3815, 35, 47, 40, 6, -47 },
  { 4021, 37, 49, 40, 2, -48 },
  { 4248, 33, 48, 40, 5, -48 },
  { 4446, 16, 36, 40, 12, -35 },
  { 4518, 20, 45, 40, 8, -35 },
  { 4631, 32, 39, 40, 6, -40 },
  { 4787, 35, 21, 40, 3, -31 },
  { 4879, 33, 39, 40, 3, -40 },
  { 5040, 30, 49, 40, 8, -48 },
  { 5224, 35, 56, 40, 3, -48 },
  { 5469, 37, 47, 40, -1, -47 },
  { 5687, 35, 47, 40, 3, -47 },
  { 5893, 36, 49, 40, 4, -48 },
  { 6114, 36, 47, 40, 3, -47 },
  { 6326, 37, 47, 40, 3, -47 },
  { 6544, 38, 47, 40, 3, -47 },
  { 6768, 35, 49, 40, 4, -48 },
  { 6983, 38, 47, 40, 2, -47 },
  { 7207, 37, 47, 40, 3, -47 },
  { 7425, 35, 48, 40, 3, -47 },
  { 7635, 42, 47, 40, 2, -47 },
  { 7882, 30, 47, 40, 4, -47 },
  { 8059, 40, 47, 40, 1, -47 },
  { 8294, 38, 47, 40, 2, -47 },
  { 8518, 36, 49, 40, 3, -48 },
  { 8739, 36, 47, 40, 3, -47 },
  { 8951, 36, 61, 40, 3, -48 },
  { 9226, 36, 47, 40, 3, -47 },
  { 9438, 38, 49, 40, 1, -48 },
  { 9671, 37, 47, 40, 6, -47 },
  { 9889, 36, 48, 40, 4, -47 },
  { 10105, 36, 47, 40, 7, -47 },
  { 10317, 41, 47, 40, 2, -47 },
  { 10558, 45, 47, 40, -2, -47 },
  { 10823, 38, 47, 40, 6, -47 },
  { 11047, 41, 47, 40, 0, -47 },
  { 11288, 29, 60, 40, 10, -51 },
  { 11506, 18, 60, 40, 12, -51 },
  { 11641, 30, 60, 40, 1, -51 },
  { 11866, 35, 28, 40, 3, -47 },
  { 11989, 33, 6, 40, 0, 6 },
  { 12014, 11, 14, 40, 14, -53 },
  { 12034, 34, 36, 40, 3, -35 },
  { 12187, 34, 51, 40, 3, -50 },
  { 12404, 32, 36, 40, 4, -35 },
  { 12548, 37, 51, 40, 3, -50 },
  { 12784, 32, 36, 40, 4, -35 },
  { 12928, 44, 64, 40, -1, -50 },
  { 13280, 37, 49, 40, 1, -35 },
  { 13507, 33, 50, 40, 3, -50 },
  { 13714, 31, 51, 40, 5, -50 },
  { 13912, 33, 64, 40, 2, -50 },
  { 14176, 36, 51, 40, 3, -50 },
  { 14406, 28, 51, 40, 7, -50 },
  { 14585, 39, 35, 40, 0, -35 },
  { 14756, 33, 35, 40, 3, -35 },
  { 14901, 33, 36, 40, 4, -35 },
  { 15050, 37, 48, 40, 0, -35 },
  { 15272, 35, 48, 40, 3, -35 },
  { 15482, 33, 35, 40, 7, -35 },
  { 15627, 33, 36, 40, 3, -35 },
  { 15776, 31, 48, 40, 5, -47 },
  { 15962, 32, 36, 40, 5, -35 },
  { 16106, 33, 36, 40, 4, -35 },
  { 16255, 36, 36, 40, 2, -35 },
  { 16417, 40, 36, 40, 0, -35 },
  { 16597, 36, 49, 40, 1, -35 },
  { 16818, 36, 36, 40, 2, -35 },
  { 16980, 32, 60, 40, 7, -51 },
  { 17220, 16, 60, 40, 13, -51 },
  { 17340, 32, 60, 40, 2, -51 },
  { 17580, 37, 16, 40, 2, -28 },
};

const GFXfont IBMPlexMono_MediumItalic67pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic67pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic67pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _IBMPLEXMONO_MEDIUMITALIC67PT7B_H_
