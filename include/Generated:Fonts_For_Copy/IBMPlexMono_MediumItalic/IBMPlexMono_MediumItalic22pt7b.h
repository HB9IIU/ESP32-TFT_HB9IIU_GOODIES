#ifndef _IBMPLEXMONO_MEDIUMITALIC22PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xCE, 0x73, 0x98, 0xC4, 0x20, 0x00, 0xCF, 0x7B, 0x80, 0x67,
  0x66, 0x66, 0x66, 0xE6, 0xC6, 0xCE, 0x03, 0x38, 0x0C, 0xC0, 0x33, 0x01,
  0x98, 0x3E, 0x7C, 0xF9, 0xF0, 0xCC, 0x03, 0x30, 0x0C, 0xC3, 0xE7, 0xCF,
  0x9F, 0x04, 0x60, 0x33, 0x00, 0xCC, 0x06, 0x70, 0x00, 0x00, 0xC0, 0x0C,
  0x01, 0xF8, 0x3F, 0xE1, 0xDB, 0x9C, 0x88, 0xE4, 0x07, 0x20, 0x1F, 0x00,
  0x7F, 0x00, 0xFC, 0x04, 0xE0, 0x23, 0x23, 0x3B, 0xDB, 0x8F, 0xFC, 0x1F,
  0x80, 0x20, 0x03, 0x00, 0x0F, 0x07, 0x1F, 0x84, 0x19, 0x8C, 0x31, 0x98,
  0x31, 0xB0, 0x31, 0xA0, 0x1F, 0x40, 0x1E, 0x78, 0x00, 0xF8, 0x0F, 0x8C,
  0x0D, 0x8C, 0x19, 0x8C, 0x31, 0x98, 0x61, 0xF8, 0xE0, 0xF0, 0x07, 0xC0,
  0x7F, 0x03, 0x18, 0x18, 0xC1, 0xC6, 0x06, 0x30, 0x33, 0x07, 0xF0, 0x66,
  0x07, 0x18, 0x38, 0xC1, 0xC7, 0x3E, 0x3B, 0x3E, 0x78, 0xE3, 0x80, 0x6D,
  0xB7, 0xF0, 0x03, 0x83, 0x03, 0x03, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60,
  0x70, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03,
  0x80, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x06, 0x06, 0x0C, 0x1C, 0x18, 0x30, 0xE0, 0x03, 0x00, 0x60,
  0x06, 0x04, 0x62, 0xFF, 0xE3, 0xFD, 0x0E, 0x01, 0xF0, 0x33, 0x07, 0x18,
  0x21, 0x00, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x07, 0xFF, 0xFF, 0xC3, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x3B, 0x9C, 0xCE, 0x60, 0x7F, 0xFC, 0x7F, 0xFE,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x07, 0x00,
  0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x00, 0x07, 0x81, 0xFE,
  0x38, 0x63, 0x07, 0x70, 0x76, 0x07, 0xE6, 0x7E, 0x67, 0xEE, 0x6E, 0x06,
  0xC0, 0xEE, 0x0C, 0x61, 0xC7, 0xF8, 0x3E, 0x00, 0x07, 0x81, 0xF0, 0xFE,
  0x3D, 0xC7, 0x30, 0x46, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0x61, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0xFF, 0x1C, 0x73, 0x83, 0x00,
  0x30, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x70,
  0x07, 0xFE, 0xFF, 0xE0, 0x07, 0xC0, 0xFF, 0x1C, 0x71, 0x03, 0x00, 0x30,
  0x06, 0x07, 0xC0, 0x7C, 0x00, 0xE0, 0x06, 0x00, 0x66, 0x06, 0xF0, 0xE7,
  0xFC, 0x1F, 0x00, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x36, 0x06, 0x60, 0xE6,
  0x1C, 0x61, 0x8E, 0x30, 0xC6, 0x0C, 0x7F, 0xFF, 0xFF, 0x01, 0xC0, 0x1C,
  0x01, 0x80, 0x1F, 0xF1, 0xFE, 0x30, 0x03, 0x00, 0x30, 0x03, 0x78, 0x6F,
  0xC7, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE4, 0x0C, 0xE1, 0xC7, 0xF8, 0x3E,
  0x00, 0x03, 0xE0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x6F, 0x1B, 0xF3, 0x87,
  0xE0, 0xFC, 0x0F, 0x83, 0xF0, 0x76, 0x1C, 0xFF, 0x0F, 0xC0, 0x7F, 0xEF,
  0xFF, 0x83, 0xE0, 0x6C, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0,
  0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x00, 0x0F, 0xC1, 0xFE, 0x38, 0x73,
  0x07, 0x70, 0x63, 0x0E, 0x1F, 0x83, 0xFC, 0x70, 0xEE, 0x0E, 0xC0, 0xEC,
  0x0E, 0xE1, 0xC7, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xF9, 0xC7, 0x70, 0x7C,
  0x0F, 0x81, 0xF0, 0x37, 0x0E, 0xFF, 0xC7, 0xB0, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x3C, 0x00, 0x3B, 0xDE, 0x60, 0x00, 0x00, 0x77, 0xBD, 0xC0, 0x1C,
  0xF3, 0xC6, 0x00, 0x00, 0x00, 0x00, 0xE7, 0x1C, 0x63, 0x8C, 0x00, 0x00,
  0x60, 0x18, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x30, 0x07, 0x00, 0x78, 0x03,
  0xC0, 0x3C, 0x01, 0xC0, 0x10, 0x7F, 0xF7, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0xFF, 0xE0, 0x20, 0x07, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03,
  0xC0, 0x38, 0x1E, 0x0F, 0x87, 0xC1, 0xE0, 0x70, 0x08, 0x00, 0x3E, 0x3F,
  0xF8, 0xF8, 0x30, 0x18, 0x18, 0xF8, 0x60, 0x30, 0x00, 0x00, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0x0F, 0x81, 0xFE, 0x38, 0x63, 0x03, 0x63, 0xB6, 0x7A,
  0x6E, 0x6E, 0xC6, 0xCC, 0x6C, 0xC6, 0xCC, 0xEC, 0xFC, 0xCF, 0xCC, 0x00,
  0x60, 0x07, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x6C, 0x0E,
  0xC0, 0xCE, 0x0C, 0xE1, 0x86, 0x18, 0x63, 0xFE, 0x3F, 0xE7, 0x06, 0x60,
  0x7E, 0x07, 0xC0, 0x70, 0x3F, 0xC7, 0xFC, 0xC1, 0x98, 0x33, 0x06, 0x61,
  0xDF, 0xF3, 0xFE, 0x60, 0xCC, 0x1D, 0x83, 0xB0, 0x7E, 0x1D, 0xFF, 0xBF,
  0xC0, 0x07, 0xC1, 0xFE, 0x38, 0x73, 0x03, 0x70, 0x07, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x46, 0x0E, 0x71, 0xC3, 0xF8, 0x1F, 0x00,
  0x3F, 0x83, 0xFC, 0x30, 0xE3, 0x06, 0x30, 0x73, 0x07, 0x70, 0x77, 0x07,
  0x60, 0x66, 0x06, 0x60, 0xE6, 0x0C, 0xE1, 0xCF, 0xF8, 0xFE, 0x00, 0x3F,
  0xF3, 0xFF, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x7F, 0xE7, 0xFC, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF3,
  0xFF, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x7F, 0xE7, 0xFC, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x00, 0x07, 0xC1, 0xFE,
  0x38, 0x63, 0x07, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x3E, 0xE3, 0xEE, 0x06,
  0xE0, 0xEE, 0x0C, 0x71, 0xC7, 0xEC, 0x3C, 0xC0, 0x38, 0x33, 0x03, 0x30,
  0x73, 0x07, 0x70, 0x67, 0x06, 0x7F, 0xE7, 0xFE, 0x60, 0xE6, 0x0E, 0xE0,
  0xCE, 0x0C, 0xE0, 0xCC, 0x1C, 0xC1, 0xC0, 0x3F, 0xF3, 0xFF, 0x03, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x0C, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xE3, 0xFC, 0x01, 0x80, 0x70,
  0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x60, 0xCE, 0x38,
  0xFE, 0x0F, 0x80, 0x38, 0x39, 0xC3, 0x8C, 0x38, 0x63, 0x83, 0x38, 0x3B,
  0x81, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0x9C, 0x18, 0xE1, 0xC3, 0x0E, 0x1C,
  0x60, 0x63, 0x03, 0x80, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x1F, 0xFF, 0xFC, 0x1C,
  0x3C, 0x70, 0xE3, 0xC7, 0x8D, 0x9E, 0x36, 0xD8, 0xDF, 0x63, 0x7B, 0x0C,
  0xCC, 0x73, 0x31, 0x88, 0xC6, 0x23, 0x18, 0x1C, 0x60, 0x61, 0x81, 0x8E,
  0x06, 0x00, 0x3C, 0x33, 0xC3, 0x3C, 0x33, 0xC7, 0x7C, 0x66, 0xE6, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x6E, 0xE3, 0xCC, 0x3C, 0xC3, 0xCC, 0x3C, 0xC3,
  0xC0, 0x0F, 0x81, 0xFE, 0x38, 0x63, 0x07, 0x70, 0x76, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x6E, 0x06, 0xE0, 0xEE, 0x0C, 0x61, 0xC7, 0xF8, 0x3E, 0x00,
  0x3F, 0xC3, 0xFE, 0x38, 0x73, 0x07, 0x30, 0x73, 0x07, 0x70, 0xE7, 0xFE,
  0x7F, 0x86, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x00, 0x07,
  0x81, 0xFE, 0x38, 0x63, 0x07, 0x70, 0x76, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x6E, 0x06, 0xE0, 0xEE, 0x0C, 0x61, 0xC7, 0xF8, 0x3E, 0x00, 0xE4, 0x06,
  0x60, 0x3C, 0x03, 0x80, 0x3F, 0xC3, 0xFE, 0x38, 0x73, 0x07, 0x30, 0x73,
  0x07, 0x70, 0xE7, 0xFE, 0x7F, 0x86, 0x30, 0x63, 0x06, 0x38, 0xE1, 0x8E,
  0x1C, 0xC1, 0xC0, 0x07, 0xE0, 0xFF, 0x87, 0x0E, 0x70, 0x23, 0x80, 0x1C,
  0x00, 0x7C, 0x01, 0xFC, 0x01, 0xE0, 0x03, 0x80, 0x1C, 0x80, 0xEF, 0x0E,
  0x3F, 0xE0, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x38, 0x00, 0x38, 0x33, 0x03, 0x30, 0x73, 0x07, 0x70, 0x67, 0x06,
  0x60, 0x66, 0x06, 0x60, 0xE6, 0x0E, 0xE0, 0xCE, 0x0C, 0x61, 0xC7, 0xF8,
  0x3F, 0x00, 0xE0, 0x7E, 0x07, 0xE0, 0x66, 0x0E, 0x60, 0xC6, 0x1C, 0x61,
  0x86, 0x38, 0x73, 0x07, 0x70, 0x76, 0x03, 0x60, 0x3C, 0x03, 0xC0, 0x3C,
  0x00, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x66, 0x73, 0x33, 0x99, 0xBC,
  0xD9, 0xEC, 0xCB, 0x66, 0xDB, 0x36, 0xD9, 0xA7, 0x8F, 0x3C, 0x79, 0xE3,
  0x8F, 0x00, 0x1C, 0x0E, 0x1C, 0x38, 0x38, 0x60, 0x31, 0x80, 0x77, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0D, 0x80, 0x3B, 0x80, 0xE3,
  0x03, 0x87, 0x06, 0x06, 0x3C, 0x0E, 0x00, 0xE0, 0x7F, 0x03, 0x18, 0x38,
  0xE3, 0x83, 0x18, 0x19, 0xC0, 0xFC, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x7F, 0xFB, 0xFF, 0x80, 0x1F, 0xC7, 0xF1,
  0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0F, 0xE3, 0xF8, 0xC3, 0x0C,
  0x10, 0x61, 0x86, 0x18, 0x20, 0xC3, 0x0C, 0x30, 0x41, 0x86, 0x18, 0x60,
  0xC3, 0x0F, 0xC7, 0xF0, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x87,
  0xE3, 0xF8, 0x03, 0x80, 0x78, 0x0F, 0x80, 0xCC, 0x18, 0xC3, 0x8E, 0x70,
  0x66, 0x06, 0xC0, 0x70, 0xFF, 0xFF, 0xF8, 0x5B, 0x36, 0x1E, 0x67, 0xED,
  0xC3, 0xB0, 0x7E, 0x0D, 0xC1, 0xB0, 0x36, 0x0E, 0xE3, 0xCF, 0xBD, 0xE3,
  0x80, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x67, 0x9D, 0xFB, 0xC7,
  0x70, 0x6C, 0x0D, 0x81, 0xB0, 0x7E, 0x0F, 0xC3, 0xB7, 0xE6, 0x78, 0x0F,
  0x83, 0xF8, 0xE3, 0xB8, 0x46, 0x00, 0xC0, 0x38, 0x23, 0x06, 0x71, 0xCF,
  0xF0, 0x78, 0x00, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x61, 0xE6,
  0x3F, 0x67, 0x0E, 0x60, 0xEE, 0x0E, 0xE0, 0xCC, 0x0C, 0xC1, 0xCE, 0x3C,
  0x7F, 0xC3, 0x9C, 0x0F, 0x83, 0xFC, 0xC3, 0xB0, 0x77, 0xFC, 0xFC, 0x38,
  0x03, 0x06, 0x71, 0xCF, 0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x7F, 0xE1, 0xFF, 0x80, 0xE0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x31, 0x80, 0xE6,
  0x01, 0xF8, 0x03, 0xC0, 0x07, 0x00, 0x0F, 0x31, 0xFB, 0x38, 0x73, 0x07,
  0x70, 0x77, 0x06, 0x70, 0x67, 0x0E, 0x71, 0x63, 0xFE, 0x1E, 0xC0, 0x0C,
  0x61, 0xCF, 0xF8, 0x3F, 0x00, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00,
  0x67, 0x8D, 0xF3, 0xC7, 0x70, 0xEE, 0x1D, 0x83, 0x30, 0x66, 0x0D, 0xC1,
  0xB8, 0x76, 0x0E, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x70, 0x18, 0x06, 0x01, 0x80, 0x62, 0x39, 0xCD, 0xC3, 0xE0, 0x70, 0x00,
  0xC0, 0x3C, 0x07, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x0C, 0x01, 0x80,
  0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC6, 0x38, 0xE6, 0x0E, 0xC0,
  0xF8, 0x0E, 0x00, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x3C,
  0x37, 0xE7, 0x8E, 0x70, 0xE7, 0x0C, 0x63, 0x86, 0xE0, 0x66, 0x2E, 0x77,
  0xE7, 0xCC, 0x38, 0xFE, 0x3F, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80,
  0x60, 0x18, 0x0E, 0x03, 0x80, 0xC6, 0x33, 0xCD, 0xC3, 0xE0, 0xE0, 0x36,
  0x71, 0xFB, 0xCC, 0xE6, 0xE6, 0x36, 0x33, 0x31, 0x99, 0x98, 0xCC, 0xC6,
  0xC6, 0x36, 0x31, 0xB1, 0x98, 0x33, 0xC6, 0xF9, 0xE3, 0xB8, 0x77, 0x0E,
  0xC1, 0x98, 0x33, 0x06, 0xE0, 0xDC, 0x3B, 0x07, 0x00, 0x0F, 0x87, 0xF9,
  0xC3, 0xB0, 0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x06, 0x61, 0xCF, 0xF0, 0xF8,
  0x00, 0x19, 0xE1, 0xBF, 0x3C, 0x73, 0x83, 0x30, 0x33, 0x03, 0x30, 0x77,
  0x07, 0x70, 0xE6, 0xFC, 0x67, 0x86, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x00,
  0x1E, 0x67, 0xED, 0xC3, 0xB0, 0x7E, 0x0F, 0xC1, 0xB0, 0x36, 0x0E, 0xE3,
  0xCF, 0xF8, 0xE6, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x7C, 0xFF, 0xFC,
  0x68, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0,
  0x00, 0x0F, 0x87, 0xFC, 0xC1, 0x38, 0x03, 0xE0, 0x7F, 0x01, 0xF0, 0x06,
  0x41, 0xDF, 0xF0, 0xFC, 0x00, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0xFF, 0xFF,
  0xF1, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x08, 0xC7, 0x37, 0x9F, 0x83, 0x80,
  0x60, 0xD8, 0x3E, 0x1F, 0x87, 0xC1, 0xB0, 0x6C, 0x1B, 0x0E, 0xC7, 0xBE,
  0xE7, 0x30, 0xF8, 0xDF, 0x1C, 0xE1, 0x98, 0x33, 0x06, 0x61, 0xCC, 0x33,
  0x8E, 0x77, 0x8F, 0xE0, 0xF0, 0x00, 0x63, 0x66, 0x66, 0x66, 0x3C, 0x63,
  0xC6, 0x3C, 0x66, 0xCC, 0x6C, 0xC6, 0xD4, 0x4F, 0x4C, 0xE7, 0x00, 0x0E,
  0x71, 0xF7, 0xDD, 0xA6, 0xC6, 0x30, 0x72, 0x03, 0x81, 0x1C, 0x18, 0xE6,
  0xCB, 0x77, 0xDF, 0x1C, 0x60, 0x18, 0x31, 0x83, 0x38, 0x73, 0x87, 0x30,
  0x63, 0x06, 0x30, 0x63, 0x0E, 0x31, 0xE3, 0xFE, 0x1E, 0xC0, 0x0C, 0x61,
  0xCF, 0xF8, 0x3E, 0x00, 0x3E, 0x73, 0xFE, 0x61, 0xE6, 0x1C, 0x03, 0x00,
  0xE0, 0x1C, 0x43, 0x0C, 0xFC, 0x6D, 0xFE, 0xC7, 0xC0, 0x07, 0xE0, 0xFC,
  0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x0F, 0x83, 0xF0,
  0x07, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFC, 0x1F,
  0x80, 0x18, 0xC6, 0x31, 0x8C, 0xC6, 0x31, 0x8C, 0x66, 0x31, 0x8C, 0x63,
  0x31, 0x80, 0x1F, 0x07, 0xE0, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x30,
  0x0C, 0x01, 0xF0, 0xFC, 0x70, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x0F, 0xC3, 0xE0, 0x38, 0x37, 0xC6, 0x6E, 0x6C, 0x7C, 0xC3, 0x80,
};

const GFXglyph IBMPlexMono_MediumItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 15, 13, 4, -15 },
  { 11, 8, 7, 13, 4, -16 },
  { 18, 14, 15, 13, 0, -15 },
  { 45, 13, 19, 13, 0, -17 },
  { 76, 16, 15, 13, -1, -15 },
  { 106, 13, 15, 13, 0, -15 },
  { 131, 3, 7, 13, 6, -16 },
  { 134, 9, 20, 13, 4, -17 },
  { 157, 8, 20, 13, 1, -17 },
  { 177, 12, 11, 13, 1, -12 },
  { 194, 11, 10, 13, 1, -12 },
  { 208, 5, 6, 13, 3, -3 },
  { 212, 7, 2, 13, 3, -8 },
  { 214, 4, 4, 13, 4, -4 },
  { 216, 13, 20, 13, 0, -17 },
  { 249, 12, 15, 13, 1, -15 },
  { 272, 11, 15, 13, 1, -15 },
  { 293, 12, 15, 13, 0, -15 },
  { 316, 12, 15, 13, 0, -15 },
  { 339, 12, 15, 13, 0, -15 },
  { 362, 12, 15, 13, 1, -15 },
  { 385, 11, 15, 13, 1, -15 },
  { 406, 11, 15, 13, 2, -15 },
  { 427, 12, 15, 13, 1, -15 },
  { 450, 11, 15, 13, 2, -15 },
  { 471, 5, 12, 13, 4, -12 },
  { 479, 6, 15, 13, 3, -12 },
  { 491, 11, 13, 13, 2, -13 },
  { 509, 12, 7, 13, 1, -10 },
  { 520, 11, 13, 13, 1, -13 },
  { 538, 9, 15, 13, 3, -15 },
  { 555, 12, 17, 13, 1, -15 },
  { 581, 12, 15, 13, 0, -15 },
  { 604, 11, 15, 13, 1, -15 },
  { 625, 12, 15, 13, 1, -15 },
  { 648, 12, 15, 13, 1, -15 },
  { 671, 12, 15, 13, 1, -15 },
  { 694, 12, 15, 13, 1, -15 },
  { 717, 12, 15, 13, 1, -15 },
  { 740, 12, 15, 13, 1, -15 },
  { 763, 12, 15, 13, 1, -15 },
  { 786, 11, 15, 13, 1, -15 },
  { 807, 13, 15, 13, 1, -15 },
  { 832, 10, 15, 13, 1, -15 },
  { 851, 14, 15, 13, 0, -15 },
  { 878, 12, 15, 13, 1, -15 },
  { 901, 12, 15, 13, 1, -15 },
  { 924, 12, 15, 13, 1, -15 },
  { 947, 12, 19, 13, 1, -15 },
  { 976, 12, 15, 13, 1, -15 },
  { 999, 13, 15, 13, 0, -15 },
  { 1024, 12, 15, 13, 2, -15 },
  { 1047, 12, 15, 13, 1, -15 },
  { 1070, 12, 15, 13, 2, -15 },
  { 1093, 13, 15, 13, 1, -15 },
  { 1118, 15, 15, 13, -1, -15 },
  { 1147, 13, 15, 13, 2, -15 },
  { 1172, 13, 15, 13, 0, -15 },
  { 1197, 10, 20, 13, 3, -17 },
  { 1222, 6, 20, 13, 4, -17 },
  { 1237, 10, 20, 13, 0, -17 },
  { 1262, 12, 9, 13, 1, -15 },
  { 1276, 11, 2, 13, 0, 2 },
  { 1279, 3, 5, 13, 5, -18 },
  { 1281, 11, 11, 13, 1, -11 },
  { 1297, 11, 16, 13, 1, -16 },
  { 1319, 11, 11, 13, 1, -11 },
  { 1335, 12, 16, 13, 1, -16 },
  { 1359, 11, 11, 13, 1, -11 },
  { 1375, 14, 20, 13, 0, -16 },
  { 1410, 12, 15, 13, 0, -11 },
  { 1433, 11, 16, 13, 1, -16 },
  { 1455, 10, 16, 13, 2, -16 },
  { 1475, 11, 20, 13, 1, -16 },
  { 1503, 12, 16, 13, 1, -16 },
  { 1527, 10, 16, 13, 2, -16 },
  { 1547, 13, 11, 13, 0, -11 },
  { 1565, 11, 11, 13, 1, -11 },
  { 1581, 11, 11, 13, 1, -11 },
  { 1597, 12, 15, 13, 0, -11 },
  { 1620, 11, 15, 13, 1, -11 },
  { 1641, 11, 11, 13, 2, -11 },
  { 1657, 11, 11, 13, 1, -11 },
  { 1673, 10, 15, 13, 2, -15 },
  { 1692, 10, 11, 13, 2, -11 },
  { 1706, 11, 11, 13, 1, -11 },
  { 1722, 12, 11, 13, 1, -11 },
  { 1739, 13, 11, 13, 0, -11 },
  { 1757, 12, 15, 13, 0, -11 },
  { 1780, 12, 11, 13, 1, -11 },
  { 1797, 11, 20, 13, 2, -17 },
  { 1825, 5, 20, 13, 4, -17 },
  { 1838, 10, 20, 13, 1, -17 },
  { 1863, 12, 5, 13, 1, -9 },
};

const GFXfont IBMPlexMono_MediumItalic22pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic22pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _IBMPLEXMONO_MEDIUMITALIC22PT7B_H_
