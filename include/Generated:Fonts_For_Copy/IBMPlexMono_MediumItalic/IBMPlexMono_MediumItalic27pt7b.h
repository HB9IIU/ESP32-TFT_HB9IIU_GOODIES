#ifndef _IBMPLEXMONO_MEDIUMITALIC27PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x38, 0x70, 0xE1, 0xC3, 0x86, 0x0C, 0x38, 0x60, 0xC1, 0x80,
  0x00, 0x00, 0x38, 0xF9, 0xE3, 0xC0, 0x73, 0xB9, 0xDC, 0xEC, 0x76, 0x3F,
  0x1B, 0x9D, 0xCE, 0x00, 0xC7, 0x00, 0xE3, 0x00, 0x73, 0x80, 0x31, 0x80,
  0x18, 0xC0, 0x1C, 0xE0, 0xFC, 0x7E, 0x7E, 0x3F, 0x07, 0x38, 0x03, 0x18,
  0x03, 0x9C, 0x1F, 0xCF, 0xCF, 0xC7, 0xE0, 0xE7, 0x00, 0x73, 0x80, 0x31,
  0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x0C, 0x60, 0x00, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x3F, 0x80, 0xFF, 0xC3, 0x9B, 0xCE, 0x33, 0x1C, 0xC0, 0x39,
  0x80, 0x73, 0x00, 0xF6, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xCE,
  0x01, 0x8E, 0x03, 0x1C, 0x06, 0x3B, 0x0C, 0xE7, 0xB3, 0xC7, 0xFF, 0x03,
  0xF8, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x07, 0x80, 0xE1, 0xF8, 0x38,
  0x73, 0x86, 0x0C, 0x31, 0x81, 0x86, 0x70, 0x30, 0xCC, 0x06, 0x3B, 0x00,
  0xC6, 0xE0, 0x1F, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xFC, 0x03, 0xB1, 0x80,
  0x6E, 0x38, 0x19, 0xC7, 0x07, 0x30, 0xC0, 0xC6, 0x18, 0x30, 0xE7, 0x0E,
  0x0F, 0xC3, 0x80, 0xF0, 0x00, 0x01, 0xF0, 0x03, 0xF8, 0x07, 0x1C, 0x0E,
  0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x06, 0x1C, 0x07, 0x18, 0x07, 0x30, 0x3F,
  0xE0, 0x73, 0x80, 0x61, 0x80, 0xE1, 0xC0, 0xE1, 0xC0, 0xE0, 0xE3, 0xE1,
  0x66, 0xF1, 0x76, 0x7E, 0x7C, 0x3C, 0x38, 0x76, 0x6E, 0xEE, 0xEC, 0x01,
  0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0E,
  0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01,
  0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0E, 0x00, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C,
  0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0C,
  0x03, 0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x00, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x73, 0x8D, 0xFF, 0xFB, 0xFF, 0x81, 0xF0, 0x0F,
  0x80, 0x7F, 0x03, 0xCE, 0x0E, 0x38, 0x70, 0x70, 0x03, 0x80, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xE0, 0xC0, 0x06, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0x1E, 0x38, 0xF1, 0xC3, 0x8E, 0x1C, 0x70, 0xFF,
  0xFF, 0x80, 0x77, 0xFD, 0xE0, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x78,
  0x70, 0xE0, 0xE3, 0x80, 0xC7, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x73, 0x9E,
  0xE7, 0x3B, 0xCE, 0x77, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0x18, 0x0E, 0x38,
  0x38, 0x70, 0xF0, 0x7F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF8,
  0x3D, 0xC3, 0xCE, 0x3C, 0x70, 0xC3, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x87, 0xFF,
  0xFF, 0xFE, 0x07, 0xE0, 0x7F, 0xE1, 0xC3, 0xCE, 0x07, 0x10, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xFF, 0xEF, 0xFF, 0x80,
  0x07, 0xF0, 0x7F, 0xE3, 0xC3, 0xC6, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0xC0, 0x1E, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0xB0, 0x1C, 0xF0, 0xF1, 0xFF, 0x83, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x78, 0x01, 0xF0, 0x07, 0xE0, 0x1D, 0xC0, 0x73, 0x80, 0xE7, 0x03,
  0x8C, 0x0E, 0x38, 0x38, 0x70, 0xE0, 0xE3, 0xC1, 0xC7, 0x03, 0x8F, 0xFF,
  0xFF, 0xFF, 0x80, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x0F, 0xFE,
  0x3F, 0xF8, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1D,
  0xF0, 0x37, 0xF0, 0x70, 0xF1, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x30, 0x3C, 0xF0, 0xF0, 0xFF, 0xC0, 0x7E, 0x00, 0x00, 0xF8,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x78,
  0x7F, 0xF9, 0xE0, 0xE7, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03,
  0x9C, 0x0E, 0x78, 0x70, 0xFF, 0x81, 0xF8, 0x00, 0x7F, 0xFD, 0xFF, 0xF7,
  0x01, 0xD8, 0x0E, 0x60, 0x39, 0x81, 0xC8, 0x0F, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x78, 0x71,
  0xC0, 0xF3, 0x80, 0xE7, 0x03, 0x8E, 0x07, 0x0E, 0x1C, 0x0F, 0xE0, 0x3F,
  0xE0, 0xE1, 0xE3, 0x81, 0xCE, 0x01, 0xDC, 0x07, 0xB8, 0x0E, 0x70, 0x1C,
  0xF0, 0x70, 0xFF, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0x7F, 0xC3, 0x87, 0x9C,
  0x0E, 0x70, 0x1B, 0x80, 0x6E, 0x03, 0xF8, 0x0E, 0xE0, 0x39, 0xC3, 0xE7,
  0xFF, 0x8F, 0x9C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x00, 0x3C, 0xF7, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x3E, 0xF3, 0xC0, 0x0F, 0x0F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x1C, 0x3C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0x00, 0x08, 0x00,
  0xC0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x0E, 0x00, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0x80, 0x04, 0x7F,
  0xFD, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xBF,
  0xFE, 0x10, 0x00, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0x00, 0x78, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x01,
  0x80, 0x10, 0x00, 0x0F, 0x83, 0xFE, 0x70, 0xFE, 0x07, 0x20, 0x70, 0x07,
  0x00, 0xF0, 0x0E, 0x07, 0xE1, 0xF8, 0x1E, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x38, 0x00, 0x03, 0xF0, 0x3F, 0xE1,
  0xE1, 0xC6, 0x03, 0x38, 0x0C, 0xC0, 0x37, 0x0E, 0xDC, 0xFF, 0x63, 0x9D,
  0x9C, 0x36, 0x71, 0xF9, 0x87, 0xE6, 0x1B, 0x98, 0x6E, 0x63, 0xB9, 0xF6,
  0xE3, 0xF9, 0x80, 0x06, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xDC, 0x01, 0xDC, 0x01, 0x9C, 0x03,
  0x9C, 0x03, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x0E, 0x0C, 0x0F, 0xFE, 0x1F,
  0xFE, 0x1C, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x30, 0x0E, 0x70, 0x0E, 0xF0,
  0x0F, 0x1F, 0xF0, 0x7F, 0xE1, 0xC1, 0xC7, 0x07, 0x38, 0x1C, 0xE0, 0x73,
  0x81, 0xCE, 0x0E, 0x3F, 0xF0, 0xFF, 0xC3, 0x03, 0x9C, 0x0E, 0x70, 0x39,
  0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x60, 0x73, 0xFF, 0x8F, 0xFC, 0x00, 0x03,
  0xE0, 0x3F, 0xE1, 0xC3, 0x8E, 0x07, 0x70, 0x19, 0xC0, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x81, 0x0E,
  0x03, 0xB8, 0x1C, 0x70, 0xF1, 0xFF, 0x81, 0xF8, 0x00, 0x1F, 0xE0, 0x3F,
  0xF0, 0x70, 0xE0, 0xE0, 0xE1, 0x81, 0xC7, 0x03, 0x8E, 0x03, 0x9C, 0x0F,
  0x38, 0x1C, 0x70, 0x38, 0xE0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x07, 0x1C,
  0x0E, 0x38, 0x38, 0x70, 0xF1, 0xFF, 0xC3, 0xFE, 0x00, 0x1F, 0xFE, 0x3F,
  0xFC, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x3F, 0xF8, 0x7F, 0xF0, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x1F, 0xFE, 0x3F,
  0xFC, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x3F, 0xF8, 0x7F, 0xF0, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x3F,
  0xC1, 0xC3, 0x8E, 0x0E, 0x70, 0x1D, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x8F, 0xEE, 0x3F, 0xB8, 0x0C, 0xE0, 0x33, 0x81, 0xCE, 0x07, 0x38,
  0x3C, 0xF1, 0x71, 0xFD, 0x83, 0xE6, 0x00, 0x1C, 0x0E, 0x38, 0x1C, 0x70,
  0x39, 0xC0, 0x73, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x3F, 0xFC,
  0xFF, 0xF9, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x70,
  0x1C, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xC0, 0x1F, 0xFE, 0x3F, 0xFC, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x07, 0xFC, 0x3F, 0xF0, 0x01,
  0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC6, 0x07, 0x38, 0x38, 0x70,
  0xE1, 0xFF, 0x01, 0xF8, 0x00, 0x1C, 0x07, 0x8E, 0x07, 0x07, 0x07, 0x03,
  0x87, 0x03, 0x87, 0x01, 0xC7, 0x80, 0xE7, 0x80, 0x77, 0x80, 0x3F, 0x80,
  0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xB8, 0x07, 0x8E, 0x03, 0x87, 0x01, 0xC1,
  0xC0, 0xE0, 0xE0, 0xE0, 0x78, 0x70, 0x1C, 0x38, 0x0F, 0x00, 0x1C, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1E, 0x07, 0x8F, 0x07, 0x87, 0xC3, 0xC3, 0xE3, 0xE1,
  0xB1, 0xF0, 0xD9, 0xB8, 0xEC, 0xDC, 0x77, 0xCC, 0x39, 0xE6, 0x1C, 0xE7,
  0x0C, 0x73, 0x86, 0x31, 0xC7, 0x18, 0xE3, 0x88, 0x61, 0xC0, 0x30, 0xE0,
  0x38, 0x60, 0x1C, 0x30, 0x0E, 0x38, 0x07, 0x00, 0x1E, 0x0E, 0x3C, 0x1C,
  0x78, 0x39, 0xF8, 0x73, 0xF0, 0xC7, 0xE1, 0x8E, 0xC7, 0x19, 0x8E, 0x33,
  0x9C, 0xE7, 0x39, 0xCE, 0x63, 0x8C, 0xC7, 0x1B, 0x8C, 0x3F, 0x18, 0x7E,
  0x70, 0xFC, 0xE0, 0xF1, 0xC1, 0xE3, 0x83, 0xC0, 0x03, 0xF0, 0x1F, 0xF0,
  0x78, 0xF0, 0xE0, 0xE3, 0x80, 0xC7, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70,
  0x1E, 0xE0, 0x3B, 0xC0, 0x77, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0x18, 0x0E,
  0x38, 0x38, 0x78, 0xF0, 0x7F, 0xC0, 0x7E, 0x00, 0x1F, 0xF8, 0x3F, 0xF8,
  0x70, 0x78, 0xE0, 0x71, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x0E, 0x38,
  0x3C, 0x7F, 0xF0, 0xFF, 0x83, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0xF0,
  0x78, 0xF0, 0xE0, 0xE3, 0x80, 0xC7, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70,
  0x1E, 0xE0, 0x3B, 0xC0, 0x77, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0x18, 0x0E,
  0x38, 0x38, 0x78, 0xF0, 0x7F, 0xC0, 0x7E, 0x00, 0x38, 0x00, 0x38, 0xC0,
  0x3B, 0x00, 0x7C, 0x00, 0x70, 0x1F, 0xF8, 0x3F, 0xF8, 0x70, 0x70, 0xE0,
  0x71, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x0E, 0x38, 0x3C, 0x7F, 0xF0,
  0xFF, 0x83, 0x8E, 0x07, 0x1C, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70,
  0x71, 0xC0, 0xE3, 0x81, 0xE0, 0x03, 0xF0, 0x1F, 0xF8, 0x70, 0x79, 0xC0,
  0x63, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x1F, 0xE0,
  0x03, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x60, 0x1C, 0xF0,
  0x70, 0xFF, 0xC0, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x38, 0x1C, 0xE0, 0x77, 0x01,
  0xDC, 0x07, 0x70, 0x1D, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0xE0, 0x3B, 0x80,
  0xEE, 0x03, 0xB8, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x38, 0xE1,
  0xE1, 0xFF, 0x03, 0xF0, 0x00, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xB8, 0x0E,
  0xE0, 0x73, 0x81, 0xCE, 0x07, 0x18, 0x38, 0x70, 0xE1, 0xC7, 0x07, 0x1C,
  0x1C, 0xE0, 0x73, 0x81, 0xCC, 0x07, 0x70, 0x1D, 0xC0, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x00, 0x30, 0x03, 0x70, 0x03, 0x70, 0x07, 0x70, 0x07, 0x70,
  0x06, 0x71, 0xC6, 0x73, 0xCE, 0x63, 0xCE, 0x63, 0xCC, 0x66, 0xCC, 0x66,
  0xCC, 0x6E, 0xDC, 0xEC, 0xDC, 0xEC, 0xD8, 0xF8, 0xD8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0x0E, 0x01, 0xC1, 0xC0, 0xE0, 0x70, 0x78,
  0x1E, 0x3C, 0x03, 0x8E, 0x00, 0xE7, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0x38, 0x01, 0xCE,
  0x00, 0xE3, 0xC0, 0x70, 0x70, 0x3C, 0x1E, 0x1E, 0x03, 0x8F, 0x00, 0xF0,
  0xF0, 0x0F, 0x70, 0x1E, 0x70, 0x1C, 0x38, 0x38, 0x38, 0x78, 0x38, 0x70,
  0x1C, 0xE0, 0x1D, 0xE0, 0x1D, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xFF, 0xFC, 0xFF, 0xFC, 0x0F, 0xF0, 0xFF, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0xC1, 0x83, 0x87, 0x06, 0x0C, 0x18,
  0x38, 0x70, 0x60, 0xC1, 0x83, 0x87, 0x06, 0x0C, 0x18, 0x38, 0x70, 0x60,
  0xC1, 0x83, 0x87, 0x06, 0x0F, 0xF8, 0x7F, 0x80, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0E, 0x0F, 0xF0, 0xFF, 0x80, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x3B, 0x80, 0xE3, 0x01, 0xC7, 0x07, 0x0E, 0x1C, 0x0C,
  0x38, 0x1C, 0xE0, 0x3B, 0x80, 0x38, 0xFF, 0xFF, 0xFF, 0xC0, 0x4E, 0xE6,
  0x72, 0x0F, 0x9C, 0x7F, 0x73, 0xC7, 0x9E, 0x0E, 0x70, 0x39, 0xC0, 0xEF,
  0x03, 0xB8, 0x0E, 0xE0, 0x7B, 0x81, 0xCE, 0x0F, 0x1C, 0x7C, 0x7F, 0x7C,
  0xF8, 0xE0, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x9F, 0x0E, 0xFE, 0x3E, 0x38, 0xF0, 0x73, 0x81, 0xDC, 0x07, 0x70,
  0x1D, 0xC0, 0x77, 0x03, 0x9C, 0x0E, 0x70, 0x3B, 0xA3, 0xCE, 0xFE, 0x39,
  0xF0, 0x07, 0xC1, 0xFF, 0x38, 0x77, 0x02, 0x70, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x02, 0xE0, 0x77, 0x0E, 0x7F, 0xC1, 0xF0, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x83, 0xE7, 0x0F,
  0xEE, 0x3C, 0x3C, 0xF0, 0x79, 0xC0, 0xE3, 0x81, 0xCF, 0x03, 0x9C, 0x07,
  0x38, 0x0E, 0x70, 0x3C, 0xE0, 0x70, 0xE3, 0xE1, 0xFD, 0xC1, 0xF3, 0x80,
  0x07, 0xC0, 0xFF, 0x8E, 0x1C, 0xE0, 0x76, 0x07, 0x70, 0xFB, 0xFF, 0x9F,
  0xE0, 0xE0, 0x07, 0x01, 0x38, 0x1D, 0xE1, 0xC7, 0xFC, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x0F, 0xF0, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x01, 0x87, 0x00, 0xF1, 0xC0, 0x0E, 0x60,
  0x03, 0xB8, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x9C, 0x7F, 0x73,
  0xC3, 0xCE, 0x0F, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0xB8, 0x0E, 0xE0, 0x3B,
  0x81, 0xC7, 0x07, 0x1C, 0x7C, 0x7F, 0x70, 0xF9, 0xC0, 0x07, 0x00, 0x38,
  0xE1, 0xE3, 0xFF, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0xE3, 0xC7, 0x7F, 0x3A, 0x39, 0xE1, 0xCE, 0x0E,
  0x70, 0x77, 0x03, 0xB8, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x73, 0x83, 0xB8,
  0x1D, 0xC0, 0xE0, 0x03, 0x80, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0xC3, 0x8F, 0x1C, 0xE0, 0xEE, 0x07, 0xE0, 0x1E, 0x00,
  0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0xC3, 0x8F, 0x38, 0x39, 0xC0,
  0xEE, 0x03, 0xE0, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x0E, 0x3C, 0x1D, 0xFC, 0x3E, 0x38, 0x78, 0x70,
  0xE0, 0xE1, 0xC1, 0xC7, 0x07, 0x0E, 0x78, 0x1D, 0xC0, 0x39, 0xC4, 0x73,
  0x8E, 0xE3, 0xB3, 0x87, 0xC7, 0x07, 0x00, 0xFF, 0x1F, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x19, 0xCE, 0x73, 0x8E, 0xE0, 0xF8, 0x1E, 0x00, 0x3B,
  0x8E, 0x3F, 0xDE, 0x39, 0xE7, 0x39, 0xC7, 0x31, 0xC6, 0x71, 0xC6, 0x71,
  0x86, 0x71, 0x8E, 0x61, 0x8E, 0x63, 0x8E, 0x63, 0x8C, 0xE3, 0x8C, 0xE3,
  0x0C, 0xE3, 0x1C, 0x38, 0xF1, 0xDF, 0xCE, 0x8E, 0x78, 0x73, 0x83, 0x9C,
  0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x1C, 0xE0, 0xEE, 0x07,
  0x70, 0x38, 0x07, 0xE0, 0x7F, 0xC3, 0xC3, 0x8E, 0x06, 0x70, 0x1D, 0xC0,
  0x77, 0x01, 0xFC, 0x0F, 0xE0, 0x39, 0x80, 0xE7, 0x07, 0x9C, 0x3C, 0x3F,
  0xE0, 0x3E, 0x00, 0x1C, 0xF8, 0x3B, 0xF8, 0x7C, 0x70, 0xF0, 0x71, 0xC0,
  0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x73,
  0xA3, 0xC7, 0x7F, 0x0E, 0x7C, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x0F, 0x9C, 0x7F, 0x73, 0xC3, 0xDE, 0x0F, 0x70, 0x39,
  0xC0, 0xEF, 0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x81, 0xEE, 0x07, 0x1C, 0x7C,
  0x7F, 0x70, 0xF9, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0xFE, 0x7F, 0xE7, 0xC7, 0x40, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00,
  0x07, 0xE0, 0xFF, 0xCF, 0x0E, 0x70, 0x23, 0x80, 0x1E, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x70, 0x01, 0xD0, 0x0D, 0xE0, 0xE7, 0xFE, 0x0F, 0xC0, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xC0,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x10, 0x61, 0xC7,
  0x1C, 0x3B, 0xC1, 0xF8, 0x07, 0x80, 0x70, 0x3B, 0x81, 0xDC, 0x0E, 0xE0,
  0x67, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x07, 0x38, 0x79,
  0xC5, 0xCF, 0xEE, 0x1E, 0x70, 0x7C, 0x19, 0xF0, 0xE9, 0xC1, 0xC7, 0x07,
  0x1C, 0x1C, 0x70, 0x73, 0x83, 0x8E, 0x0E, 0x38, 0x38, 0xE1, 0xC3, 0x8E,
  0x0E, 0xF8, 0x3F, 0x80, 0x78, 0x00, 0x71, 0x8D, 0xC6, 0x77, 0x18, 0xD8,
  0x63, 0x63, 0x8D, 0x8E, 0x3E, 0x30, 0xF8, 0xC3, 0xE3, 0x0F, 0x1C, 0x7C,
  0x71, 0xB3, 0xC6, 0xFB, 0x31, 0xC7, 0x00, 0x07, 0x1E, 0x1F, 0xBF, 0x39,
  0xA7, 0x71, 0xE3, 0x41, 0xC3, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0xE3, 0x84, 0xE3, 0xCE, 0xE5, 0xDC, 0xFC, 0xF8, 0x78, 0xF0, 0x1C,
  0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x61, 0xC1, 0xC7, 0x03, 0x8E, 0x07,
  0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x70, 0xE0, 0xE1, 0xC7, 0xC1, 0xFB, 0x81,
  0xE7, 0x00, 0x0C, 0x00, 0x38, 0x70, 0xE1, 0xFF, 0x80, 0xFE, 0x00, 0x0F,
  0x8C, 0xFF, 0xF3, 0x0F, 0xCC, 0x1E, 0x70, 0xF0, 0x07, 0x80, 0x38, 0x01,
  0xC0, 0x0E, 0x38, 0x70, 0x67, 0x81, 0xBF, 0xE6, 0xEF, 0xFB, 0x87, 0xC0,
  0x03, 0xF8, 0x3F, 0xC1, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x00, 0x1C, 0x01, 0xC1, 0xFC, 0x0F, 0xC0, 0x03, 0x00, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x87, 0x0C,
  0x18, 0x30, 0xE1, 0xC3, 0x86, 0x0C, 0x18, 0x70, 0xE1, 0xC3, 0x06, 0x0C,
  0x38, 0x70, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x07, 0xF0, 0x3F,
  0x83, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x1C, 0x1F, 0xC0, 0xFE, 0x00, 0x1E, 0x0E, 0x7E, 0x19,
  0xCC, 0x73, 0x1C, 0xCE, 0x1F, 0x98, 0x1E, 0x00,
};

const GFXglyph IBMPlexMono_MediumItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 7, 19, 16, 5, -19 },
  { 18, 9, 8, 16, 5, -20 },
  { 27, 17, 19, 16, 0, -19 },
  { 68, 15, 25, 16, 1, -22 },
  { 115, 19, 19, 16, -1, -19 },
  { 161, 16, 19, 16, 0, -19 },
  { 199, 4, 8, 16, 8, -20 },
  { 203, 11, 25, 16, 5, -21 },
  { 238, 11, 25, 16, 1, -21 },
  { 273, 14, 13, 16, 1, -15 },
  { 296, 13, 12, 16, 2, -14 },
  { 316, 7, 8, 16, 3, -4 },
  { 323, 9, 2, 16, 4, -9 },
  { 326, 5, 4, 16, 5, -4 },
  { 329, 16, 25, 16, 0, -21 },
  { 379, 15, 19, 16, 1, -19 },
  { 415, 13, 19, 16, 1, -19 },
  { 446, 14, 19, 16, 1, -19 },
  { 480, 14, 19, 16, 1, -19 },
  { 514, 15, 19, 16, 0, -19 },
  { 550, 15, 19, 16, 1, -19 },
  { 586, 14, 19, 16, 1, -19 },
  { 620, 14, 19, 16, 2, -19 },
  { 654, 15, 19, 16, 1, -19 },
  { 690, 14, 19, 16, 2, -19 },
  { 724, 6, 14, 16, 5, -14 },
  { 735, 8, 18, 16, 3, -14 },
  { 753, 13, 16, 16, 2, -16 },
  { 779, 14, 8, 16, 1, -12 },
  { 793, 13, 16, 16, 1, -16 },
  { 819, 12, 19, 16, 3, -19 },
  { 848, 14, 22, 16, 1, -19 },
  { 887, 16, 19, 16, -1, -19 },
  { 925, 14, 19, 16, 1, -19 },
  { 959, 14, 19, 16, 2, -19 },
  { 993, 15, 19, 16, 1, -19 },
  { 1029, 15, 19, 16, 1, -19 },
  { 1065, 15, 19, 16, 1, -19 },
  { 1101, 14, 19, 16, 2, -19 },
  { 1135, 15, 19, 16, 1, -19 },
  { 1171, 15, 19, 16, 1, -19 },
  { 1207, 14, 19, 16, 1, -19 },
  { 1241, 17, 19, 16, 1, -19 },
  { 1282, 12, 19, 16, 2, -19 },
  { 1311, 17, 19, 16, 0, -19 },
  { 1352, 15, 19, 16, 1, -19 },
  { 1388, 15, 19, 16, 1, -19 },
  { 1424, 15, 19, 16, 1, -19 },
  { 1460, 15, 24, 16, 1, -19 },
  { 1505, 15, 19, 16, 1, -19 },
  { 1541, 15, 19, 16, 1, -19 },
  { 1577, 16, 19, 16, 2, -19 },
  { 1615, 14, 19, 16, 2, -19 },
  { 1649, 14, 19, 16, 3, -19 },
  { 1683, 16, 19, 16, 1, -19 },
  { 1721, 18, 19, 16, -1, -19 },
  { 1764, 16, 19, 16, 2, -19 },
  { 1802, 16, 19, 16, 0, -19 },
  { 1840, 12, 25, 16, 4, -21 },
  { 1878, 7, 25, 16, 5, -21 },
  { 1900, 13, 25, 16, 0, -21 },
  { 1941, 15, 11, 16, 1, -19 },
  { 1962, 13, 2, 16, 0, 3 },
  { 1966, 4, 6, 16, 6, -22 },
  { 1969, 14, 14, 16, 1, -14 },
  { 1994, 14, 20, 16, 1, -20 },
  { 2029, 12, 14, 16, 2, -14 },
  { 2050, 15, 20, 16, 1, -20 },
  { 2088, 13, 14, 16, 2, -14 },
  { 2111, 18, 25, 16, -1, -20 },
  { 2168, 14, 19, 16, 1, -14 },
  { 2202, 13, 20, 16, 1, -20 },
  { 2235, 13, 20, 16, 2, -20 },
  { 2268, 13, 25, 16, 1, -20 },
  { 2309, 15, 20, 16, 1, -20 },
  { 2347, 11, 20, 16, 3, -20 },
  { 2375, 16, 14, 16, 0, -14 },
  { 2403, 13, 14, 16, 1, -14 },
  { 2426, 14, 14, 16, 1, -14 },
  { 2451, 15, 19, 16, 0, -14 },
  { 2487, 14, 19, 16, 1, -14 },
  { 2521, 13, 14, 16, 3, -14 },
  { 2544, 13, 14, 16, 1, -14 },
  { 2567, 13, 19, 16, 2, -19 },
  { 2598, 13, 14, 16, 2, -14 },
  { 2621, 14, 14, 16, 1, -14 },
  { 2646, 14, 14, 16, 1, -14 },
  { 2671, 16, 14, 16, 0, -14 },
  { 2699, 15, 19, 16, 0, -14 },
  { 2735, 14, 14, 16, 1, -14 },
  { 2760, 13, 25, 16, 3, -21 },
  { 2801, 7, 25, 16, 5, -21 },
  { 2823, 13, 25, 16, 1, -21 },
  { 2864, 15, 6, 16, 1, -11 },
};

const GFXfont IBMPlexMono_MediumItalic27pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic27pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic27pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _IBMPLEXMONO_MEDIUMITALIC27PT7B_H_
