#ifndef _IBMPLEXMONO_MEDIUMITALIC49PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFE, 0x07, 0xC0, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xC7, 0xC3,
  0xE3, 0xE1, 0xF1, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1E, 0x3E,
  0x1F, 0x1F, 0x0F, 0x8F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF0,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0x3E, 0x1F, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xE1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0x07, 0x80, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x07, 0x83, 0xC0, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x1F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0x03, 0xE1, 0xF0,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x3C, 0x1F, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x3C, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07,
  0xF9, 0xCF, 0xF0, 0x7E, 0x1C, 0x3E, 0x0F, 0xC1, 0xC1, 0xC0, 0xF8, 0x3C,
  0x08, 0x0F, 0x83, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x83, 0x80, 0x00,
  0xFC, 0x38, 0x00, 0x0F, 0xE3, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0x3F, 0x80, 0x00,
  0xF1, 0xFC, 0x00, 0x0E, 0x0F, 0xC0, 0x00, 0xE0, 0xFC, 0x00, 0x0E, 0x0F,
  0xC1, 0x01, 0xE0, 0xFC, 0x10, 0x1E, 0x0F, 0x87, 0x81, 0xE1, 0xF8, 0xFE,
  0x1C, 0x3F, 0x8F, 0xF9, 0xCF, 0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x03, 0xC0, 0x7F, 0xF0, 0x03, 0xC0, 0x7F, 0xF8, 0x03, 0xE0, 0x7C, 0x3E,
  0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0x81, 0xF0, 0x1E, 0x03,
  0xC0, 0xF0, 0x0F, 0x01, 0xE0, 0xF0, 0x07, 0x80, 0xF0, 0xF8, 0x03, 0xC0,
  0x78, 0x78, 0x01, 0xE0, 0x78, 0x78, 0x00, 0xF0, 0x3C, 0x7C, 0x00, 0x7C,
  0x3E, 0x3C, 0x00, 0x3F, 0xFE, 0x3C, 0x00, 0x0F, 0xFE, 0x3E, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xC7, 0xFF, 0x00, 0x03, 0xC7, 0xFF, 0xC0,
  0x03, 0xC7, 0xC3, 0xE0, 0x03, 0xE3, 0xC0, 0xF0, 0x01, 0xE1, 0xE0, 0x78,
  0x01, 0xE1, 0xE0, 0x3C, 0x01, 0xF0, 0xF0, 0x1E, 0x00, 0xF0, 0x78, 0x0F,
  0x00, 0xF0, 0x3C, 0x07, 0x80, 0xF8, 0x1E, 0x07, 0xC0, 0x78, 0x0F, 0x03,
  0xC0, 0x78, 0x07, 0xC3, 0xE0, 0x7C, 0x01, 0xFF, 0xE0, 0x3C, 0x00, 0xFF,
  0xE0, 0x3C, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3E,
  0x01, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x07,
  0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xFE, 0x7C, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xE1,
  0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0xFC, 0x07, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0xF8, 0x09,
  0xF8, 0x07, 0xC0, 0xFF, 0xC0, 0x3F, 0x0F, 0xFE, 0x03, 0xF8, 0x79, 0xF0,
  0x1B, 0xE7, 0x8F, 0xC3, 0x9F, 0x7C, 0x7F, 0xFC, 0x7F, 0xC1, 0xFF, 0xC3,
  0xFE, 0x07, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0x3C, 0x00, 0x3E, 0x7C, 0xF9,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x7C, 0x06,
  0x3E, 0x1F, 0x0F, 0x9F, 0xF7, 0xDF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x7E, 0x7E, 0x00,
  0x3F, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xE0, 0x0F,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xFC,
  0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x7C, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF,
  0xFE, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81,
  0xFE, 0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x07,
  0xC7, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x3F, 0x00,
  0x07, 0xCF, 0x80, 0x01, 0xF7, 0xE0, 0x00, 0x7D, 0xF8, 0x3C, 0x1F, 0x7E,
  0x1F, 0x87, 0xDF, 0x8F, 0xE3, 0xF7, 0xC3, 0xF0, 0xFD, 0xF0, 0xFC, 0x3F,
  0x7C, 0x1E, 0x0F, 0xDF, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFB, 0xF0, 0x00,
  0x7E, 0x7C, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xC7, 0xC0, 0x03, 0xF1, 0xF0,
  0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x03, 0xF8, 0x3F, 0xC0,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFD, 0xF0, 0x07, 0xFB,
  0xF0, 0x0F, 0xF3, 0xF0, 0x1F, 0xC3, 0xE0, 0x3F, 0x83, 0xE0, 0x1F, 0x03,
  0xE0, 0x0E, 0x03, 0xE0, 0x04, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x07, 0xF0, 0x7F, 0x81, 0xF8, 0x03, 0xF0, 0x7E, 0x00,
  0x3E, 0x0F, 0xC0, 0x07, 0xE0, 0x70, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xF8, 0x03, 0xF0, 0x1E, 0x00, 0x3F,
  0x01, 0x80, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x40, 0x00, 0x7C, 0x0C, 0x00, 0x1F, 0x87, 0x80, 0x03, 0xF1, 0xF8,
  0x00, 0xFC, 0x1F, 0xC0, 0x7F, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3E, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0x7C,
  0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x83, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x7C,
  0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0,
  0x7C, 0x01, 0xF0, 0x0F, 0x00, 0x3E, 0x03, 0xC0, 0x07, 0xC0, 0xF0, 0x00,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x0F, 0xE0,
  0x03, 0xCF, 0xFE, 0x01, 0xF7, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xF0, 0x03, 0xF0, 0x98, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC1, 0x80, 0x03, 0xF1, 0xE0, 0x01,
  0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0xC0, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x7E, 0x00, 0xFC, 0xFF, 0xC0, 0x7C, 0xFF, 0xF0, 0x7E,
  0xFF, 0xFC, 0x3E, 0xFF, 0xFF, 0x1F, 0xF0, 0x7F, 0x9F, 0xE0, 0x0F, 0xEF,
  0xE0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0x9F, 0x00, 0x0F,
  0xCF, 0x80, 0x0F, 0xE7, 0xE0, 0x0F, 0xE1, 0xFC, 0x0F, 0xE0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x9F, 0x00, 0x07, 0xE7, 0xC0, 0x01,
  0xF1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x1E, 0x00, 0x1F, 0x07, 0x80,
  0x0F, 0xC2, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFC, 0x07,
  0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xE0,
  0x01, 0xF1, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x83,
  0xE0, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0x03, 0xF8, 0x3F, 0x00,
  0x3F, 0x1F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF3, 0xF0, 0x00, 0x7E, 0xFC,
  0x00, 0x1F, 0xBE, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0xFC,
  0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xCF, 0xF0, 0x1F, 0xE1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0x00, 0x7E, 0x7E,
  0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0xFE, 0xFF, 0x03, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0x7C, 0x3F, 0xFE, 0xFC, 0x1F, 0xFC, 0xF8, 0x07, 0xF1, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xC1, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF0, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x3F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFE, 0x0F, 0x80, 0x00,
  0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xF0,
  0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0,
  0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x04, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFF, 0xBF, 0x83, 0xFD, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0x78, 0x00,
  0xF8, 0x80, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xF8,
  0x1F, 0x81, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x0F,
  0x00, 0x03, 0xC7, 0xC0, 0x00, 0xF1, 0xE0, 0x3E, 0x3C, 0x78, 0x1F, 0xCF,
  0x3E, 0x0F, 0xFB, 0xCF, 0x87, 0xFF, 0xF3, 0xC3, 0xF0, 0xFC, 0xF0, 0xF8,
  0x1E, 0x7C, 0x3C, 0x07, 0x9F, 0x1F, 0x01, 0xE7, 0xC7, 0xC0, 0x79, 0xE1,
  0xE0, 0x3E, 0x78, 0x78, 0x0F, 0x9E, 0x1E, 0x03, 0xC7, 0x8F, 0x80, 0xF3,
  0xE3, 0xE0, 0x3C, 0xF8, 0xF8, 0x1F, 0x3E, 0x1E, 0x07, 0xCF, 0x87, 0x83,
  0xF3, 0xE1, 0xFB, 0xF8, 0xF8, 0x7F, 0xDE, 0x3E, 0x0F, 0xE7, 0x87, 0x83,
  0xF9, 0xE1, 0xE0, 0x10, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F,
  0x9F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x8F, 0xC0,
  0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0,
  0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00,
  0xF8, 0x07, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xF0, 0x00, 0xF8, 0x7E,
  0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F,
  0xCF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7C, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xF0, 0x07, 0xE0, 0x7C, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xE0, 0xF8,
  0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x07, 0xE0, 0x1F, 0x81,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x01, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x1F,
  0x80, 0x0F, 0xC7, 0xC0, 0x03, 0xF1, 0xF0, 0x01, 0xF8, 0x7C, 0x01, 0xFE,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFE, 0x0F,
  0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0,
  0x01, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x06, 0x0F, 0xC0, 0x03, 0xF1, 0xF0, 0x01, 0xF8,
  0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0xE0, 0x7C, 0x01,
  0xF8, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xE0, 0x01, 0xF1,
  0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0xC7, 0xC0, 0x03,
  0xF1, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xE3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x1F,
  0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xF8, 0x7C, 0x03, 0xFC,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0x3F,
  0x1F, 0x80, 0x0F, 0x9F, 0x80, 0x07, 0x8F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xFF, 0xBF, 0x03, 0xFF, 0xDF, 0x81,
  0xFF, 0xEF, 0xC0, 0xFF, 0xE7, 0xE0, 0x7F, 0xF3, 0xE0, 0x00, 0xF9, 0xF0,
  0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x1F,
  0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xE1, 0xF8, 0x07, 0xF0,
  0xFE, 0x0E, 0xF8, 0x3F, 0xFE, 0x78, 0x0F, 0xFF, 0x7C, 0x03, 0xFE, 0x3E,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F,
  0x00, 0x0F, 0x83, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F,
  0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0,
  0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF0, 0x00, 0xF8,
  0x3E, 0x00, 0x1F, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0x00, 0x0F, 0x83,
  0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01,
  0xF0, 0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E,
  0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x1F,
  0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x0E, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x07,
  0xE0, 0x7E, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0x7C, 0x00, 0x7F, 0x01,
  0xF0, 0x03, 0xF8, 0x07, 0xC0, 0x1F, 0xC0, 0x1F, 0x00, 0xFE, 0x00, 0xFC,
  0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0x81, 0xFC, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x07, 0xDF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xF9, 0xF0, 0x00, 0x3F, 0xC7, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF0,
  0x3F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x7E, 0x01, 0xF0, 0x01, 0xF8, 0x07,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xFC,
  0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80,
  0x1F, 0xC1, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF,
  0x87, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F,
  0xFC, 0x3D, 0xF0, 0x79, 0xE3, 0xEF, 0x83, 0xCF, 0x1E, 0x78, 0x3E, 0x79,
  0xF3, 0xC1, 0xF3, 0xEF, 0x3E, 0x0F, 0x8F, 0xF9, 0xF0, 0x7C, 0x7F, 0x8F,
  0x83, 0xE3, 0xF8, 0x7C, 0x1E, 0x1F, 0xC3, 0xC1, 0xF0, 0xFC, 0x1E, 0x0F,
  0x83, 0xE1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1F, 0x07,
  0x03, 0xE0, 0xF0, 0x18, 0x1E, 0x0F, 0x80, 0x81, 0xF0, 0x7C, 0x08, 0x0F,
  0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0xF0,
  0x01, 0xE0, 0xFF, 0x00, 0x7C, 0x1F, 0xE0, 0x0F, 0x83, 0xFC, 0x01, 0xF0,
  0xFF, 0x80, 0x3E, 0x1F, 0xF0, 0x07, 0xC3, 0xFF, 0x01, 0xF0, 0x7F, 0xE0,
  0x3E, 0x0F, 0xFC, 0x07, 0xC1, 0xE7, 0x80, 0xF8, 0x7C, 0xF0, 0x1F, 0x0F,
  0x9F, 0x03, 0xE1, 0xF3, 0xE0, 0xF8, 0x3E, 0x7C, 0x1F, 0x07, 0xC7, 0x83,
  0xE0, 0xF0, 0xF0, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF8,
  0x7C, 0x7C, 0x1F, 0x07, 0x8F, 0x83, 0xE0, 0xF9, 0xF0, 0x78, 0x1F, 0x3E,
  0x1F, 0x03, 0xE7, 0xC3, 0xE0, 0x7C, 0xF0, 0x7C, 0x07, 0xBE, 0x0F, 0x80,
  0xFF, 0xC1, 0xF0, 0x1F, 0xF8, 0x3C, 0x03, 0xFF, 0x0F, 0x80, 0x3F, 0xE1,
  0xF0, 0x07, 0xF8, 0x3E, 0x00, 0xFF, 0x07, 0xC0, 0x1F, 0xE0, 0xF8, 0x03,
  0xFC, 0x1E, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFE, 0x0F,
  0xE0, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC7, 0xE0,
  0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xCF,
  0xC0, 0x01, 0xF7, 0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x0F,
  0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0x7C, 0x00,
  0x0F, 0xDF, 0x00, 0x03, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0x7C,
  0x00, 0x1F, 0x9F, 0x00, 0x0F, 0xC7, 0xC0, 0x03, 0xF1, 0xF0, 0x01, 0xF8,
  0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x03, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0x80, 0x1F, 0x81, 0xF0,
  0x01, 0xF8, 0x3E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00,
  0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x01, 0xFC, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x81, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x1F,
  0x80, 0x07, 0xC7, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x1F,
  0x3F, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF7, 0xE0, 0x00, 0x7D, 0xF8, 0x00,
  0x1F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF0,
  0x00, 0x3F, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB,
  0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0xC7, 0xC0, 0x07,
  0xF1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x0F, 0xE0, 0xFF, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x03, 0x00, 0x0F, 0xC1,
  0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x3E, 0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x01, 0xF8,
  0x3E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x87, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x87,
  0xE0, 0x03, 0xF0, 0xFC, 0x01, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7E,
  0x1F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x3E, 0x03, 0xE0,
  0x07, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x07, 0xE0,
  0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0x80, 0xFF, 0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x1C, 0x0F,
  0xC0, 0x00, 0x80, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x10, 0x00, 0x0F, 0x81, 0x00, 0x01, 0xF8, 0x78, 0x00, 0x1F,
  0x8F, 0xE0, 0x03, 0xF0, 0xFF, 0x80, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x0F, 0xC0,
  0x03, 0xE1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xE0,
  0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xFC, 0x00,
  0x7E, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x07,
  0xE1, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE1, 0xF8,
  0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x7C,
  0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0,
  0x1F, 0x80, 0xFC, 0x0F, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x0F,
  0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0xC3, 0xE0,
  0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xF0,
  0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80,
  0x7C, 0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0xFC, 0x00,
  0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7E, 0x1F,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x78, 0x00,
  0x01, 0xE3, 0xE0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x7C,
  0x3E, 0x0F, 0xC1, 0xF0, 0xF0, 0x3F, 0x07, 0x83, 0xC1, 0xFC, 0x1E, 0x0F,
  0x07, 0xF0, 0xF8, 0x3C, 0x1F, 0xC3, 0xE1, 0xF0, 0xFF, 0x0F, 0x07, 0xC3,
  0xFC, 0x3C, 0x1F, 0x0E, 0xF0, 0xF0, 0x7C, 0x7B, 0xC7, 0xC1, 0xF1, 0xEF,
  0x1F, 0x07, 0xCF, 0x3C, 0x78, 0x1E, 0x3C, 0xF1, 0xE0, 0x78, 0xE3, 0xCF,
  0x81, 0xE7, 0x8F, 0x3E, 0x07, 0x9E, 0x3C, 0xF0, 0x3E, 0x70, 0xF3, 0xC0,
  0xFB, 0xC3, 0xDF, 0x03, 0xEF, 0x0F, 0x7C, 0x0F, 0xB8, 0x3D, 0xE0, 0x3F,
  0xE0, 0xF7, 0x80, 0xFF, 0x83, 0xDE, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0,
  0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x0F,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x80, 0x7E,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x03,
  0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x01, 0xF9, 0xF0,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0xFC, 0x3E, 0x00, 0x1F, 0x83, 0xF0, 0x03, 0xF8, 0x1F, 0x00, 0x3F, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0xC1,
  0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x7E, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xF8, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xEF, 0x80, 0x03, 0xE7, 0xE0, 0x03,
  0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x1F, 0x01,
  0xF8, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xEE, 0x00, 0x01, 0xE1, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x18, 0xF8,
  0x7C, 0x7C, 0x3E, 0x3E, 0x1E, 0x1F, 0x0F, 0x0C, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0xC7, 0xC1, 0xFF, 0xF7, 0xE1, 0xFF, 0xFB, 0xF0, 0xFE, 0x0F, 0xF0,
  0xFC, 0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x3F,
  0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03,
  0xE3, 0xE0, 0x01, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00,
  0x7C, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x87, 0xC0,
  0x1F, 0xC3, 0xF0, 0x1F, 0xE1, 0xFC, 0x3B, 0xFE, 0x7F, 0xFD, 0xFE, 0x3F,
  0xFC, 0x7F, 0x0F, 0xFC, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0xFC, 0x01, 0xF1, 0xFF, 0x80, 0xF9,
  0xFF, 0xE0, 0x7D, 0xFF, 0xF8, 0x3E, 0xE1, 0xFC, 0x3F, 0xC0, 0x3E, 0x1F,
  0xC0, 0x1F, 0x8F, 0xE0, 0x0F, 0xC7, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xF1,
  0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x3F,
  0x3E, 0x00, 0x1F, 0x9F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xCF, 0xC0, 0x07,
  0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0x7F, 0x83, 0xFC, 0x7E, 0xFF, 0xFC, 0x3E, 0x7F, 0xFC, 0x1F, 0x1F,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFE, 0x0F, 0xC3, 0xF0, 0x0F, 0xC7, 0xC0,
  0x0F, 0x1F, 0x80, 0x10, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x23, 0xF0, 0x00, 0xE3,
  0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0xCF, 0xC0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x3F,
  0x00, 0xFF, 0xC7, 0xC0, 0x3F, 0xFC, 0xF8, 0x0F, 0xFF, 0xDF, 0x03, 0xF8,
  0x3B, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xE0,
  0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xF8, 0x00,
  0x7E, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x3E, 0x1F,
  0x80, 0x07, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x0F,
  0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x7F, 0x03, 0xF0, 0x1F, 0xE0, 0x7F,
  0x0F, 0x7C, 0x07, 0xFF, 0xDF, 0x80, 0xFF, 0xF3, 0xE0, 0x0F, 0xFC, 0x7C,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0xFE, 0x07, 0xE3, 0xF0, 0x07, 0xC7, 0xC0, 0x0F,
  0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0xFC, 0x00, 0xFD, 0xF0, 0x03, 0xFB,
  0xE0, 0x7F, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F,
  0xF8, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x43, 0xE0,
  0x01, 0xE7, 0xC0, 0x07, 0xEF, 0xC0, 0x1F, 0x8F, 0xC0, 0xFE, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x06, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8,
  0x7C, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0xF1, 0xF0, 0x3F, 0xFE, 0x7C, 0x1F, 0xFF, 0xDF, 0x07, 0xF0, 0x77,
  0xC3, 0xF0, 0x07, 0xF0, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x1F, 0x00,
  0x0F, 0x8F, 0xC0, 0x03, 0xE3, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7E, 0x3E,
  0x00, 0x1F, 0x8F, 0x80, 0x07, 0xC7, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x7C,
  0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC3, 0xE0, 0x07, 0xE0, 0xF8, 0x03,
  0xF8, 0x3F, 0x01, 0xBE, 0x0F, 0xE0, 0xEF, 0x81, 0xFF, 0xF3, 0xE0, 0x7F,
  0xF9, 0xF8, 0x0F, 0xFC, 0x7C, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x04, 0x00, 0x7E, 0x03, 0x80, 0x1F,
  0x81, 0xF8, 0x1F, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC3, 0xF0, 0x0F, 0xC7, 0xFC, 0x0F, 0x8F, 0xFE, 0x0F, 0x9F, 0xFE, 0x0F,
  0xB8, 0x7F, 0x0F, 0xA0, 0x3F, 0x1F, 0xC0, 0x1F, 0x1F, 0xC0, 0x1F, 0x1F,
  0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3F, 0x3F,
  0x00, 0x3F, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x40, 0x1F,
  0x01, 0xC0, 0x3E, 0x07, 0xE0, 0x7C, 0x1F, 0x81, 0xF8, 0x7E, 0x03, 0xF1,
  0xF8, 0x07, 0xC7, 0xE0, 0x0F, 0x9F, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x04, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x10, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xFC, 0x0F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x9F,
  0x00, 0x0F, 0xDF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x1F, 0xF0, 0x0F, 0x8F, 0xFE, 0x03, 0xE7,
  0xFF, 0xC0, 0xFB, 0x87, 0xF0, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0x1F, 0x07,
  0xF0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x00, 0x3E,
  0x07, 0xC0, 0x1F, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x3E, 0x1F,
  0xC0, 0x0F, 0x9F, 0xC0, 0x03, 0xE7, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7E,
  0x3F, 0x01, 0x9F, 0x87, 0xC0, 0xF7, 0xC1, 0xF0, 0x7D, 0xF0, 0x3E, 0x3E,
  0x7C, 0x0F, 0x9F, 0x1F, 0x03, 0xFF, 0x8F, 0xC0, 0x7F, 0xC3, 0xF0, 0x0F,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x02, 0x03, 0xE0, 0x3C, 0x1F, 0x03, 0xF0, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0,
  0x7C, 0x3F, 0x03, 0xE3, 0xF0, 0x1F, 0x3F, 0x00, 0xFF, 0xF0, 0x07, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0xFB,
  0xF8, 0xFE, 0x0F, 0xBF, 0xDF, 0xF0, 0xF7, 0xFD, 0xFF, 0x0F, 0x47, 0xF1,
  0xF0, 0xF8, 0x7E, 0x0F, 0x1F, 0x07, 0xE0, 0xF1, 0xF0, 0x7C, 0x0F, 0x1F,
  0x07, 0xC0, 0xF1, 0xE0, 0x7C, 0x1F, 0x1E, 0x07, 0x81, 0xF1, 0xE0, 0x78,
  0x1F, 0x3E, 0x07, 0x81, 0xE3, 0xE0, 0xF8, 0x1E, 0x3C, 0x0F, 0x81, 0xE3,
  0xC0, 0xF8, 0x3E, 0x3C, 0x0F, 0x03, 0xE3, 0xC0, 0xF0, 0x3E, 0x7C, 0x0F,
  0x03, 0xC7, 0xC1, 0xF0, 0x3C, 0x78, 0x1F, 0x03, 0xC7, 0x81, 0xF0, 0x7C,
  0x78, 0x1E, 0x07, 0xCF, 0x81, 0xE0, 0x7C, 0xF8, 0x1E, 0x07, 0x8F, 0x83,
  0xE0, 0x78, 0x00, 0x03, 0xF0, 0x0F, 0xC7, 0xFC, 0x0F, 0x8F, 0xFE, 0x0F,
  0x9F, 0xFE, 0x0F, 0xB8, 0x7F, 0x0F, 0xA0, 0x3F, 0x1F, 0xC0, 0x1F, 0x1F,
  0xC0, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F,
  0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xC0, 0xFC, 0x1F,
  0x80, 0x7E, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x3F, 0x7C,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0x7C,
  0x01, 0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7C, 0x7F, 0xE0,
  0x0F, 0x9F, 0xFE, 0x01, 0xF7, 0xFF, 0xE0, 0x3E, 0xE1, 0xFC, 0x0F, 0xF0,
  0x0F, 0x81, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x03, 0xE0,
  0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xF8, 0x00,
  0x7E, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xF8, 0x3F, 0xC1, 0xFB,
  0xFF, 0xF0, 0x3E, 0x7F, 0xFC, 0x07, 0xC7, 0xFE, 0x00, 0xF8, 0x3F, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0xC7, 0xC0, 0xFF, 0xF3, 0xE0, 0xFF, 0xFD, 0xF0, 0xFE, 0x0E, 0xF8, 0xFC,
  0x01, 0xFC, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x3F,
  0x00, 0x0F, 0x9F, 0x80, 0x07, 0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x03, 0xF3,
  0xE0, 0x01, 0xF3, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x7E,
  0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x1F, 0x87, 0xC0, 0x1F,
  0xC3, 0xF0, 0x1B, 0xE1, 0xFC, 0x3D, 0xF0, 0x7F, 0xFD, 0xF8, 0x3F, 0xFC,
  0xFC, 0x0F, 0xFC, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x7F, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF3, 0xFE,
  0x03, 0xF7, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xEC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x0F, 0xE0, 0x3F, 0x0F, 0x80, 0x0C, 0x0F, 0x80, 0x08,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x10, 0x00, 0x7E, 0x30, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0xFF, 0x01, 0xFC,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x01, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x10,
  0x1F, 0x80, 0xF0, 0x3F, 0x03, 0xF0, 0x7C, 0x0F, 0xC0, 0xF8, 0x7F, 0x01,
  0xF1, 0xFC, 0x03, 0xE7, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x7E,
  0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0x7C, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x02, 0xF8, 0x7C, 0x06, 0xF8, 0x7E, 0x0D, 0xF8, 0x7F,
  0xFD, 0xF0, 0x3F, 0xF9, 0xF0, 0x1F, 0xF1, 0xF0, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x0C, 0xFF, 0xC0, 0x7E, 0xFF, 0xC0, 0x7E, 0xFF, 0xC0, 0x3E, 0xFF,
  0xC0, 0x3E, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x0F,
  0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x1F,
  0x80, 0x3E, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7C, 0x1F,
  0x00, 0xFC, 0x1F, 0x01, 0xF8, 0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xF0, 0x3E,
  0x0F, 0xE0, 0x3E, 0x7F, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xC1, 0xE0, 0x78, 0x78,
  0x7C, 0x1F, 0x0F, 0x0F, 0x83, 0xE1, 0xF1, 0xE0, 0x78, 0x3E, 0x3C, 0x0F,
  0x07, 0xC7, 0x81, 0xE0, 0x78, 0xF0, 0x3C, 0x0F, 0x3E, 0x0F, 0x81, 0xE7,
  0xC1, 0xF0, 0x3C, 0xF0, 0x3E, 0x07, 0x9E, 0x07, 0x81, 0xF3, 0xC0, 0xF0,
  0x3E, 0x78, 0x1E, 0x07, 0xDF, 0x07, 0xC0, 0xF3, 0xE0, 0xF8, 0x1E, 0x78,
  0x1F, 0x03, 0xCF, 0x03, 0xC0, 0xF9, 0xE0, 0x78, 0x1E, 0x3C, 0x1F, 0x03,
  0xC7, 0x83, 0xE0, 0xF1, 0xF0, 0xFC, 0x1E, 0x3F, 0x3B, 0x87, 0x83, 0xFE,
  0x79, 0xF0, 0x7F, 0xCF, 0xFC, 0x0F, 0xF1, 0xFE, 0x00, 0x78, 0x0F, 0x80,
  0x00, 0x00, 0x3C, 0x03, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0xFF, 0xC7, 0xFE,
  0x0F, 0xFE, 0x3F, 0xF1, 0xFC, 0xF3, 0x8F, 0x9F, 0xC7, 0x98, 0x3C, 0xF8,
  0x3D, 0x81, 0xE3, 0x81, 0xEC, 0x0F, 0x10, 0x0F, 0xE0, 0x78, 0x00, 0x7E,
  0x02, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0xC0, 0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x11, 0xF0, 0x6F,
  0x03, 0x8F, 0x83, 0x78, 0x3E, 0x7C, 0x3B, 0xC7, 0xF3, 0xE3, 0x9F, 0x7F,
  0x1F, 0xFC, 0x7F, 0xF0, 0x7F, 0xC3, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x07,
  0xC0, 0x3C, 0x00, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00,
  0x7C, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xE0, 0xF8,
  0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x07, 0xE1,
  0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07,
  0xC1, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x07, 0xC0,
  0x1F, 0x81, 0xF0, 0x0F, 0xE0, 0x7C, 0x06, 0xF8, 0x1F, 0x83, 0x3E, 0x07,
  0xFF, 0xDF, 0x80, 0xFF, 0xE7, 0xC0, 0x1F, 0xF1, 0xF0, 0x03, 0xF0, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x20, 0x01,
  0xF8, 0x0C, 0x00, 0xFC, 0x07, 0xC0, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFF, 0xC1, 0xF0, 0xFF, 0xF8, 0x7C, 0x3F, 0xFF, 0x9E, 0x1F, 0x07,
  0xFF, 0x87, 0x80, 0x7F, 0xE1, 0xE0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x3C,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x10, 0x03, 0xF8, 0x1E, 0x01, 0xF8, 0x07, 0x80, 0xFC, 0x01, 0xE0, 0x7E,
  0x00, 0x7C, 0x3F, 0x80, 0x0F, 0x1F, 0xFE, 0x03, 0xCF, 0xBF, 0xF8, 0xF3,
  0xE3, 0xFF, 0xFC, 0xF8, 0x1F, 0xFE, 0x3E, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7E,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xE0, 0x03, 0x83, 0xFE, 0x00, 0xF1, 0xFF, 0x80, 0x7C,
  0x7F, 0xF0, 0x1E, 0x3E, 0x3E, 0x07, 0x9F, 0x0F, 0x83, 0xE7, 0x81, 0xF1,
  0xF1, 0xE0, 0x3F, 0xF8, 0xF0, 0x0F, 0xFE, 0x3C, 0x01, 0xFF, 0x07, 0x00,
  0x1F, 0x00,
};

const GFXglyph IBMPlexMono_MediumItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 12, 34, 29, 9, -34 },
  { 52, 17, 15, 29, 9, -36 },
  { 84, 31, 34, 29, 0, -34 },
  { 216, 28, 46, 29, 1, -40 },
  { 377, 33, 36, 29, -1, -35 },
  { 526, 29, 36, 29, 0, -35 },
  { 657, 7, 15, 29, 14, -36 },
  { 671, 20, 44, 29, 9, -37 },
  { 781, 19, 44, 29, 2, -37 },
  { 886, 26, 24, 29, 2, -27 },
  { 964, 24, 24, 29, 3, -27 },
  { 1036, 13, 14, 29, 6, -7 },
  { 1059, 16, 5, 29, 7, -17 },
  { 1069, 8, 8, 29, 9, -8 },
  { 1077, 28, 44, 29, 1, -37 },
  { 1231, 26, 36, 29, 2, -35 },
  { 1348, 24, 34, 29, 2, -34 },
  { 1450, 27, 35, 29, 1, -35 },
  { 1569, 27, 36, 29, 1, -35 },
  { 1691, 27, 34, 29, 1, -34 },
  { 1806, 26, 35, 29, 2, -34 },
  { 1920, 25, 35, 29, 2, -34 },
  { 2030, 26, 34, 29, 4, -34 },
  { 2141, 26, 36, 29, 2, -35 },
  { 2258, 24, 35, 29, 4, -35 },
  { 2363, 11, 26, 29, 9, -26 },
  { 2399, 14, 33, 29, 6, -26 },
  { 2457, 24, 29, 29, 4, -30 },
  { 2544, 26, 14, 29, 2, -22 },
  { 2590, 24, 29, 29, 2, -30 },
  { 2677, 21, 35, 29, 6, -35 },
  { 2769, 26, 40, 29, 2, -35 },
  { 2899, 27, 34, 29, -1, -34 },
  { 3014, 26, 34, 29, 2, -34 },
  { 3125, 26, 36, 29, 3, -35 },
  { 3242, 26, 34, 29, 2, -34 },
  { 3353, 27, 34, 29, 2, -34 },
  { 3468, 28, 34, 29, 2, -34 },
  { 3587, 25, 36, 29, 3, -35 },
  { 3700, 27, 34, 29, 2, -34 },
  { 3815, 27, 34, 29, 2, -34 },
  { 3930, 26, 35, 29, 2, -34 },
  { 4044, 30, 34, 29, 2, -34 },
  { 4172, 22, 34, 29, 3, -34 },
  { 4266, 29, 34, 29, 1, -34 },
  { 4390, 27, 34, 29, 2, -34 },
  { 4505, 26, 36, 29, 2, -35 },
  { 4622, 27, 34, 29, 2, -34 },
  { 4737, 26, 45, 29, 2, -35 },
  { 4884, 27, 34, 29, 2, -34 },
  { 4999, 28, 36, 29, 1, -35 },
  { 5125, 28, 34, 29, 4, -34 },
  { 5244, 27, 35, 29, 3, -34 },
  { 5363, 27, 34, 29, 5, -34 },
  { 5478, 30, 34, 29, 2, -34 },
  { 5606, 33, 34, 29, -1, -34 },
  { 5747, 28, 34, 29, 4, -34 },
  { 5866, 30, 34, 29, 0, -34 },
  { 5994, 22, 44, 29, 7, -37 },
  { 6115, 14, 44, 29, 8, -37 },
  { 6192, 22, 44, 29, 1, -37 },
  { 6313, 25, 21, 29, 3, -34 },
  { 6379, 24, 5, 29, 0, 4 },
  { 6394, 8, 10, 29, 10, -38 },
  { 6404, 25, 27, 29, 2, -26 },
  { 6489, 25, 37, 29, 2, -36 },
  { 6605, 23, 27, 29, 3, -26 },
  { 6683, 27, 37, 29, 2, -36 },
  { 6808, 23, 27, 29, 3, -26 },
  { 6886, 33, 46, 29, -1, -36 },
  { 7076, 26, 36, 29, 1, -26 },
  { 7193, 24, 36, 29, 2, -36 },
  { 7301, 23, 38, 29, 4, -37 },
  { 7411, 24, 47, 29, 2, -37 },
  { 7552, 26, 37, 29, 2, -36 },
  { 7673, 21, 37, 29, 5, -36 },
  { 7771, 28, 26, 29, 0, -26 },
  { 7862, 24, 26, 29, 2, -26 },
  { 7940, 24, 27, 29, 3, -26 },
  { 8021, 27, 36, 29, 0, -26 },
  { 8143, 25, 36, 29, 2, -26 },
  { 8256, 24, 25, 29, 5, -25 },
  { 8331, 24, 27, 29, 2, -26 },
  { 8412, 23, 35, 29, 4, -34 },
  { 8513, 24, 26, 29, 3, -25 },
  { 8591, 24, 26, 29, 3, -26 },
  { 8669, 27, 27, 29, 1, -26 },
  { 8761, 29, 27, 29, 0, -26 },
  { 8859, 26, 35, 29, 1, -25 },
  { 8973, 26, 27, 29, 2, -26 },
  { 9061, 24, 44, 29, 5, -37 },
  { 9193, 12, 44, 29, 9, -37 },
  { 9259, 23, 44, 29, 2, -37 },
  { 9386, 26, 11, 29, 2, -20 },
};

const GFXfont IBMPlexMono_MediumItalic49pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic49pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic49pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _IBMPLEXMONO_MEDIUMITALIC49PT7B_H_
