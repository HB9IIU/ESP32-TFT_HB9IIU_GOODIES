#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/IBMPlexMono_MediumItalic
// Headers: 67

#include "IBMPlexMono_MediumItalic6pt7b.h"
#include "IBMPlexMono_MediumItalic7pt7b.h"
#include "IBMPlexMono_MediumItalic8pt7b.h"
#include "IBMPlexMono_MediumItalic9pt7b.h"
#include "IBMPlexMono_MediumItalic10pt7b.h"
#include "IBMPlexMono_MediumItalic11pt7b.h"
#include "IBMPlexMono_MediumItalic12pt7b.h"
#include "IBMPlexMono_MediumItalic13pt7b.h"
#include "IBMPlexMono_MediumItalic14pt7b.h"
#include "IBMPlexMono_MediumItalic15pt7b.h"
#include "IBMPlexMono_MediumItalic16pt7b.h"
#include "IBMPlexMono_MediumItalic17pt7b.h"
#include "IBMPlexMono_MediumItalic18pt7b.h"
#include "IBMPlexMono_MediumItalic19pt7b.h"
#include "IBMPlexMono_MediumItalic20pt7b.h"
#include "IBMPlexMono_MediumItalic21pt7b.h"
#include "IBMPlexMono_MediumItalic22pt7b.h"
#include "IBMPlexMono_MediumItalic23pt7b.h"
#include "IBMPlexMono_MediumItalic24pt7b.h"
#include "IBMPlexMono_MediumItalic25pt7b.h"
#include "IBMPlexMono_MediumItalic26pt7b.h"
#include "IBMPlexMono_MediumItalic27pt7b.h"
#include "IBMPlexMono_MediumItalic28pt7b.h"
#include "IBMPlexMono_MediumItalic29pt7b.h"
#include "IBMPlexMono_MediumItalic30pt7b.h"
#include "IBMPlexMono_MediumItalic31pt7b.h"
#include "IBMPlexMono_MediumItalic32pt7b.h"
#include "IBMPlexMono_MediumItalic33pt7b.h"
#include "IBMPlexMono_MediumItalic34pt7b.h"
#include "IBMPlexMono_MediumItalic35pt7b.h"
#include "IBMPlexMono_MediumItalic36pt7b.h"
#include "IBMPlexMono_MediumItalic37pt7b.h"
#include "IBMPlexMono_MediumItalic38pt7b.h"
#include "IBMPlexMono_MediumItalic39pt7b.h"
#include "IBMPlexMono_MediumItalic40pt7b.h"
#include "IBMPlexMono_MediumItalic41pt7b.h"
#include "IBMPlexMono_MediumItalic42pt7b.h"
#include "IBMPlexMono_MediumItalic43pt7b.h"
#include "IBMPlexMono_MediumItalic44pt7b.h"
#include "IBMPlexMono_MediumItalic45pt7b.h"
#include "IBMPlexMono_MediumItalic46pt7b.h"
#include "IBMPlexMono_MediumItalic47pt7b.h"
#include "IBMPlexMono_MediumItalic48pt7b.h"
#include "IBMPlexMono_MediumItalic49pt7b.h"
#include "IBMPlexMono_MediumItalic50pt7b.h"
#include "IBMPlexMono_MediumItalic51pt7b.h"
#include "IBMPlexMono_MediumItalic52pt7b.h"
#include "IBMPlexMono_MediumItalic53pt7b.h"
#include "IBMPlexMono_MediumItalic54pt7b.h"
#include "IBMPlexMono_MediumItalic55pt7b.h"
#include "IBMPlexMono_MediumItalic56pt7b.h"
#include "IBMPlexMono_MediumItalic57pt7b.h"
#include "IBMPlexMono_MediumItalic58pt7b.h"
#include "IBMPlexMono_MediumItalic59pt7b.h"
#include "IBMPlexMono_MediumItalic60pt7b.h"
#include "IBMPlexMono_MediumItalic61pt7b.h"
#include "IBMPlexMono_MediumItalic62pt7b.h"
#include "IBMPlexMono_MediumItalic63pt7b.h"
#include "IBMPlexMono_MediumItalic64pt7b.h"
#include "IBMPlexMono_MediumItalic65pt7b.h"
#include "IBMPlexMono_MediumItalic66pt7b.h"
#include "IBMPlexMono_MediumItalic67pt7b.h"
#include "IBMPlexMono_MediumItalic68pt7b.h"
#include "IBMPlexMono_MediumItalic69pt7b.h"
#include "IBMPlexMono_MediumItalic70pt7b.h"
#include "IBMPlexMono_MediumItalic71pt7b.h"
#include "IBMPlexMono_MediumItalic72pt7b.h"
