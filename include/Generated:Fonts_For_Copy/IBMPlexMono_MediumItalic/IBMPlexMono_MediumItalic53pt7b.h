#ifndef _IBMPLEXMONO_MEDIUMITALIC53PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x01, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F,
  0xE0, 0x3E, 0x00, 0x3F, 0x07, 0xCF, 0x83, 0xF3, 0xE0, 0xFC, 0xF8, 0x3E,
  0x3E, 0x0F, 0x8F, 0x83, 0xE7, 0xE0, 0xF9, 0xF0, 0x7E, 0x7C, 0x1F, 0x9F,
  0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0xFC, 0x1F, 0x3E, 0x0F, 0xCF, 0x83,
  0xF3, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0x7C, 0x1E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x1F, 0x07, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x0F, 0xC1, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x01, 0xFF, 0xE0, 0xFF,
  0xE1, 0xFF, 0xF0, 0x7F, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F,
  0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x01, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xCF, 0x3F, 0xC1, 0xFC, 0x3C, 0x3E, 0x07, 0xE0, 0xF0,
  0x70, 0x3F, 0x03, 0xC0, 0x80, 0xFC, 0x0E, 0x00, 0x03, 0xF0, 0x78, 0x00,
  0x0F, 0xC1, 0xE0, 0x00, 0x3F, 0x07, 0x80, 0x00, 0xFC, 0x1E, 0x00, 0x01,
  0xF8, 0x78, 0x00, 0x07, 0xF9, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xEF, 0xF8, 0x00, 0x07, 0x8F,
  0xE0, 0x00, 0x1E, 0x1F, 0xC0, 0x00, 0x78, 0x3F, 0x00, 0x01, 0xE0, 0xFC,
  0x00, 0x07, 0x03, 0xF0, 0x00, 0x3C, 0x0F, 0xC1, 0x00, 0xF0, 0x3F, 0x0E,
  0x03, 0xC1, 0xF8, 0x7C, 0x0F, 0x07, 0xE3, 0xF8, 0x3C, 0x7F, 0x87, 0xFC,
  0xF7, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xC0, 0x3F, 0xFC, 0x00, 0x7C, 0x03, 0xFF, 0xF0, 0x03, 0xC0, 0x1F,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x3C, 0x03, 0xE0, 0x0F, 0x01, 0xF0, 0x1E,
  0x00, 0x78, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x7C, 0x1F, 0x00, 0x3E, 0x03,
  0xC0, 0xF0, 0x01, 0xE0, 0x1E, 0x0F, 0x80, 0x0F, 0x00, 0xF0, 0xF8, 0x00,
  0x78, 0x0F, 0x87, 0x80, 0x03, 0xE0, 0x78, 0x7C, 0x00, 0x1F, 0x0F, 0xC7,
  0xC0, 0x00, 0x7F, 0xFC, 0x3C, 0x00, 0x03, 0xFF, 0xC3, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7C,
  0x7F, 0xF8, 0x00, 0x07, 0xC7, 0xFF, 0xE0, 0x00, 0x3C, 0x3E, 0x1F, 0x00,
  0x03, 0xE3, 0xE0, 0x78, 0x00, 0x3E, 0x1E, 0x03, 0xC0, 0x01, 0xE1, 0xF0,
  0x1E, 0x00, 0x1F, 0x0F, 0x80, 0xF0, 0x01, 0xF0, 0x7C, 0x07, 0x80, 0x0F,
  0x03, 0xC0, 0x3C, 0x00, 0xF8, 0x1E, 0x03, 0xE0, 0x0F, 0x80, 0xF0, 0x1F,
  0x00, 0xF8, 0x07, 0x80, 0xF0, 0x07, 0x80, 0x3E, 0x1F, 0x80, 0x7C, 0x00,
  0xFF, 0xF8, 0x07, 0xC0, 0x07, 0xFF, 0x80, 0x3C, 0x00, 0x1F, 0xF8, 0x02,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3E, 0x01, 0xF8,
  0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0,
  0x03, 0xE0, 0x1F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x01,
  0xFE, 0x7F, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFC,
  0xFF, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x0F,
  0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x81, 0x9F, 0x80, 0x3F,
  0x03, 0xFF, 0x00, 0x7F, 0x0F, 0xFE, 0x01, 0xBE, 0x1F, 0x7E, 0x03, 0x7C,
  0x7C, 0xFE, 0x1E, 0xFD, 0xF1, 0xFF, 0xF8, 0xFF, 0xE1, 0xFF, 0xF1, 0xFF,
  0x81, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xE0,
  0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C,
  0x7C, 0xFC, 0xFC, 0xF8, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x02, 0x00, 0x7C, 0x02, 0x78, 0x1F, 0x81, 0xEF, 0xE3, 0xE3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0x3F, 0x00,
  0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x07, 0xE0, 0x3E, 0x00,
  0xF0, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF8, 0x7F,
  0x83, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x01,
  0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0x7F,
  0xFF, 0xBF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x3E, 0x3F,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x3E, 0x3F,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x0F, 0x03, 0xFF,
  0xE1, 0xF8, 0x7F, 0xFC, 0x3F, 0x87, 0xEF, 0xC3, 0xF8, 0x7E, 0xFC, 0x3F,
  0x87, 0xEF, 0xC3, 0xF0, 0x7E, 0xFC, 0x1F, 0x07, 0xEF, 0xC0, 0x00, 0xFE,
  0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xCF, 0x80,
  0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xBF,
  0x00, 0x3F, 0xCF, 0xC0, 0x1F, 0xE3, 0xE0, 0x0F, 0xE0, 0xF8, 0x07, 0xF0,
  0x7E, 0x03, 0xF8, 0x1F, 0x80, 0x3C, 0x07, 0xE0, 0x06, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x0F,
  0xE0, 0x03, 0xF8, 0x1E, 0x00, 0x0F, 0xC0, 0x20, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xC0,
  0x1F, 0xE0, 0x3C, 0x00, 0x7F, 0x00, 0xC0, 0x03, 0xF8, 0x04, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x04, 0x00, 0x07,
  0xE0, 0xE0, 0x00, 0x7F, 0x0F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x83,
  0xFC, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7E, 0xFC, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x07,
  0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF8, 0x1F, 0x80,
  0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x07,
  0xE0, 0x7C, 0x00, 0x3F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF1, 0xFF, 0xC0, 0x0F,
  0xBF, 0xFF, 0x00, 0x7B, 0xFF, 0xFC, 0x07, 0xDF, 0xFF, 0xE0, 0x3F, 0xC0,
  0xFF, 0x81, 0xF8, 0x01, 0xFC, 0x07, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x80, 0x00, 0xFC, 0x0C, 0x00,
  0x0F, 0xE1, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE1, 0xFC, 0x01, 0xF9, 0xFF, 0xC0, 0xFC, 0xFF, 0xF8, 0x3F,
  0x7F, 0xFF, 0x1F, 0xBF, 0xFF, 0xE7, 0xFE, 0x07, 0xF9, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xEF, 0xC0, 0x03, 0xF1,
  0xF8, 0x01, 0xFC, 0x7F, 0x81, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xF3, 0xE0,
  0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xE3, 0xE0, 0x01, 0xF8,
  0x7C, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFE,
  0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x01,
  0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x3F, 0x00, 0xFE,
  0x03, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0,
  0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0xFE, 0x7E, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF8,
  0xFE, 0x00, 0x3F, 0x83, 0xFC, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xF8, 0x1F, 0xE3, 0xF8, 0x01,
  0xFC, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xF7, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xF7, 0xF0, 0x07, 0xF9, 0xFE, 0x07, 0xFE, 0x7F, 0xFF, 0xDF, 0x8F, 0xFF,
  0xEF, 0xC1, 0xFF, 0xF3, 0xF0, 0x3F, 0xF9, 0xF8, 0x03, 0xF8, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xE1, 0xFE, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x07, 0xF0, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x0F, 0xF0,
  0x7C, 0x00, 0x00, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F,
  0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x04,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x3F, 0x81, 0xFE, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0x18, 0x00, 0x3F, 0x08, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x1F,
  0x0F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x07, 0x9F, 0x00,
  0xF8, 0xF3, 0xE0, 0x7F, 0x9E, 0x7C, 0x1F, 0xF7, 0xDF, 0x07, 0xFF, 0xFB,
  0xE0, 0xFC, 0x7F, 0x7C, 0x3E, 0x07, 0xEF, 0x87, 0xC0, 0x79, 0xF1, 0xF0,
  0x0F, 0x7C, 0x3E, 0x01, 0xEF, 0x87, 0xC0, 0x7D, 0xF0, 0xF8, 0x0F, 0xBE,
  0x3E, 0x01, 0xF7, 0xC7, 0xC0, 0x3C, 0xF8, 0xF8, 0x07, 0x9E, 0x1F, 0x01,
  0xF3, 0xC3, 0xE0, 0x3E, 0x78, 0x7C, 0x0F, 0xCF, 0x07, 0xC3, 0xF9, 0xE0,
  0xFC, 0xDF, 0x3C, 0x1F, 0xFB, 0xC7, 0x81, 0xFE, 0xF8, 0xF0, 0x3F, 0x9F,
  0x1F, 0x01, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x1F, 0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F,
  0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0,
  0x3E, 0x00, 0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xF0, 0x00, 0xFC, 0x0F,
  0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0xC0, 0xF8, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x81, 0xF8,
  0x03, 0xF8, 0x1F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFC, 0x3E,
  0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x87, 0xE0, 0x07,
  0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0x81, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x40, 0x7C, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0x3F,
  0x00, 0x7F, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7E, 0x01, 0xFE, 0x07, 0xE0, 0x07,
  0xE0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07,
  0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00,
  0x1F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF1,
  0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80,
  0x03, 0xF1, 0xF8, 0x00, 0x7F, 0x1F, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x7E,
  0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xC3, 0xF0,
  0x01, 0xFC, 0x3E, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x7F,
  0x07, 0xE0, 0x1F, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x0F,
  0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x3F, 0x1F,
  0x80, 0x03, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xFC, 0xFE, 0x07,
  0xFF, 0xCF, 0xC0, 0x7F, 0xFC, 0xFC, 0x07, 0xFF, 0xCF, 0xC0, 0x7F, 0xF8,
  0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x8F, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF0, 0xFE, 0x00, 0x3F,
  0x07, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF8, 0x1D, 0xF0, 0x3F,
  0xFF, 0xBF, 0x03, 0xFF, 0xFB, 0xE0, 0x1F, 0xFF, 0x3E, 0x00, 0xFF, 0xE3,
  0xE0, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x03,
  0xF0, 0x7E, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8,
  0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7E, 0x0F,
  0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x3E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x80,
  0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01,
  0xF8, 0x1F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0xFC,
  0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x82, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x40, 0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0,
  0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x83, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0x7F,
  0x00, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x7F, 0x80, 0x0F, 0xC0, 0x3F,
  0x80, 0x07, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x3F, 0x80, 0x03, 0xF0, 0x3F,
  0x80, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x7E, 0x3F,
  0x80, 0x00, 0x3E, 0x3F, 0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x1F, 0xBF,
  0xC0, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0x80, 0x00, 0xFF,
  0x8F, 0xE0, 0x00, 0x7F, 0x83, 0xF0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFE,
  0x07, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE,
  0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xBE, 0x0F, 0xFC,
  0x0F, 0xBE, 0x1F, 0x7C, 0x0F, 0x9E, 0x1F, 0x7C, 0x0F, 0x9E, 0x3E, 0x7C,
  0x0F, 0x9F, 0x3C, 0x7C, 0x0F, 0x9F, 0x7C, 0xF8, 0x1F, 0x9F, 0x78, 0xF8,
  0x1F, 0x0F, 0xF8, 0xF8, 0x1F, 0x0F, 0xF0, 0xF8, 0x1F, 0x0F, 0xF0, 0xF8,
  0x1F, 0x0F, 0xE1, 0xF8, 0x1F, 0x07, 0xE1, 0xF0, 0x3F, 0x07, 0xC1, 0xF0,
  0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x01, 0xF0,
  0x3E, 0x03, 0x03, 0xF0, 0x3E, 0x02, 0x03, 0xE0, 0x7E, 0x02, 0x03, 0xE0,
  0x7E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x7C, 0x0F, 0xF0, 0x03, 0xF0,
  0x7F, 0xC0, 0x0F, 0x81, 0xFF, 0x00, 0x3E, 0x07, 0xFC, 0x00, 0xF8, 0x1F,
  0xF8, 0x03, 0xE0, 0x7F, 0xE0, 0x0F, 0x81, 0xFF, 0x80, 0x7E, 0x0F, 0xFE,
  0x01, 0xF0, 0x3E, 0xF8, 0x07, 0xC0, 0xF9, 0xF0, 0x1F, 0x03, 0xE7, 0xC0,
  0x7C, 0x0F, 0x9F, 0x01, 0xF0, 0x3E, 0x7C, 0x0F, 0xC1, 0xF9, 0xF0, 0x3E,
  0x07, 0xC3, 0xE0, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0x7C, 0x3E, 0x0F, 0x81,
  0xF0, 0xF8, 0x3E, 0x07, 0xC3, 0xE1, 0xF8, 0x3F, 0x07, 0xC7, 0xC0, 0xF8,
  0x1F, 0x1F, 0x03, 0xE0, 0x7C, 0x7C, 0x0F, 0x81, 0xF1, 0xF0, 0x3E, 0x07,
  0xC7, 0xC0, 0xF8, 0x0F, 0xBF, 0x07, 0xE0, 0x3E, 0xF8, 0x1F, 0x00, 0xFB,
  0xE0, 0x7C, 0x03, 0xEF, 0x81, 0xF0, 0x0F, 0xFE, 0x07, 0xC0, 0x1F, 0xF8,
  0x1F, 0x00, 0x7F, 0xE0, 0xFC, 0x01, 0xFF, 0x03, 0xE0, 0x07, 0xFC, 0x0F,
  0x80, 0x1F, 0xF0, 0x3E, 0x00, 0x3F, 0xC0, 0xF8, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x3E, 0x3F, 0x80,
  0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F,
  0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE, 0xFC,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01,
  0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x0F,
  0xE0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xF0,
  0x03, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01,
  0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0,
  0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0xFE, 0x0F, 0x80, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x1F,
  0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x3E, 0x3F, 0x80, 0x03, 0xF3, 0xF0, 0x00,
  0x3F, 0x3F, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E,
  0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F,
  0x8F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xE0, 0x7F,
  0x83, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7E, 0x01, 0x00,
  0x03, 0xF0, 0x18, 0x00, 0x3F, 0x83, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x03, 0xF0, 0x03, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F,
  0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x1F,
  0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xFC, 0x3F, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0xFE, 0x0F, 0x80, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x03,
  0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x0F,
  0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0x80, 0x1F,
  0x81, 0xFC, 0x00, 0x1C, 0x07, 0xE0, 0x00, 0x20, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x40,
  0x00, 0x1F, 0x83, 0x80, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xF8, 0xFF, 0x00,
  0x1F, 0xC1, 0xFF, 0x01, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xE0, 0xFC,
  0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x7E, 0x0F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC,
  0x3F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7C,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8,
  0x0F, 0xC0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xDF, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x03, 0xE0, 0x03,
  0xF0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x3E,
  0x03, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7C, 0x1F,
  0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xFC, 0x7E, 0x00,
  0x07, 0xE3, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x07,
  0xDF, 0x80, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x07, 0xE0, 0x7C, 0x3E, 0x07, 0xE0,
  0x7C, 0x3E, 0x0F, 0xE0, 0x7C, 0x3E, 0x0F, 0xE0, 0xF8, 0x3E, 0x0F, 0xE0,
  0xF8, 0x3E, 0x1F, 0xE0, 0xF8, 0x3E, 0x1F, 0xE0, 0xF8, 0x3E, 0x1F, 0xE0,
  0xF0, 0x7C, 0x3D, 0xE1, 0xF0, 0x7C, 0x3D, 0xE1, 0xF0, 0x7C, 0x3D, 0xE1,
  0xF0, 0x7C, 0x79, 0xE1, 0xE0, 0x7C, 0x79, 0xE3, 0xE0, 0x7C, 0x79, 0xE3,
  0xE0, 0x7C, 0xF1, 0xF3, 0xE0, 0x7C, 0xF1, 0xF3, 0xC0, 0x7C, 0xF1, 0xF7,
  0xC0, 0x7D, 0xE1, 0xF7, 0xC0, 0x79, 0xE0, 0xF7, 0xC0, 0xFB, 0xE0, 0xF7,
  0xC0, 0xFB, 0xC0, 0xF7, 0x80, 0xFB, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x07, 0xE7,
  0xF0, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x7E,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x02,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0x9F,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x0F,
  0xC0, 0xFC, 0x01, 0xF8, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x3F,
  0x03, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0xF9, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3E,
  0x70, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x7C, 0xFC,
  0x7C, 0x7E, 0x3E, 0x3E, 0x1F, 0x0F, 0x0F, 0x04, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0xE3, 0xF0, 0x7F, 0xFC, 0xFC, 0x3F, 0xFF, 0xBF, 0x1F, 0xFF, 0xEF,
  0xC7, 0xF8, 0x1B, 0xE3, 0xF8, 0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x7F, 0x00,
  0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x7C, 0xFC,
  0x00, 0x1F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC,
  0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xE3, 0xE0, 0x01,
  0xF8, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x8F, 0xC0, 0x37, 0xE3, 0xFC,
  0x3D, 0xFF, 0x7F, 0xFE, 0x7F, 0xDF, 0xFF, 0x1F, 0xE3, 0xFF, 0xC7, 0xF8,
  0x7F, 0xC0, 0x7E, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x7C, 0x3F, 0xF0, 0x1F, 0x8F, 0xFF, 0x03, 0xF3, 0xFF, 0xF0, 0x7E, 0xFF,
  0xFE, 0x0F, 0xFC, 0x1F, 0xE1, 0xF6, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0x8F,
  0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x01,
  0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC,
  0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x1F,
  0x8F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0,
  0x07, 0xF1, 0xFF, 0x03, 0xFC, 0x3E, 0xFF, 0xFF, 0x07, 0xCF, 0xFF, 0xC1,
  0xF9, 0xFF, 0xF0, 0x3F, 0x1F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x1F, 0xE0, 0x7F, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x1E, 0x7E, 0x00,
  0x18, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x18, 0xF8, 0x00, 0x3E, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7E, 0xFE, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xF8, 0x7E,
  0x03, 0xFF, 0xE3, 0xE0, 0x3F, 0xFF, 0x9F, 0x01, 0xFF, 0xFF, 0xF8, 0x1F,
  0xE0, 0x7F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0xFE, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E,
  0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xF8, 0x3F,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00,
  0x1F, 0x83, 0xE0, 0x01, 0xFC, 0x1F, 0x00, 0x1F, 0xC0, 0xFC, 0x01, 0xFE,
  0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF, 0x80, 0xFF, 0xFE, 0xFC, 0x07,
  0xFF, 0xE7, 0xE0, 0x1F, 0xFE, 0x3E, 0x00, 0x7F, 0xE1, 0xF0, 0x00, 0xFC,
  0x10, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFC, 0x0F, 0xE1, 0xFC, 0x00,
  0xFC, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xE7, 0xE0,
  0x01, 0xF9, 0xF8, 0x01, 0xFE, 0x7E, 0x07, 0xFF, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x30, 0x7E, 0x00, 0x0F, 0x1F, 0x80,
  0x07, 0xE7, 0xF0, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x20, 0x0F, 0x80, 0x00, 0x0E,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00,
  0x0F, 0xE1, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0xC7, 0xC0,
  0x00, 0x01, 0xFC, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0x0F, 0xC0,
  0x7F, 0xFC, 0x7C, 0x07, 0xFF, 0xF3, 0xE0, 0x7F, 0xFF, 0xBF, 0x03, 0xFC,
  0x0F, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x03,
  0xE0, 0xFC, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xF0, 0x7E, 0x00, 0x7F, 0x83, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x77, 0xC0,
  0xFF, 0x07, 0x7E, 0x03, 0xFF, 0xFB, 0xF0, 0x1F, 0xFF, 0x9F, 0x80, 0x7F,
  0xF8, 0xFC, 0x01, 0xFF, 0x87, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x02, 0x00, 0x0F, 0xC0,
  0x38, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x83, 0xF0, 0x07, 0xE3, 0xFF, 0x01, 0xF1, 0xFF, 0xE0,
  0xFC, 0xFF, 0xF8, 0x3F, 0x3F, 0xFF, 0x0F, 0xDC, 0x1F, 0xC3, 0xFE, 0x03,
  0xF0, 0xFF, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x1F, 0xC0, 0x0F, 0xC7, 0xF0,
  0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7,
  0xC0, 0x03, 0xE3, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F,
  0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x7E, 0x00,
  0x1F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7C,
  0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x8F, 0xC0, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x80, 0x1F, 0x80, 0xE0, 0x0F, 0x81, 0xF8, 0x07, 0xC1, 0xFE, 0x07, 0xE1,
  0xFC, 0x03, 0xF1, 0xFC, 0x01, 0xF9, 0xFC, 0x00, 0xF9, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x06, 0x01, 0xF8, 0x03, 0x80, 0x7E, 0x01, 0xF0, 0x1F, 0x80,
  0xFE, 0x07, 0xC0, 0x1F, 0xC3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x3F,
  0x00, 0x0F, 0xEF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x3F, 0xF0, 0x03, 0xE3, 0xFF, 0xC0,
  0x3F, 0x3F, 0xFF, 0x01, 0xFB, 0xFF, 0xF8, 0x0F, 0xDC, 0x1F, 0xC0, 0x7F,
  0xC0, 0x7E, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0x81, 0xFC, 0x00,
  0xFC, 0x0F, 0xC0, 0x07, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xE0,
  0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x0F, 0xE0, 0x0F, 0xC3, 0xFC, 0x00, 0x7E,
  0x7F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x20, 0xFC, 0x7E,
  0x01, 0x87, 0xC1, 0xF8, 0x3E, 0x7E, 0x0F, 0xC3, 0xF3, 0xF0, 0x7E, 0x3F,
  0xDF, 0x81, 0xFB, 0xF8, 0xFC, 0x0F, 0xFF, 0x87, 0xE0, 0x3F, 0xF8, 0x3E,
  0x01, 0xFF, 0x83, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0xC0, 0x7C, 0x07, 0xC1, 0xF8, 0x1F,
  0xC3, 0xF0, 0x7F, 0x07, 0xE1, 0xFC, 0x0F, 0xC7, 0xF0, 0x1F, 0x1F, 0xC0,
  0x3E, 0x7F, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01,
  0xFE, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x0F, 0x1F, 0x87,
  0xF8, 0x3E, 0x7F, 0x9F, 0xF0, 0x7D, 0xFF, 0x3F, 0xF0, 0xFB, 0xFE, 0xFF,
  0xE1, 0xFC, 0x7D, 0x8F, 0xC3, 0xF0, 0xFE, 0x0F, 0x87, 0xC0, 0xF8, 0x1F,
  0x1F, 0x83, 0xF0, 0x3C, 0x3E, 0x07, 0xC0, 0xF8, 0x7C, 0x0F, 0x81, 0xF0,
  0xF8, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x07, 0xC3, 0xC0, 0x7C, 0x0F, 0x8F,
  0x81, 0xF0, 0x1E, 0x1F, 0x03, 0xE0, 0x3C, 0x3E, 0x07, 0xC0, 0xF8, 0x7C,
  0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x03, 0xE1, 0xE0, 0x3C, 0x07, 0xC7, 0xC0,
  0xF8, 0x0F, 0x0F, 0x81, 0xF0, 0x3E, 0x1F, 0x03, 0xE0, 0x7C, 0x3E, 0x07,
  0xC0, 0xF8, 0x7C, 0x0F, 0x81, 0xF0, 0xF0, 0x1E, 0x03, 0xE3, 0xE0, 0x7C,
  0x07, 0x87, 0xC0, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0xFF,
  0xC0, 0x7C, 0x7F, 0xF8, 0x3F, 0x3F, 0xFE, 0x0F, 0xCF, 0xFF, 0xC3, 0xF7,
  0x07, 0xF0, 0xFF, 0x80, 0xFC, 0x3F, 0xC0, 0x3F, 0x0F, 0xE0, 0x0F, 0xC7,
  0xF0, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F,
  0xC7, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x3E, 0x3F, 0x00,
  0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3E,
  0x00, 0x1F, 0x1F, 0x80, 0x07, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC,
  0x7E, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0xC7, 0xC0, 0x03, 0xE3, 0xF0, 0x01,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x07, 0xF8, 0x1F, 0xE1, 0xFC, 0x01, 0xF8,
  0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00,
  0xFD, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF,
  0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x1F,
  0xC7, 0xE0, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x0F, 0x87, 0xFE, 0x00, 0xFC, 0x7F, 0xF8, 0x07,
  0xE7, 0xFF, 0xE0, 0x3F, 0x7F, 0xFF, 0x01, 0xFF, 0x83, 0xFC, 0x0F, 0xB0,
  0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x0F,
  0xC1, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0,
  0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83,
  0xFE, 0x07, 0xF8, 0x1F, 0x7F, 0xFF, 0x80, 0xF9, 0xFF, 0xF8, 0x0F, 0xCF,
  0xFF, 0x80, 0x7E, 0x3F, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xF0, 0xFC, 0x1F, 0xFF, 0x1F, 0x07, 0xFF, 0xF3, 0xE0,
  0xFF, 0xFF, 0xFC, 0x3F, 0xC0, 0xFF, 0x8F, 0xE0, 0x07, 0xF1, 0xF8, 0x00,
  0xFE, 0x7F, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF1, 0xF8, 0x00, 0x7E, 0x7E,
  0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xE3, 0xE0,
  0x00, 0xFC, 0x7C, 0x00, 0x3F, 0x8F, 0x80, 0x0F, 0xE1, 0xF8, 0x03, 0xFC,
  0x3F, 0x00, 0xFF, 0x87, 0xF8, 0x3B, 0xF0, 0x7F, 0xFF, 0x7E, 0x0F, 0xFF,
  0xCF, 0xC0, 0xFF, 0xF1, 0xF0, 0x0F, 0xFC, 0x3E, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFC,
  0x0F, 0xDF, 0xFF, 0x0F, 0xF7, 0xFF, 0xC7, 0xFD, 0xFF, 0xE3, 0xFF, 0x7F,
  0xF9, 0xFF, 0xE0, 0x7E, 0xE0, 0x00, 0x1F, 0xB0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFC, 0x07, 0xE0, 0xFC, 0x00,
  0x70, 0x3F, 0x00, 0x08, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x86, 0x00,
  0x07, 0xC3, 0xC0, 0x03, 0xF1, 0xFE, 0x03, 0xFC, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x03, 0x00, 0xFC, 0x03, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x07, 0xF8, 0x1F,
  0x07, 0xF8, 0x0F, 0x8F, 0xF0, 0x0F, 0xCF, 0xF0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03,
  0xF3, 0xF0, 0x01, 0xF9, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0xFC, 0x00,
  0x3E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0x80,
  0x07, 0xE7, 0xC0, 0x03, 0xE7, 0xE0, 0x01, 0xF3, 0xF0, 0x01, 0xF9, 0xF8,
  0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x7F, 0x3E, 0x00, 0x3F, 0x1F,
  0x00, 0x3F, 0x8F, 0xC0, 0x3F, 0xC7, 0xE0, 0x37, 0xE3, 0xF8, 0x3B, 0xF1,
  0xFF, 0xF9, 0xF8, 0x7F, 0xFC, 0xF8, 0x3F, 0xFC, 0xFC, 0x0F, 0xFC, 0x7E,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0x1F, 0xF8, 0x07, 0xEF, 0xFE,
  0x01, 0xFB, 0xFF, 0x80, 0x7E, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xF0,
  0x7E, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0,
  0x03, 0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x07,
  0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x1F, 0x01, 0xFC,
  0x07, 0xC0, 0xFF, 0x01, 0xF0, 0x7F, 0x80, 0x7C, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x61, 0xF0, 0x3E, 0x3E, 0x1F, 0x03,
  0xC1, 0xF1, 0xE0, 0x7C, 0x1F, 0x3E, 0x07, 0xC1, 0xF3, 0xE0, 0x7C, 0x1F,
  0x3E, 0x07, 0xC1, 0xF3, 0xE0, 0x7C, 0x0F, 0x3E, 0x07, 0x80, 0xF3, 0xC0,
  0xF8, 0x0F, 0x7C, 0x0F, 0x81, 0xF7, 0xC0, 0xF8, 0x1F, 0x7C, 0x0F, 0x81,
  0xF7, 0xC0, 0xF8, 0x1F, 0x78, 0x0F, 0x01, 0xF7, 0x81, 0xF0, 0x1F, 0xF8,
  0x1F, 0x01, 0xEF, 0x81, 0xF0, 0x3E, 0xF8, 0x1F, 0x03, 0xEF, 0x81, 0xF0,
  0x3E, 0xF0, 0x3E, 0x07, 0xCF, 0x03, 0xE0, 0x7C, 0xF8, 0x7E, 0x0F, 0x8F,
  0x8F, 0xE0, 0xF8, 0xFF, 0xEF, 0x1F, 0x0F, 0xFC, 0xFF, 0xE0, 0xFF, 0x8F,
  0xFC, 0x07, 0xF8, 0x7F, 0x80, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0xF8, 0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x8F,
  0xFE, 0x07, 0xFF, 0xCF, 0xFE, 0x0F, 0xE7, 0xDE, 0x3F, 0x3F, 0xC7, 0xDC,
  0x1F, 0x1F, 0x07, 0xD8, 0x1F, 0x1E, 0x07, 0xF8, 0x1F, 0x08, 0x07, 0xF0,
  0x1F, 0x00, 0x07, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x0F, 0xE0,
  0x00, 0xF8, 0x0F, 0xE0, 0x30, 0xF8, 0x1F, 0xE0, 0x78, 0xF8, 0x1B, 0xE1,
  0xF8, 0xF8, 0x3B, 0xE3, 0xFC, 0xFC, 0x7B, 0xEF, 0xF0, 0xFF, 0xF3, 0xFF,
  0xE0, 0x7F, 0xF1, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xC0, 0xFE,
  0x00, 0x1F, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x1F,
  0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7C,
  0x00, 0x3F, 0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x07,
  0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x0F,
  0x80, 0x07, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00,
  0xFC, 0x1F, 0x80, 0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x81,
  0xF8, 0x07, 0xF8, 0x1F, 0x80, 0xFF, 0x81, 0xFC, 0x1D, 0xF8, 0x1F, 0xFF,
  0x9F, 0x80, 0xFF, 0xF9, 0xF0, 0x0F, 0xFF, 0x1F, 0x00, 0x7F, 0xE3, 0xF0,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x10, 0x00, 0xFE, 0x03, 0x80, 0x1F, 0xC0, 0x7E, 0x07, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x1F, 0x07, 0xFF, 0xE1, 0xF0, 0xFF, 0xFF, 0x3F, 0x0F, 0xFF, 0xFF, 0xF1,
  0xF8, 0x3F, 0xFE, 0x1F, 0x00, 0x7F, 0xE1, 0xF0, 0x01, 0xFC, 0x1E, 0x00,
  0x3F, 0x01, 0xE0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x01, 0x00, 0x1F, 0xC0, 0xF8, 0x03, 0xF8, 0x07,
  0x80, 0x7E, 0x00, 0x78, 0x1F, 0xC0, 0x07, 0xC3, 0xF8, 0x00, 0x7C, 0x7F,
  0xFC, 0x03, 0xC7, 0xFF, 0xFE, 0x3C, 0xFD, 0xFF, 0xFF, 0xCF, 0xC7, 0xFF,
  0xFC, 0xF8, 0x0F, 0xFF, 0x8F, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0xC0, 0x3F, 0xE0, 0x07, 0xC3, 0xFF, 0x00, 0x3C, 0x3F, 0xFC,
  0x03, 0xE1, 0xFF, 0xF0, 0x1F, 0x1F, 0x9F, 0x81, 0xF0, 0xF8, 0x7E, 0x0F,
  0x8F, 0x81, 0xF8, 0xF8, 0x7C, 0x07, 0xFF, 0xC7, 0xC0, 0x3F, 0xFC, 0x3E,
  0x00, 0xFF, 0xC1, 0xE0, 0x03, 0xFC, 0x03, 0x00, 0x0F, 0x80, 0x00,
};

const GFXglyph IBMPlexMono_MediumItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 13, 38, 32, 10, -37 },
  { 63, 18, 16, 32, 10, -39 },
  { 99, 33, 37, 32, 0, -37 },
  { 252, 30, 49, 32, 1, -43 },
  { 436, 37, 39, 32, -2, -38 },
  { 617, 31, 39, 32, 0, -38 },
  { 769, 8, 16, 32, 15, -39 },
  { 785, 21, 47, 32, 10, -40 },
  { 909, 21, 47, 32, 2, -40 },
  { 1033, 27, 26, 32, 3, -29 },
  { 1121, 26, 27, 32, 3, -30 },
  { 1209, 13, 16, 32, 7, -8 },
  { 1235, 17, 5, 32, 8, -19 },
  { 1246, 9, 9, 32, 10, -8 },
  { 1257, 31, 47, 32, 1, -40 },
  { 1440, 28, 39, 32, 3, -38 },
  { 1577, 26, 37, 32, 2, -37 },
  { 1698, 29, 38, 32, 1, -38 },
  { 1836, 29, 39, 32, 1, -38 },
  { 1978, 29, 37, 32, 1, -37 },
  { 2113, 29, 38, 32, 2, -37 },
  { 2251, 26, 38, 32, 3, -37 },
  { 2375, 27, 37, 32, 5, -37 },
  { 2500, 29, 39, 32, 2, -38 },
  { 2642, 26, 38, 32, 4, -38 },
  { 2766, 12, 29, 32, 10, -28 },
  { 2810, 15, 36, 32, 7, -28 },
  { 2878, 26, 31, 32, 4, -32 },
  { 2979, 28, 16, 32, 2, -24 },
  { 3035, 25, 31, 32, 3, -32 },
  { 3132, 24, 39, 32, 6, -38 },
  { 3249, 27, 44, 32, 3, -38 },
  { 3398, 30, 37, 32, -1, -37 },
  { 3537, 28, 37, 32, 2, -37 },
  { 3667, 28, 39, 32, 3, -38 },
  { 3804, 28, 37, 32, 2, -37 },
  { 3934, 30, 37, 32, 2, -37 },
  { 4073, 30, 37, 32, 2, -37 },
  { 4212, 28, 39, 32, 3, -38 },
  { 4349, 30, 37, 32, 2, -37 },
  { 4488, 29, 37, 32, 2, -37 },
  { 4623, 28, 38, 32, 2, -37 },
  { 4756, 33, 37, 32, 2, -37 },
  { 4909, 23, 37, 32, 4, -37 },
  { 5016, 32, 37, 32, 1, -37 },
  { 5164, 30, 37, 32, 2, -37 },
  { 5303, 28, 39, 32, 3, -38 },
  { 5440, 29, 37, 32, 2, -37 },
  { 5575, 28, 48, 32, 3, -38 },
  { 5743, 29, 37, 32, 2, -37 },
  { 5878, 30, 39, 32, 1, -38 },
  { 6025, 30, 37, 32, 4, -37 },
  { 6164, 29, 38, 32, 3, -37 },
  { 6302, 29, 37, 32, 5, -37 },
  { 6437, 32, 37, 32, 2, -37 },
  { 6585, 35, 37, 32, -1, -37 },
  { 6747, 31, 37, 32, 4, -37 },
  { 6891, 32, 37, 32, 0, -37 },
  { 7039, 23, 47, 32, 8, -40 },
  { 7175, 15, 47, 32, 9, -40 },
  { 7264, 24, 47, 32, 1, -40 },
  { 7405, 27, 22, 32, 3, -37 },
  { 7480, 26, 5, 32, 0, 4 },
  { 7497, 8, 11, 32, 11, -42 },
  { 7508, 26, 29, 32, 3, -28 },
  { 7603, 27, 40, 32, 2, -39 },
  { 7738, 24, 29, 32, 4, -28 },
  { 7825, 29, 40, 32, 3, -39 },
  { 7970, 26, 29, 32, 3, -28 },
  { 8065, 35, 50, 32, -1, -39 },
  { 8284, 29, 39, 32, 1, -28 },
  { 8426, 26, 39, 32, 2, -39 },
  { 8553, 25, 40, 32, 4, -39 },
  { 8678, 26, 50, 32, 2, -39 },
  { 8841, 29, 40, 32, 2, -39 },
  { 8986, 23, 40, 32, 5, -39 },
  { 9101, 31, 28, 32, 0, -28 },
  { 9210, 26, 28, 32, 2, -28 },
  { 9301, 26, 29, 32, 3, -28 },
  { 9396, 29, 39, 32, 0, -28 },
  { 9538, 27, 39, 32, 3, -28 },
  { 9670, 26, 27, 32, 5, -27 },
  { 9758, 26, 29, 32, 2, -28 },
  { 9853, 25, 38, 32, 4, -37 },
  { 9972, 25, 28, 32, 4, -27 },
  { 10060, 26, 29, 32, 3, -28 },
  { 10155, 28, 29, 32, 2, -28 },
  { 10257, 32, 29, 32, 0, -28 },
  { 10373, 28, 38, 32, 1, -27 },
  { 10506, 28, 29, 32, 2, -28 },
  { 10608, 25, 47, 32, 6, -40 },
  { 10755, 13, 47, 32, 10, -40 },
  { 10832, 25, 47, 32, 2, -40 },
  { 10979, 29, 13, 32, 2, -23 },
};

const GFXfont IBMPlexMono_MediumItalic53pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic53pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic53pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _IBMPLEXMONO_MEDIUMITALIC53PT7B_H_
