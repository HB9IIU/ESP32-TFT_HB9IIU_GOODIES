#ifndef _IBMPLEXMONO_MEDIUMITALIC7PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x58, 0x80, 0xB8, 0x35, 0x6F, 0xA0, 0x27, 0xA6, 0x5E, 0x40, 0x5D,
  0x91, 0x6B, 0x00, 0x65, 0x6A, 0xF0, 0xC0, 0x72, 0x48, 0x80, 0x64, 0x95,
  0x80, 0x2F, 0x6A, 0x22, 0xD4, 0xE0, 0xC0, 0x80, 0x12, 0x24, 0x48, 0x79,
  0xB9, 0x60, 0x2E, 0x22, 0xF0, 0x71, 0x24, 0xF0, 0x71, 0x61, 0xE0, 0x17,
  0x6F, 0x20, 0x74, 0x71, 0xE0, 0x34, 0x79, 0x60, 0xF5, 0x28, 0x75, 0x69,
  0xE0, 0xF6, 0xA8, 0x42, 0x43, 0x80, 0x3A, 0x20, 0x7F, 0x43, 0x2C, 0xE5,
  0x08, 0x7B, 0xDD, 0xA6, 0x26, 0x67, 0x90, 0x75, 0x69, 0xE0, 0x74, 0x88,
  0x70, 0x75, 0x99, 0xE0, 0x74, 0x78, 0xE0, 0x74, 0x78, 0x80, 0x74, 0x8B,
  0x70, 0x55, 0x79, 0xA0, 0x72, 0x24, 0xE0, 0x71, 0x12, 0xE0, 0x5B, 0x19,
  0x49, 0x00, 0x44, 0x48, 0xF0, 0x5D, 0xBD, 0x90, 0x5D, 0xBB, 0xA0, 0x79,
  0x99, 0x60, 0x75, 0x78, 0x80, 0x79, 0x99, 0x63, 0x75, 0x7A, 0xB0, 0x74,
  0x61, 0xE0, 0xF4, 0x48, 0x80, 0x55, 0x99, 0x60, 0xBA, 0xCC, 0xC0, 0x9D,
  0xAD, 0xEA, 0x00, 0x5B, 0x08, 0xC9, 0x00, 0xBA, 0xC8, 0x80, 0x71, 0x24,
  0xF0, 0x72, 0x49, 0x80, 0xA9, 0x50, 0x64, 0x95, 0x80, 0x25, 0x90, 0xE0,
  0xB0, 0x79, 0x9F, 0x46, 0x59, 0xE0, 0x2D, 0x87, 0x17, 0x99, 0xE0, 0x2D,
  0xA7, 0x3B, 0x88, 0x44, 0x60, 0x79, 0x96, 0xE0, 0x46, 0x59, 0xA0, 0x5A,
  0x5C, 0x16, 0x22, 0x2E, 0x46, 0x5E, 0xB0, 0xD2, 0x6E, 0x5B, 0xDD, 0x65,
  0x9A, 0x69, 0x96, 0x65, 0x9E, 0x80, 0x79, 0x9E, 0x20, 0xEA, 0x40, 0x65,
  0x2F, 0x27, 0xC6, 0x70, 0x59, 0x96, 0xD5, 0x5E, 0xBB, 0xDE, 0x5B, 0x4F,
  0x59, 0x96, 0xE0, 0x7A, 0x6F, 0x69, 0x69, 0x80, 0x56, 0xA0, 0x62, 0x47,
  0x4C, 0x5A,
};

const GFXglyph IBMPlexMono_MediumItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 5, 4, 1, -5 },
  { 3, 3, 2, 4, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 7, 4, 0, -6 },
  { 11, 5, 5, 4, 0, -5 },
  { 15, 4, 5, 4, 0, -5 },
  { 18, 1, 2, 4, 2, -5 },
  { 19, 3, 6, 4, 1, -5 },
  { 22, 3, 6, 4, 0, -5 },
  { 25, 4, 4, 4, 0, -4 },
  { 27, 4, 4, 4, 0, -4 },
  { 29, 2, 2, 4, 1, -1 },
  { 30, 2, 1, 4, 1, -3 },
  { 31, 1, 1, 4, 1, -1 },
  { 32, 4, 6, 4, 0, -5 },
  { 35, 4, 5, 4, 0, -5 },
  { 38, 4, 5, 4, 0, -5 },
  { 41, 4, 5, 4, 0, -5 },
  { 44, 4, 5, 4, 0, -5 },
  { 47, 4, 5, 4, 0, -5 },
  { 50, 4, 5, 4, 0, -5 },
  { 53, 4, 5, 4, 0, -5 },
  { 56, 3, 5, 4, 1, -5 },
  { 58, 4, 5, 4, 0, -5 },
  { 61, 3, 5, 4, 1, -5 },
  { 63, 2, 4, 4, 1, -4 },
  { 64, 2, 5, 4, 1, -4 },
  { 66, 3, 4, 4, 1, -4 },
  { 68, 4, 2, 4, 0, -3 },
  { 69, 4, 4, 4, 0, -4 },
  { 71, 3, 5, 4, 1, -5 },
  { 73, 4, 6, 4, 0, -5 },
  { 76, 4, 5, 4, 0, -5 },
  { 79, 4, 5, 4, 0, -5 },
  { 82, 4, 5, 4, 0, -5 },
  { 85, 4, 5, 4, 0, -5 },
  { 88, 4, 5, 4, 0, -5 },
  { 91, 4, 5, 4, 0, -5 },
  { 94, 4, 5, 4, 0, -5 },
  { 97, 4, 5, 4, 0, -5 },
  { 100, 4, 5, 4, 0, -5 },
  { 103, 4, 5, 4, 0, -5 },
  { 106, 5, 5, 4, 0, -5 },
  { 110, 4, 5, 4, 0, -5 },
  { 113, 4, 5, 4, 0, -5 },
  { 116, 4, 5, 4, 0, -5 },
  { 119, 4, 5, 4, 0, -5 },
  { 122, 4, 5, 4, 0, -5 },
  { 125, 4, 6, 4, 0, -5 },
  { 128, 4, 5, 4, 0, -5 },
  { 131, 4, 5, 4, 0, -5 },
  { 134, 4, 5, 4, 1, -5 },
  { 137, 4, 5, 4, 0, -5 },
  { 140, 4, 5, 4, 1, -5 },
  { 143, 5, 5, 4, 0, -5 },
  { 147, 5, 5, 4, 0, -5 },
  { 151, 4, 5, 4, 1, -5 },
  { 154, 4, 5, 4, 0, -5 },
  { 157, 3, 6, 4, 1, -5 },
  { 160, 2, 6, 4, 1, -5 },
  { 162, 3, 6, 4, 0, -5 },
  { 165, 4, 3, 4, 0, -5 },
  { 167, 3, 1, 4, 0, 0 },
  { 168, 2, 2, 4, 1, -6 },
  { 169, 4, 4, 4, 0, -4 },
  { 171, 4, 5, 4, 0, -5 },
  { 174, 4, 4, 4, 0, -4 },
  { 176, 4, 5, 4, 0, -5 },
  { 179, 4, 4, 4, 0, -4 },
  { 181, 5, 6, 4, 0, -5 },
  { 185, 4, 5, 4, 0, -4 },
  { 188, 4, 5, 4, 0, -5 },
  { 191, 3, 5, 4, 1, -5 },
  { 193, 4, 6, 4, 0, -5 },
  { 196, 4, 5, 4, 0, -5 },
  { 199, 3, 5, 4, 1, -5 },
  { 201, 4, 4, 4, 0, -4 },
  { 203, 4, 4, 4, 0, -4 },
  { 205, 4, 4, 4, 0, -4 },
  { 207, 4, 5, 4, 0, -4 },
  { 210, 4, 5, 4, 0, -4 },
  { 213, 3, 4, 4, 1, -4 },
  { 215, 4, 4, 4, 0, -4 },
  { 217, 4, 5, 4, 0, -5 },
  { 220, 4, 4, 4, 0, -4 },
  { 222, 4, 4, 4, 0, -4 },
  { 224, 4, 4, 4, 0, -4 },
  { 226, 4, 4, 4, 0, -4 },
  { 228, 4, 5, 4, 0, -4 },
  { 231, 4, 4, 4, 0, -4 },
  { 233, 3, 6, 4, 1, -5 },
  { 236, 2, 6, 4, 1, -5 },
  { 238, 4, 6, 4, 0, -5 },
  { 241, 4, 2, 4, 0, -3 },
};

const GFXfont IBMPlexMono_MediumItalic7pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic7pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _IBMPLEXMONO_MEDIUMITALIC7PT7B_H_
