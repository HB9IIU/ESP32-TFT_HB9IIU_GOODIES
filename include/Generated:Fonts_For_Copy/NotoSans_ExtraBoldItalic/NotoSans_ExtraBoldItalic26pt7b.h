#ifndef _NOTOSANS_EXTRABOLDITALIC26PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0x80, 0x00, 0x00, 0xF0, 0xF8, 0x7C, 0x3C, 0x00, 0x79,
  0xEF, 0x39, 0xEF, 0x39, 0xE7, 0x38, 0xE7, 0x38, 0xE0, 0x01, 0xCF, 0x00,
  0xE7, 0x00, 0x73, 0x80, 0x71, 0xC0, 0x39, 0xC1, 0xFF, 0xFC, 0xFF, 0xFE,
  0x7F, 0xFF, 0x07, 0x38, 0x03, 0x9C, 0x03, 0x8E, 0x0F, 0xFF, 0xEF, 0xFF,
  0xF7, 0xFF, 0xF8, 0x73, 0xC0, 0x39, 0xC0, 0x1C, 0xE0, 0x1C, 0x70, 0x0E,
  0x70, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x7F, 0x07, 0xFF, 0x3F, 0xF8, 0xFF,
  0xE3, 0xD8, 0x0F, 0x60, 0x3F, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03,
  0xF0, 0x1B, 0xC8, 0x6F, 0x39, 0xFC, 0xFF, 0xF3, 0xFF, 0x87, 0xF8, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x0F, 0x00, 0xE0, 0xFC, 0x0F, 0x0F, 0xE0,
  0x70, 0xF7, 0x87, 0x07, 0x3C, 0x70, 0x39, 0xE7, 0x83, 0xCF, 0x38, 0x1E,
  0x73, 0x80, 0xF7, 0xB9, 0xF3, 0xFB, 0xDF, 0xDF, 0xDD, 0xFE, 0x79, 0xCE,
  0x70, 0x1E, 0xF3, 0x81, 0xE7, 0x9C, 0x0E, 0x38, 0xE0, 0xE1, 0xCF, 0x0F,
  0x0F, 0xF0, 0xF0, 0x3F, 0x8F, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xFC, 0x03,
  0xFE, 0x03, 0xEF, 0x81, 0xE3, 0xC0, 0xF3, 0xE0, 0x79, 0xE0, 0x3F, 0xE0,
  0x0F, 0xE0, 0x1F, 0xC3, 0xDF, 0xF1, 0xFF, 0x7D, 0xEF, 0x1F, 0xF7, 0x8F,
  0xF3, 0xC3, 0xF1, 0xF3, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xE7, 0xC0,
  0x7B, 0xDE, 0xE7, 0x3B, 0x80, 0x03, 0xC1, 0xE0, 0xF0, 0x38, 0x1E, 0x0F,
  0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x80, 0x07, 0x80,
  0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3C,
  0x0E, 0x0F, 0x80, 0x03, 0x00, 0x1C, 0x10, 0xE0, 0xC6, 0x07, 0xF0, 0x7F,
  0xFC, 0x7F, 0xE3, 0xFF, 0x3F, 0x83, 0xDC, 0x1E, 0xF0, 0x23, 0x80, 0x10,
  0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x3C,
  0xF7, 0x9E, 0xF3, 0xC0, 0x7F, 0x7F, 0x7E, 0xFE, 0x7F, 0xFF, 0xE0, 0x00,
  0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x7F,
  0x87, 0xFE, 0x7F, 0xF3, 0xC7, 0xBE, 0x3D, 0xE1, 0xEF, 0x0F, 0xF8, 0x7F,
  0xC3, 0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7B, 0xC7, 0xDF, 0x7C, 0xFF,
  0xE3, 0xFE, 0x0F, 0xC0, 0x00, 0xE0, 0x7C, 0x3F, 0x8F, 0xF7, 0xFD, 0xFF,
  0x9C, 0xF1, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03,
  0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x78, 0x00, 0x01, 0xF0, 0x0F, 0xF8, 0x7F,
  0xF0, 0x7F, 0xF0, 0xE3, 0xE0, 0x83, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0xFE, 0x7F, 0xF8, 0xFF, 0xF3, 0xFF, 0xE0, 0x03, 0xE0, 0x7F, 0xE1, 0xFF,
  0xC3, 0xFF, 0x08, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x0F, 0xF0, 0x3F,
  0x00, 0xFF, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE8, 0x0F, 0xB8, 0x7E, 0xFF,
  0xF3, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F,
  0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xDE, 0x1E, 0x78, 0x73, 0xC3, 0xCF,
  0x1E, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x20, 0x3E, 0x71, 0xFC, 0xFF, 0xF1, 0xFF,
  0xC1, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0xF0, 0xFF, 0xC7, 0xFE, 0x3E, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0xF8, 0x7F, 0xF3, 0xFF, 0xCF, 0xCF, 0xBE, 0x3E,
  0xF0, 0xFB, 0xC3, 0xEF, 0x0F, 0x3E, 0x7C, 0x7F, 0xE1, 0xFF, 0x01, 0xF8,
  0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF3, 0xFF, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x7F, 0x87, 0xFE, 0x7D, 0xF3, 0xC7, 0x9E, 0x3C, 0xF1,
  0xE7, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xF8, 0xFB, 0xEF, 0x0F, 0x78, 0x7B,
  0xC3, 0xDE, 0x3E, 0xFF, 0xF3, 0xFF, 0x0F, 0xE0, 0x07, 0xC0, 0xFF, 0x0F,
  0xFC, 0xFF, 0xF7, 0xC7, 0xBC, 0x3D, 0xE1, 0xFF, 0x1F, 0x78, 0xFB, 0xFF,
  0xDF, 0xFE, 0x7F, 0xE1, 0xCF, 0x00, 0xF8, 0x07, 0x91, 0xFC, 0xFF, 0xC7,
  0xFC, 0x3F, 0x80, 0x04, 0x3C, 0x79, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xCF, 0x9F, 0x3C, 0x00, 0x02, 0x0F, 0x0F, 0x1F, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7C, 0x78, 0x70, 0xF0, 0xE0, 0x00,
  0x18, 0x03, 0xC0, 0x7E, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xE0, 0x1F, 0x80,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF0, 0x01, 0x80, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x3F,
  0x0F, 0xF1, 0xFC, 0x3F, 0x81, 0xF0, 0x0E, 0x00, 0x40, 0x00, 0x0F, 0x0F,
  0xFB, 0xFF, 0xBF, 0xF6, 0x1E, 0x03, 0xC0, 0xF8, 0x3E, 0x1F, 0x87, 0xE0,
  0xF0, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0x03, 0xE1,
  0xE0, 0x07, 0x1E, 0x0E, 0x3D, 0xE3, 0xFC, 0xEE, 0x3F, 0xE7, 0x73, 0xCF,
  0x3F, 0x1C, 0x71, 0xF9, 0xE3, 0x8F, 0xCE, 0x1C, 0x7E, 0x71, 0xE7, 0x73,
  0xDF, 0x7B, 0x8F, 0xFF, 0x9E, 0x7D, 0xF8, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x87, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0x78, 0x07, 0xBC,
  0x07, 0x9E, 0x03, 0xCF, 0x03, 0xE3, 0x81, 0xE1, 0xC1, 0xFF, 0xF0, 0xFF,
  0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x7C, 0x0F, 0x3C, 0x07, 0xBE, 0x03, 0xFE,
  0x01, 0xE0, 0x1F, 0xE0, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xF1, 0xE3, 0xE7,
  0xC7, 0xCF, 0x8F, 0x9E, 0x3E, 0x3F, 0xF8, 0x7F, 0xC1, 0xFF, 0xE3, 0xE3,
  0xC7, 0x87, 0xCF, 0x0F, 0xBE, 0x1F, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xE3,
  0xFF, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0x06,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7F, 0x78, 0x3F, 0xF8,
  0x3F, 0xF8, 0x0F, 0xF0, 0x1F, 0x80, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE,
  0x1E, 0x3E, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1F, 0x3C, 0x1F, 0x3C, 0x1F,
  0x7C, 0x1F, 0x7C, 0x1E, 0x78, 0x3E, 0x78, 0x3E, 0xF8, 0x7C, 0xFF, 0xF8,
  0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7,
  0xFF, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3F, 0xF0, 0xFF, 0xC7,
  0xFF, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3F, 0xF8, 0xFF, 0xE3,
  0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFE, 0x1E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3F, 0xF0, 0xFF, 0xC7, 0xFF, 0x1F,
  0xF8, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xE1, 0xF0,
  0x21, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0xFF, 0x3C, 0x7F, 0xBE,
  0x3F, 0x9F, 0x1F, 0xCF, 0x81, 0xE3, 0xC1, 0xF1, 0xF0, 0xF8, 0xFE, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0x07, 0xC7, 0xC1, 0xE1,
  0xE0, 0x78, 0x78, 0x3E, 0x1E, 0x0F, 0x8F, 0x83, 0xC3, 0xE0, 0xF0, 0xF0,
  0x3C, 0x3F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xE1, 0xF0, 0x78, 0x78, 0x1E,
  0x1E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF0, 0xF8, 0x3C, 0x3C, 0x1F, 0x0F,
  0x07, 0xC0, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x7F, 0x87, 0xFC, 0x3F, 0xE0, 0x00, 0x78, 0x03,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xC0,
  0x70, 0x00, 0x1F, 0x07, 0xC7, 0xC3, 0xE1, 0xE1, 0xF0, 0x78, 0xF8, 0x1E,
  0x7C, 0x0F, 0x9F, 0x03, 0xEF, 0x80, 0xF7, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x79, 0xF0, 0x1E, 0x7C, 0x0F, 0x8F, 0x03,
  0xE3, 0xE0, 0xF0, 0xF8, 0x3C, 0x1F, 0x0F, 0x07, 0xC0, 0x1F, 0x03, 0xE0,
  0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0,
  0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0xC7, 0xE0, 0x7F, 0x1F,
  0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x8F, 0xE1, 0xDE, 0x3F, 0xCF,
  0x78, 0xEF, 0x3B, 0xC7, 0xBD, 0xEF, 0x1E, 0xF7, 0x3C, 0x7B, 0xDC, 0xF1,
  0xE7, 0xE3, 0xCF, 0x1F, 0x9E, 0x3C, 0x7C, 0x78, 0xF1, 0xF1, 0xE3, 0xC7,
  0x87, 0x8F, 0x1E, 0x3E, 0x00, 0x1F, 0x81, 0xE3, 0xF0, 0x3C, 0x7E, 0x07,
  0x8F, 0xE0, 0xF1, 0xFC, 0x3C, 0x7F, 0x87, 0x8F, 0xF0, 0xF1, 0xEF, 0x1E,
  0x3D, 0xE3, 0xC7, 0x3C, 0xF1, 0xE3, 0xDE, 0x3C, 0x7B, 0xC7, 0x8F, 0x78,
  0xF0, 0xFE, 0x3C, 0x1F, 0xC7, 0x83, 0xF8, 0xF0, 0x7F, 0x1E, 0x07, 0xE3,
  0xC0, 0xF8, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3,
  0xF0, 0xF9, 0xF0, 0x7D, 0xF0, 0x1E, 0xF8, 0x0F, 0x78, 0x07, 0xBC, 0x03,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xF3, 0xC0, 0xF9, 0xF0, 0xFC, 0xFF,
  0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0xF0,
  0x7F, 0xF0, 0xFF, 0xE1, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9E, 0x1F, 0x3C,
  0x7C, 0x7F, 0xF9, 0xFF, 0xE3, 0xFF, 0x87, 0xF0, 0x0F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x03, 0xFF,
  0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xF0, 0xF9, 0xF0, 0x7D, 0xF0, 0x1E, 0xF8,
  0x0F, 0x78, 0x07, 0xBC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xF3,
  0xC0, 0xF9, 0xF0, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x03, 0xFC,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x3F,
  0xF0, 0x7F, 0xF0, 0xFF, 0xE1, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9E, 0x1E,
  0x3C, 0xFC, 0x7F, 0xF1, 0xFF, 0xC3, 0xFF, 0x07, 0x9E, 0x0F, 0x3E, 0x3E,
  0x3C, 0x7C, 0x7C, 0xF8, 0xF9, 0xE0, 0xFB, 0xC1, 0xF0, 0x03, 0xE0, 0x7F,
  0xC7, 0xFE, 0x7F, 0xE3, 0xC1, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x00,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF2, 0x07, 0x9E, 0xFC, 0xFF,
  0xC7, 0xFE, 0x3F, 0xC0, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x0F,
  0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07,
  0xC0, 0x00, 0x3E, 0x0F, 0x3E, 0x0F, 0x3C, 0x1F, 0x3C, 0x1F, 0x7C, 0x1E,
  0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x78, 0x3E, 0xF8, 0x3C, 0xF8, 0x3C,
  0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0,
  0x7F, 0xE0, 0x3F, 0xC0, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3E, 0xF8, 0x3C,
  0xF8, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0x78, 0xF0, 0x79, 0xF0, 0x79, 0xE0,
  0x79, 0xE0, 0x7B, 0xC0, 0x7B, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x1F,
  0xF0, 0x7C, 0x1E, 0xF0, 0x7C, 0x3E, 0xF0, 0xFC, 0x3C, 0xF0, 0xFC, 0x3C,
  0xF1, 0xFC, 0x78, 0xF1, 0xDC, 0x78, 0xF1, 0xDC, 0xF8, 0xF3, 0xDC, 0xF0,
  0xF3, 0x9C, 0xF0, 0x77, 0x9D, 0xE0, 0x77, 0x1D, 0xE0, 0x77, 0x1D, 0xC0,
  0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7C, 0x1F, 0x80,
  0x7C, 0x1F, 0x00, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0x3C,
  0x7C, 0x03, 0xE7, 0x80, 0x3E, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00,
  0xFB, 0xE0, 0x0F, 0x9E, 0x01, 0xF1, 0xF0, 0x3E, 0x1F, 0x03, 0xE0, 0xF0,
  0xFC, 0x0F, 0x80, 0xF8, 0x3E, 0xF0, 0x7D, 0xE1, 0xF3, 0xC3, 0xC7, 0xCF,
  0x87, 0xBE, 0x0F, 0x78, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xFC, 0x7F,
  0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x70, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x7E,
  0x07, 0xE0, 0xFE, 0x00, 0xE3, 0xCF, 0x3C, 0xF1, 0xC7, 0x1E, 0x79, 0xE7,
  0x8E, 0x38, 0xE3, 0xCF, 0x3C, 0xF1, 0xC0, 0x07, 0xE0, 0xFC, 0x1F, 0x80,
  0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x07, 0xE0,
  0xFC, 0x3F, 0x80, 0x00, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0xF8, 0x07, 0xE0,
  0x1D, 0xC0, 0xE7, 0x07, 0x9C, 0x1C, 0x78, 0xF0, 0xE7, 0x83, 0x9C, 0x0E,
  0xF0, 0x1C, 0xFF, 0xFF, 0xFC, 0xF3, 0xE7, 0x8F, 0x02, 0x00, 0x3E, 0xF1,
  0xFF, 0xCF, 0xFF, 0x7C, 0xF9, 0xF1, 0xE7, 0x87, 0xBE, 0x1E, 0xF8, 0x7B,
  0xE3, 0xCF, 0x8F, 0x3E, 0x7C, 0xFF, 0xF1, 0xFF, 0xC3, 0xEE, 0x00, 0x07,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE4, 0x07, 0xBE,
  0x0F, 0xFE, 0x1F, 0xFC, 0x3C, 0x78, 0xF8, 0xF9, 0xE1, 0xE3, 0xC3, 0xC7,
  0x87, 0x8F, 0x1F, 0x3E, 0x3E, 0x7C, 0xF8, 0xFF, 0xF1, 0xDF, 0xC7, 0x9F,
  0x00, 0x01, 0x80, 0xFF, 0x1F, 0xF3, 0xFE, 0x7C, 0x27, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x00, 0xF8, 0x0F, 0x8C, 0x7F, 0xC7, 0xFC, 0x3F, 0x80,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x47, 0x83,
  0xEF, 0x0F, 0xFE, 0x3F, 0xFC, 0xF9, 0xF1, 0xF1, 0xE3, 0xC3, 0xCF, 0x87,
  0x9F, 0x0F, 0x3E, 0x3C, 0x7C, 0x78, 0xF9, 0xF1, 0xFF, 0xE1, 0xFF, 0xC1,
  0xF7, 0x00, 0x01, 0x80, 0x7F, 0x87, 0xFE, 0x7F, 0xF7, 0xC7, 0xBC, 0x3D,
  0xE7, 0xFF, 0xFE, 0xFF, 0xC7, 0x80, 0x3E, 0x01, 0xF0, 0x47, 0xFE, 0x3F,
  0xF0, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFA, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0xBF,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0x00, 0x0F, 0xBC, 0x3F,
  0xF8, 0xFF, 0xF3, 0xE3, 0xC7, 0xC7, 0x8F, 0x0F, 0x3E, 0x1E, 0x7C, 0x7C,
  0xF8, 0xF1, 0xF1, 0xE3, 0xE7, 0xC7, 0xFF, 0x87, 0xFF, 0x07, 0xBC, 0x00,
  0x78, 0x00, 0xF1, 0x87, 0xC3, 0xFF, 0x87, 0xFE, 0x07, 0xF8, 0x00, 0x07,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE6, 0x07, 0xBF,
  0x0F, 0xFE, 0x1F, 0xFE, 0x3E, 0x7C, 0xF8, 0xF9, 0xF1, 0xE3, 0xC3, 0xC7,
  0x87, 0x8F, 0x0F, 0x3E, 0x3E, 0x78, 0x78, 0xF0, 0xF1, 0xE1, 0xE7, 0xC7,
  0xC0, 0x07, 0x07, 0xC3, 0xE1, 0xE0, 0x00, 0x00, 0x7C, 0x3C, 0x1E, 0x0F,
  0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x1F, 0x00,
  0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8,
  0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0xBE, 0x0F, 0xE0,
  0xFC, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF8, 0x04, 0x7C, 0x7C, 0x3C, 0x7C, 0x1E, 0x7C, 0x0F, 0x7C,
  0x0F, 0xFC, 0x07, 0xBC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFB,
  0xE0, 0x78, 0xF0, 0x3C, 0x7C, 0x1E, 0x3E, 0x1F, 0x0F, 0x80, 0x07, 0x87,
  0xC3, 0xC1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x0F, 0x87, 0xC3,
  0xC1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x1F, 0x00, 0x00, 0x10, 0x20,
  0x3D, 0xF9, 0xF8, 0x7F, 0xF7, 0xF0, 0xFF, 0xFF, 0xE1, 0xF3, 0xF3, 0xE7,
  0xC7, 0xC7, 0x8F, 0x8F, 0x8F, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x78,
  0xF8, 0xF9, 0xF1, 0xF1, 0xF3, 0xC3, 0xC3, 0xC7, 0x87, 0x87, 0x8F, 0x0F,
  0x0F, 0x3E, 0x3E, 0x3E, 0x00, 0x00, 0x30, 0x3D, 0xF8, 0x7F, 0xF0, 0xFF,
  0xF1, 0xF3, 0xE7, 0xC7, 0xCF, 0x8F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x79,
  0xF1, 0xF3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x3E, 0x3E, 0x00, 0x01, 0x00,
  0x7F, 0x07, 0xFC, 0x7F, 0xF7, 0xC7, 0xBC, 0x3D, 0xE1, 0xFF, 0x0F, 0xF8,
  0x7F, 0x87, 0xFE, 0x3F, 0xF3, 0xE7, 0xFE, 0x3F, 0xF0, 0xFE, 0x00, 0x00,
  0x10, 0x0F, 0x7C, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0x1E, 0x1F, 0x1F, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x3F,
  0xFC, 0x3F, 0xF8, 0x7D, 0xF0, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x02, 0x00, 0x3E, 0x71, 0xFF, 0xCF, 0xFF,
  0x7C, 0xF9, 0xF1, 0xE7, 0x87, 0xBE, 0x1E, 0xF8, 0x7B, 0xE3, 0xCF, 0x8F,
  0x3E, 0x7C, 0xFF, 0xF1, 0xFF, 0xC3, 0xDE, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x11, 0xEF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xE3, 0xF0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80,
  0x78, 0x07, 0x80, 0xF8, 0x00, 0x01, 0x01, 0xFF, 0x3F, 0xF3, 0xFE, 0x3C,
  0x23, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xEC, 0x3E, 0xFF,
  0xCF, 0xFC, 0xFF, 0x00, 0x0F, 0x01, 0xC0, 0x78, 0x3F, 0xFF, 0xFD, 0xFF,
  0x8F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF2, 0x3F,
  0xC3, 0xF8, 0x7F, 0x00, 0x3E, 0x3E, 0x78, 0x78, 0xF0, 0xF3, 0xE3, 0xE7,
  0xC7, 0xCF, 0x0F, 0x1E, 0x1E, 0x3C, 0x7C, 0xF8, 0xF9, 0xF1, 0xE3, 0xE7,
  0xC7, 0xFF, 0x87, 0xFF, 0x07, 0xDE, 0x00, 0xF8, 0x7F, 0xE1, 0xE7, 0x8F,
  0x9E, 0x3C, 0x79, 0xF1, 0xE7, 0x87, 0xBE, 0x1E, 0xF0, 0x7F, 0x81, 0xFE,
  0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0xF8, 0x7B, 0xC7,
  0xC7, 0x9E, 0x7E, 0x3C, 0xF3, 0xF3, 0xE7, 0xBF, 0x9E, 0x3D, 0xDD, 0xF1,
  0xEE, 0xEF, 0x0F, 0xE7, 0x78, 0x77, 0x3F, 0x83, 0xB9, 0xFC, 0x1F, 0x8F,
  0xC0, 0xFC, 0x7E, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x87,
  0x9F, 0x03, 0xCF, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xBC, 0x07, 0x9F, 0x07, 0xC7,
  0x87, 0xC3, 0xE0, 0x1F, 0x0F, 0x8F, 0x87, 0x83, 0xC7, 0xC1, 0xE3, 0xC0,
  0xF3, 0xE0, 0x79, 0xE0, 0x3D, 0xF0, 0x1E, 0xF0, 0x0F, 0x78, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0x00, 0x00, 0x0F, 0xFC,
  0x7F, 0xE1, 0xFF, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0x78, 0x03, 0xE1, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF, 0x80, 0x00,
  0x60, 0x7C, 0x1F, 0x83, 0xE0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03,
  0xC3, 0xF8, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00,
  0xE0, 0x3C, 0x07, 0xE0, 0x7C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x08, 0x03, 0xC1, 0xF0, 0x7E, 0x07, 0x81,
  0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0x7C, 0x0F, 0x0F, 0xC7, 0xF1, 0xE0,
  0x70, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0xF8, 0x3E, 0x0E, 0x00, 0x7F, 0x0F,
  0xFF, 0xFF, 0xFF, 0x03, 0xE0,
};

const GFXglyph NotoSans_ExtraBoldItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 19, 8, 0, -19 },
  { 23, 11, 7, 12, 2, -19 },
  { 33, 17, 19, 17, 0, -19 },
  { 74, 14, 22, 15, 1, -20 },
  { 113, 21, 19, 23, 1, -19 },
  { 163, 17, 19, 19, 1, -19 },
  { 204, 5, 7, 6, 2, -19 },
  { 209, 10, 23, 9, 1, -19 },
  { 238, 10, 23, 9, -2, -19 },
  { 267, 13, 13, 14, 2, -20 },
  { 289, 13, 13, 15, 1, -16 },
  { 311, 6, 6, 8, -1, -3 },
  { 316, 8, 4, 8, 0, -9 },
  { 320, 5, 4, 8, 0, -4 },
  { 323, 14, 19, 12, -1, -19 },
  { 357, 13, 19, 15, 1, -19 },
  { 388, 11, 19, 15, 2, -19 },
  { 415, 15, 19, 15, -1, -19 },
  { 451, 14, 19, 15, 0, -19 },
  { 485, 14, 19, 15, 0, -19 },
  { 519, 15, 19, 15, 0, -19 },
  { 555, 14, 19, 15, 1, -19 },
  { 589, 15, 19, 15, 1, -19 },
  { 625, 13, 19, 15, 1, -19 },
  { 656, 13, 19, 15, 1, -19 },
  { 687, 7, 15, 8, 0, -15 },
  { 701, 8, 18, 8, -1, -15 },
  { 719, 13, 14, 15, 1, -16 },
  { 742, 13, 8, 15, 1, -13 },
  { 755, 13, 14, 15, 1, -16 },
  { 778, 11, 19, 12, 2, -19 },
  { 805, 21, 21, 23, 1, -19 },
  { 861, 17, 19, 17, -2, -19 },
  { 902, 15, 19, 16, 1, -19 },
  { 938, 16, 19, 16, 1, -19 },
  { 976, 16, 19, 18, 1, -19 },
  { 1014, 14, 19, 14, 1, -19 },
  { 1048, 14, 19, 14, 1, -19 },
  { 1082, 17, 19, 18, 1, -19 },
  { 1123, 18, 19, 18, 1, -19 },
  { 1166, 13, 19, 10, -1, -19 },
  { 1197, 13, 25, 9, -4, -19 },
  { 1238, 18, 19, 17, 1, -19 },
  { 1281, 11, 19, 14, 1, -19 },
  { 1308, 22, 19, 23, 1, -19 },
  { 1361, 19, 19, 20, 1, -19 },
  { 1407, 17, 19, 19, 1, -19 },
  { 1448, 15, 19, 16, 1, -19 },
  { 1484, 17, 23, 19, 1, -19 },
  { 1533, 15, 19, 16, 1, -19 },
  { 1569, 13, 19, 14, 1, -19 },
  { 1600, 14, 19, 14, 2, -19 },
  { 1634, 16, 19, 18, 2, -19 },
  { 1672, 16, 19, 16, 2, -19 },
  { 1710, 24, 19, 24, 2, -19 },
  { 1767, 20, 19, 16, -2, -19 },
  { 1815, 15, 19, 15, 2, -19 },
  { 1851, 16, 19, 14, -1, -19 },
  { 1889, 12, 23, 9, -1, -19 },
  { 1924, 6, 19, 12, 3, -19 },
  { 1939, 11, 23, 9, -2, -19 },
  { 1971, 14, 13, 14, 0, -19 },
  { 1994, 11, 2, 11, -2, 2 },
  { 1997, 6, 4, 9, 4, -20 },
  { 2000, 14, 15, 16, 1, -15 },
  { 2027, 15, 20, 16, 0, -20 },
  { 2065, 12, 15, 13, 1, -15 },
  { 2088, 15, 20, 16, 1, -20 },
  { 2126, 13, 15, 15, 1, -15 },
  { 2151, 16, 26, 10, -3, -20 },
  { 2203, 15, 21, 16, 0, -15 },
  { 2243, 15, 20, 16, 0, -20 },
  { 2281, 9, 20, 8, 0, -20 },
  { 2304, 12, 26, 8, -3, -20 },
  { 2343, 17, 20, 15, 0, -20 },
  { 2386, 9, 20, 8, 0, -20 },
  { 2409, 23, 15, 24, 0, -15 },
  { 2453, 15, 15, 16, 0, -15 },
  { 2482, 13, 15, 15, 1, -15 },
  { 2507, 16, 21, 16, -1, -15 },
  { 2549, 14, 21, 16, 1, -15 },
  { 2586, 12, 15, 11, 0, -15 },
  { 2609, 12, 15, 13, 0, -15 },
  { 2632, 11, 17, 11, 1, -17 },
  { 2656, 15, 14, 16, 1, -14 },
  { 2683, 14, 14, 14, 1, -14 },
  { 2708, 21, 14, 21, 1, -14 },
  { 2745, 17, 14, 14, -1, -14 },
  { 2775, 17, 20, 14, -2, -14 },
  { 2818, 14, 14, 12, -1, -14 },
  { 2843, 11, 23, 9, 0, -19 },
  { 2875, 3, 26, 15, 6, -20 },
  { 2885, 10, 23, 9, -1, -19 },
  { 2914, 13, 4, 15, 1, -11 },
};

const GFXfont NotoSans_ExtraBoldItalic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic26pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_EXTRABOLDITALIC26PT7B_H_
