#ifndef _NOTOSANS_EXTRABOLDITALIC61PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xC0, 0x00,
  0x3F, 0xE3, 0xFF, 0x3F, 0xE3, 0xFE, 0x3F, 0xC3, 0xFE, 0x7F, 0xC3, 0xFE,
  0x7F, 0xC3, 0xFC, 0x7F, 0xC3, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x87, 0xFC,
  0x7F, 0x87, 0xF8, 0x7F, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF0,
  0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x7F, 0x07,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x00, 0x3F, 0x83, 0xFC, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFE, 0x78, 0x7C, 0x0F, 0xFC, 0x78, 0x08, 0x0F, 0xFC, 0xF8, 0x00, 0x0F,
  0xF8, 0xF8, 0x00, 0x0F, 0xFC, 0xF0, 0x00, 0x0F, 0xFC, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xDF, 0xF8, 0x00,
  0x07, 0x8F, 0xF8, 0x00, 0x07, 0x8F, 0xF8, 0x00, 0x0F, 0x8F, 0xF8, 0x80,
  0x0F, 0x8F, 0xF8, 0xF0, 0x0F, 0x9F, 0xF8, 0xFF, 0x0F, 0x3F, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0xC7, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x01,
  0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0,
  0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8,
  0x7F, 0x80, 0x00, 0x7F, 0x83, 0xFC, 0x7F, 0x81, 0xF0, 0x3F, 0xC3, 0xFE,
  0x3F, 0xC7, 0xFF, 0x0F, 0xF1, 0xFE, 0x3F, 0xC7, 0xFF, 0xC7, 0xFF, 0xFF,
  0x3F, 0xC7, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xC7, 0xFF, 0xF9, 0xFF, 0xFF,
  0x9F, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF,
  0x9F, 0xE3, 0xFE, 0x7F, 0x87, 0xFF, 0x1F, 0xE3, 0xFE, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF1, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0xFF, 0x87, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x00,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x07, 0xF8, 0x3F, 0xC0,
  0x03, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x9F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x01, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC7, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0xBF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xFF, 0xFC, 0x07,
  0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xC3,
  0xFF, 0xDF, 0xFC, 0x7F, 0xF1, 0xFF, 0xC3, 0xFF, 0x9F, 0xF8, 0x7F, 0xF0,
  0x7F, 0xFF, 0xFE, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xFE, 0x03, 0xFF,
  0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x3F, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF3, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF,
  0x9F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x03, 0x00, 0x7F, 0x00, 0x0F, 0x01, 0xFC, 0x00, 0x3F,
  0x07, 0xF0, 0x01, 0xFF, 0x1F, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFE, 0x3F, 0x81, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xEF, 0xE0, 0x03, 0xFF, 0x3F, 0x80, 0x1F, 0xF8, 0xFF, 0x00, 0x1F,
  0xE1, 0xFC, 0x00, 0x3F, 0x07, 0xF8, 0x00, 0x38, 0x1F, 0xE0, 0x00, 0x60,
  0x7F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF,
  0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF,
  0x00, 0x0F, 0xC3, 0xFE, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xE7, 0xFC, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x8F,
  0xFE, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x07,
  0xFF, 0x1F, 0xFC, 0x07, 0xFF, 0x1F, 0xF8, 0x07, 0xFF, 0x3F, 0xF8, 0x07,
  0xFF, 0x3F, 0xF8, 0x07, 0xFF, 0x3F, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x07,
  0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFE, 0x7F, 0xE0, 0x07,
  0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xE0, 0x07,
  0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x0F,
  0xFC, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xC0, 0x1F,
  0xFC, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xC0, 0x3F,
  0xF0, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFB, 0xFE, 0x1F, 0xFD, 0xFF, 0x83, 0xFC,
  0x7F, 0xE0, 0x7E, 0x1F, 0xF8, 0x1E, 0x0F, 0xFC, 0x02, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x1F, 0xFC, 0x00, 0xF8, 0x03, 0xFF,
  0x80, 0x0E, 0x00, 0x3F, 0xF0, 0x00, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0x07, 0xFF, 0x80, 0x3C, 0x01, 0xFF, 0xC0, 0x08, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x40, 0x00, 0x07, 0xFF, 0x38, 0x00, 0x07,
  0xFF, 0x1F, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x03, 0xFE,
  0x7F, 0xC0, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0x83, 0xFF, 0x00,
  0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFC, 0x40, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0x80, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x40, 0x00, 0x1F, 0xFC, 0x30, 0x00, 0x1F, 0xFE, 0x1F, 0x00, 0x3F, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0B, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xF8, 0x02, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x7C, 0x00, 0x1F, 0xF1, 0xFF, 0x80,
  0x1F, 0xF9, 0xFF, 0xF0, 0x0F, 0xF9, 0xFF, 0xFC, 0x07, 0xFD, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x07,
  0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x8F, 0xFE, 0x00,
  0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0,
  0x3F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8,
  0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0x8F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x03,
  0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03,
  0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x0F,
  0xFC, 0x03, 0xFF, 0x9F, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFE, 0xFF, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F,
  0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F,
  0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x1F,
  0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xF0, 0x7F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF3, 0xFF,
  0x00, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFD, 0xFF, 0x80,
  0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xF7, 0xFE, 0x01, 0xFF, 0xDF, 0xF8, 0x0F, 0xFF,
  0x7F, 0xF0, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0x7F, 0xE0, 0xFF,
  0xF9, 0xFF, 0x81, 0xFF, 0xC7, 0xFC, 0x01, 0xFC, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x20, 0x07, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x1F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x07, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x03, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE,
  0x3F, 0x81, 0xFF, 0xCF, 0x80, 0x3F, 0xF1, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0x7F,
  0xFF, 0xC3, 0xF8, 0x7F, 0x80, 0x7F, 0xFF, 0xE1, 0xFE, 0x7F, 0x80, 0xFF,
  0xFF, 0xF0, 0x7F, 0x3F, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0x9F, 0xC0, 0xFF,
  0xFF, 0xF8, 0x1F, 0xDF, 0xE0, 0x7F, 0xC1, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F,
  0xC0, 0xFE, 0x07, 0xF7, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFF, 0xF8, 0x3F,
  0xC0, 0x7F, 0x01, 0xFF, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0xFC, 0x1F,
  0xE0, 0x1F, 0xC0, 0x7F, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xFF, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0xBF, 0x83, 0xF8, 0x07, 0xF0, 0x1F, 0xDF, 0xC3,
  0xFC, 0x07, 0xF8, 0x1F, 0xEF, 0xE1, 0xFE, 0x03, 0xFC, 0x0F, 0xE7, 0xF0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF3, 0xF8, 0x3F, 0x81, 0xFE, 0x0F, 0xF1, 0xFC,
  0x1F, 0xE3, 0xFF, 0x8F, 0xF8, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xC1, 0xFF, 0xFB, 0xFF, 0xF8, 0x1F,
  0xE0, 0x7F, 0xF9, 0xFF, 0xF8, 0x07, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0x03,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00,
  0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x07, 0xFC,
  0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x07,
  0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x07,
  0xFE, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x1F,
  0xF8, 0x00, 0x03, 0xFE, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xF8,
  0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F,
  0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3E, 0x01, 0xFF,
  0xF0, 0x00, 0x70, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x0E, 0x00, 0x7F, 0xFC, 0x03, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x03,
  0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x03,
  0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00,
  0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xC0,
  0x03, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xFC,
  0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xF0,
  0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x40, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xBF, 0xF0, 0x07, 0xFF, 0xE0, 0x03,
  0xE0, 0x1F, 0xFF, 0x00, 0x00, 0x80, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0xFF,
  0xFF, 0xC7, 0xFF, 0x01, 0xFF, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0xFE, 0x1F,
  0xF8, 0x07, 0xFF, 0xFC, 0x3F, 0xF0, 0x1F, 0xFF, 0xF8, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xFF, 0x87,
  0xFF, 0x02, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00,
  0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x1E, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x0F,
  0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0xF1, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xFC,
  0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xE7, 0xFF, 0x00, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xC3, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xF7, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFB,
  0xFC, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFE, 0x00,
  0xFF, 0xBF, 0xC0, 0x3F, 0xCF, 0xF8, 0x03, 0xFE, 0xFF, 0x00, 0xFF, 0x7F,
  0xC0, 0x0F, 0xFB, 0xFC, 0x07, 0xF9, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x1F,
  0xE7, 0xFC, 0x01, 0xFF, 0x3F, 0xC0, 0x7F, 0x3F, 0xF0, 0x07, 0xFC, 0xFF,
  0x03, 0xFC, 0xFF, 0xC0, 0x1F, 0xF3, 0xFC, 0x0F, 0xF3, 0xFE, 0x00, 0x7F,
  0xCF, 0xF0, 0x7F, 0x8F, 0xF8, 0x01, 0xFF, 0x3F, 0xC1, 0xFE, 0x3F, 0xE0,
  0x0F, 0xFC, 0xFF, 0x0F, 0xF1, 0xFF, 0x80, 0x3F, 0xE3, 0xFC, 0x3F, 0xC7,
  0xFC, 0x00, 0xFF, 0x8F, 0xF1, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xC7,
  0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0x3F, 0xC3, 0xFF, 0x00, 0x7F, 0xE1,
  0xFC, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x07, 0xF7, 0xF8, 0x3F, 0xE0, 0x07,
  0xFC, 0x1F, 0xDF, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xFF, 0x03, 0xFE,
  0x00, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xF8, 0x03, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xE0, 0x0F, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F,
  0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xF0, 0x07, 0xFE,
  0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF0, 0x1F, 0xFE, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x3F,
  0xE0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFC,
  0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFB, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xEF, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x0F, 0xF8, 0x03,
  0xFE, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF9, 0xFF, 0x81, 0xFF, 0x80, 0x3F,
  0xE3, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x8F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC,
  0x3F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0xC1,
  0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F,
  0xF8, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x80, 0xFF,
  0xCF, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0xFF,
  0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0x00, 0x7F,
  0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xD0, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x07, 0xFF, 0x03, 0xFF,
  0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x7F,
  0xF0, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x01,
  0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x1F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xE0,
  0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xE3, 0xFC, 0x07, 0xFF, 0x80, 0x38, 0x07,
  0xFF, 0x00, 0x08, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0xC0, 0x00, 0x7F, 0xE0, 0xF0,
  0x00, 0xFF, 0xE0, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x1F,
  0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F,
  0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x07,
  0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x1F,
  0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x01,
  0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x07,
  0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00,
  0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0x81,
  0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0x80,
  0x07, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0xF8,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFE,
  0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x00,
  0xFF, 0xCF, 0xFC, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE3, 0xFF,
  0x00, 0x07, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x03, 0xFF,
  0x83, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xC0,
  0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xE0,
  0x00, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xE1,
  0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x1F,
  0xEF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFC, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xF0,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xC0, 0xFF, 0x7F, 0x81, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x7F, 0x81, 0xFF,
  0x80, 0x7F, 0xC0, 0xFF, 0x7F, 0x81, 0xFF, 0x00, 0x7F, 0xC1, 0xFE, 0x7F,
  0x83, 0xFF, 0x00, 0x7F, 0xC1, 0xFE, 0x7F, 0x83, 0xFE, 0x00, 0x7F, 0xC3,
  0xFE, 0x7F, 0x87, 0xFE, 0x00, 0x7F, 0xC3, 0xFC, 0x7F, 0x87, 0xFE, 0x00,
  0x7F, 0xC7, 0xFC, 0x7F, 0x8F, 0xFC, 0x00, 0x7F, 0xC7, 0xF8, 0x7F, 0x8F,
  0xFC, 0x00, 0x7F, 0xC7, 0xF8, 0x7F, 0x8F, 0xF8, 0x00, 0x7F, 0xCF, 0xF8,
  0x7F, 0x9F, 0xF8, 0x00, 0x7F, 0xCF, 0xF0, 0x7F, 0x9F, 0xF0, 0x00, 0x7F,
  0xDF, 0xF0, 0x7F, 0x9F, 0xF0, 0x00, 0x7F, 0xDF, 0xE0, 0x7F, 0xBF, 0xE0,
  0x00, 0x7F, 0x9F, 0xE0, 0x7F, 0xBF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x7F,
  0xBF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF3, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xF7, 0xFE, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0xC7,
  0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x7F,
  0xF0, 0x3F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF0,
  0x1F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF8, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0x8F, 0xFE,
  0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x0F, 0xFD,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x3F, 0xC7, 0xF0,
  0x00, 0x7F, 0x87, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xF8,
  0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC,
  0x07, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFE,
  0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x3F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xC7, 0xFF, 0x1F, 0xF8, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8,
  0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x7F, 0xC0, 0x3F, 0xFE, 0x3F, 0xC0, 0x7F, 0xFF, 0xBF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF,
  0x0F, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0xFF,
  0xC3, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0xC0, 0x1F,
  0xF8, 0xFF, 0xE0, 0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xFC, 0x3F, 0xF0, 0x07,
  0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0xF0, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0xFF, 0x00, 0x7F, 0xFE, 0x7F, 0x80, 0x1F, 0xFE, 0x3F, 0xC0, 0x07,
  0xFE, 0x1F, 0xE0, 0x00, 0x30, 0x10, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x07, 0xFD, 0xFF, 0xF0, 0x07, 0xFE,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x0F,
  0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE1,
  0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xC0, 0x1F, 0xFC,
  0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xF0, 0x07, 0xFF,
  0x0F, 0xF8, 0x03, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0x01, 0xFF,
  0xC3, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xEF, 0xFF, 0xF8, 0x1F, 0xF3, 0xFF, 0xF8, 0x0F, 0xF0, 0xFF,
  0xF0, 0x07, 0xF8, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0x83, 0xFF, 0xC0, 0x08, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x06, 0x0F, 0xFF, 0x01, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFC, 0x1F, 0xF8, 0x00, 0xFF,
  0xE3, 0xFF, 0x00, 0x3F, 0xFE, 0x7F, 0xC0, 0x0F, 0xFF, 0xDF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0,
  0x0F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x7F,
  0xF0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF0,
  0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0xDF,
  0xE0, 0x01, 0xFF, 0xE3, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0x1F, 0xFC, 0x0F,
  0xFC, 0xFF, 0xE0, 0x3F, 0xF3, 0xFF, 0x00, 0xFF, 0xDF, 0xFC, 0x03, 0xFF,
  0x7F, 0xF0, 0x1F, 0xFD, 0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x83, 0xFF, 0x80, 0x06, 0x0F, 0xFF, 0x00, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x02,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x87, 0xFC, 0x00, 0xFF, 0xF8, 0xFF, 0x00, 0x7F, 0xFF, 0xBF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xC7, 0xFF, 0x81, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x81, 0xFF,
  0xC0, 0x3F, 0xF0, 0x3F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC1,
  0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF8, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xF7, 0xFC, 0x00, 0x7F, 0xFD,
  0xFF, 0x80, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xC7, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x20, 0x00, 0x3F, 0xF0, 0x07, 0x00, 0x0F, 0xFE,
  0x00, 0xFE, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x7F, 0x00, 0x0F,
  0xFC, 0xFF, 0xE0, 0x07, 0xFC, 0xFF, 0xF8, 0x07, 0xFE, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFC,
  0x1F, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x01, 0xFF,
  0x87, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x3F,
  0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x0F,
  0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFF, 0x0F, 0xFC, 0x03,
  0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0,
  0x1F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8,
  0x07, 0xFF, 0x1F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x04,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xFE, 0x1F,
  0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x01,
  0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xF7, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x0F, 0xFE, 0x3F, 0xF8,
  0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFF,
  0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xE1, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFE, 0x3F,
  0xFE, 0x0F, 0xFF, 0xC0, 0x3F, 0xE7, 0xFF, 0xF1, 0xFF, 0xFC, 0x03, 0xFE,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x3F, 0xDF, 0xFF, 0xF7, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xF0, 0x7F, 0xF8, 0x1F, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x03, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE1, 0xFF,
  0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE1,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x07, 0xFE,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xF0, 0x0F,
  0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xE0,
  0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F,
  0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0x8F,
  0xFF, 0x80, 0x7F, 0xCF, 0xFF, 0xE0, 0x3F, 0xEF, 0xFF, 0xF0, 0x1F, 0xEF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xE3, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF,
  0xE0, 0x3F, 0xF0, 0xFF, 0xE0, 0x1F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFC, 0x3F,
  0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x0F,
  0xFE, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE1,
  0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8,
  0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFF,
  0x1F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xC0, 0x3F,
  0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0x1F, 0xFC, 0x7F, 0xF8, 0x1F,
  0xF8, 0xFF, 0xE0, 0x3F, 0xFB, 0xFF, 0x80, 0x7F, 0xF7, 0xFF, 0x00, 0xFF,
  0xEF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFB, 0xFF, 0x00, 0x3F, 0xF7,
  0xFE, 0x00, 0x7F, 0xEF, 0xFC, 0x01, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0x3F,
  0xF0, 0x0F, 0xFE, 0x7F, 0xE0, 0x1F, 0xFC, 0xFF, 0xC0, 0x7F, 0xF1, 0xFF,
  0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0xF0, 0x00,
  0x3F, 0xCF, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00,
  0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF0,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x07, 0xFF, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFF,
  0xE0, 0x3F, 0xE0, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x7F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFB, 0xFF, 0xFC, 0x01, 0xFF, 0xBF,
  0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0xE0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x1F,
  0xF8, 0x1C, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x7F, 0xC0, 0x3F, 0xFE, 0x3F, 0xC0, 0x3F, 0xFF, 0x9F, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF,
  0x0F, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0xFF,
  0xC3, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0xC0, 0x1F,
  0xF8, 0xFF, 0xE0, 0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xFC, 0x3F, 0xF0, 0x07,
  0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x00,
  0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFD, 0xFF, 0x00, 0x7F, 0xFE, 0xFF, 0x80, 0x1F, 0xFE, 0xFF, 0xC0, 0x03,
  0xFC, 0x7F, 0xE0, 0x00, 0x30, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xE1,
  0xFE, 0x01, 0xFE, 0x3F, 0xE0, 0x3F, 0xE7, 0xFE, 0x03, 0xFE, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0xFC, 0x1F, 0xFC, 0x03, 0x83,
  0xFF, 0x80, 0x10, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x80, 0x03, 0xFF, 0x98, 0x00, 0x7F, 0xE3, 0xE0, 0x3F, 0xFC,
  0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x40, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x60, 0x00,
  0x00, 0x0F, 0xFE, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xE0,
  0x1F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8,
  0x07, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x7F, 0xF1, 0xFF,
  0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F,
  0xF0, 0x0F, 0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x0F,
  0xFC, 0x03, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0xE1,
  0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFD, 0xFE,
  0x03, 0xFF, 0xFC, 0xFF, 0x00, 0xFF, 0xFC, 0x7F, 0x80, 0x3F, 0xFC, 0x3F,
  0xC0, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0x9F, 0xF8,
  0x01, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0xC1, 0xFF,
  0x00, 0xFF, 0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x07,
  0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x87, 0xFE, 0x00,
  0x7F, 0xC7, 0xFE, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x1F, 0xF3, 0xFF, 0x00,
  0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80,
  0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xBF, 0xE0, 0x1F,
  0xFE, 0x01, 0xFF, 0x9F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xCF, 0xF8, 0x07,
  0xFF, 0x80, 0xFF, 0xC7, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xE3, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xE1, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xF0, 0xFF, 0x81,
  0xFF, 0xF8, 0x1F, 0xF8, 0x7F, 0xC1, 0xFD, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0,
  0xFE, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0x7F, 0x0F, 0xFC, 0x0F, 0xF8,
  0x7F, 0x3F, 0x87, 0xFE, 0x07, 0xFC, 0x3F, 0x9F, 0xC3, 0xFE, 0x03, 0xFE,
  0x3F, 0xCF, 0xE3, 0xFF, 0x01, 0xFF, 0x1F, 0xC7, 0xF1, 0xFF, 0x00, 0xFF,
  0x8F, 0xE7, 0xF9, 0xFF, 0x80, 0x7F, 0xCF, 0xF3, 0xFC, 0xFF, 0x80, 0x3F,
  0xE7, 0xF1, 0xFE, 0xFF, 0xC0, 0x1F, 0xF3, 0xF8, 0xFF, 0x7F, 0xC0, 0x0F,
  0xFB, 0xF8, 0x7F, 0xBF, 0xE0, 0x07, 0xFD, 0xFC, 0x3F, 0xBF, 0xE0, 0x01,
  0xFF, 0xFE, 0x1F, 0xDF, 0xF0, 0x00, 0xFF, 0xFE, 0x0F, 0xEF, 0xF0, 0x00,
  0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC,
  0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x00, 0x7F,
  0xF0, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x3F, 0xF9, 0xFF,
  0xC0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xDF,
  0xF8, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x03, 0xFF, 0x8F, 0xFC, 0x00,
  0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xFE,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x00,
  0x7F, 0xC1, 0xFF, 0x80, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x00, 0x7F, 0xC3,
  0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x00, 0x7F, 0xC7, 0xFE, 0x00,
  0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xFC, 0x00, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x04, 0xFF, 0xF8, 0x00, 0x37,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFB, 0x00, 0x07, 0xFF, 0x88, 0x00, 0x03, 0xF8, 0x00,
};

const GFXglyph NotoSans_ExtraBoldItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 19, 45, 18, 1, -44 },
  { 108, 24, 16, 28, 6, -44 },
  { 156, 39, 44, 39, 1, -44 },
  { 371, 32, 50, 34, 2, -46 },
  { 571, 49, 45, 54, 3, -44 },
  { 847, 42, 45, 44, 1, -44 },
  { 1084, 11, 16, 15, 6, -44 },
  { 1106, 24, 54, 22, 2, -44 },
  { 1268, 24, 55, 22, -4, -45 },
  { 1433, 30, 30, 33, 5, -47 },
  { 1546, 30, 29, 35, 3, -36 },
  { 1655, 15, 15, 18, -3, -7 },
  { 1684, 18, 9, 20, 1, -21 },
  { 1705, 12, 11, 18, 0, -10 },
  { 1722, 34, 44, 27, -3, -44 },
  { 1909, 32, 45, 34, 2, -44 },
  { 2089, 26, 44, 34, 5, -44 },
  { 2232, 35, 44, 34, -2, -44 },
  { 2425, 33, 45, 34, 0, -44 },
  { 2611, 35, 44, 34, -1, -44 },
  { 2804, 33, 45, 34, 1, -44 },
  { 2990, 33, 45, 34, 2, -44 },
  { 3176, 35, 44, 34, 2, -44 },
  { 3369, 32, 45, 34, 2, -44 },
  { 3549, 30, 45, 34, 3, -44 },
  { 3718, 17, 35, 18, 0, -34 },
  { 3793, 20, 42, 18, -3, -34 },
  { 3898, 30, 32, 35, 3, -38 },
  { 4018, 30, 19, 35, 3, -31 },
  { 4090, 30, 32, 35, 3, -38 },
  { 4210, 26, 45, 29, 5, -44 },
  { 4357, 49, 50, 53, 3, -44 },
  { 4664, 40, 44, 40, -4, -44 },
  { 4884, 37, 44, 38, 1, -44 },
  { 5088, 37, 45, 38, 3, -44 },
  { 5297, 39, 44, 41, 1, -44 },
  { 5512, 35, 44, 34, 1, -44 },
  { 5705, 34, 44, 34, 1, -44 },
  { 5892, 39, 45, 42, 3, -44 },
  { 6112, 42, 44, 43, 1, -44 },
  { 6343, 30, 44, 25, -2, -44 },
  { 6508, 32, 57, 21, -10, -44 },
  { 6736, 43, 44, 39, 1, -44 },
  { 6973, 27, 44, 32, 1, -44 },
  { 7122, 54, 44, 54, 1, -44 },
  { 7419, 46, 44, 47, 1, -44 },
  { 7672, 40, 45, 45, 3, -44 },
  { 7897, 36, 44, 38, 1, -44 },
  { 8095, 40, 54, 45, 3, -44 },
  { 8365, 36, 44, 39, 1, -44 },
  { 8563, 32, 45, 33, 1, -44 },
  { 8743, 32, 44, 33, 5, -44 },
  { 8919, 39, 45, 42, 4, -44 },
  { 9139, 37, 44, 37, 5, -44 },
  { 9343, 56, 44, 56, 5, -44 },
  { 9651, 47, 44, 39, -4, -44 },
  { 9910, 36, 44, 36, 5, -44 },
  { 10108, 38, 44, 33, -2, -44 },
  { 10317, 26, 54, 21, -1, -44 },
  { 10493, 15, 44, 27, 7, -44 },
  { 10576, 26, 54, 21, -4, -44 },
  { 10752, 32, 29, 33, 0, -44 },
  { 10868, 28, 5, 26, -6, 5 },
  { 10886, 13, 10, 21, 9, -47 },
  { 10903, 33, 35, 37, 3, -34 },
  { 11048, 33, 47, 37, 1, -46 },
  { 11242, 28, 35, 30, 3, -34 },
  { 11365, 35, 47, 37, 3, -46 },
  { 11571, 30, 35, 35, 3, -34 },
  { 11703, 36, 62, 24, -6, -47 },
  { 11982, 35, 49, 37, 1, -34 },
  { 12197, 33, 46, 37, 1, -46 },
  { 12387, 20, 47, 19, 1, -47 },
  { 12505, 29, 62, 19, -8, -47 },
  { 12730, 38, 46, 36, 1, -46 },
  { 12949, 20, 46, 19, 1, -46 },
  { 13064, 52, 34, 56, 1, -34 },
  { 13285, 33, 34, 37, 1, -34 },
  { 13426, 31, 35, 36, 3, -34 },
  { 13562, 36, 49, 37, -2, -34 },
  { 13783, 33, 49, 37, 3, -34 },
  { 13986, 28, 34, 26, 1, -34 },
  { 14105, 27, 35, 30, 1, -34 },
  { 14224, 25, 41, 26, 2, -40 },
  { 14353, 33, 34, 37, 3, -33 },
  { 14494, 33, 33, 32, 3, -33 },
  { 14631, 49, 33, 49, 3, -33 },
  { 14834, 40, 33, 33, -3, -33 },
  { 14999, 40, 48, 32, -4, -33 },
  { 15239, 31, 33, 29, -1, -33 },
  { 15367, 26, 54, 22, 0, -44 },
  { 15543, 8, 60, 34, 13, -46 },
  { 15603, 25, 54, 22, -3, -44 },
  { 15772, 30, 11, 35, 3, -27 },
};

const GFXfont NotoSans_ExtraBoldItalic61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic61pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_EXTRABOLDITALIC61PT7B_H_
