#ifndef _NOTOSANS_EXTRABOLDITALIC31PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F,
  0x07, 0xC1, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0x00, 0x00, 0x0F, 0x07,
  0xC3, 0xF0, 0xFC, 0x1E, 0x00, 0x7D, 0xF7, 0x9F, 0x79, 0xEF, 0x9E, 0xF1,
  0xEF, 0x1C, 0xF3, 0xCE, 0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x00, 0xE3,
  0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0x80, 0x1E, 0x78, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF0, 0x38, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xE0, 0x07,
  0x9E, 0x07, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x0E, 0x3C, 0x01,
  0xE3, 0xC0, 0x1E, 0x38, 0x01, 0xE7, 0x80, 0x1C, 0x78, 0x03, 0xC7, 0x00,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x03, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF,
  0x3F, 0xFE, 0x3E, 0xE2, 0x3E, 0xE0, 0x3E, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xBE, 0x83, 0xBE,
  0xE3, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x3F, 0xC0, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x1F, 0x80, 0x3C, 0x1F, 0xE0, 0x3C, 0x1F, 0xF8,
  0x3C, 0x0F, 0x3C, 0x1E, 0x0F, 0x9E, 0x1E, 0x07, 0x8F, 0x1E, 0x03, 0xC7,
  0x9E, 0x01, 0xE7, 0x8F, 0x00, 0xF3, 0xCF, 0x18, 0x7B, 0xEF, 0x3F, 0x3F,
  0xEF, 0x3F, 0xDF, 0xF7, 0xBF, 0xE7, 0xE7, 0xBE, 0x78, 0x07, 0x9E, 0x3C,
  0x07, 0xCF, 0x1E, 0x03, 0xC7, 0x9E, 0x03, 0xC3, 0xCF, 0x03, 0xC1, 0xE7,
  0x81, 0xE0, 0xF7, 0xC1, 0xE0, 0x7F, 0xC1, 0xE0, 0x3F, 0xC1, 0xE0, 0x0F,
  0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xBE, 0x00,
  0xF8, 0xF8, 0x07, 0x87, 0x80, 0x3E, 0x7C, 0x01, 0xF7, 0xE0, 0x0F, 0xFE,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x3E, 0x7F, 0xE3, 0xE7, 0xFF, 0x1F, 0x7E,
  0xFD, 0xF3, 0xE3, 0xFF, 0x9F, 0x0F, 0xF8, 0xF8, 0x3F, 0xC7, 0xE1, 0xFC,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xF3, 0xF0, 0x7D,
  0xE7, 0xBE, 0xF3, 0xCF, 0x38, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F,
  0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC0,
  0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1E, 0x03,
  0xC0, 0x7C, 0x0F, 0x80, 0x01, 0x80, 0x01, 0xF0, 0x01, 0xE0, 0x21, 0xE0,
  0x79, 0xC0, 0x7F, 0xC0, 0xFF, 0xFF, 0x3F, 0xFE, 0x07, 0xFE, 0x0F, 0xCE,
  0x1F, 0xE0, 0x7E, 0xE0, 0x3C, 0xF0, 0x18, 0xF0, 0x08, 0xF8, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0x1F, 0x1F, 0x1E, 0x3E, 0x3C, 0x7C, 0x78, 0xF8, 0x7F,
  0xBF, 0xDF, 0xFF, 0xF0, 0x7B, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x07, 0xFE, 0x0F,
  0xFE, 0x1F, 0xFF, 0x3F, 0x1F, 0x3E, 0x1F, 0x7E, 0x1F, 0x7C, 0x1F, 0x7C,
  0x1F, 0x7C, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x7E, 0xF8, 0x7C, 0xFC, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F,
  0xE0, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0x83, 0xFC, 0x3F, 0xE7, 0xFF, 0x7F,
  0xFB, 0xEF, 0x8E, 0x7C, 0x43, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01,
  0xF0, 0x0F, 0x80, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF,
  0x07, 0x8F, 0xC0, 0x83, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0xF1, 0xFF, 0xFC,
  0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xF0, 0x61, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7F,
  0x03, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x60, 0x3F, 0x3F, 0xFF, 0x9F, 0xFF, 0x8F,
  0xFF, 0x83, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xBE, 0x07, 0xBE, 0x07,
  0xDF, 0x07, 0xCF, 0x87, 0xC7, 0xC3, 0xC7, 0xC3, 0xC3, 0xE7, 0xFF, 0xFD,
  0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x0F, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3E, 0x60, 0x3F, 0x3F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0x83,
  0xFF, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xE1, 0xF8,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x40, 0x7D, 0xFC, 0x3F, 0xFE, 0x1F,
  0xFF, 0x8F, 0xFF, 0xCF, 0xC3, 0xE7, 0xE1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C,
  0xF8, 0x7E, 0x3E, 0x3E, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF,
  0x00, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x1F, 0xBF, 0x1F,
  0x1F, 0x3E, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x1F, 0xFE, 0x0F, 0xF8, 0x07,
  0xF0, 0x1F, 0xF8, 0x7F, 0xFC, 0x7C, 0x7C, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x7E, 0xFF, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x1F, 0xE0, 0x07,
  0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE, 0x7E, 0x3F, 0x7C, 0x1F, 0x7C,
  0x1F, 0x7C, 0x1F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7F, 0xFF, 0x7F, 0xFE, 0x3F,
  0xFE, 0x1F, 0xBE, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0xFF,
  0xF0, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0x0F, 0xC7, 0xE3, 0xF1,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x87, 0xE3, 0xF1,
  0xF8, 0xF8, 0x00, 0x03, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xC1,
  0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x80, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x78, 0x03, 0xF0, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFC,
  0x01, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F,
  0x80, 0x0F, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F,
  0xE0, 0x3E, 0x00, 0x70, 0x00, 0x80, 0x00, 0x1F, 0xE1, 0xFF, 0xE7, 0xFF,
  0x9F, 0xFE, 0x30, 0xFC, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0x80, 0xFC, 0x0F,
  0x80, 0x0F, 0x07, 0x80, 0x01, 0xE3, 0xC1, 0xFE, 0x78, 0xF1, 0xFF, 0x8E,
  0x78, 0xFF, 0xE3, 0x9E, 0x3C, 0x78, 0xF7, 0x1E, 0x1C, 0x39, 0xC7, 0x87,
  0x0E, 0xF3, 0xC3, 0xC7, 0xBC, 0xF0, 0xF1, 0xEF, 0x3C, 0x7C, 0xF3, 0xCF,
  0x9F, 0x7C, 0xF1, 0xFF, 0xFE, 0x1E, 0x7F, 0x7F, 0x07, 0x87, 0x0F, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x40, 0x07, 0xF1, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xBE, 0x00,
  0xFB, 0xE0, 0x0F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x03, 0xE1, 0xE0,
  0x3E, 0x1E, 0x07, 0xC1, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF3, 0xF0, 0x1F, 0x3E, 0x01, 0xF7, 0xE0, 0x1F, 0x7C, 0x01,
  0xFF, 0xC0, 0x1F, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF,
  0x1F, 0x8F, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x3E, 0x3F, 0x3F, 0x8F,
  0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFF, 0x1F, 0x87, 0xC7, 0xE1,
  0xF9, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x1F, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8,
  0xFF, 0xFC, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFC,
  0x7F, 0xFE, 0x3F, 0x83, 0x8F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x83, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xE0,
  0x3F, 0xFE, 0x07, 0xFF, 0xE1, 0xF8, 0xFC, 0x3E, 0x0F, 0xC7, 0xC1, 0xF8,
  0xF8, 0x1F, 0x3F, 0x03, 0xE7, 0xE0, 0x7C, 0xF8, 0x0F, 0x9F, 0x03, 0xF3,
  0xE0, 0x7E, 0xFC, 0x0F, 0x9F, 0x83, 0xF3, 0xE0, 0x7E, 0x7C, 0x1F, 0x8F,
  0x9F, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE1, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC3, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x0F,
  0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE1, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xC3, 0xFF, 0xE1, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFC, 0x1C, 0x7E, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x8F, 0xFB, 0xE1, 0xFF,
  0x7C, 0x3F, 0xEF, 0x87, 0xF9, 0xF1, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C,
  0xFC, 0x1F, 0x9F, 0xC3, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0,
  0x1F, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x7E, 0x1F,
  0x03, 0xE1, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x7C,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x3F, 0x03, 0xE1, 0xF8, 0x1F, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0xC3,
  0xE0, 0x7C, 0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x81, 0xF8, 0x7C, 0x0F,
  0xC0, 0x07, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xC0, 0x3F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0xFF,
  0x03, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0x80, 0xFF, 0x00, 0x7C, 0x00, 0x0F, 0xC1, 0xF8, 0x7C, 0x1F, 0x83, 0xE1,
  0xF8, 0x1F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0x8F, 0xC0, 0x7C, 0xFC, 0x03,
  0xEF, 0xC0, 0x3F, 0xFC, 0x01, 0xF7, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0xC0, 0x7C,
  0x7E, 0x03, 0xE1, 0xF0, 0x3F, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x81, 0xF0,
  0x7C, 0x0F, 0xC0, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x3F, 0x80,
  0xFF, 0x07, 0xF0, 0x1F, 0xE1, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0xFF, 0x87,
  0xB8, 0x3F, 0xE0, 0xF7, 0x07, 0xBC, 0x3E, 0xF0, 0xFF, 0x87, 0xDE, 0x3D,
  0xF0, 0xFB, 0xC7, 0xBE, 0x1F, 0x79, 0xE7, 0x83, 0xCF, 0x3D, 0xF0, 0xF9,
  0xEF, 0x3E, 0x1F, 0x3D, 0xE7, 0xC3, 0xE7, 0xF8, 0xF8, 0x78, 0xFF, 0x1E,
  0x0F, 0x1F, 0xC7, 0xC3, 0xE3, 0xF8, 0xF8, 0x7C, 0x7E, 0x1F, 0x0F, 0x8F,
  0xC3, 0xC1, 0xE1, 0xF0, 0xF8, 0x00, 0x0F, 0xE0, 0x3E, 0x1F, 0xC0, 0x7C,
  0x3F, 0x80, 0xF8, 0x7F, 0x81, 0xE1, 0xFF, 0x07, 0xC3, 0xFE, 0x0F, 0x87,
  0xBC, 0x1F, 0x0F, 0x7C, 0x3E, 0x3E, 0xF8, 0x78, 0x7C, 0xF1, 0xF0, 0xF9,
  0xF3, 0xE1, 0xF3, 0xE7, 0xC3, 0xC7, 0xCF, 0x0F, 0x87, 0xDE, 0x1F, 0x0F,
  0xFC, 0x3E, 0x1F, 0xF8, 0x7C, 0x1F, 0xF0, 0xF0, 0x3F, 0xC3, 0xE0, 0x7F,
  0x87, 0xC0, 0x7F, 0x0F, 0x80, 0xFE, 0x1E, 0x01, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0x87, 0xE3, 0xF0,
  0x3F, 0x7E, 0x03, 0xF7, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xEF,
  0x80, 0xFC, 0xFC, 0x0F, 0xCF, 0xE3, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x1F, 0x8F, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x3F,
  0x0F, 0xCF, 0xC7, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0x87, 0xE3, 0xF0, 0x3F, 0x7E, 0x03,
  0xF7, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xEF, 0x80, 0xFC, 0xFC,
  0x0F, 0xCF, 0xE3, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00,
  0xFF, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x1F, 0x8F, 0xC7, 0xC3, 0xF1, 0xF0, 0xFC, 0x7C, 0x3E, 0x3F, 0x0F, 0x8F,
  0xCF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xE7,
  0xC1, 0xF1, 0xF0, 0x7C, 0x7E, 0x1F, 0x0F, 0x8F, 0xC3, 0xF3, 0xE0, 0xFC,
  0xF8, 0x1F, 0x3E, 0x07, 0xE0, 0x03, 0xFE, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F,
  0xFE, 0x3F, 0x04, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x80, 0xF8, 0xC1, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F,
  0xC0, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE8, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x1F, 0x03, 0xF1, 0xF0, 0x3E, 0x1F, 0x03, 0xE3, 0xF0, 0x3E, 0x3F, 0x03,
  0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xC0,
  0xFC, 0x7C, 0x0F, 0xC7, 0xC0, 0xF8, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0xF8,
  0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0xC7, 0xF0, 0xFF, 0xFE, 0x07,
  0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0xF8, 0x0F, 0xFE, 0x03, 0xEF,
  0x80, 0xFB, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE7, 0xC0, 0x79, 0xF0,
  0x1E, 0xF8, 0x07, 0xBE, 0x01, 0xEF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x01,
  0xFF, 0x81, 0xF0, 0x3E, 0xF8, 0x3F, 0x03, 0xEF, 0x83, 0xF0, 0x7E, 0xF8,
  0x7F, 0x07, 0xCF, 0x87, 0xF0, 0x7C, 0xF0, 0x7F, 0x0F, 0x8F, 0x0F, 0xF0,
  0xF8, 0xF0, 0xFF, 0x1F, 0x0F, 0x1E, 0xF1, 0xF0, 0xF1, 0xEF, 0x1E, 0x0F,
  0x3E, 0xF3, 0xE0, 0xF3, 0xCF, 0x3E, 0x0F, 0x3C, 0xF7, 0xC0, 0xF7, 0x8F,
  0x7C, 0x0F, 0x78, 0xF7, 0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00,
  0xFF, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0,
  0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0xFC, 0x01,
  0xF0, 0xF8, 0x01, 0xF1, 0xF8, 0x01, 0xF3, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x07,
  0xEF, 0xC0, 0x0F, 0xCF, 0xC0, 0x1F, 0x87, 0xC0, 0x1F, 0x87, 0xE0, 0x3F,
  0x07, 0xE0, 0x7E, 0x03, 0xE0, 0xFC, 0x03, 0xF0, 0xF8, 0x0F, 0xFE, 0x07,
  0xEF, 0xC3, 0xF1, 0xF0, 0xF8, 0x7C, 0x7E, 0x1F, 0x3F, 0x07, 0xCF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF,
  0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x20, 0x7F, 0x01, 0xFC,
  0x0F, 0xF0, 0x00, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x7C, 0x7C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x0F,
  0x0F, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xBC, 0x07,
  0x9C, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x0E, 0x3C, 0x0F, 0x78, 0x0F, 0xF8,
  0x0F, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0xF8, 0xF0, 0xF1, 0xE0,
  0x07, 0xE7, 0x87, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xE3, 0xF3, 0xF3, 0xF0,
  0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1E, 0x7E, 0x1F, 0x3F, 0x0F, 0x9F,
  0x8F, 0xCF, 0xC7, 0xE3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0x78, 0x3F, 0x7C,
  0x00, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x7C, 0x0F, 0xFF, 0x07, 0xFF, 0xC7, 0xFF,
  0xE3, 0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E,
  0x0F, 0x9F, 0x0F, 0xCF, 0x87, 0xCF, 0xC7, 0xE7, 0xFF, 0xE3, 0xFF, 0xF1,
  0xEF, 0xF1, 0xF3, 0xE0, 0x03, 0xFE, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0xE3,
  0xF0, 0x8F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC1, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x3F, 0x7C, 0x0F, 0xEF, 0x83, 0xFF, 0xF0,
  0xFF, 0xFC, 0x1F, 0x9F, 0x87, 0xE1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3,
  0xE0, 0xF0, 0xFC, 0x3E, 0x1F, 0x87, 0xC3, 0xF1, 0xF8, 0x7E, 0x3E, 0x07,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xEF, 0x01, 0xF9, 0xE0, 0x03, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFE, 0x3F, 0xBF, 0x3E, 0x1F, 0x7E, 0x1F, 0x7C, 0x3E, 0x7F,
  0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x08, 0x7F,
  0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x07, 0x80, 0x0F, 0xF0,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7C, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xF3, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC,
  0x7F, 0xFE, 0x1F, 0x9F, 0x8F, 0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E,
  0x0F, 0x1F, 0x87, 0xC7, 0xE1, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC2,
  0x03, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x7E, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE3, 0xF1,
  0xF1, 0xF8, 0xF8, 0xF8, 0x7C, 0xFC, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F,
  0x0F, 0xCF, 0x87, 0xCF, 0xC3, 0xE7, 0xC1, 0xF3, 0xE1, 0xF9, 0xF0, 0xF9,
  0xF8, 0x7C, 0x03, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x3E,
  0x0F, 0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0x00, 0x38, 0x00, 0xF8,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x07, 0xFC,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x3F, 0x0F, 0x87, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x01, 0xF3,
  0xF0, 0x1F, 0x7E, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0xC0, 0x3E, 0x7C, 0x07, 0xE7, 0xE0, 0x7C, 0x7E, 0x07,
  0xC3, 0xF0, 0x7C, 0x3F, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0x81,
  0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xC0,
  0xF8, 0x1F, 0x07, 0xE0, 0x0F, 0x3F, 0x0F, 0x81, 0xEF, 0xF7, 0xF8, 0x3F,
  0xFE, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xF8, 0xFE, 0x7E, 0x3F, 0x1F, 0x87,
  0xC7, 0xC3, 0xF0, 0xF9, 0xF8, 0x7C, 0x3F, 0x3E, 0x0F, 0x87, 0xC7, 0xC3,
  0xF0, 0xF8, 0xF8, 0x7C, 0x1F, 0x1F, 0x0F, 0x83, 0xE7, 0xE1, 0xF0, 0xF8,
  0xF8, 0x3E, 0x1F, 0x1F, 0x0F, 0xC3, 0xE3, 0xE1, 0xF0, 0x7C, 0xFC, 0x3E,
  0x1F, 0x80, 0x0F, 0x3F, 0x07, 0xBF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF1, 0xF8,
  0xF8, 0xFC, 0x7C, 0x7C, 0x3E, 0x7E, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF,
  0x87, 0xE7, 0xC3, 0xE7, 0xE1, 0xF3, 0xE0, 0xF9, 0xF0, 0xFC, 0xF8, 0x7C,
  0xFC, 0x3E, 0x00, 0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFF, 0x3E,
  0x1F, 0x7E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3E, 0xFC, 0x7E, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F,
  0xE0, 0x07, 0x9F, 0x01, 0xEF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xC7,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF1,
  0xF0, 0xFC, 0x7C, 0x3E, 0x3F, 0x1F, 0x8F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xF8, 0x3E, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x07, 0xE7, 0x87, 0xFB, 0xC7,
  0xFF, 0xE7, 0xFF, 0xE3, 0xF3, 0xF3, 0xF0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E,
  0x7C, 0x1E, 0x7E, 0x1F, 0x3F, 0x0F, 0x9F, 0x87, 0xCF, 0xC7, 0xE3, 0xFF,
  0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x3E,
  0x1E, 0xF8, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0x83, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0xF1, 0xFF, 0xCF,
  0xCE, 0x3E, 0x08, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x1F, 0x80, 0x3E, 0x80, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8, 0x7F, 0xC0,
  0x03, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x01, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF,
  0xFE, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xFE, 0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x00, 0x3E,
  0x1F, 0x9F, 0x0F, 0x9F, 0x87, 0xCF, 0x83, 0xE7, 0xC3, 0xF3, 0xE1, 0xF3,
  0xF0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x3F, 0x3E, 0x1F, 0x1F, 0x1F,
  0x8F, 0x8F, 0xC7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFE, 0xF0, 0x7E, 0x78, 0x00,
  0xFC, 0x1F, 0xBE, 0x0F, 0x9F, 0x0F, 0xCF, 0x87, 0xC7, 0xC7, 0xE3, 0xE3,
  0xE1, 0xF3, 0xF0, 0xF9, 0xF0, 0x3D, 0xF8, 0x1E, 0xF8, 0x0F, 0x78, 0x07,
  0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x7E, 0x1F, 0xFC, 0x3F, 0x0F, 0xBE, 0x3F, 0x8F, 0x9F, 0x1F,
  0xC7, 0xCF, 0x9F, 0xE7, 0xC7, 0xCF, 0xF3, 0xE3, 0xE7, 0x79, 0xE1, 0xF7,
  0xBD, 0xF0, 0xFB, 0xDE, 0xF8, 0x7F, 0xCF, 0xF8, 0x3F, 0xE7, 0x7C, 0x1E,
  0xE3, 0xBC, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x00,
  0xFC, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF8, 0x3E, 0x1F,
  0x81, 0xF9, 0xF8, 0x07, 0xDF, 0x80, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0xFB, 0xE0, 0x0F, 0xCF, 0x80, 0xFC, 0x7C, 0x07, 0xC3,
  0xF0, 0xFE, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xE0,
  0xF8, 0x7C, 0x0F, 0x8F, 0xC0, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF9, 0xF0,
  0x07, 0x9F, 0x00, 0x7B, 0xE0, 0x07, 0xBE, 0x00, 0x7B, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF8,
  0xFF, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0xFE, 0x0F, 0xE0, 0x7C,
  0x03, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80,
  0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x7C, 0x0F, 0xE0, 0xFE,
  0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x1F,
  0xC0, 0xFE, 0x07, 0xE0, 0x3C, 0x00, 0x18, 0x03, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xD0, 0x1E, 0x00,
};

const GFXglyph NotoSans_ExtraBoldItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 22, 9, 0, -22 },
  { 29, 12, 8, 14, 3, -22 },
  { 41, 20, 22, 20, 0, -22 },
  { 96, 16, 26, 17, 1, -24 },
  { 148, 25, 22, 28, 2, -22 },
  { 217, 21, 22, 22, 1, -22 },
  { 275, 6, 8, 8, 3, -22 },
  { 281, 12, 27, 11, 1, -22 },
  { 322, 12, 28, 11, -2, -23 },
  { 364, 16, 15, 17, 2, -24 },
  { 394, 15, 15, 18, 2, -18 },
  { 423, 8, 8, 9, -2, -4 },
  { 431, 9, 4, 10, 0, -10 },
  { 436, 6, 5, 9, 0, -5 },
  { 440, 17, 22, 14, -1, -22 },
  { 487, 16, 22, 17, 1, -22 },
  { 531, 13, 22, 17, 3, -22 },
  { 567, 18, 22, 17, -1, -22 },
  { 617, 17, 22, 17, 0, -22 },
  { 664, 17, 22, 17, 0, -22 },
  { 711, 17, 22, 17, 0, -22 },
  { 758, 17, 22, 17, 1, -22 },
  { 805, 18, 22, 17, 1, -22 },
  { 855, 16, 22, 17, 1, -22 },
  { 899, 16, 22, 17, 1, -22 },
  { 943, 9, 17, 9, 0, -17 },
  { 963, 11, 21, 9, -2, -17 },
  { 992, 15, 17, 18, 2, -20 },
  { 1024, 15, 10, 18, 2, -16 },
  { 1043, 15, 17, 18, 2, -20 },
  { 1075, 14, 22, 15, 2, -22 },
  { 1114, 26, 25, 27, 1, -22 },
  { 1196, 20, 22, 20, -2, -22 },
  { 1251, 18, 22, 19, 1, -22 },
  { 1301, 18, 22, 19, 2, -22 },
  { 1351, 19, 22, 21, 1, -22 },
  { 1404, 17, 22, 17, 1, -22 },
  { 1451, 17, 22, 17, 1, -22 },
  { 1498, 19, 22, 22, 2, -22 },
  { 1551, 21, 22, 22, 1, -22 },
  { 1609, 15, 22, 13, -1, -22 },
  { 1651, 16, 29, 11, -5, -22 },
  { 1709, 21, 22, 20, 1, -22 },
  { 1767, 13, 22, 16, 1, -22 },
  { 1803, 27, 22, 28, 1, -22 },
  { 1878, 23, 22, 24, 1, -22 },
  { 1942, 20, 22, 23, 2, -22 },
  { 1997, 18, 22, 19, 1, -22 },
  { 2047, 20, 27, 23, 2, -22 },
  { 2115, 18, 22, 20, 1, -22 },
  { 2165, 16, 22, 17, 1, -22 },
  { 2209, 17, 22, 17, 2, -22 },
  { 2256, 20, 22, 22, 2, -22 },
  { 2311, 18, 22, 19, 3, -22 },
  { 2361, 28, 22, 28, 3, -22 },
  { 2438, 24, 22, 20, -2, -22 },
  { 2504, 18, 22, 18, 3, -22 },
  { 2554, 19, 22, 17, -1, -22 },
  { 2607, 14, 27, 11, -1, -22 },
  { 2655, 8, 22, 14, 3, -22 },
  { 2677, 13, 27, 11, -2, -22 },
  { 2721, 16, 14, 17, 0, -22 },
  { 2749, 14, 3, 13, -3, 2 },
  { 2755, 7, 5, 10, 4, -24 },
  { 2760, 17, 17, 19, 1, -17 },
  { 2797, 17, 24, 19, 0, -24 },
  { 2848, 15, 17, 15, 1, -17 },
  { 2880, 19, 24, 19, 1, -24 },
  { 2937, 16, 17, 18, 1, -17 },
  { 2971, 18, 31, 12, -3, -24 },
  { 3041, 18, 24, 19, 0, -17 },
  { 3095, 17, 24, 19, 0, -24 },
  { 3146, 10, 24, 10, 0, -24 },
  { 3176, 15, 31, 10, -4, -24 },
  { 3235, 20, 24, 18, 0, -24 },
  { 3295, 11, 24, 10, 0, -24 },
  { 3328, 27, 17, 28, 0, -17 },
  { 3386, 17, 17, 19, 0, -17 },
  { 3423, 16, 17, 18, 1, -17 },
  { 3457, 18, 24, 19, -1, -17 },
  { 3511, 17, 24, 19, 1, -17 },
  { 3562, 15, 17, 13, 0, -17 },
  { 3594, 14, 17, 15, 0, -17 },
  { 3624, 13, 21, 13, 1, -21 },
  { 3659, 17, 17, 19, 2, -17 },
  { 3696, 17, 17, 16, 1, -17 },
  { 3733, 25, 17, 25, 2, -17 },
  { 3787, 21, 17, 17, -2, -17 },
  { 3832, 20, 24, 16, -2, -17 },
  { 3892, 16, 17, 15, -1, -17 },
  { 3926, 13, 27, 11, 0, -22 },
  { 3970, 3, 30, 17, 7, -23 },
  { 3982, 13, 27, 11, -2, -22 },
  { 4026, 15, 6, 18, 2, -14 },
};

const GFXfont NotoSans_ExtraBoldItalic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic31pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_EXTRABOLDITALIC31PT7B_H_
