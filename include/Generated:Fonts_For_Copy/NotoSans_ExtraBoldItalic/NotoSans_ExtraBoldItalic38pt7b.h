#ifndef _NOTOSANS_EXTRABOLDITALIC38PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x01, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x1F, 0x00, 0x7E, 0x7D, 0xF3,
  0xF7, 0xCF, 0xFF, 0x3E, 0xF8, 0xFB, 0xE3, 0xEF, 0x8F, 0xBC, 0x3C, 0xF0,
  0xF3, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78,
  0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF1, 0xF0,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x03, 0xE3, 0xC0, 0x03, 0xC3, 0xC0, 0x07, 0xC7, 0xC0, 0x07, 0xC7, 0xC0,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0x0F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x0F, 0xFC, 0x03, 0xFF,
  0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0x98, 0x61, 0xFB,
  0x80, 0x1F, 0xB8, 0x01, 0xFB, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xEF, 0xC0,
  0x0E, 0x7E, 0x00, 0xE7, 0xEC, 0x0E, 0xFC, 0xF8, 0xDF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x7C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x03, 0xE0, 0x7F, 0xE0, 0x0F, 0x81, 0xFF, 0xC0, 0x3E, 0x03, 0xFF, 0x80,
  0xF8, 0x0F, 0xCF, 0x81, 0xE0, 0x1F, 0x1F, 0x07, 0xC0, 0x3E, 0x3E, 0x1F,
  0x00, 0xF8, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0xF0, 0x03, 0xE3, 0xE3, 0xE0,
  0x07, 0xC7, 0xCF, 0x8E, 0x0F, 0x9F, 0xBE, 0x7F, 0x9F, 0xFE, 0x79, 0xFF,
  0x9F, 0xF9, 0xF7, 0xFF, 0x3F, 0xF7, 0xCF, 0xFE, 0x3F, 0x9F, 0x3E, 0x3E,
  0x08, 0x3E, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0xF8, 0x03, 0xE3, 0xE1, 0xF0,
  0x0F, 0x87, 0xC7, 0xC0, 0x1F, 0x0F, 0x8F, 0x80, 0x7C, 0x1F, 0x1F, 0x01,
  0xF0, 0x3E, 0x7C, 0x07, 0xC0, 0x7F, 0xF8, 0x0F, 0x80, 0x7F, 0xE0, 0x3E,
  0x00, 0xFF, 0xC0, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01,
  0xFC, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x07, 0xE3, 0xF0,
  0x01, 0xF9, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x83, 0xF1, 0xFF, 0xC1, 0xF8, 0xFF, 0xF8, 0x7E, 0x7F,
  0xFF, 0x3F, 0x9F, 0xDF, 0xCF, 0xCF, 0xE3, 0xFF, 0xF3, 0xF0, 0x7F, 0xF8,
  0xFC, 0x1F, 0xFC, 0x3F, 0x03, 0xFE, 0x0F, 0xE0, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xE3, 0xFC, 0x7E, 0xF9, 0xF7, 0xEF, 0x9F, 0x3E, 0x78, 0xF1, 0xE0, 0x00,
  0x7E, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8,
  0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0x80, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x20, 0x7C, 0x07, 0x0F, 0x00, 0xF9, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xF8, 0x61, 0xFF, 0x80,
  0x7E, 0xF0, 0x1F, 0x9F, 0x00, 0xE3, 0xE0, 0x0C, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1F, 0x87,
  0xE1, 0xF8, 0xFC, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x00, 0x7F, 0xFF,
  0xFB, 0xFF, 0x7F, 0xEF, 0xFC, 0x3E, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xC7, 0xF1, 0xF8, 0x7F, 0x3F, 0x83,
  0xF3, 0xF0, 0x3F, 0x7F, 0x03, 0xF7, 0xF0, 0x3F, 0x7E, 0x07, 0xF7, 0xE0,
  0x7F, 0x7E, 0x07, 0xFF, 0xE0, 0x7E, 0xFE, 0x07, 0xEF, 0xE0, 0xFE, 0xFE,
  0x0F, 0xEF, 0xE0, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0x7E, 0x3F, 0x87,
  0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x3F, 0xFE,
  0xFF, 0xFE, 0x7F, 0x7E, 0x7E, 0xFC, 0x38, 0xFC, 0x20, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x06, 0x00, 0x01, 0xFF, 0x00,
  0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3C,
  0x3F, 0x80, 0xE0, 0x7F, 0x01, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x00,
  0x0C, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xFC, 0x0C, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x40, 0x07, 0xF3, 0x80, 0x7F, 0x9F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x0F, 0xBF, 0x00, 0xFD, 0xF8, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F,
  0xC7, 0xE0, 0x7C, 0x3F, 0x07, 0xC1, 0xF8, 0x7E, 0x1F, 0x87, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xC8, 0x00, 0xFE, 0x70, 0x0F, 0xE3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0,
  0xFF, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x3C, 0x07, 0xEF, 0xF0, 0xFD, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xCF, 0xF1, 0xFC, 0xFE, 0x1F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC1,
  0xFC, 0xFC, 0x1F, 0xCF, 0xC1, 0xF8, 0xFC, 0x3F, 0x8F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xF0, 0xFE, 0x7F, 0x1F, 0xC3, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xFC,
  0x7F, 0x0F, 0xCF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xF1, 0xFC, 0x7E, 0x0F, 0xCF,
  0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFE, 0x0F, 0xCF, 0xF3, 0xFC,
  0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x20,
  0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF,
  0x9F, 0xC3, 0xF3, 0xF0, 0x7E, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0xFF, 0x07, 0xFF, 0xE1, 0xFD, 0xFE, 0x7F, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE,
  0x3F, 0xEF, 0xC3, 0xFB, 0xF8, 0x3C, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x7F, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x07, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0x80, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x7E, 0x1F, 0xC3, 0xF8, 0x7F, 0x07, 0xC0, 0x01, 0xF0,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F,
  0x80, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C,
  0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F,
  0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xF0, 0x00, 0x3C,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x38, 0x00,
  0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x01,
  0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x80,
  0x0F, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x1F, 0xF8, 0x7F, 0xFC, 0xFF,
  0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0x30, 0x3F, 0x20, 0x3F, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x20, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0xFE, 0x1F, 0x3E, 0x0F, 0xFE,
  0x3D, 0xF0, 0xFF, 0xF8, 0xF7, 0xC7, 0xFF, 0xC3, 0xFE, 0x1F, 0x0F, 0x0F,
  0xF8, 0xF8, 0x7C, 0x3F, 0xC3, 0xE1, 0xF0, 0xFF, 0x1F, 0x07, 0x83, 0xFC,
  0x7C, 0x1E, 0x1F, 0xF1, 0xF0, 0xF8, 0x7F, 0xC7, 0xC3, 0xE3, 0xEF, 0x1F,
  0x1F, 0x8F, 0xBC, 0x7F, 0xFF, 0xFC, 0xF0, 0xFF, 0xFF, 0xE3, 0xE3, 0xFD,
  0xFF, 0x0F, 0x87, 0xE3, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x20, 0x01, 0xFF, 0x3F, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x01,
  0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F,
  0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x0F,
  0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x7F, 0x07, 0xF1, 0xFF, 0xFF, 0x87,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xE3,
  0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x1F, 0xC0, 0xFC,
  0x7F, 0x07, 0xF1, 0xF8, 0x7F, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x87, 0xFC, 0x0E, 0x0F, 0xE0, 0x04, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x08, 0x1F,
  0xE0, 0x70, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xE3, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7E, 0x3F,
  0x80, 0x7E, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFE, 0x3F,
  0x01, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x07, 0xF8, 0x7E, 0x3F, 0xF0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x41,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xF0, 0x1C, 0x1F, 0xE0, 0x04,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x0F, 0xFE, 0xFE, 0x0F, 0xFC, 0xFE, 0x1F, 0xFC, 0xFE, 0x1F, 0xFC,
  0xFE, 0x1F, 0xFC, 0xFE, 0x1F, 0xFC, 0xFE, 0x01, 0xF8, 0xFE, 0x01, 0xF8,
  0xFE, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0x80,
  0x7E, 0x07, 0xE0, 0x1F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F,
  0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x0F, 0xC1, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0x3F, 0x03, 0xF0,
  0x0F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x07,
  0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE,
  0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F,
  0xFF, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x08, 0x7F, 0x80, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x3F,
  0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x1F, 0x83, 0xF8, 0x07, 0xE1,
  0xFE, 0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x1F, 0xC0, 0x0F,
  0xCF, 0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7E, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xC7, 0xF0, 0x03, 0xF1, 0xFC, 0x01, 0xFC,
  0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0x83, 0xF8, 0x07, 0xE0, 0xFE, 0x01,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xC0, 0x3F,
  0x80, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x05,
  0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xE0,
  0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xFC, 0x1F, 0x78, 0x0F, 0xFE, 0x0F, 0xBC, 0x0F, 0xBE,
  0x0F, 0xDE, 0x07, 0xFF, 0x07, 0xEF, 0x07, 0xDF, 0x83, 0xF7, 0x83, 0xEF,
  0xC1, 0xFB, 0xC3, 0xE7, 0xC0, 0xF9, 0xE1, 0xF7, 0xE0, 0xFC, 0xF1, 0xF3,
  0xF0, 0x7E, 0x7C, 0xF9, 0xF8, 0x3F, 0x3E, 0xF8, 0xFC, 0x1F, 0x9F, 0x7C,
  0x7C, 0x0F, 0x8F, 0xFC, 0x7E, 0x0F, 0xC7, 0xFE, 0x3F, 0x07, 0xE3, 0xFE,
  0x1F, 0x83, 0xF1, 0xFF, 0x0F, 0xC1, 0xF0, 0xFF, 0x07, 0xC0, 0xF8, 0x7F,
  0x87, 0xE0, 0xFC, 0x3F, 0x83, 0xF0, 0x7E, 0x1F, 0xC1, 0xF8, 0x3F, 0x0F,
  0xC0, 0xF8, 0x00, 0x07, 0xF8, 0x01, 0xF8, 0x3F, 0xC0, 0x1F, 0x81, 0xFF,
  0x00, 0xFC, 0x0F, 0xF8, 0x07, 0xE0, 0x7F, 0xC0, 0x3F, 0x07, 0xFF, 0x01,
  0xF0, 0x3F, 0xF8, 0x1F, 0x81, 0xFF, 0xC0, 0xFC, 0x0F, 0xBF, 0x07, 0xE0,
  0xFD, 0xF8, 0x3F, 0x07, 0xEF, 0xC3, 0xF0, 0x3F, 0x3F, 0x1F, 0x81, 0xF9,
  0xF8, 0xFC, 0x0F, 0x8F, 0xC7, 0xE0, 0xFC, 0x3F, 0x3E, 0x07, 0xE1, 0xF9,
  0xF0, 0x3F, 0x0F, 0xDF, 0x81, 0xF8, 0x7E, 0xFC, 0x0F, 0x81, 0xFF, 0xE0,
  0xFC, 0x0F, 0xFE, 0x07, 0xE0, 0x7F, 0xF0, 0x3F, 0x01, 0xFF, 0x81, 0xF8,
  0x0F, 0xFC, 0x0F, 0x80, 0x7F, 0xE0, 0xFC, 0x01, 0xFE, 0x07, 0xE0, 0x0F,
  0xF0, 0x3F, 0x00, 0x7F, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x7F, 0xC3, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F,
  0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xE0, 0x03, 0xFB, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0x7F, 0x00,
  0x3F, 0xBF, 0x80, 0x1F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x1F, 0xE3, 0xF8,
  0x0F, 0xE1, 0xFE, 0x1F, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F,
  0x8F, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x7F, 0x03,
  0xF1, 0xFC, 0x1F, 0xC7, 0xE0, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F, 0xC3, 0xFC, 0x3F, 0x80,
  0xFE, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0,
  0x07, 0xF7, 0xE0, 0x03, 0xFB, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFD, 0xFC,
  0x00, 0x7E, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0x9F,
  0xC0, 0x1F, 0xCF, 0xE0, 0x1F, 0xE3, 0xF8, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x7F, 0x0F, 0xC1, 0xFC,
  0x7F, 0x07, 0xF1, 0xFC, 0x3F, 0x87, 0xF1, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFC, 0x7E,
  0x03, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x87,
  0xE0, 0xFE, 0x1F, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x0F, 0xCF, 0xC0,
  0x3F, 0x80, 0x00, 0x08, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xC0, 0xC1, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x88, 0x03, 0xF8, 0xE0, 0x7F, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE0, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x87,
  0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE1, 0xFC, 0x07, 0xF0,
  0xFE, 0x03, 0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFE,
  0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F,
  0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF0, 0x7E, 0x01,
  0xF8, 0x3F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7E, 0x07, 0xE0,
  0x7F, 0x03, 0xF8, 0x7F, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xF7, 0xF0, 0x0F, 0xCF, 0xE0, 0x3F, 0x8F,
  0xC0, 0x7E, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC,
  0x1F, 0x81, 0xF8, 0x7F, 0x03, 0xF0, 0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xC7,
  0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7D, 0xF8,
  0x00, 0xFB, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x0F, 0xFF, 0x80, 0x7E, 0x01, 0xFB,
  0xF0, 0x0F, 0xC0, 0x3F, 0x7E, 0x03, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F, 0x01,
  0xF9, 0xF8, 0x1F, 0xE0, 0x7F, 0x3F, 0x03, 0xFC, 0x0F, 0xC7, 0xE0, 0xFF,
  0xC1, 0xF8, 0xFC, 0x1F, 0xF8, 0x7E, 0x1F, 0x83, 0xDF, 0x0F, 0xC3, 0xF0,
  0xFB, 0xE3, 0xF0, 0x3E, 0x1F, 0x7C, 0x7E, 0x07, 0xC7, 0xCF, 0x8F, 0xC0,
  0xF8, 0xF9, 0xF3, 0xF0, 0x1F, 0x3F, 0x3E, 0x7E, 0x03, 0xE7, 0xC7, 0xDF,
  0x80, 0x7D, 0xF8, 0xFB, 0xF0, 0x0F, 0xBE, 0x1F, 0x7C, 0x01, 0xF7, 0xC3,
  0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xF0, 0x07, 0xFE, 0x0F, 0x7C, 0x00, 0xFF,
  0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x03,
  0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xC3, 0xFC, 0x00, 0x7E, 0x1F, 0xC0,
  0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x0F,
  0xE3, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x07,
  0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x01, 0xFD, 0xF8, 0x0F, 0xE7, 0xE0, 0x3F,
  0x9F, 0xC1, 0xFC, 0x7F, 0x0F, 0xE0, 0xFC, 0x3F, 0x83, 0xF1, 0xFC, 0x0F,
  0xC7, 0xE0, 0x1F, 0xBF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00,
  0xF8, 0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0x80, 0x1F, 0x78, 0x03, 0xE7, 0x80, 0x3C, 0x7C, 0x07, 0xC3,
  0xC0, 0xF8, 0x3C, 0x0F, 0x03, 0xE1, 0xF0, 0x3E, 0x3E, 0x01, 0xE3, 0xE0,
  0x1E, 0x7C, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xC0, 0xFE, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3C, 0x03, 0xF1, 0xF0, 0xFF,
  0x9F, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xF8, 0xFE, 0x7F,
  0x0F, 0xE7, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFC, 0xFC, 0x0F, 0xCF,
  0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xE3, 0xF8,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFD, 0xF0, 0x3F, 0x9F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xCF, 0x80,
  0xFF, 0xFC, 0x1F, 0xBF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFC, 0x7F,
  0x1F, 0x83, 0xF3, 0xF8, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x07,
  0xF3, 0xF0, 0x7F, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x0F, 0xE7, 0xF1,
  0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xBF, 0xF0, 0xF9,
  0xFC, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE3, 0xFF,
  0xF3, 0xFC, 0x11, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x18,
  0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x03, 0xF3, 0xF0,
  0x3F, 0xEF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFE,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xF8, 0xFE, 0x0F, 0xC3, 0xF8, 0x3F,
  0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x8F, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x1F, 0xF7, 0xC0, 0x3F, 0x9F, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xF0,
  0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFC, 0xFE, 0x7E, 0x0F, 0xDF, 0xC3, 0xFB,
  0xF0, 0x7E, 0xFE, 0x3F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F,
  0xFF, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x10, 0xFF, 0x1E, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0xF8, 0x3F, 0xE7, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x1F, 0xE3, 0xF8, 0xFE, 0x1F, 0xC7, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8,
  0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x07, 0xE1,
  0xF8, 0x3F, 0x0F, 0xE3, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE0, 0x7F, 0xBF, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0xC0, 0x7F, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0xFF, 0xFE, 0x1F, 0xBF, 0xF1, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF1, 0xFE, 0x3F, 0x1F, 0xC3, 0xF3, 0xF8, 0x3F, 0x3F, 0x83,
  0xF3, 0xF0, 0x3F, 0x3F, 0x07, 0xF3, 0xF0, 0x7F, 0x7F, 0x07, 0xE7, 0xE0,
  0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0xFE, 0x7E, 0x0F, 0xEF, 0xE0, 0xFC, 0xFC,
  0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x1F, 0xC0, 0x03, 0xE0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1,
  0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x03,
  0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFE, 0x1F, 0x83, 0xF8, 0x7F, 0x0F,
  0xE0, 0xFE, 0x3F, 0x81, 0xF8, 0xFE, 0x03, 0xF3, 0xF8, 0x07, 0xEF, 0xE0,
  0x1F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F,
  0x1F, 0xC0, 0x7E, 0x1F, 0x81, 0xFC, 0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xE0,
  0x7F, 0x0F, 0xC0, 0xFE, 0x00, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07,
  0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F,
  0x81, 0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x7F,
  0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x00, 0x0F, 0x8F, 0xC1, 0xFC, 0x0F, 0xBF, 0xE3, 0xFE, 0x1F, 0xBF, 0xF7,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xE3, 0xFC,
  0x7F, 0x1F, 0xC3, 0xF8, 0x3F, 0x3F, 0x83, 0xF8, 0x7F, 0x3F, 0x83, 0xF0,
  0x7F, 0x3F, 0x03, 0xF0, 0x7E, 0x3F, 0x07, 0xF0, 0x7E, 0x3F, 0x07, 0xE0,
  0x7E, 0x7F, 0x07, 0xE0, 0xFE, 0x7F, 0x07, 0xE0, 0xFE, 0x7E, 0x07, 0xE0,
  0xFC, 0x7E, 0x0F, 0xE0, 0xFC, 0x7E, 0x0F, 0xC0, 0xFC, 0xFE, 0x0F, 0xC1,
  0xFC, 0xFC, 0x0F, 0xC1, 0xFC, 0xFC, 0x1F, 0xC1, 0xF8, 0xFC, 0x1F, 0xC1,
  0xF8, 0x0F, 0x8F, 0xC0, 0xFB, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF1, 0xFE, 0x3F, 0x1F, 0xC3, 0xF3, 0xF8, 0x3F, 0x3F, 0x83, 0xF3,
  0xF0, 0x3F, 0x3F, 0x07, 0xF3, 0xF0, 0x7F, 0x7F, 0x07, 0xE7, 0xE0, 0x7E,
  0x7E, 0x07, 0xE7, 0xE0, 0xFE, 0x7E, 0x0F, 0xEF, 0xE0, 0xFC, 0xFC, 0x0F,
  0xCF, 0xC0, 0xFC, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x3F,
  0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0x1F, 0xDF, 0xC3, 0xFB, 0xF0,
  0x3F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFD, 0xF8, 0x3F, 0xBF, 0x07, 0xF7, 0xF1, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF,
  0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xE7, 0xE0, 0x0F,
  0xBF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xC7,
  0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0,
  0xFC, 0x1F, 0xC3, 0xE0, 0x7F, 0x1F, 0x81, 0xFC, 0x7E, 0x07, 0xE1, 0xFC,
  0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC,
  0x0F, 0xDF, 0xE0, 0x3F, 0x3F, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF1, 0xF0, 0xFF, 0x9F,
  0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xF8, 0xFE, 0x7F, 0x0F,
  0xE7, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0,
  0xFC, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xE3, 0xF8, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0x8F,
  0x87, 0xCF, 0x87, 0xEF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F,
  0x80, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0xF0,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xC7, 0x07, 0xE0, 0x41, 0xF8, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x1F, 0xC0, 0x07, 0xF3, 0x01, 0xFC, 0xFC, 0xFF, 0x3F, 0xFF, 0x8F,
  0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x0F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF,
  0xFE, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0x83, 0xF9,
  0xFC, 0x1F, 0x8F, 0xE0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x7F, 0x1F, 0x83,
  0xF9, 0xFC, 0x1F, 0x8F, 0xE0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x7F, 0x1F,
  0x83, 0xF9, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x0F, 0xE3, 0xF0, 0x7F,
  0x1F, 0xC7, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFB, 0xE0, 0xFF,
  0xBF, 0x03, 0xF9, 0xF0, 0x00, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F,
  0xEF, 0xC0, 0xFC, 0xFC, 0x1F, 0xCF, 0xC1, 0xF8, 0x7C, 0x3F, 0x87, 0xC3,
  0xF0, 0x7E, 0x7F, 0x07, 0xE7, 0xE0, 0x7E, 0xFE, 0x07, 0xEF, 0xC0, 0x7E,
  0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x0F,
  0xE0, 0xFF, 0xF8, 0x3F, 0xC1, 0xFB, 0xF0, 0x7F, 0x87, 0xE7, 0xE1, 0xFE,
  0x0F, 0xCF, 0xC3, 0xFC, 0x3F, 0x9F, 0x87, 0xF8, 0x7E, 0x3F, 0x1F, 0xF1,
  0xFC, 0x7E, 0x3D, 0xE3, 0xF0, 0x7C, 0xFB, 0xC7, 0xE0, 0xF9, 0xF7, 0x9F,
  0x81, 0xF3, 0xCF, 0x3F, 0x03, 0xEF, 0x9E, 0xFC, 0x07, 0xDE, 0x3D, 0xF8,
  0x0F, 0xBC, 0x7B, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03,
  0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x7F, 0x83,
  0xF8, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0x80,
  0x0F, 0xDF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xCF,
  0xE0, 0x0F, 0xE3, 0xF0, 0x0F, 0xE1, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0,
  0x3F, 0x80, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0xC0,
  0xFC, 0x0F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0x87, 0xE0, 0x0F, 0xC7, 0xF0,
  0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0xC0, 0xFF,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x3E, 0x01, 0xFE, 0x03,
  0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x5F, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0x01, 0xF0,
};

const GFXglyph NotoSans_ExtraBoldItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 13, 27, 11, 0, -27 },
  { 45, 14, 10, 17, 4, -27 },
  { 63, 24, 27, 25, 1, -27 },
  { 144, 20, 31, 21, 1, -29 },
  { 222, 31, 28, 34, 2, -28 },
  { 331, 26, 28, 27, 1, -28 },
  { 422, 7, 10, 9, 4, -27 },
  { 431, 15, 33, 13, 1, -27 },
  { 493, 15, 34, 14, -3, -28 },
  { 557, 19, 19, 21, 3, -29 },
  { 603, 18, 19, 22, 2, -23 },
  { 646, 10, 9, 11, -2, -4 },
  { 658, 11, 5, 12, 1, -13 },
  { 665, 7, 6, 11, 0, -6 },
  { 671, 22, 27, 17, -2, -27 },
  { 746, 20, 28, 21, 1, -28 },
  { 816, 16, 27, 21, 3, -27 },
  { 870, 22, 28, 21, -1, -28 },
  { 947, 21, 28, 21, 0, -28 },
  { 1021, 21, 27, 21, 0, -27 },
  { 1092, 21, 27, 21, 0, -27 },
  { 1163, 20, 28, 21, 2, -28 },
  { 1233, 22, 27, 21, 1, -27 },
  { 1308, 20, 28, 21, 1, -28 },
  { 1378, 19, 28, 21, 2, -28 },
  { 1445, 11, 21, 11, 0, -21 },
  { 1474, 13, 26, 11, -2, -21 },
  { 1517, 18, 20, 22, 2, -24 },
  { 1562, 18, 13, 22, 2, -20 },
  { 1592, 18, 20, 22, 2, -24 },
  { 1637, 16, 29, 18, 3, -28 },
  { 1695, 30, 30, 33, 2, -27 },
  { 1808, 24, 27, 25, -2, -27 },
  { 1889, 22, 27, 24, 1, -27 },
  { 1964, 23, 28, 24, 2, -28 },
  { 2045, 24, 27, 26, 1, -27 },
  { 2126, 21, 27, 21, 1, -27 },
  { 2197, 21, 27, 21, 1, -27 },
  { 2268, 24, 28, 26, 2, -28 },
  { 2352, 26, 27, 27, 1, -27 },
  { 2440, 18, 27, 15, -1, -27 },
  { 2501, 20, 35, 13, -6, -27 },
  { 2589, 26, 27, 24, 1, -27 },
  { 2677, 17, 27, 20, 1, -27 },
  { 2735, 33, 27, 34, 1, -27 },
  { 2847, 29, 27, 29, 1, -27 },
  { 2945, 25, 28, 28, 2, -28 },
  { 3033, 22, 27, 23, 1, -27 },
  { 3108, 25, 34, 28, 2, -28 },
  { 3215, 22, 27, 24, 1, -27 },
  { 3290, 20, 28, 20, 1, -28 },
  { 3360, 20, 27, 21, 3, -27 },
  { 3428, 25, 27, 26, 2, -27 },
  { 3513, 23, 27, 23, 3, -27 },
  { 3591, 35, 27, 35, 3, -27 },
  { 3710, 29, 27, 24, -2, -27 },
  { 3808, 22, 27, 22, 3, -27 },
  { 3883, 23, 27, 20, -1, -27 },
  { 3961, 17, 33, 13, -1, -27 },
  { 4032, 10, 27, 17, 4, -27 },
  { 4066, 17, 33, 13, -3, -27 },
  { 4137, 20, 18, 21, 0, -27 },
  { 4182, 17, 3, 16, -3, 3 },
  { 4189, 9, 6, 13, 5, -29 },
  { 4196, 20, 21, 23, 2, -21 },
  { 4249, 20, 29, 23, 1, -29 },
  { 4322, 17, 21, 19, 2, -21 },
  { 4367, 22, 29, 23, 2, -29 },
  { 4447, 19, 21, 22, 2, -21 },
  { 4497, 23, 38, 15, -4, -29 },
  { 4607, 21, 30, 23, 1, -21 },
  { 4686, 20, 29, 23, 1, -29 },
  { 4759, 12, 29, 12, 1, -29 },
  { 4803, 18, 38, 12, -5, -29 },
  { 4889, 23, 29, 22, 1, -29 },
  { 4973, 12, 29, 12, 1, -29 },
  { 5017, 32, 21, 35, 1, -21 },
  { 5101, 20, 21, 23, 1, -21 },
  { 5154, 19, 21, 23, 2, -21 },
  { 5204, 22, 30, 23, -1, -21 },
  { 5287, 20, 30, 23, 2, -21 },
  { 5362, 17, 21, 16, 1, -21 },
  { 5407, 18, 21, 19, 0, -21 },
  { 5455, 16, 25, 16, 1, -25 },
  { 5505, 21, 21, 23, 2, -21 },
  { 5561, 20, 21, 20, 2, -21 },
  { 5614, 31, 21, 31, 2, -21 },
  { 5696, 25, 21, 21, -2, -21 },
  { 5762, 25, 30, 20, -3, -21 },
  { 5856, 20, 21, 18, -1, -21 },
  { 5909, 16, 33, 14, 0, -27 },
  { 5975, 5, 38, 21, 8, -29 },
  { 5999, 16, 33, 14, -2, -27 },
  { 6065, 18, 7, 22, 2, -17 },
};

const GFXfont NotoSans_ExtraBoldItalic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic38pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_EXTRABOLDITALIC38PT7B_H_
