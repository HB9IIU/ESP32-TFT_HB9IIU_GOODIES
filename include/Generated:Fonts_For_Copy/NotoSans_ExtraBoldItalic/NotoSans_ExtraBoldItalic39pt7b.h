#ifndef _NOTOSANS_EXTRABOLDITALIC39PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x80, 0xFC, 0x00, 0x7E,
  0x7E, 0xFC, 0xFD, 0xF1, 0xF3, 0xE3, 0xEF, 0xCF, 0xDF, 0x1F, 0x3E, 0x3E,
  0x7C, 0x7C, 0xF0, 0xF9, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x3E, 0x3E,
  0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0xC7,
  0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xE1, 0xE0, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x3E, 0x3E, 0x00, 0x1E,
  0x1F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x8F, 0x80, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x80, 0xF0, 0xF8, 0x00,
  0x78, 0x78, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x1E, 0x00,
  0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0x87, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x03,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xDC, 0xE0, 0xFC, 0xE1,
  0x07, 0xE6, 0x00, 0x3F, 0x70, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x0E, 0x7E, 0x40, 0x73, 0xF3, 0x03, 0x9F, 0x9F, 0xDF,
  0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00,
  0x3C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0xF0,
  0x01, 0xF8, 0x0F, 0xF8, 0x01, 0xF0, 0x1F, 0xF8, 0x03, 0xE0, 0x3F, 0xFC,
  0x07, 0xC0, 0x7E, 0x7C, 0x0F, 0x80, 0x7C, 0x7C, 0x0F, 0x80, 0x7C, 0x7C,
  0x1F, 0x00, 0x7C, 0x7C, 0x3E, 0x00, 0xFC, 0x7C, 0x7C, 0x00, 0xF8, 0x7C,
  0x7C, 0x00, 0xF8, 0xF8, 0xF8, 0x00, 0xF8, 0xF9, 0xF1, 0xF8, 0xF9, 0xFB,
  0xE7, 0xFC, 0xFF, 0xF3, 0xEF, 0xFE, 0x7F, 0xF7, 0xCF, 0xFE, 0x3F, 0xEF,
  0x9F, 0xBE, 0x1F, 0x9F, 0x9F, 0x3F, 0x00, 0x1F, 0x3F, 0x3F, 0x00, 0x3E,
  0x3E, 0x3E, 0x00, 0x7C, 0x3E, 0x3E, 0x00, 0x7C, 0x3E, 0x3E, 0x00, 0xF8,
  0x3E, 0x3E, 0x01, 0xF0, 0x3E, 0x7E, 0x03, 0xE0, 0x3E, 0x7C, 0x03, 0xE0,
  0x3F, 0xFC, 0x07, 0xC0, 0x3F, 0xF8, 0x0F, 0x80, 0x1F, 0xF0, 0x1F, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8,
  0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC,
  0x1F, 0xC7, 0xFF, 0x83, 0xF1, 0xFF, 0xF8, 0xFE, 0x7F, 0xFF, 0x1F, 0x9F,
  0xE7, 0xF7, 0xF3, 0xF8, 0xFF, 0xFC, 0x7F, 0x0F, 0xFF, 0x0F, 0xC0, 0xFF,
  0xE1, 0xFC, 0x0F, 0xF8, 0x3F, 0xC3, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x3F,
  0xC0, 0x7E, 0xFD, 0xF3, 0xEF, 0xDF, 0x3E, 0x7C, 0xF1, 0xE0, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xFC, 0x00, 0x00, 0x60,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x02, 0x0F, 0x80, 0xF1, 0xF0,
  0x1F, 0xBC, 0x03, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFC, 0x0F, 0xFF,
  0x83, 0xFF, 0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xDF, 0x01, 0xF3, 0xE0,
  0x1C, 0x3E, 0x00, 0x87, 0xC0, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC7, 0xF1, 0xF8, 0x7E, 0x3F,
  0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xEF, 0xFC, 0x3E, 0x7E, 0xFF, 0xFE, 0xFE, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x0F, 0xF3, 0xF8, 0x7F, 0x0F, 0xC7, 0xF0, 0x7E, 0x3F, 0x83,
  0xF9, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xE7, 0xF0, 0x3F, 0x3F,
  0x01, 0xF9, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F,
  0xBF, 0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x0F, 0xE1, 0xF8,
  0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0,
  0xFF, 0xF0, 0xFF, 0xF9, 0xFF, 0xF9, 0xFF, 0xFC, 0x7F, 0x7E, 0x1E, 0x7F,
  0x0E, 0x3F, 0x84, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x83,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xCF, 0xF0, 0x3C, 0x1F, 0xC0, 0x40,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x1F,
  0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xC1, 0xFC,
  0x08, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x40, 0x07, 0xFB, 0x80, 0x7F, 0x9F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07,
  0xEF, 0xC0, 0x1F, 0x7E, 0x00, 0xFD, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0x3F,
  0x81, 0xF8, 0xFE, 0x0F, 0xC3, 0xF0, 0x3E, 0x0F, 0xC1, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0x87, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF2, 0x00, 0x3F, 0x8F, 0x03, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x0F,
  0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x7F, 0x07,
  0xEF, 0xF8, 0xFD, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xF1, 0xFC,
  0xFE, 0x0F, 0xEF, 0xC0, 0xFE, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x1F,
  0xCF, 0xC1, 0xFC, 0xFE, 0x3F, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF,
  0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xE1, 0xFC, 0x7F, 0x07, 0xE3, 0xF8, 0x3F,
  0x1F, 0xC3, 0xF0, 0x7E, 0x3F, 0x83, 0xFB, 0xF8, 0x0F, 0xFF, 0x80, 0x7F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0x9F, 0xC3,
  0xF8, 0x7E, 0x3F, 0x83, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03,
  0xF3, 0xF8, 0x3F, 0x9F, 0xF7, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xFE,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0x1F, 0xDF, 0xC3, 0xFB, 0xF0, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x3F, 0xEF, 0xC3, 0xF9, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x20, 0x7F, 0xC7,
  0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x00,
  0x01, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x0F,
  0xC3, 0xFC, 0x7F, 0x0F, 0xE0, 0xF8, 0x00, 0x00, 0x70, 0x0F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07,
  0xE0, 0x3E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03,
  0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F,
  0x80, 0x00, 0xF0, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x0C,
  0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF,
  0xF1, 0xE1, 0xFC, 0x80, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F,
  0x80, 0x01, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x81,
  0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x60, 0x1F, 0x3E,
  0x07, 0xFF, 0x3E, 0x7C, 0x3F, 0xFC, 0x7D, 0xF0, 0xFF, 0xF8, 0x7B, 0xE3,
  0xF9, 0xF0, 0xFF, 0x87, 0xC3, 0xE1, 0xFF, 0x1F, 0x07, 0xC3, 0xFE, 0x3E,
  0x0F, 0x07, 0xF8, 0x78, 0x3E, 0x1F, 0xF1, 0xF0, 0x7C, 0x3F, 0xE3, 0xE0,
  0xF8, 0x7B, 0xC7, 0xC3, 0xE1, 0xF7, 0x8F, 0x8F, 0xC7, 0xCF, 0x0F, 0xFF,
  0xFF, 0x9F, 0x1F, 0xF7, 0xFE, 0x3E, 0x1F, 0xCF, 0xF8, 0x7E, 0x1F, 0x0F,
  0xC0, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x30,
  0x00, 0xFF, 0xDF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0xC3,
  0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0,
  0x3F, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0xFC, 0x7F, 0x00, 0x7E, 0x7F,
  0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0xFC, 0x7F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F,
  0xE0, 0xFE, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0x87,
  0xF8, 0x7F, 0x07, 0xF0, 0xFC, 0x0F, 0xE1, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F,
  0x8F, 0xE0, 0xFF, 0x1F, 0xC7, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x0F, 0xF8, 0x7C, 0x1F, 0xE0, 0x0C, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x20, 0x7F, 0xC1, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F,
  0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F,
  0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0x01, 0xFE, 0x7F, 0x03, 0xFC,
  0x7F, 0x07, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x08, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xE1, 0xF0, 0x7F, 0xC0, 0x10, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0xFF, 0xE7,
  0xF0, 0x7F, 0xF3, 0xF8, 0x3F, 0xF9, 0xFC, 0x3F, 0xFC, 0xFE, 0x1F, 0xFC,
  0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F,
  0xC3, 0xF8, 0x0F, 0xC1, 0xFF, 0x0F, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x0F,
  0xE0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xE0, 0x7F,
  0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFE,
  0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x1F, 0xC0,
  0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xC0, 0xFE, 0x01,
  0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x01, 0xFC, 0x1F,
  0xC0, 0x3F, 0x03, 0xF8, 0x07, 0xE0, 0x7F, 0x01, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xFF,
  0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x10,
  0x00, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFE,
  0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xF0, 0x0F, 0xC3, 0xFC, 0x03, 0xF8,
  0xFF, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xC7, 0xF0, 0x01, 0xF9, 0xFC, 0x00,
  0x3F, 0x7F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xF3, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xF0, 0x07, 0xF0, 0xFE,
  0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x7E,
  0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFE,
  0x00, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xC0,
  0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xDF, 0x03, 0xEF, 0x81, 0xFF, 0xC0, 0xFB, 0xE0, 0xFB, 0xF0,
  0x7E, 0xF8, 0x3E, 0xFC, 0x1F, 0xBE, 0x1F, 0x7E, 0x07, 0xEF, 0x87, 0xDF,
  0x81, 0xFB, 0xE3, 0xE7, 0xE0, 0xFC, 0xF8, 0xF9, 0xF8, 0x3F, 0x3E, 0x7C,
  0x7E, 0x0F, 0xCF, 0x9F, 0x3F, 0x03, 0xF3, 0xEF, 0x8F, 0xC0, 0xFC, 0xFB,
  0xE3, 0xF0, 0x7E, 0x3F, 0xF0, 0xFC, 0x1F, 0x8F, 0xFC, 0x3E, 0x07, 0xE3,
  0xFE, 0x1F, 0x81, 0xF8, 0xFF, 0x87, 0xE0, 0x7C, 0x3F, 0xC1, 0xF8, 0x3F,
  0x0F, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x3F, 0x03, 0xF0, 0xFE, 0x0F, 0xC0,
  0x03, 0xF8, 0x01, 0xF8, 0x3F, 0xE0, 0x0F, 0xC1, 0xFF, 0x00, 0x7E, 0x0F,
  0xF8, 0x03, 0xF0, 0x7F, 0xE0, 0x3F, 0x03, 0xFF, 0x01, 0xF8, 0x3F, 0xF8,
  0x0F, 0xC1, 0xFF, 0xE0, 0x7E, 0x0F, 0xBF, 0x03, 0xF0, 0x7D, 0xF8, 0x3F,
  0x03, 0xEF, 0xE1, 0xF8, 0x3F, 0x3F, 0x0F, 0xC1, 0xF9, 0xF8, 0x7E, 0x0F,
  0xCF, 0xC3, 0xF0, 0x7E, 0x3F, 0x3F, 0x07, 0xE1, 0xF9, 0xF8, 0x3F, 0x0F,
  0xCF, 0xC1, 0xF8, 0x3F, 0x7E, 0x0F, 0xC1, 0xFB, 0xE0, 0x7E, 0x0F, 0xDF,
  0x07, 0xE0, 0x3F, 0xF8, 0x3F, 0x01, 0xFF, 0xC1, 0xF8, 0x0F, 0xFE, 0x0F,
  0xC0, 0x7F, 0xE0, 0x7C, 0x01, 0xFF, 0x07, 0xE0, 0x0F, 0xF8, 0x3F, 0x00,
  0x7F, 0xC1, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xC7,
  0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0,
  0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x1F, 0xEF, 0xE0, 0x0F, 0xE3,
  0xF8, 0x0F, 0xF1, 0xFE, 0x1F, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x83, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE,
  0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0xC3,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xE7, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0x9F,
  0xC0, 0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x1F, 0xEF, 0xE0, 0x0F,
  0xE3, 0xF8, 0x0F, 0xF1, 0xFF, 0x3F, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F,
  0x8F, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x0F, 0xE0, 0xFC, 0x3F, 0x03,
  0xF0, 0xFC, 0x1F, 0xC7, 0xF0, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xF1,
  0xFC, 0x0F, 0xC7, 0xF0, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0x81, 0xFC, 0x7E, 0x07, 0xF3, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF,
  0x80, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE1, 0xFE, 0x1E, 0x1F, 0xC0, 0x41, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x88, 0x03, 0xF8, 0xF0, 0x7F, 0x8F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x7F, 0x1F,
  0x80, 0x7F, 0x1F, 0x80, 0x7F, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0xFE, 0x3F,
  0x80, 0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7F,
  0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0xFE, 0x01, 0xF8, 0xFE,
  0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC,
  0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0x7E,
  0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E,
  0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7E,
  0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0x3E,
  0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0x80, 0x7F, 0xFC,
  0x03, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x80, 0xFE, 0xFC, 0x07, 0xF8, 0x0F,
  0xCF, 0xC0, 0x7F, 0x81, 0xFC, 0xFC, 0x0F, 0xF8, 0x1F, 0x8F, 0xC0, 0xFF,
  0x81, 0xF8, 0x7C, 0x0F, 0xF8, 0x3F, 0x07, 0xC1, 0xFF, 0x83, 0xF0, 0x7C,
  0x1F, 0xF8, 0x7F, 0x07, 0xC3, 0xEF, 0x87, 0xE0, 0x7C, 0x3E, 0xF8, 0xFE,
  0x07, 0xC7, 0xEF, 0x8F, 0xC0, 0x7C, 0x7C, 0xF8, 0xFC, 0x07, 0xCF, 0xCF,
  0x9F, 0x80, 0x7C, 0xF8, 0xF9, 0xF8, 0x07, 0xCF, 0x8F, 0x9F, 0x80, 0x7D,
  0xF8, 0xFB, 0xF0, 0x07, 0xDF, 0x0F, 0xBF, 0x00, 0x7D, 0xF0, 0xFF, 0xE0,
  0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFC, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0xFC,
  0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0xFF, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F,
  0x9F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFE, 0x7E, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0,
  0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x07,
  0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0xFC, 0x03, 0xF9, 0xFC,
  0x0F, 0xF3, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0x07, 0xE0, 0xFC, 0x0F, 0xC3,
  0xF8, 0x1F, 0xCF, 0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x7F, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0,
  0x7F, 0xE0, 0x00, 0xFC, 0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF8, 0x7E, 0x1F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0,
  0xFC, 0x1F, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0,
  0x7F, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3E, 0xF0,
  0x01, 0xF7, 0xC0, 0x1F, 0x3E, 0x01, 0xF0, 0xF0, 0x0F, 0x87, 0xC0, 0xF8,
  0x3E, 0x0F, 0x80, 0xF0, 0x7C, 0x07, 0x87, 0xC0, 0x3E, 0x7E, 0x01, 0xF7,
  0xE0, 0x07, 0xC0, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFE,
  0xFC, 0xFE, 0x7E, 0x3E, 0x1F, 0x1F, 0x01, 0xE0, 0x00, 0x3F, 0xCF, 0xC3,
  0xFF, 0x7C, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFE, 0x3F,
  0xCF, 0xE0, 0xFC, 0x7F, 0x07, 0xE7, 0xF0, 0x3F, 0x3F, 0x81, 0xF9, 0xFC,
  0x1F, 0xCF, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x7F, 0x1F, 0x83, 0xF8,
  0xFE, 0x3F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFD,
  0xF8, 0x1F, 0xCF, 0x80, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xC7, 0x80, 0x7E, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0x0F, 0xE3, 0xF0, 0x7F, 0x3F, 0x83,
  0xF9, 0xF8, 0x1F, 0xCF, 0xC0, 0xFE, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x3F,
  0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xE1, 0xFC, 0x7F, 0x1F, 0xE3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0x9F, 0xF0, 0x7C, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x0F, 0xFB,
  0xC7, 0xF8, 0x11, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE,
  0x0C, 0x3F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x01, 0xE3, 0xF8, 0x0F, 0xF7, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x07, 0xFB, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0x83, 0xF0, 0x7E,
  0x07, 0xE1, 0xFC, 0x0F, 0xC3, 0xF8, 0x1F, 0x87, 0xF0, 0x7F, 0x0F, 0xC0,
  0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0xFE, 0x3F,
  0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFD, 0xF8,
  0x03, 0xF3, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07,
  0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0x0F, 0xDF, 0xC1, 0xFB, 0xF8, 0x3F, 0x7E,
  0x0F, 0xFF, 0xDF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF,
  0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x01, 0x1F, 0xF7, 0xE1, 0xFF,
  0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x03, 0xF8, 0x80, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF3, 0xF0, 0x7F, 0xEF, 0xC3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFC, 0x7F, 0x8F, 0xE0, 0xFC,
  0x3F, 0x83, 0xF1, 0xFC, 0x0F, 0xC7, 0xF0, 0x3F, 0x1F, 0xC1, 0xFC, 0x7E,
  0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0xFE, 0x1F, 0x83, 0xF8, 0x7F, 0x1F,
  0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0x7E, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x83, 0x01,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xC7, 0x80, 0x7E, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x8F, 0xFB, 0xFC, 0x7F, 0x8F, 0xE3, 0xF8, 0x7F, 0x3F, 0x83,
  0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x3F,
  0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x7F,
  0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xC0, 0xFC, 0x7E, 0x07, 0xE0, 0x01,
  0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x3F,
  0x83, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E,
  0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0x80, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x01, 0x0F, 0xC0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0xC3, 0xF8,
  0x1F, 0xC7, 0xF0, 0x1F, 0xCF, 0xE0, 0x1F, 0x9F, 0xC0, 0x1F, 0xBF, 0x80,
  0x3F, 0xFF, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x7E, 0x3F, 0x80,
  0x7E, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0,
  0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xF0, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF0,
  0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x38, 0x07, 0xCF, 0xF0, 0xFF, 0x03,
  0xEF, 0xFC, 0xFF, 0xC3, 0xF7, 0xFE, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xBF, 0xFB, 0xFC, 0x7F, 0x8F, 0xF0, 0xFE, 0x3F, 0x87, 0xF8, 0x7F,
  0x3F, 0x83, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0x1F, 0x8F, 0xE0, 0xFC, 0x0F,
  0xC7, 0xE0, 0x7E, 0x07, 0xE3, 0xF0, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x83,
  0xF9, 0xFC, 0x1F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC0, 0xFC, 0x7E, 0x07, 0xE0,
  0x7E, 0x3F, 0x07, 0xF0, 0x7F, 0x3F, 0x83, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC,
  0x1F, 0x8F, 0xC0, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x0F, 0xE0, 0x00, 0x03,
  0x80, 0x7C, 0xFF, 0x03, 0xEF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F,
  0xFB, 0xFC, 0x7F, 0x8F, 0xE3, 0xF8, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F,
  0xCF, 0xE0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x3F, 0x83, 0xF9, 0xFC,
  0x1F, 0xCF, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x7F, 0x3F, 0x83, 0xF9,
  0xFC, 0x1F, 0xCF, 0xC0, 0xFC, 0x7E, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x3F,
  0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFC, 0xFE, 0x7F,
  0x07, 0xE7, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xEF,
  0xC0, 0x7E, 0xFC, 0x0F, 0xEF, 0xC0, 0xFE, 0xFC, 0x0F, 0xEF, 0xC1, 0xFC,
  0xFE, 0x3F, 0xCF, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x07, 0xCF, 0xE0, 0x0F, 0xBF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFC, 0x3F, 0x83,
  0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF8, 0x7E,
  0x07, 0xE0, 0xFC, 0x0F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE1,
  0xFC, 0x1F, 0xC7, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x03, 0xF7, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x3F, 0xCF, 0xC3, 0xFF, 0x7C, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xEF,
  0xF9, 0xFE, 0x3F, 0xCF, 0xE0, 0xFC, 0x7E, 0x07, 0xE7, 0xF0, 0x3F, 0x3F,
  0x81, 0xF9, 0xFC, 0x1F, 0xCF, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F,
  0x1F, 0x83, 0xF8, 0xFE, 0x3F, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xDF, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0x87, 0xCF, 0xC3,
  0xEF, 0xE3, 0xF7, 0xF1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xE4, 0x3F, 0xC0,
  0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0xE0, 0xFF,
  0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0x87, 0xF0, 0xE1, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0xC0, 0x3F, 0x3F, 0xFF, 0xCF, 0xFF,
  0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFC, 0x00, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE1, 0x1F,
  0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xC0, 0x1F, 0x81, 0xF9,
  0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF0, 0x3F, 0x1F, 0x81,
  0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F,
  0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F,
  0x1F, 0xC7, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F, 0xFB, 0xE0, 0xFF,
  0x9F, 0x03, 0xF8, 0xF8, 0x00, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xBF, 0x03,
  0xF9, 0xF8, 0x1F, 0xCF, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x7E, 0x0F,
  0xC7, 0xF0, 0x7E, 0x3F, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFD, 0xF8,
  0x07, 0xEF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x00, 0xFC, 0x0F, 0xE0, 0x7F, 0xF8, 0x3F, 0xC1, 0xFF, 0xF0, 0x7F, 0x83,
  0xF7, 0xE0, 0xFF, 0x0F, 0xEF, 0xC3, 0xFE, 0x1F, 0x9F, 0x87, 0xBC, 0x7F,
  0x1F, 0x1F, 0xF8, 0xFC, 0x3E, 0x3F, 0xF3, 0xF8, 0x7C, 0x7B, 0xE7, 0xE0,
  0xF9, 0xF7, 0xCF, 0xC1, 0xF3, 0xCF, 0xBF, 0x03, 0xEF, 0x9F, 0x7E, 0x07,
  0xDF, 0x3E, 0xF8, 0x0F, 0xBC, 0x7F, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F,
  0xE1, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFE,
  0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x7F, 0xC0, 0xFC, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F, 0xE7, 0xF0,
  0x01, 0xF9, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xBF, 0x80, 0x0F, 0xE7, 0xE0, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0x7F,
  0x01, 0xFE, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0xC1,
  0xF8, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7E,
  0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC7, 0xF0, 0x03, 0xF1,
  0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xDF, 0x80, 0x01,
  0xF7, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xC0, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x01, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F,
  0x01, 0xFE, 0x03, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x00, 0xFF, 0xA0, 0x03,
  0xC0,
};

const GFXglyph NotoSans_ExtraBoldItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 13, 28, 12, 0, -28 },
  { 47, 15, 10, 18, 4, -28 },
  { 66, 25, 28, 25, 1, -28 },
  { 154, 21, 32, 22, 1, -30 },
  { 238, 32, 28, 35, 2, -28 },
  { 350, 27, 28, 28, 1, -28 },
  { 445, 7, 10, 10, 4, -28 },
  { 454, 16, 34, 14, 1, -28 },
  { 522, 15, 34, 14, -3, -28 },
  { 586, 19, 19, 21, 3, -30 },
  { 632, 19, 19, 23, 2, -23 },
  { 678, 10, 10, 12, -2, -5 },
  { 691, 11, 5, 13, 1, -13 },
  { 698, 8, 6, 12, 0, -6 },
  { 704, 22, 28, 17, -2, -28 },
  { 781, 21, 28, 22, 1, -28 },
  { 855, 17, 28, 22, 3, -28 },
  { 915, 22, 28, 22, -1, -28 },
  { 992, 21, 28, 22, 0, -28 },
  { 1066, 22, 28, 22, 0, -28 },
  { 1143, 22, 28, 22, 0, -28 },
  { 1220, 20, 28, 22, 2, -28 },
  { 1290, 23, 28, 22, 1, -28 },
  { 1371, 21, 28, 22, 1, -28 },
  { 1445, 19, 28, 22, 2, -28 },
  { 1512, 11, 22, 12, 0, -22 },
  { 1543, 13, 27, 12, -2, -22 },
  { 1587, 19, 21, 23, 2, -25 },
  { 1637, 19, 13, 23, 2, -20 },
  { 1668, 19, 21, 23, 2, -25 },
  { 1718, 17, 29, 18, 3, -28 },
  { 1780, 31, 32, 34, 2, -28 },
  { 1904, 25, 28, 25, -2, -28 },
  { 1992, 23, 28, 24, 1, -28 },
  { 2073, 24, 28, 24, 2, -28 },
  { 2157, 24, 28, 27, 1, -28 },
  { 2241, 22, 28, 22, 1, -28 },
  { 2318, 22, 28, 21, 1, -28 },
  { 2395, 25, 28, 27, 2, -28 },
  { 2483, 27, 28, 28, 1, -28 },
  { 2578, 19, 28, 16, -1, -28 },
  { 2645, 20, 37, 14, -6, -28 },
  { 2738, 27, 28, 25, 1, -28 },
  { 2833, 17, 28, 20, 1, -28 },
  { 2893, 34, 28, 35, 1, -28 },
  { 3012, 29, 28, 30, 1, -28 },
  { 3114, 25, 28, 29, 2, -28 },
  { 3202, 23, 28, 24, 1, -28 },
  { 3283, 25, 35, 29, 2, -28 },
  { 3393, 22, 28, 25, 1, -28 },
  { 3470, 20, 28, 21, 1, -28 },
  { 3540, 21, 28, 21, 3, -28 },
  { 3614, 24, 28, 27, 3, -28 },
  { 3698, 24, 28, 23, 3, -28 },
  { 3782, 36, 28, 36, 3, -28 },
  { 3908, 30, 28, 25, -2, -28 },
  { 4013, 23, 28, 23, 3, -28 },
  { 4094, 24, 28, 21, -1, -28 },
  { 4178, 17, 34, 13, -1, -28 },
  { 4251, 10, 28, 17, 4, -28 },
  { 4286, 17, 34, 13, -3, -28 },
  { 4359, 21, 18, 21, 0, -28 },
  { 4407, 18, 4, 17, -4, 3 },
  { 4416, 8, 6, 13, 6, -30 },
  { 4422, 21, 22, 23, 2, -22 },
  { 4480, 21, 30, 23, 1, -30 },
  { 4559, 18, 22, 19, 2, -22 },
  { 4609, 23, 30, 23, 2, -30 },
  { 4696, 19, 22, 22, 2, -22 },
  { 4749, 23, 39, 15, -4, -30 },
  { 4862, 22, 31, 23, 1, -22 },
  { 4948, 21, 30, 24, 1, -30 },
  { 5027, 12, 30, 12, 1, -30 },
  { 5072, 18, 39, 12, -5, -30 },
  { 5160, 24, 30, 23, 1, -30 },
  { 5250, 12, 30, 12, 1, -30 },
  { 5295, 33, 22, 36, 1, -22 },
  { 5386, 21, 22, 24, 1, -22 },
  { 5444, 20, 22, 23, 2, -22 },
  { 5499, 23, 31, 23, -1, -22 },
  { 5589, 21, 31, 23, 2, -22 },
  { 5671, 17, 22, 17, 1, -22 },
  { 5718, 18, 22, 19, 0, -22 },
  { 5768, 15, 26, 17, 2, -26 },
  { 5817, 21, 21, 24, 2, -21 },
  { 5873, 21, 21, 21, 2, -21 },
  { 5929, 31, 21, 31, 2, -21 },
  { 6011, 26, 21, 21, -2, -21 },
  { 6080, 26, 30, 21, -3, -21 },
  { 6178, 20, 21, 19, -1, -21 },
  { 6231, 17, 34, 14, 0, -28 },
  { 6304, 4, 39, 22, 9, -30 },
  { 6324, 16, 34, 14, -2, -28 },
  { 6392, 19, 7, 23, 2, -17 },
};

const GFXfont NotoSans_ExtraBoldItalic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic39pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_EXTRABOLDITALIC39PT7B_H_
