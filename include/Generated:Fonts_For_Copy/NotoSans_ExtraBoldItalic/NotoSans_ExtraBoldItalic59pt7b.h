#ifndef _NOTOSANS_EXTRABOLDITALIC59PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xC0, 0x01,
  0xC0, 0x00, 0x3F, 0xC3, 0xFE, 0xFF, 0x87, 0xF9, 0xFF, 0x1F, 0xF3, 0xFC,
  0x3F, 0xE7, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0x83,
  0xF8, 0xFF, 0x07, 0xF1, 0xFE, 0x1F, 0xE3, 0xF8, 0x3F, 0xC7, 0xF0, 0x7F,
  0x0F, 0xE0, 0xFE, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xEF, 0x8F, 0x81, 0xFF, 0x9E, 0x02,
  0x03, 0xFE, 0x3C, 0x00, 0x07, 0xFC, 0x78, 0x00, 0x0F, 0xF9, 0xF0, 0x00,
  0x1F, 0xFB, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xF3, 0xFE, 0x00, 0x03, 0xE7, 0xFC, 0x00, 0x07, 0x8F, 0xF8, 0x80, 0x0F,
  0x1F, 0xF1, 0xC0, 0x1E, 0x3F, 0xE3, 0xF0, 0x7C, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xE7, 0xF8, 0x01, 0xFC, 0x00,
  0x3F, 0xC3, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0xC3, 0xF8, 0x07, 0xF8, 0x00,
  0x7F, 0x83, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0x00,
  0x7F, 0x83, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0xFF, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x7F, 0x80, 0x00,
  0xFF, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF1, 0xFE, 0x0F, 0xC0,
  0xFF, 0x0F, 0xF1, 0xFC, 0x3F, 0xF0, 0xFF, 0x1F, 0xE3, 0xFC, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE7, 0xF9, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xF3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xCF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0x9F, 0xE7, 0xFF, 0xFE,
  0x1F, 0xFF, 0x3F, 0xC7, 0xF8, 0xFF, 0x0F, 0xFC, 0x3F, 0x8F, 0xF0, 0xFF,
  0x01, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0xFF,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0xFF,
  0x00, 0x03, 0xF8, 0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE1, 0xFE,
  0x00, 0x0F, 0xF0, 0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC1, 0xFE,
  0x00, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xC3, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xE7, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFF, 0xF0, 0x0F, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFC, 0x1F, 0xFF,
  0xFE, 0x07, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3,
  0xFF, 0x0F, 0xFE, 0x7F, 0xF3, 0xFF, 0x0F, 0xFE, 0x1F, 0xFB, 0xFF, 0x87,
  0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0x00,
  0xFF, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x3F, 0xFC, 0x00,
  0x7F, 0xFE, 0x0F, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xDF,
  0xF7, 0xFD, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFC, 0xFF, 0x3F, 0xCF, 0xE3,
  0xF8, 0xFE, 0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x02, 0x00,
  0xFF, 0x00, 0x38, 0x0F, 0xE0, 0x03, 0xE0, 0xFE, 0x00, 0x7F, 0x8F, 0xC0,
  0x07, 0xFE, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0x7F, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xF7, 0xF0, 0x03, 0xFE, 0x7F, 0x80, 0x7F, 0xE3,
  0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0x83, 0xFC, 0x00, 0x38, 0x3F, 0xC0,
  0x01, 0x01, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F,
  0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF,
  0xFD, 0xFF, 0xFE, 0x03, 0x03, 0xF8, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xCF, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xBF, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0,
  0xFF, 0xE0, 0x3F, 0xE1, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0xCF,
  0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x07, 0xFE, 0xFF,
  0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0x7F, 0xE0,
  0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xFD, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x00,
  0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0x9F, 0xF8, 0x07,
  0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF8, 0xFF, 0xC0, 0x7F,
  0xE1, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFE, 0xFF, 0x87, 0xFE, 0x7F,
  0xC1, 0xFE, 0x7F, 0xE0, 0xFC, 0x3F, 0xF0, 0x38, 0x1F, 0xF8, 0x08, 0x0F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xE0, 0x7F, 0xF0, 0x03, 0xE0, 0x0F, 0xFC, 0x00, 0x70, 0x03, 0xFF, 0x00,
  0x10, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x20, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x1F, 0xFF, 0x00,
  0x78, 0x07, 0xFF, 0x00, 0x20, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0xC0,
  0x00, 0x3F, 0xF8, 0xF0, 0x00, 0x7F, 0xF8, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0xE0, 0x00,
  0x7F, 0xDF, 0xF0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x07, 0xF8, 0xFF, 0xC0, 0x03, 0xFC, 0x3F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x3F, 0xE0, 0x7F,
  0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF0, 0x02, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x80, 0x00, 0x7F, 0xF0, 0xF0, 0x01, 0xFF, 0xF0, 0xFF, 0x9F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x0C, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x7C, 0x00, 0x1F, 0xF3, 0xFF, 0x80, 0x3F, 0xE7, 0xFF, 0xC0, 0x3F, 0xEF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0,
  0x1F, 0xF8, 0x7F, 0xF0, 0x1F, 0xF8, 0xFF, 0xE0, 0x1F, 0xF8, 0xFF, 0xE0,
  0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0,
  0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0,
  0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xF9, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8,
  0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0x81,
  0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0xBF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xF9, 0xFF, 0xC1, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0x1F, 0xF0, 0x03,
  0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F,
  0xF1, 0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0xC7, 0xFF, 0x03, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC1, 0xFF, 0x9F, 0xFC, 0x07, 0xFE,
  0xFF, 0xC0, 0x3F, 0xF7, 0xFE, 0x01, 0xFF, 0xBF, 0xF0, 0x0F, 0xFD, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xF7, 0xFF, 0x1F, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xDF, 0xF0, 0xFF, 0xFD, 0xFF, 0x83, 0xFF, 0xCF, 0xF8, 0x0F, 0xFC,
  0x7F, 0xC0, 0x06, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0xC1, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x0E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x03, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F,
  0xC1, 0xFF, 0xC7, 0x80, 0x3F, 0xF0, 0x80, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x1F, 0xF8, 0x0F, 0xE1, 0xFE, 0x01, 0xFF, 0xFE, 0x1F,
  0xE3, 0xF8, 0x07, 0xFF, 0xFE, 0x1F, 0xCF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F,
  0x9F, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0x7F, 0x81, 0xFF, 0xFF, 0xE0, 0xFE,
  0xFE, 0x07, 0xFC, 0x1F, 0xC0, 0xFD, 0xFC, 0x1F, 0xF0, 0x7F, 0x01, 0xFF,
  0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0x01, 0xFC, 0x0F, 0xFF,
  0xC1, 0xFC, 0x03, 0xF8, 0x1F, 0xFF, 0x83, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF,
  0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0xFE, 0x1F, 0xC0, 0x3F, 0x81, 0xFD, 0xF8,
  0x3F, 0x80, 0x7F, 0x03, 0xFB, 0xF0, 0x7F, 0x01, 0xFE, 0x07, 0xF7, 0xE0,
  0xFE, 0x03, 0xF8, 0x1F, 0xCF, 0xC1, 0xFC, 0x0F, 0xF0, 0x7F, 0x9F, 0xC3,
  0xFC, 0x3F, 0xE1, 0xFE, 0x3F, 0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xFF, 0xDF, 0xFF, 0xC1, 0xFE, 0x0F,
  0xFF, 0x3F, 0xFF, 0x03, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x03, 0xFC, 0x07,
  0xE0, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x01,
  0xFF, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x0F, 0xF9, 0xFF,
  0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x1F, 0xF0,
  0x7F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x00, 0x7F, 0xC3, 0xFF, 0x00,
  0x00, 0xFF, 0x8F, 0xFE, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x03, 0xFE,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFF, 0x07, 0xFE,
  0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xF8, 0x07,
  0xFF, 0x80, 0x03, 0x80, 0xFF, 0xF0, 0x00, 0x08, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x03, 0x00, 0x7F,
  0xFC, 0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x81,
  0xFF, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F,
  0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFE,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x07, 0xFF, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x1F,
  0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFC,
  0x00, 0xFF, 0xF0, 0x7F, 0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xF8,
  0x3F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x04, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1E, 0x01, 0xFF, 0xF0,
  0x00, 0x30, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0xFE,
  0x3F, 0xF0, 0x1F, 0xFF, 0xF1, 0xFF, 0x80, 0xFF, 0xFF, 0x9F, 0xFC, 0x07,
  0xFF, 0xF8, 0xFF, 0xE0, 0x7F, 0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0xFE, 0x3F,
  0xF0, 0x1F, 0xFF, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xFE, 0x00, 0x1F,
  0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xF8,
  0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xA0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00,
  0x03, 0xFE, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xF8, 0x00, 0x07, 0xFE, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC7, 0xFF, 0x00,
  0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xDF, 0xF8, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0x7F, 0xE1, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFE,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x07, 0xF7, 0xFC, 0x03, 0xFE, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xEF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFE, 0xFE, 0x01, 0xFE, 0xFF, 0x80, 0x3F,
  0xCF, 0xE0, 0x1F, 0xEF, 0xF8, 0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFF, 0x00,
  0x7F, 0xCF, 0xE0, 0x3F, 0xDF, 0xF0, 0x07, 0xFC, 0xFE, 0x07, 0xF9, 0xFF,
  0x00, 0x7F, 0xCF, 0xE0, 0x7F, 0x9F, 0xF0, 0x07, 0xFC, 0xFE, 0x0F, 0xF1,
  0xFF, 0x00, 0x7F, 0x8F, 0xE0, 0xFF, 0x3F, 0xE0, 0x0F, 0xF8, 0xFE, 0x1F,
  0xE3, 0xFE, 0x00, 0xFF, 0x8F, 0xE1, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0xFE,
  0x1F, 0xC3, 0xFE, 0x00, 0xFF, 0x8F, 0xE3, 0xFC, 0x7F, 0xE0, 0x1F, 0xF0,
  0xFE, 0x3F, 0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xE7, 0xF8, 0x7F, 0xC0, 0x1F,
  0xF0, 0xFE, 0x7F, 0x07, 0xFC, 0x01, 0xFF, 0x0F, 0xEF, 0xF0, 0x7F, 0xC0,
  0x1F, 0xF0, 0xFE, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0x80, 0x3F, 0xE0, 0xFF, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xFF, 0xC0,
  0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xFF,
  0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x0F,
  0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x07, 0xFC,
  0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF8,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xFE, 0x00, 0x07, 0xFC, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x07, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x3F,
  0xE0, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x9F, 0xF8, 0x0F, 0xF8,
  0x03, 0xFC, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0x01,
  0xFF, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x00, 0x7F,
  0xC3, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE0,
  0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F,
  0xF1, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xCF, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xE0,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x07, 0xFF,
  0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x3F, 0xF1, 0xFF, 0xC0,
  0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x0F, 0xFC,
  0xFF, 0xC0, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00,
  0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xF7,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x01, 0xFF, 0xBF,
  0xF0, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x01,
  0xFF, 0xCF, 0xFE, 0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x7F,
  0xF0, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xE0,
  0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0xFF,
  0xC0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xE0,
  0x7F, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFE, 0x00,
  0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x00, 0xFF, 0xCF,
  0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00,
  0x3F, 0xF7, 0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x03, 0xFF, 0x7F,
  0xE0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x0F,
  0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x01, 0xFF, 0xCF, 0xFE,
  0x00, 0x0F, 0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x01, 0xFF,
  0xC1, 0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF,
  0xC1, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xE7, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x1F,
  0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xE0, 0x0F,
  0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xF1, 0xFF, 0x80,
  0x0F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xEF, 0xF8, 0x0F, 0xFE,
  0x00, 0xF0, 0x1F, 0xF8, 0x00, 0x40, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x80, 0x00, 0xFF, 0xE1, 0xC0, 0x01, 0xFF, 0x83, 0xF0,
  0x07, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x7F,
  0xE0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x07, 0xFF,
  0x3F, 0xF0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xC0, 0x07,
  0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xE0,
  0x07, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0,
  0x0F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x7F,
  0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x0F, 0xF8,
  0xFF, 0xC0, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x07,
  0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF7, 0xFE, 0x00,
  0x03, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xBF, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF3,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFE, 0x3F, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x0F, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFC, 0x3F, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0xFF,
  0x80, 0x7F, 0xFF, 0x01, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFC,
  0x0F, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xBF, 0xC0,
  0xFF, 0x80, 0xFF, 0x81, 0xFE, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x07, 0xFB,
  0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0,
  0xFF, 0x3F, 0xC3, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0xFF, 0x0F, 0xF8, 0x01,
  0xFE, 0x1F, 0xE3, 0xFC, 0x7F, 0xE0, 0x07, 0xF8, 0x7F, 0x8F, 0xF1, 0xFF,
  0x00, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0xFF,
  0x3F, 0xE0, 0x01, 0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0x80, 0x07, 0xF9, 0xFE,
  0x0F, 0xF7, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x3F, 0xDF, 0xF0, 0x00, 0x7F,
  0xBF, 0xC0, 0xFF, 0x7F, 0xC0, 0x01, 0xFE, 0xFF, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x3F, 0xBF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0xF0, 0x03, 0xFF,
  0x87, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x1F, 0xFC, 0x0F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF8, 0x03, 0xFE,
  0x07, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xF0, 0x01,
  0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xE0,
  0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x01, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x10,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x08, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFE, 0x7E,
  0x00, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x81,
  0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0xFE, 0x3F,
  0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x80, 0x1F, 0xF8, 0x7F, 0x80, 0x3F, 0xFE, 0x3F, 0xC0, 0x3F, 0xFF, 0x9F,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x1F, 0xFE, 0x0F, 0xFE, 0x07,
  0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0,
  0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0xF8, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF8,
  0x03, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0x07, 0xFF,
  0x01, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xE0, 0xFF, 0xF0, 0x3F, 0xFD, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFE, 0xFF, 0x00, 0x1F, 0xFE, 0x7F, 0x80, 0x07, 0xFC, 0x3F, 0xC0,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x0F, 0xC0, 0x01, 0xFF, 0x3F,
  0xF0, 0x03, 0xFF, 0x7F, 0xF8, 0x03, 0xFE, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x03,
  0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xF8, 0x03,
  0xFF, 0x0F, 0xF8, 0x03, 0xFF, 0x0F, 0xF8, 0x03, 0xFF, 0x1F, 0xF0, 0x03,
  0xFF, 0x1F, 0xF0, 0x07, 0xFE, 0x1F, 0xF0, 0x07, 0xFE, 0x1F, 0xF0, 0x07,
  0xFE, 0x1F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F,
  0xFC, 0x3F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xFC, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xBF, 0xFF, 0xC0, 0xFF, 0xBF, 0xFF, 0x80, 0xFF, 0x1F, 0xFF,
  0x00, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0x03, 0x81, 0xFF, 0xC0, 0x08, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x20, 0x7F, 0xF0, 0x0E,
  0x07, 0xFF, 0xCF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0x83, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x1F, 0xFF, 0x3F, 0xE0,
  0x0F, 0xFF, 0xEF, 0xF8, 0x07, 0xFF, 0xFB, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x3F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC0,
  0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFE,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F,
  0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xFC, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF7, 0xF8, 0x00, 0x7F,
  0xF9, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xC3, 0xFF, 0x1F, 0xF8, 0x0F, 0xF9, 0xFF, 0xC0, 0x7F,
  0xCF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xF7, 0xFE, 0x03, 0xFF, 0x3F,
  0xF0, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0x07, 0xFF, 0x00, 0x78, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x9C, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x40, 0x07, 0xFE, 0x1F, 0xE0, 0x07, 0xFF, 0xC7, 0xF8,
  0x03, 0xFF, 0xF9, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x8F,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF,
  0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0xF0, 0x07, 0xFC, 0x0F,
  0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0,
  0x7F, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFB, 0xFE, 0x00, 0x1F,
  0xFC, 0xFF, 0x80, 0x03, 0xFC, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x20, 0x00, 0x7F, 0xE0, 0x0E, 0x00, 0x3F, 0xF8, 0x03, 0xFE, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x07, 0xE0, 0x01,
  0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x7F, 0xFC, 0x03, 0xFE, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x07,
  0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x0F,
  0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x1F,
  0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x1F,
  0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F,
  0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x7F,
  0xE0, 0x0F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F,
  0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF,
  0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xF8,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x03, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x80, 0xFF, 0x80,
  0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x03,
  0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0x83, 0xFF,
  0x80, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x03, 0xFF,
  0x1F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x9F, 0xF8, 0x00,
  0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFE,
  0x7F, 0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F,
  0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0x3F, 0xC7, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xF3, 0xFF, 0xF8,
  0xFF, 0xFE, 0x03, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0x80, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC3, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x87,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x03,
  0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE1, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0xF8,
  0x03, 0xFC, 0x7F, 0xFC, 0x03, 0xFC, 0xFF, 0xFE, 0x03, 0xFD, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xC7, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x03, 0xFF,
  0x0F, 0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFF,
  0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x07, 0xFE,
  0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFE,
  0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC,
  0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x7F, 0xE0, 0x0F, 0xF8,
  0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8,
  0x7F, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xFC,
  0x3F, 0xF8, 0xFF, 0xE0, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0xDF, 0xFC, 0x03,
  0xFF, 0x7F, 0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x00, 0x7F, 0xEF,
  0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xFB, 0xFE,
  0x00, 0xFF, 0xCF, 0xFC, 0x07, 0xFF, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0,
  0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0xC0, 0x01, 0xFE, 0x7F,
  0xFC, 0x00, 0x3F, 0xDF, 0xFF, 0xC0, 0x07, 0xFB, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0x01,
  0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x07,
  0xFF, 0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFE, 0xFF, 0xFC, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0x80,
  0x03, 0xFE, 0x03, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0x00, 0x7F, 0xE1, 0xFE, 0x01, 0xFF,
  0xF1, 0xFE, 0x03, 0xFF, 0xF9, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0,
  0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0xE0,
  0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0,
  0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0,
  0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0,
  0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF3, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFE, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0x80, 0x0F, 0xF9,
  0xFF, 0x80, 0x00, 0x81, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x7F, 0xE0,
  0x3F, 0xDF, 0xFC, 0x07, 0xFB, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x70, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0xFF, 0xE0, 0xF8, 0x1F, 0xF8, 0x03, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0xC0,
  0x07, 0xFF, 0x1E, 0x01, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x20, 0x7F, 0xF9, 0xC0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x0F, 0xFC, 0x03,
  0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xF8, 0x03,
  0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x07,
  0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0x0F,
  0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x0F,
  0xFC, 0x7F, 0xE0, 0x0F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F,
  0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF8, 0xFF, 0xC0, 0x3F,
  0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xC0, 0x7F,
  0xF0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE7, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xBF,
  0xC0, 0x7F, 0xFF, 0xBF, 0xC0, 0x3F, 0xFF, 0x3F, 0xC0, 0x1F, 0xFE, 0x3F,
  0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F,
  0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F,
  0xF0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF,
  0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x80, 0x7F, 0xC1, 0xFF,
  0x80, 0x3F, 0xC3, 0xFF, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x3F, 0xC7, 0xFE,
  0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFC, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFC, 0x7F, 0xC0, 0xFF, 0xF8, 0x0F, 0xF8, 0x7F,
  0xC0, 0xFF, 0xF8, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0xF8, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0xF8, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0xF8, 0x3F, 0xE0, 0x7F,
  0xC3, 0xFB, 0xF8, 0x7F, 0xE0, 0x7F, 0xC3, 0xFB, 0xF8, 0x7F, 0xC0, 0x7F,
  0xC3, 0xFB, 0xF8, 0x7F, 0xC0, 0x7F, 0xC7, 0xF3, 0xF8, 0xFF, 0x80, 0x7F,
  0xC7, 0xF3, 0xF8, 0xFF, 0x80, 0x7F, 0xCF, 0xF3, 0xF9, 0xFF, 0x80, 0x7F,
  0xCF, 0xE3, 0xF9, 0xFF, 0x00, 0x7F, 0xCF, 0xE3, 0xF1, 0xFF, 0x00, 0x7F,
  0xDF, 0xC3, 0xF3, 0xFE, 0x00, 0x7F, 0xDF, 0xC3, 0xF3, 0xFE, 0x00, 0x7F,
  0xBF, 0xC3, 0xF7, 0xFC, 0x00, 0x7F, 0xBF, 0x83, 0xF7, 0xFC, 0x00, 0x7F,
  0xBF, 0x83, 0xF7, 0xF8, 0x00, 0x7F, 0xBF, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFF,
  0x80, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x0F,
  0xFC, 0x7F, 0xE0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xCF,
  0xFC, 0x00, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFE, 0x3F, 0xF0, 0x00,
  0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xF8,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x03, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00,
  0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x7F, 0xCF,
  0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00,
  0x0F, 0xF7, 0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x09, 0xFF, 0xF0, 0x00, 0xDF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xE4, 0x00, 0x07, 0xFE,
  0x00,
};

const GFXglyph NotoSans_ExtraBoldItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 18, 43, 17, 1, -42 },
  { 98, 23, 15, 27, 6, -42 },
  { 142, 38, 42, 38, 1, -42 },
  { 342, 31, 48, 33, 2, -45 },
  { 528, 48, 44, 53, 3, -43 },
  { 792, 41, 44, 42, 1, -43 },
  { 1018, 10, 15, 15, 6, -42 },
  { 1037, 23, 52, 21, 2, -43 },
  { 1187, 23, 52, 21, -4, -43 },
  { 1337, 28, 29, 32, 5, -45 },
  { 1439, 29, 28, 34, 3, -35 },
  { 1541, 15, 15, 17, -3, -7 },
  { 1570, 17, 8, 19, 1, -20 },
  { 1587, 11, 11, 17, 0, -10 },
  { 1603, 33, 43, 26, -3, -43 },
  { 1781, 31, 44, 33, 2, -43 },
  { 1952, 25, 42, 33, 5, -42 },
  { 2084, 34, 43, 33, -2, -43 },
  { 2267, 32, 44, 33, 0, -43 },
  { 2443, 34, 42, 33, -1, -42 },
  { 2622, 32, 43, 33, 1, -42 },
  { 2794, 32, 44, 33, 2, -43 },
  { 2970, 34, 42, 33, 2, -42 },
  { 3149, 31, 44, 33, 2, -43 },
  { 3320, 29, 44, 33, 3, -43 },
  { 3480, 17, 34, 17, 0, -33 },
  { 3553, 20, 41, 17, -3, -33 },
  { 3656, 29, 32, 34, 3, -37 },
  { 3772, 29, 19, 34, 3, -30 },
  { 3841, 29, 32, 34, 3, -37 },
  { 3957, 26, 44, 28, 4, -43 },
  { 4100, 47, 47, 52, 3, -42 },
  { 4377, 39, 42, 38, -4, -42 },
  { 4582, 35, 42, 37, 1, -42 },
  { 4766, 36, 44, 37, 3, -43 },
  { 4964, 37, 42, 40, 1, -42 },
  { 5159, 33, 42, 33, 1, -42 },
  { 5333, 33, 42, 32, 1, -42 },
  { 5507, 37, 44, 41, 3, -43 },
  { 5711, 41, 42, 42, 1, -42 },
  { 5927, 29, 42, 24, -2, -42 },
  { 6080, 30, 55, 21, -9, -42 },
  { 6287, 42, 42, 38, 1, -42 },
  { 6508, 26, 42, 31, 1, -42 },
  { 6645, 52, 42, 53, 1, -42 },
  { 6918, 45, 42, 46, 1, -42 },
  { 7155, 38, 44, 43, 3, -43 },
  { 7364, 35, 42, 36, 1, -42 },
  { 7548, 38, 53, 43, 3, -43 },
  { 7800, 34, 42, 37, 1, -42 },
  { 7979, 31, 44, 32, 1, -43 },
  { 8150, 31, 42, 32, 5, -42 },
  { 8313, 38, 43, 41, 4, -42 },
  { 8518, 35, 42, 36, 5, -42 },
  { 8702, 54, 42, 54, 5, -42 },
  { 8986, 45, 42, 37, -3, -42 },
  { 9223, 35, 42, 34, 5, -42 },
  { 9407, 37, 42, 32, -2, -42 },
  { 9602, 25, 53, 20, -1, -43 },
  { 9768, 15, 43, 26, 6, -43 },
  { 9849, 26, 53, 20, -4, -43 },
  { 10022, 31, 27, 32, 0, -42 },
  { 10127, 26, 5, 25, -5, 5 },
  { 10144, 14, 9, 20, 8, -45 },
  { 10160, 33, 34, 35, 2, -33 },
  { 10301, 32, 46, 35, 1, -45 },
  { 10485, 28, 34, 29, 2, -33 },
  { 10604, 34, 46, 35, 3, -45 },
  { 10800, 29, 34, 33, 3, -33 },
  { 10924, 35, 59, 23, -6, -45 },
  { 11183, 34, 47, 35, 1, -33 },
  { 11383, 32, 45, 36, 1, -45 },
  { 11563, 19, 45, 18, 1, -45 },
  { 11670, 28, 59, 18, -8, -45 },
  { 11877, 37, 45, 35, 1, -45 },
  { 12086, 19, 45, 18, 1, -45 },
  { 12193, 50, 33, 54, 1, -33 },
  { 12400, 32, 33, 36, 1, -33 },
  { 12532, 30, 34, 35, 3, -33 },
  { 12660, 35, 47, 35, -2, -33 },
  { 12866, 32, 47, 35, 3, -33 },
  { 13054, 27, 33, 25, 1, -33 },
  { 13166, 27, 34, 29, 1, -33 },
  { 13281, 24, 40, 25, 2, -39 },
  { 13401, 32, 33, 36, 3, -32 },
  { 13533, 32, 32, 31, 3, -32 },
  { 13661, 48, 32, 47, 3, -32 },
  { 13853, 39, 32, 32, -3, -32 },
  { 14009, 38, 46, 31, -4, -32 },
  { 14228, 30, 32, 28, -1, -32 },
  { 14348, 25, 51, 21, 0, -42 },
  { 14508, 7, 58, 33, 13, -45 },
  { 14559, 24, 51, 21, -3, -42 },
  { 14712, 29, 10, 34, 3, -26 },
};

const GFXfont NotoSans_ExtraBoldItalic59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic59pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_EXTRABOLDITALIC59PT7B_H_
