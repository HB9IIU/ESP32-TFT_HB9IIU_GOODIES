#ifndef _NOTOSANS_EXTRABOLDITALIC18PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0xF3, 0x8E, 0x38, 0xE3, 0x1C, 0x70, 0x06, 0x3C, 0xE0, 0xEF,
  0xDB, 0x36, 0x6D, 0x80, 0x06, 0x60, 0x6C, 0x0C, 0xC0, 0xCC, 0x7F, 0xF7,
  0xFF, 0x19, 0x81, 0x98, 0xFF, 0xE3, 0x30, 0x33, 0x03, 0x70, 0x76, 0x00,
  0x03, 0x00, 0x81, 0xFC, 0xFF, 0x3E, 0x4F, 0x83, 0xE0, 0x7C, 0x07, 0x83,
  0xE8, 0xBB, 0xFE, 0xFF, 0x02, 0x01, 0x80, 0x3C, 0x19, 0xF0, 0xCE, 0xC6,
  0x3B, 0x38, 0xCC, 0xC3, 0x36, 0xEF, 0xB7, 0xDD, 0xDB, 0x06, 0xEC, 0x33,
  0x31, 0x8C, 0xCE, 0x3F, 0x70, 0x78, 0x0F, 0x80, 0xFE, 0x07, 0x70, 0x3B,
  0x81, 0xFC, 0x0F, 0xC0, 0xF8, 0xEF, 0xEE, 0x77, 0xF7, 0x1F, 0x3C, 0xF0,
  0xFF, 0xC3, 0xEF, 0x00, 0xFF, 0x6C, 0x0E, 0x30, 0xE3, 0x87, 0x1C, 0x38,
  0x70, 0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x38, 0x30, 0x1C, 0x18, 0x30, 0x70,
  0xE1, 0xC3, 0x87, 0x0C, 0x18, 0x70, 0xC3, 0x86, 0x1C, 0x70, 0x0C, 0x07,
  0x13, 0x0F, 0x9B, 0xF8, 0xFD, 0xD8, 0x6C, 0x27, 0x00, 0x18, 0x0C, 0x06,
  0x03, 0x0F, 0xFF, 0xFC, 0x60, 0x30, 0x18, 0x00, 0x3B, 0x99, 0xC0, 0x7F,
  0xC0, 0x7F, 0x80, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x03, 0x80, 0xE0,
  0x70, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x00, 0x1E, 0x1F, 0x9F, 0xEE,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE7, 0x73, 0xBB, 0xDF, 0xC7, 0xC0, 0x07,
  0x1F, 0x3F, 0xFE, 0x6E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x38,
  0x0F, 0x0F, 0xE3, 0xFC, 0x47, 0x03, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x0F, 0xFB, 0xFC, 0xFF, 0x00, 0x1F, 0x0F, 0xE1, 0xBC, 0x07, 0x03, 0x87,
  0xE1, 0xE0, 0x7E, 0x03, 0x80, 0xEC, 0x7B, 0xFC, 0xFE, 0x00, 0x01, 0xC0,
  0xF0, 0x78, 0x3E, 0x1F, 0x86, 0xE3, 0x39, 0xDC, 0xFF, 0xFF, 0xE0, 0x70,
  0x1C, 0x0E, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0xE0, 0x38, 0x0F, 0xC7, 0xF8,
  0x0E, 0x03, 0x80, 0xEC, 0x7B, 0xFC, 0xFE, 0x00, 0x0F, 0x8F, 0xCF, 0x2E,
  0x06, 0x07, 0xFB, 0xFD, 0xCE, 0xE7, 0x73, 0xB9, 0xDF, 0xC7, 0xC0, 0x3F,
  0xE7, 0xFC, 0xFF, 0x01, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1E, 0x03,
  0x80, 0xE0, 0x3C, 0x0F, 0x00, 0x0F, 0x87, 0xF3, 0x9C, 0xE7, 0x39, 0xC7,
  0xE1, 0xF1, 0xFE, 0x73, 0xB8, 0xE7, 0x39, 0xFE, 0x3E, 0x00, 0x3E, 0x3F,
  0x9D, 0xFC, 0x7E, 0x3F, 0x3F, 0xFE, 0xF6, 0x37, 0x03, 0xA7, 0x9F, 0x8F,
  0x80, 0x39, 0xCE, 0x00, 0x00, 0x0C, 0xE7, 0x00, 0x1C, 0x71, 0xC0, 0x00,
  0x00, 0x00, 0x79, 0xC6, 0x38, 0x01, 0x83, 0xC7, 0xCF, 0x0E, 0x07, 0xC0,
  0xF8, 0x0F, 0x01, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0xC0,
  0x78, 0x1F, 0x03, 0xE0, 0x78, 0x7D, 0xF1, 0xE0, 0xC0, 0x00, 0x3E, 0xFF,
  0x67, 0x07, 0x0F, 0x1E, 0x3C, 0x30, 0x70, 0x00, 0x60, 0xF0, 0xE0, 0x07,
  0xE0, 0x7F, 0xE3, 0x81, 0xDC, 0x03, 0x67, 0xEF, 0x3B, 0xBC, 0xCC, 0xF7,
  0x33, 0xD9, 0xCF, 0x7F, 0xEC, 0xEF, 0x38, 0x00, 0x70, 0x40, 0xFF, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x3E, 0x07, 0xE0, 0x7E, 0x0E, 0xE0, 0xEE, 0x1C,
  0xE1, 0xCE, 0x3F, 0xE3, 0xFE, 0x70, 0xE7, 0x06, 0xE0, 0x70, 0x1F, 0x83,
  0xFC, 0x7F, 0x9C, 0x73, 0x8E, 0x7F, 0x8F, 0xE1, 0xFE, 0x71, 0xCE, 0x39,
  0xCF, 0x3F, 0xCF, 0xF0, 0x0F, 0xC3, 0xFC, 0xFF, 0x3C, 0x07, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC4, 0x3F, 0x83, 0xF0, 0x1F, 0x81,
  0xFC, 0x1F, 0xE3, 0x8F, 0x38, 0x73, 0x87, 0x38, 0x73, 0x8E, 0x70, 0xE7,
  0x1E, 0x7F, 0xC7, 0xF8, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x7F, 0x1C, 0x03,
  0x80, 0x7F, 0x0F, 0xE1, 0xFC, 0x70, 0x0E, 0x01, 0xFC, 0x3F, 0x8F, 0xF0,
  0x1F, 0xC7, 0xF1, 0xFC, 0xE0, 0x38, 0x0E, 0x03, 0xF8, 0xFE, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0xF0, 0x00, 0x0F, 0xE3, 0xFC, 0xFF, 0xBC, 0x07, 0x01,
  0xE0, 0x39, 0xFF, 0x3E, 0xE1, 0xDC, 0x3B, 0xCF, 0x3F, 0xC3, 0xF8, 0x1C,
  0x38, 0xE3, 0xC7, 0x1C, 0x70, 0xE3, 0x87, 0x1F, 0xF8, 0xFF, 0x87, 0xFC,
  0x70, 0xE3, 0x87, 0x1C, 0x38, 0xE3, 0x8F, 0x1C, 0x00, 0x1F, 0x8F, 0xC3,
  0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x0F, 0xCF, 0xE0,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0xF3, 0xF1, 0xF8, 0xF0, 0x00, 0x1C, 0x78, 0xE7, 0x87,
  0x38, 0x73, 0x83, 0xB8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x73, 0x83, 0x9C,
  0x1C, 0xF0, 0xE3, 0x8F, 0x1C, 0x00, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x70, 0x70, 0x7F, 0x7F, 0xFF, 0x1E, 0x0F, 0x1E, 0x1F, 0x1E,
  0x1F, 0x3E, 0x3E, 0x3E, 0x36, 0x3E, 0x7E, 0x36, 0x6E, 0x36, 0xEE, 0x76,
  0xCC, 0x76, 0xDC, 0x77, 0x9C, 0x67, 0x9C, 0xE7, 0x1C, 0x1E, 0x1C, 0x78,
  0x71, 0xE1, 0xCF, 0xC6, 0x3F, 0x38, 0xFC, 0xE3, 0x3B, 0x8C, 0xEC, 0x73,
  0xB1, 0xC7, 0xC7, 0x1F, 0x18, 0x7C, 0xE0, 0xE0, 0x0F, 0x81, 0xFE, 0x3D,
  0xE7, 0x8F, 0x70, 0x7F, 0x07, 0xE0, 0xFE, 0x0E, 0xE0, 0xEE, 0x1E, 0xF3,
  0xC7, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF8, 0x7F, 0x9C, 0x73, 0x8E, 0x73,
  0xCF, 0xF1, 0xFC, 0x7E, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x00, 0x0F, 0x81,
  0xFE, 0x3F, 0xE7, 0x8F, 0x70, 0x7F, 0x07, 0xE0, 0xFE, 0x0E, 0xE0, 0xEE,
  0x1E, 0xF3, 0xC7, 0xF8, 0x3F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x1F, 0x83,
  0xF8, 0x7F, 0x9C, 0x73, 0x8E, 0x73, 0x8F, 0xF1, 0xF8, 0x73, 0x8E, 0x71,
  0xCE, 0x38, 0xEF, 0x1C, 0x0F, 0x87, 0xF3, 0xD8, 0xE0, 0x38, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x01, 0xCC, 0x73, 0xFC, 0x7E, 0x00, 0x7F, 0xDF, 0xFF,
  0xF8, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x70, 0x00, 0x38, 0x73, 0x8E, 0x38, 0xE7, 0x0E, 0x70, 0xE7, 0x1E, 0x71,
  0xCF, 0x1C, 0xE1, 0xCE, 0x3C, 0xF7, 0x87, 0xF8, 0x3E, 0x00, 0xE0, 0xEC,
  0x1D, 0xC7, 0x38, 0xE7, 0x38, 0xE7, 0x1D, 0xC3, 0xB8, 0x7E, 0x0F, 0xC1,
  0xF0, 0x3E, 0x07, 0x80, 0xE1, 0xC3, 0xB0, 0xE3, 0x98, 0xF1, 0xCC, 0x78,
  0xE6, 0x3C, 0xE3, 0x36, 0x71, 0x9B, 0x70, 0xDD, 0xB8, 0x6C, 0xD8, 0x3E,
  0x7C, 0x1E, 0x3E, 0x0F, 0x1E, 0x07, 0x0F, 0x00, 0x1C, 0x3C, 0x79, 0xE0,
  0xE7, 0x03, 0xB8, 0x0F, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0xC0,
  0x77, 0x03, 0x9C, 0x1C, 0x38, 0xF0, 0xE0, 0xE3, 0xF8, 0xEE, 0x73, 0x9C,
  0x7E, 0x1F, 0x07, 0xC1, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x00,
  0x1F, 0xF1, 0xFE, 0x1F, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0,
  0x1C, 0x03, 0x80, 0x7F, 0xC7, 0xF8, 0xFF, 0x80, 0x1E, 0x3C, 0xE1, 0xC3,
  0x86, 0x0C, 0x38, 0x70, 0xC1, 0x83, 0x0E, 0x1C, 0x3C, 0x78, 0xC7, 0x39,
  0xC6, 0x31, 0x8E, 0x73, 0x8C, 0x63, 0x80, 0x1F, 0x1E, 0x06, 0x0E, 0x0E,
  0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0xF0, 0xF0, 0x06,
  0x03, 0x03, 0xC3, 0xE1, 0xB1, 0x8D, 0xC6, 0xC3, 0xE1, 0x80, 0x7F, 0xFF,
  0xEE, 0x70, 0x3D, 0xDF, 0xE7, 0x7B, 0xCE, 0xE3, 0xB8, 0xCE, 0x73, 0xBC,
  0xFF, 0x1D, 0xC0, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x3B, 0x8F, 0xF3, 0x9C,
  0xE7, 0x71, 0xDC, 0x77, 0x3D, 0xCE, 0x7F, 0xBB, 0xC0, 0x1F, 0x7F, 0x72,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE6, 0xFE, 0x7C, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x3D, 0x9F, 0xE7, 0x7B, 0x8E, 0xE3, 0xB8, 0xCE, 0x73, 0x9C, 0xFF, 0x1F,
  0xC0, 0x1F, 0x1F, 0xDC, 0xFC, 0x7F, 0xF7, 0xF3, 0x81, 0xC4, 0xFE, 0x3F,
  0x00, 0x01, 0xC0, 0x7C, 0x1F, 0x03, 0x80, 0xFC, 0x3F, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0xF8,
  0x1E, 0x00, 0x1E, 0xE7, 0xF8, 0xEF, 0x3C, 0xE7, 0x1C, 0xE3, 0x1C, 0xE3,
  0xBC, 0x7F, 0x87, 0x70, 0x1C, 0x43, 0x8F, 0xE1, 0xF8, 0x00, 0x1C, 0x07,
  0x01, 0xC0, 0xE0, 0x3B, 0x8F, 0xF3, 0xDC, 0xE7, 0x71, 0xDC, 0x77, 0x1D,
  0xCE, 0x73, 0xB8, 0xE0, 0x1C, 0x71, 0xC0, 0x38, 0xE3, 0x8E, 0x71, 0xC7,
  0x1C, 0x73, 0x80, 0x07, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E,
  0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0xF8, 0xF0, 0x1C, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x38, 0xF3, 0x9C, 0x3B, 0x83, 0xF0, 0x7E, 0x07, 0xF0,
  0x7F, 0x07, 0x78, 0x73, 0x8E, 0x3C, 0x1C, 0x71, 0xCE, 0x38, 0xE3, 0x8E,
  0x71, 0xC7, 0x1C, 0x73, 0x80, 0x3B, 0x9E, 0x3F, 0xFE, 0x3D, 0xEF, 0x39,
  0xC7, 0x71, 0xCE, 0x71, 0xCE, 0x71, 0x8E, 0x73, 0x8E, 0x73, 0x8E, 0xE3,
  0x9C, 0x3B, 0x8F, 0xF3, 0xDC, 0xE7, 0x71, 0xDC, 0x77, 0x1D, 0xCE, 0x73,
  0xB8, 0xE0, 0x1E, 0x3F, 0x9C, 0xFC, 0x7E, 0x3F, 0x1F, 0x9F, 0xCE, 0xFE,
  0x3E, 0x00, 0x1D, 0xC3, 0xFC, 0x73, 0x8E, 0x73, 0x8E, 0x71, 0xCE, 0x79,
  0xCE, 0x3F, 0xCE, 0xF1, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x00, 0x3D, 0xDF,
  0xE7, 0x7B, 0x8E, 0xE3, 0xB8, 0xCE, 0x73, 0x9C, 0xFF, 0x1D, 0xC0, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0x3B, 0x3F, 0x3F, 0x38, 0x78, 0x70, 0x70, 0x70,
  0x70, 0xE0, 0x1F, 0x3F, 0x71, 0x78, 0x3C, 0x1E, 0x0F, 0x8E, 0xFE, 0xFC,
  0x18, 0x71, 0xFF, 0xF7, 0x0E, 0x1C, 0x70, 0xE1, 0xCB, 0xE3, 0xC0, 0x71,
  0xDC, 0xE7, 0x39, 0xCE, 0xE3, 0xB8, 0xEE, 0x73, 0xBC, 0xFF, 0x1D, 0xC0,
  0xE3, 0xF8, 0xEE, 0x73, 0x9C, 0xEE, 0x1B, 0x87, 0xC1, 0xF0, 0x78, 0x1C,
  0x00, 0xE7, 0x9F, 0x9E, 0x7E, 0x7B, 0xBB, 0x6E, 0xED, 0xB3, 0xFF, 0xCF,
  0xBE, 0x3E, 0xF8, 0xF3, 0xC3, 0xCF, 0x00, 0x3C, 0xF1, 0xDE, 0x1D, 0xC0,
  0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x03, 0xB8, 0x7B, 0x8F, 0x3C, 0x38, 0xF3,
  0x8E, 0x39, 0xC3, 0x9C, 0x3B, 0x81, 0xB8, 0x1F, 0x01, 0xF0, 0x1E, 0x01,
  0xE0, 0x1C, 0x03, 0x80, 0xF8, 0x0F, 0x00, 0x3F, 0x9F, 0xD1, 0xC1, 0xC1,
  0xC1, 0xE1, 0xE0, 0xE0, 0xFE, 0x7F, 0x00, 0x07, 0x0E, 0x1C, 0x1C, 0x18,
  0x18, 0x38, 0xF0, 0xF0, 0x70, 0x30, 0x70, 0x70, 0x70, 0x78, 0x38, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x1C, 0x3C, 0x0C, 0x1C, 0x1C, 0x1D, 0x0E,
  0x1E, 0x3C, 0x38, 0x38, 0x30, 0x70, 0xF0, 0xC0, 0x70, 0xFF, 0xE7, 0xC0,
};

const GFXglyph NotoSans_ExtraBoldItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 13, 5, 0, -13 },
  { 11, 7, 5, 8, 2, -13 },
  { 16, 12, 13, 12, 0, -13 },
  { 36, 10, 15, 10, 0, -14 },
  { 55, 14, 13, 16, 1, -13 },
  { 78, 13, 13, 13, 0, -13 },
  { 100, 3, 5, 4, 2, -13 },
  { 102, 7, 16, 6, 1, -13 },
  { 116, 7, 16, 6, -1, -13 },
  { 130, 9, 9, 10, 1, -14 },
  { 141, 9, 9, 10, 1, -11 },
  { 152, 5, 4, 5, -1, -2 },
  { 155, 5, 2, 6, 0, -6 },
  { 157, 3, 3, 5, 0, -3 },
  { 159, 10, 13, 8, -1, -13 },
  { 176, 9, 13, 10, 1, -13 },
  { 191, 8, 13, 10, 1, -13 },
  { 204, 10, 13, 10, 0, -13 },
  { 221, 10, 13, 10, 0, -13 },
  { 238, 10, 13, 10, 0, -13 },
  { 255, 10, 13, 10, 0, -13 },
  { 272, 9, 13, 10, 1, -13 },
  { 287, 11, 13, 10, 0, -13 },
  { 305, 10, 13, 10, 0, -13 },
  { 322, 9, 13, 10, 1, -13 },
  { 337, 5, 10, 5, 0, -10 },
  { 344, 6, 12, 5, -1, -10 },
  { 353, 9, 9, 10, 1, -11 },
  { 364, 9, 6, 10, 1, -9 },
  { 371, 9, 9, 10, 1, -11 },
  { 382, 8, 13, 9, 1, -13 },
  { 395, 14, 15, 16, 1, -13 },
  { 422, 12, 13, 12, -1, -13 },
  { 442, 11, 13, 11, 0, -13 },
  { 460, 11, 13, 11, 1, -13 },
  { 478, 12, 13, 12, 0, -13 },
  { 498, 11, 13, 10, 0, -13 },
  { 516, 10, 13, 10, 0, -13 },
  { 533, 11, 13, 12, 1, -13 },
  { 551, 13, 13, 13, 0, -13 },
  { 573, 9, 13, 7, -1, -13 },
  { 588, 9, 17, 6, -3, -13 },
  { 608, 13, 13, 12, 0, -13 },
  { 630, 8, 13, 9, 0, -13 },
  { 643, 16, 13, 16, 0, -13 },
  { 669, 14, 13, 14, 0, -13 },
  { 692, 12, 13, 13, 1, -13 },
  { 712, 11, 13, 11, 0, -13 },
  { 730, 12, 16, 13, 1, -13 },
  { 754, 11, 13, 11, 0, -13 },
  { 772, 10, 13, 10, 0, -13 },
  { 789, 10, 13, 10, 1, -13 },
  { 806, 12, 13, 13, 1, -13 },
  { 826, 11, 13, 11, 1, -13 },
  { 844, 17, 13, 16, 1, -13 },
  { 872, 14, 13, 11, -1, -13 },
  { 895, 10, 13, 10, 2, -13 },
  { 912, 12, 13, 10, -1, -13 },
  { 932, 7, 16, 6, 0, -13 },
  { 946, 5, 13, 8, 2, -13 },
  { 955, 8, 16, 6, -1, -13 },
  { 971, 9, 9, 10, 0, -13 },
  { 982, 8, 2, 8, -2, 1 },
  { 984, 4, 3, 6, 3, -14 },
  { 986, 10, 10, 11, 1, -10 },
  { 999, 10, 14, 11, 0, -14 },
  { 1017, 8, 10, 9, 1, -10 },
  { 1027, 10, 14, 11, 1, -14 },
  { 1045, 9, 10, 10, 1, -10 },
  { 1057, 11, 18, 7, -2, -14 },
  { 1082, 11, 14, 11, 0, -10 },
  { 1102, 10, 14, 11, 0, -14 },
  { 1120, 6, 14, 6, 0, -14 },
  { 1131, 8, 18, 6, -2, -14 },
  { 1149, 12, 14, 11, 0, -14 },
  { 1170, 6, 14, 6, 0, -14 },
  { 1181, 16, 10, 16, 0, -10 },
  { 1201, 10, 10, 11, 0, -10 },
  { 1214, 9, 10, 11, 1, -10 },
  { 1226, 11, 14, 11, -1, -10 },
  { 1246, 10, 14, 11, 1, -10 },
  { 1264, 8, 10, 8, 0, -10 },
  { 1274, 8, 10, 9, 0, -10 },
  { 1284, 7, 12, 8, 1, -12 },
  { 1295, 10, 10, 11, 1, -10 },
  { 1308, 10, 10, 9, 1, -10 },
  { 1321, 14, 10, 14, 1, -10 },
  { 1339, 12, 10, 10, -1, -10 },
  { 1354, 12, 14, 10, -1, -10 },
  { 1375, 9, 10, 9, 0, -10 },
  { 1387, 8, 16, 6, 0, -13 },
  { 1403, 2, 18, 10, 4, -14 },
  { 1408, 8, 16, 6, -1, -13 },
  { 1424, 9, 3, 10, 1, -8 },
};

const GFXfont NotoSans_ExtraBoldItalic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic18pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_EXTRABOLDITALIC18PT7B_H_
