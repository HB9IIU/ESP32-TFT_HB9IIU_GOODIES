#ifndef _NOTOSANS_EXTRABOLDITALIC35PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0x7C, 0x00, 0x7E, 0x7D, 0xF1, 0xF7, 0xCF, 0x9F, 0x3E, 0x78, 0xF9,
  0xE3, 0xC7, 0x8F, 0x3E, 0x3C, 0xF1, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0xF1,
  0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x3C,
  0x00, 0x3C, 0x78, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0x1E, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x1F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF2, 0x3C,
  0x3C, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xE3, 0xC0, 0x07, 0x8F,
  0x80, 0x0F, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0xFF, 0x80, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xF0,
  0xFF, 0xBC, 0x3F, 0x30, 0x87, 0xEE, 0x00, 0xFD, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x1B, 0xF0, 0x07, 0x3E, 0x40, 0xE7, 0xCE, 0x1D, 0xF9, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xF8, 0x01, 0xFC, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x07, 0x81, 0xFE, 0x00, 0xF0, 0x3F,
  0xF0, 0x1F, 0x07, 0xFF, 0x03, 0xE0, 0x7C, 0xF0, 0x3C, 0x07, 0x8F, 0x07,
  0x80, 0xF8, 0xF0, 0xF8, 0x0F, 0x8F, 0x1F, 0x00, 0xF9, 0xF1, 0xE0, 0x0F,
  0x9F, 0x3C, 0x00, 0xF9, 0xF7, 0xCF, 0xCF, 0xFE, 0xFB, 0xFE, 0xFF, 0xCF,
  0x3F, 0xF7, 0xFD, 0xF7, 0xFF, 0x3F, 0x3E, 0x78, 0xF0, 0x07, 0xCF, 0x8F,
  0x00, 0x78, 0xF9, 0xF0, 0x0F, 0x8F, 0x1F, 0x01, 0xF0, 0xF1, 0xF0, 0x1E,
  0x0F, 0x1E, 0x03, 0xC0, 0xF3, 0xE0, 0x7C, 0x0F, 0xFE, 0x0F, 0x80, 0xFF,
  0xC0, 0xF0, 0x07, 0xF8, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xC7, 0xE0, 0x0F,
  0xC7, 0xE0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC7, 0xC0, 0x07, 0xCF, 0xC0, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0x1F, 0xF8, 0x3E, 0x3F,
  0xFC, 0x7E, 0x7F, 0xFC, 0x7E, 0xFE, 0x7E, 0xFC, 0xFC, 0x7F, 0xF8, 0xFC,
  0x3F, 0xF8, 0xFC, 0x1F, 0xF0, 0xFC, 0x1F, 0xE0, 0xFF, 0x7F, 0xE0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xF1, 0xFC, 0x7E,
  0xF9, 0xF3, 0xE7, 0x8F, 0x1E, 0x7C, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x3F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x80, 0x00, 0xF8, 0x00, 0x7C,
  0x08, 0x3E, 0x06, 0x1E, 0x03, 0xCF, 0x03, 0xFF, 0x83, 0xFF, 0xFF, 0x3F,
  0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE3, 0xFC, 0x03, 0xEF, 0x03, 0xE7, 0x80,
  0xF3, 0xE0, 0x30, 0xF8, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x1F, 0x8F, 0xC7, 0xC7,
  0xE3, 0xE1, 0xE1, 0xF0, 0xF0, 0xF8, 0x00, 0x7F, 0xEF, 0xF9, 0xFF, 0x3F,
  0xEF, 0xFC, 0x18, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xDF, 0xC7, 0xE3,
  0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD,
  0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7E, 0xFC,
  0x1F, 0xBF, 0x07, 0xEF, 0xC3, 0xF3, 0xF0, 0xFC, 0x7E, 0xFE, 0x1F, 0xFF,
  0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x01, 0xF8,
  0x0F, 0xF0, 0x7F, 0xE1, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0x3F, 0x7C, 0x79,
  0xF8, 0x43, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xFC,
  0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x38, 0x3F, 0x03, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xC7,
  0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7D, 0xFE, 0x04, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xFE,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x40, 0x0F, 0xCF, 0xCF, 0xF9,
  0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7D, 0xF0, 0x1F, 0x3E,
  0x07, 0xCF, 0xC1, 0xF1, 0xF8, 0x7E, 0x3E, 0x0F, 0x87, 0xC3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x8C, 0x03, 0xF8,
  0xFD, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0x84, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xDF,
  0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFE, 0x3F, 0x1F, 0x87,
  0xE7, 0xF0, 0x7C, 0xFC, 0x1F, 0x9F, 0x83, 0xF1, 0xF0, 0x7E, 0x3F, 0x1F,
  0xC7, 0xF7, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF0,
  0x00, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x07,
  0xFF, 0xE1, 0xF8, 0xFC, 0x3F, 0x0F, 0xC7, 0xE1, 0xF0, 0xFC, 0x3E, 0x1F,
  0x8F, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F,
  0xFC, 0x0F, 0xFF, 0xC3, 0xF1, 0xF8, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0,
  0x7E, 0x7E, 0x0F, 0xCF, 0xE3, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF,
  0xE0, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF,
  0xE7, 0xFB, 0xF3, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x0F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0x7C,
  0x7F, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x8C, 0x7F,
  0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x01, 0x03,
  0xF0, 0xFC, 0x7F, 0x1F, 0xC3, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x81, 0xF8, 0xFE, 0x3F, 0x8F, 0xE1, 0xF0, 0x00,
  0x40, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x3E, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF0,
  0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0x7E, 0x00, 0x3F, 0xC0,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x00,
  0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00,
  0x1F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xC0, 0x1F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x83,
  0xFE, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x20, 0x00, 0x00, 0x1F,
  0xF0, 0xFF, 0xF3, 0xFF, 0xF3, 0xFF, 0xE7, 0xCF, 0xEC, 0x0F, 0xC0, 0x1F,
  0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x07,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFC, 0xFF,
  0x80, 0x7E, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xC3,
  0xC1, 0xFF, 0x9F, 0x3E, 0x1F, 0xFC, 0x79, 0xE1, 0xFF, 0xE3, 0xDF, 0x1F,
  0x1E, 0x1E, 0xF1, 0xF0, 0xF0, 0xF7, 0x8F, 0x07, 0x87, 0xBC, 0x78, 0x7C,
  0x3D, 0xE7, 0xC3, 0xC3, 0xDF, 0x3E, 0x1E, 0x1E, 0xF9, 0xF1, 0xF1, 0xF3,
  0xCF, 0x8F, 0x9F, 0x1E, 0x3F, 0xFF, 0xF0, 0xF1, 0xFE, 0xFF, 0x07, 0xC7,
  0xE7, 0xF0, 0x3E, 0x08, 0x04, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x03,
  0x00, 0x1F, 0xF3, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xDF, 0x00, 0x1F, 0xBE,
  0x00, 0x3E, 0x7C, 0x00, 0xFC, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xE3, 0xE0,
  0x0F, 0x87, 0xC0, 0x3F, 0x0F, 0x80, 0x7E, 0x1F, 0x01, 0xF8, 0x3F, 0x03,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE3, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x9F, 0x80, 0x1F, 0x3F, 0x00,
  0x3E, 0xFC, 0x00, 0x7E, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xE1, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x7F, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0xFC, 0x7F, 0x07, 0xE0, 0xFC, 0x3E, 0x07,
  0xE3, 0xF0, 0x3F, 0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0x87, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F,
  0xE0, 0x30, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x02, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0x0F, 0xE0, 0xFC, 0x1F, 0x87,
  0xE0, 0x7F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0,
  0x3F, 0x3F, 0x01, 0xFC, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E,
  0x3F, 0x03, 0xF9, 0xF8, 0x1F, 0xC7, 0xE0, 0xFF, 0x1F, 0x87, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF,
  0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF,
  0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x02, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC1, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x7F, 0x80, 0xC3, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x87, 0xFE, 0xFC, 0x3F,
  0xF3, 0xF0, 0xFF, 0xCF, 0xC3, 0xFF, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xE3,
  0xF0, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x81, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0xE0,
  0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0x80,
  0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x03,
  0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03,
  0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07,
  0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x67,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x38,
  0x00, 0x00, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x0F,
  0xC1, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xC7, 0xF0, 0x0F, 0xCF, 0xE0, 0x1F,
  0x9F, 0xC0, 0x1F, 0x9F, 0x80, 0x1F, 0xBF, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xBF, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x7E,
  0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0,
  0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F,
  0xE0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x87, 0xDE, 0x07, 0xBE, 0x1F, 0x78,
  0x3F, 0xF8, 0x7D, 0xE0, 0xF7, 0xC1, 0xF7, 0x87, 0xDF, 0x07, 0xDE, 0x1E,
  0x7C, 0x3F, 0x78, 0xFB, 0xF0, 0xF9, 0xE3, 0xCF, 0xC3, 0xE7, 0x9F, 0x3E,
  0x0F, 0x9E, 0x78, 0xF8, 0x3E, 0x7B, 0xE3, 0xE1, 0xF9, 0xEF, 0x1F, 0x87,
  0xC7, 0xFC, 0x7E, 0x1F, 0x1F, 0xE1, 0xF0, 0x7C, 0x7F, 0x87, 0xC3, 0xF1,
  0xFE, 0x1F, 0x0F, 0xC7, 0xF0, 0xFC, 0x3E, 0x1F, 0xC3, 0xE0, 0xF8, 0x7E,
  0x0F, 0x80, 0x07, 0xF0, 0x07, 0xC1, 0xFC, 0x01, 0xF0, 0xFF, 0x80, 0xFC,
  0x3F, 0xE0, 0x3F, 0x0F, 0xF8, 0x0F, 0x83, 0xFF, 0x03, 0xE0, 0xFF, 0xC1,
  0xF8, 0x7D, 0xF0, 0x7E, 0x1F, 0x7E, 0x1F, 0x07, 0xDF, 0x87, 0xC1, 0xF3,
  0xE1, 0xF0, 0x7C, 0xF8, 0xFC, 0x3F, 0x3F, 0x3F, 0x0F, 0x87, 0xCF, 0x83,
  0xE1, 0xF3, 0xE0, 0xF8, 0x7E, 0xF8, 0x3E, 0x0F, 0xBE, 0x1F, 0x83, 0xFF,
  0x87, 0xC0, 0xFF, 0xC1, 0xF0, 0x3F, 0xF0, 0x7C, 0x07, 0xFC, 0x3F, 0x01,
  0xFF, 0x0F, 0xC0, 0x7F, 0x83, 0xE0, 0x0F, 0xE0, 0xF8, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC3, 0xF8, 0x3F, 0x8F, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x7F,
  0x00, 0xFE, 0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0xFE, 0xFC, 0x01,
  0xF9, 0xF8, 0x07, 0xF3, 0xF8, 0x0F, 0xC7, 0xF0, 0x3F, 0x87, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x1F, 0x1F, 0x83, 0xF1, 0xF8,
  0x3F, 0x1F, 0x87, 0xF1, 0xFB, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F,
  0xFF, 0x83, 0xFF, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xF8, 0x3F, 0x8F, 0xE0, 0x3F, 0x1F,
  0x80, 0x7E, 0x7F, 0x00, 0xFE, 0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00,
  0xFE, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xF3, 0xF8, 0x0F, 0xC7, 0xF0, 0x7F,
  0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x7F, 0x1F, 0x8F,
  0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF,
  0xE0, 0x3E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x8F, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFE, 0xFC, 0x07, 0xE0,
  0x01, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x87,
  0xE0, 0x43, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x88, 0x07, 0xE3, 0x01, 0xF8, 0xFF, 0xFE, 0x3F,
  0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x81, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x1F, 0x81, 0xF8,
  0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC,
  0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80,
  0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F,
  0x87, 0xF0, 0x7E, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xBF,
  0x00, 0xFD, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x07, 0xE3, 0xF0, 0x3F,
  0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xE1, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8,
  0xFC, 0x07, 0xC7, 0xE0, 0x3E, 0x3E, 0x01, 0xF3, 0xF0, 0x0F, 0x9F, 0x00,
  0x7D, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xF8, 0x07, 0xE0, 0x3F, 0xF8, 0x07, 0xE0, 0x3E, 0xF8, 0x0F, 0xE0, 0x7E,
  0xF8, 0x0F, 0xE0, 0x7E, 0xF8, 0x1F, 0xE0, 0xFC, 0xF8, 0x1F, 0xE0, 0xFC,
  0xF8, 0x1F, 0xE0, 0xF8, 0xF8, 0x3F, 0xE1, 0xF8, 0xF8, 0x3F, 0xE1, 0xF0,
  0xF8, 0x7F, 0xE3, 0xF0, 0xF8, 0x7B, 0xE3, 0xF0, 0xF8, 0xFB, 0xE3, 0xE0,
  0xF8, 0xFB, 0xE7, 0xE0, 0xF9, 0xF3, 0xE7, 0xC0, 0xF9, 0xF3, 0xEF, 0xC0,
  0xF9, 0xE3, 0xEF, 0x80, 0xFB, 0xE3, 0xEF, 0x80, 0xFB, 0xE3, 0xFF, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x00,
  0x7F, 0x83, 0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x03, 0xF8, 0x07,
  0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x01, 0xF9, 0xFC,
  0x00, 0x3F, 0x3F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xF1, 0xF8, 0x01,
  0xFC, 0x3F, 0x80, 0x7F, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F,
  0xE0, 0xFE, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0x7E, 0x0F,
  0xE7, 0xE0, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x3E, 0x3F, 0x03, 0xF7,
  0xE0, 0x3F, 0x7E, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x00, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xC1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F,
  0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x80, 0x03, 0xFE, 0x07,
  0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1E, 0xF0,
  0x0F, 0x3C, 0x07, 0xCF, 0x01, 0xE3, 0xC0, 0xF8, 0x78, 0x7C, 0x1E, 0x1E,
  0x07, 0x8F, 0x81, 0xF7, 0xC0, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFC, 0x7C, 0x7E, 0x3E, 0x1E, 0x0F, 0x00, 0xC0, 0x10, 0x3F,
  0x1E, 0x0F, 0xFB, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFD, 0xFE, 0x3F,
  0x0F, 0xC7, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0x87,
  0xE0, 0xF8, 0xFC, 0x1F, 0x8F, 0xE1, 0xF8, 0x7E, 0x3F, 0x87, 0xF7, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xDF, 0x01, 0xF9, 0xF0, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x20, 0x1F, 0xBF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF,
  0x0F, 0xFF, 0xE1, 0xFC, 0xFC, 0x7F, 0x1F, 0x8F, 0xC1, 0xF9, 0xF0, 0x3F,
  0x3E, 0x0F, 0xC7, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE1, 0xF8,
  0xFC, 0x3F, 0x3F, 0xDF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0x7F, 0x83,
  0xC7, 0xE0, 0x00, 0x00, 0x20, 0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xE1,
  0xFF, 0xF1, 0xFC, 0x30, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x10, 0xFE,
  0x78, 0x7F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x18, 0x7E, 0x03, 0xF3, 0xE0, 0x7F, 0xDF,
  0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xF9, 0xFE, 0x1F, 0x87, 0xE1, 0xFC,
  0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x03, 0xE1,
  0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x1F, 0xC1, 0xFD, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x01, 0xFE, 0xF8, 0x07, 0xE7, 0xC0, 0x00, 0x38, 0x00,
  0x7F, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xE3, 0xF3, 0xF0,
  0xFD, 0xF8, 0x3F, 0x7E, 0x3F, 0x9F, 0xFF, 0xE7, 0xFF, 0xF1, 0xFF, 0xF0,
  0xFF, 0x40, 0x1F, 0x00, 0x07, 0xE0, 0x11, 0xF8, 0x18, 0x7F, 0xFE, 0x0F,
  0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xC0,
  0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x02, 0x7F, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x40, 0x10, 0x3F, 0x1E, 0x0F, 0xFB, 0xE0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE3, 0xFD, 0xFE, 0x3F, 0x0F, 0xC7, 0xF0, 0xFC, 0x7E, 0x0F,
  0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0x87, 0xE0, 0xF8, 0xFC, 0x1F, 0x8F, 0xE1,
  0xF8, 0x7E, 0x3F, 0x87, 0xF7, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x01, 0xF3, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x80, 0x7E, 0x0C,
  0x1F, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x20, 0x1F, 0xBF, 0x83, 0xFF, 0xF8,
  0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFC, 0xFE, 0x7F, 0x0F, 0xCF, 0xC1, 0xF9,
  0xF8, 0x3E, 0x3F, 0x0F, 0xC7, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7,
  0xE0, 0xF8, 0xFC, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F,
  0x83, 0xE3, 0xE0, 0xFC, 0x00, 0x03, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0x7C,
  0x06, 0x00, 0x00, 0x02, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0xBF, 0xC0, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x83, 0xF8, 0xFC, 0x3F, 0x87, 0xE3, 0xF8, 0x3F, 0x3F,
  0x81, 0xF1, 0xF8, 0x1F, 0x9F, 0x80, 0xFD, 0xF8, 0x07, 0xFF, 0x80, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xF7, 0xE0,
  0x3E, 0x3F, 0x03, 0xF1, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x87, 0xE0,
  0xFC, 0x3E, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x04, 0x00,
  0x80, 0xF9, 0xFC, 0x3F, 0x87, 0xDF, 0xF3, 0xFC, 0x3F, 0xFF, 0xBF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x8F, 0xE7, 0xFC, 0xFC, 0xFE, 0x1F, 0xC7, 0xE7, 0xE0,
  0xFC, 0x3F, 0x3F, 0x07, 0xE1, 0xF9, 0xF8, 0x7E, 0x0F, 0xCF, 0x83, 0xF0,
  0x7E, 0xFC, 0x1F, 0x83, 0xE7, 0xE0, 0xFC, 0x3F, 0x3F, 0x07, 0xC1, 0xF9,
  0xF8, 0x7E, 0x0F, 0xDF, 0x83, 0xF0, 0x7E, 0xFC, 0x1F, 0x83, 0xE7, 0xE0,
  0xFC, 0x3F, 0x3F, 0x07, 0xC1, 0xF9, 0xF0, 0x7E, 0x0F, 0xC0, 0x00, 0x04,
  0x03, 0xE7, 0xF0, 0x7D, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0x9F,
  0xCF, 0xE1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xC7, 0xE1, 0xF8, 0xF8, 0x3F,
  0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x1F, 0x87, 0xE7, 0xE0, 0xFC,
  0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7C, 0x7C, 0x1F, 0x80, 0x00, 0x30,
  0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0xCF, 0xE3, 0xF3,
  0xF0, 0xFD, 0xFC, 0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xE7, 0xE1, 0xF9, 0xF9, 0xFC, 0x7F, 0xFF,
  0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x01, 0x00, 0x3E, 0x7E,
  0x01, 0xF7, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xF1, 0xF8, 0x3F,
  0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0x81, 0xF8, 0x7C, 0x1F, 0x83, 0xE0, 0xFC,
  0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x87, 0xFB,
  0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xBF, 0xC0, 0x7C, 0xFC, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x10,
  0x3F, 0x1E, 0x0F, 0xFB, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xF9, 0xFE,
  0x3F, 0x0F, 0xC7, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F,
  0x87, 0xC0, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0x7E, 0x3F, 0x87, 0xF7,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFB, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x02, 0x3E, 0x7C, 0x7D,
  0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0x8F, 0xF0, 0x1F, 0xC0, 0x3F, 0x00,
  0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x60, 0x07,
  0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x3F, 0x06, 0x3F, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFE, 0x80, 0x7E, 0xE0, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F,
  0xE0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x01, 0xFF, 0xEF, 0xFF,
  0x9F, 0xFF, 0x7F, 0xFE, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFD,
  0x83, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0x07, 0xE7,
  0xE0, 0xFC, 0xFC, 0x1F, 0x1F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F,
  0x83, 0xF3, 0xF0, 0xFC, 0x7C, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E,
  0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0xFE, 0x3F, 0xBF, 0xC7, 0xFF, 0xF8, 0xFF,
  0xDE, 0x0F, 0xF7, 0xC0, 0xFC, 0xF8, 0x00, 0xF8, 0x0F, 0xFE, 0x07, 0xFF,
  0xC1, 0xFB, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x1F, 0x8F, 0xC7, 0xE1, 0xF3,
  0xF0, 0x7C, 0xFC, 0x1F, 0x3E, 0x07, 0xDF, 0x81, 0xF7, 0xC0, 0x7F, 0xF0,
  0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xF8, 0x3F, 0x83, 0xFF, 0x83, 0xF8, 0x7E, 0xF8, 0x3F, 0x87,
  0xEF, 0x87, 0xF8, 0x7C, 0xF8, 0x7F, 0x8F, 0xCF, 0x8F, 0x78, 0xF8, 0xF8,
  0xF7, 0x9F, 0x8F, 0x8F, 0x79, 0xF0, 0xF9, 0xE7, 0xBF, 0x0F, 0x9E, 0x7B,
  0xE0, 0xFB, 0xE7, 0xBE, 0x07, 0xBC, 0x7F, 0xC0, 0x7B, 0xC7, 0xFC, 0x07,
  0xF8, 0x7F, 0xC0, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x07,
  0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFE,
  0x0F, 0xC3, 0xF8, 0x0F, 0xCF, 0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x7E, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xC7, 0xE0, 0x3F, 0x8F, 0xC0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x1F, 0x80, 0x0F, 0x80, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x1F,
  0x83, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0x80, 0x7C, 0x7E, 0x01,
  0xF1, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0x7D, 0xF8, 0x01, 0xF7,
  0xC0, 0x07, 0xDF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x09, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F,
  0xFF, 0xC0, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E,
  0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x20,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0x00,
  0x7E, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x03, 0xFC, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0x80, 0x30, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xF4, 0x01, 0xE0,
};

const GFXglyph NotoSans_ExtraBoldItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 12, 25, 10, 0, -25 },
  { 39, 14, 9, 16, 3, -25 },
  { 55, 23, 25, 23, 0, -25 },
  { 127, 19, 29, 20, 1, -27 },
  { 196, 28, 25, 31, 2, -25 },
  { 284, 24, 25, 25, 1, -25 },
  { 359, 7, 9, 9, 3, -25 },
  { 367, 14, 31, 12, 1, -25 },
  { 422, 13, 32, 12, -2, -26 },
  { 474, 17, 17, 19, 3, -27 },
  { 511, 17, 17, 20, 2, -21 },
  { 548, 9, 9, 10, -2, -4 },
  { 559, 11, 5, 11, 0, -12 },
  { 566, 7, 6, 10, 0, -6 },
  { 572, 20, 25, 16, -2, -25 },
  { 635, 18, 25, 20, 1, -25 },
  { 692, 15, 25, 20, 3, -25 },
  { 739, 20, 25, 20, -1, -25 },
  { 802, 19, 25, 20, 0, -25 },
  { 862, 19, 25, 20, 0, -25 },
  { 922, 20, 25, 20, 0, -25 },
  { 985, 19, 25, 20, 1, -25 },
  { 1045, 20, 25, 20, 1, -25 },
  { 1108, 19, 25, 20, 1, -25 },
  { 1168, 17, 25, 20, 2, -25 },
  { 1222, 10, 20, 10, 0, -20 },
  { 1247, 12, 25, 10, -2, -20 },
  { 1285, 17, 19, 20, 2, -22 },
  { 1326, 17, 11, 20, 2, -18 },
  { 1350, 17, 19, 20, 2, -22 },
  { 1391, 15, 25, 17, 3, -25 },
  { 1438, 29, 28, 31, 1, -25 },
  { 1540, 23, 25, 23, -2, -25 },
  { 1612, 21, 25, 22, 1, -25 },
  { 1678, 21, 25, 22, 2, -25 },
  { 1744, 22, 25, 24, 1, -25 },
  { 1813, 19, 25, 19, 1, -25 },
  { 1873, 19, 25, 19, 1, -25 },
  { 1933, 22, 25, 24, 2, -25 },
  { 2002, 24, 25, 25, 1, -25 },
  { 2077, 17, 25, 14, -1, -25 },
  { 2131, 19, 33, 12, -6, -25 },
  { 2210, 24, 25, 22, 1, -25 },
  { 2285, 15, 25, 18, 1, -25 },
  { 2332, 30, 25, 31, 1, -25 },
  { 2426, 26, 25, 27, 1, -25 },
  { 2508, 23, 25, 26, 2, -25 },
  { 2580, 20, 25, 22, 1, -25 },
  { 2643, 23, 31, 26, 2, -25 },
  { 2733, 20, 25, 22, 1, -25 },
  { 2796, 18, 25, 19, 1, -25 },
  { 2853, 18, 25, 19, 3, -25 },
  { 2910, 23, 25, 24, 2, -25 },
  { 2982, 21, 25, 21, 3, -25 },
  { 3048, 32, 25, 32, 3, -25 },
  { 3148, 27, 25, 22, -2, -25 },
  { 3233, 20, 25, 20, 3, -25 },
  { 3296, 22, 25, 19, -1, -25 },
  { 3365, 15, 31, 12, -1, -25 },
  { 3424, 9, 25, 16, 4, -25 },
  { 3453, 15, 31, 12, -2, -25 },
  { 3512, 18, 16, 19, 0, -25 },
  { 3548, 15, 3, 15, -3, 3 },
  { 3554, 8, 6, 12, 5, -27 },
  { 3560, 20, 20, 21, 1, -20 },
  { 3610, 19, 27, 21, 1, -27 },
  { 3675, 17, 20, 17, 1, -20 },
  { 3718, 21, 27, 21, 1, -27 },
  { 3789, 18, 20, 20, 1, -20 },
  { 3834, 21, 35, 14, -4, -27 },
  { 3926, 20, 28, 21, 1, -20 },
  { 3996, 19, 27, 21, 1, -27 },
  { 4061, 11, 27, 11, 1, -27 },
  { 4099, 16, 35, 11, -4, -27 },
  { 4169, 21, 27, 21, 1, -27 },
  { 4240, 12, 27, 11, 0, -27 },
  { 4281, 29, 20, 32, 1, -20 },
  { 4354, 19, 20, 21, 1, -20 },
  { 4402, 18, 20, 21, 1, -20 },
  { 4447, 21, 28, 21, -1, -20 },
  { 4521, 20, 28, 21, 1, -20 },
  { 4591, 15, 20, 15, 1, -20 },
  { 4629, 16, 20, 17, 0, -20 },
  { 4669, 15, 23, 15, 1, -23 },
  { 4713, 19, 19, 21, 2, -19 },
  { 4759, 18, 19, 18, 2, -19 },
  { 4802, 28, 19, 28, 2, -19 },
  { 4869, 23, 19, 19, -2, -19 },
  { 4924, 22, 27, 19, -2, -19 },
  { 4999, 18, 19, 17, -1, -19 },
  { 5042, 15, 31, 13, 0, -25 },
  { 5101, 4, 35, 20, 8, -27 },
  { 5119, 15, 31, 13, -2, -25 },
  { 5178, 17, 6, 20, 2, -15 },
};

const GFXfont NotoSans_ExtraBoldItalic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic35pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_EXTRABOLDITALIC35PT7B_H_
