#ifndef _NOTOSANS_EXTRABOLDITALIC27PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x3E, 0x1E,
  0x0F, 0x07, 0x83, 0xC0, 0x00, 0x00, 0xF0, 0xF8, 0x7C, 0x1E, 0x00, 0xFB,
  0xFC, 0xFF, 0x3B, 0x8E, 0xE7, 0xB9, 0xCE, 0x70, 0x01, 0xE7, 0x00, 0x73,
  0xC0, 0x1C, 0xE0, 0x0F, 0x38, 0x03, 0x8E, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC,
  0xFF, 0xFF, 0x07, 0x3C, 0x01, 0xCE, 0x00, 0xE3, 0x81, 0xFF, 0xFC, 0xFF,
  0xFF, 0x3F, 0xFF, 0xC1, 0xC7, 0x00, 0x73, 0xC0, 0x1C, 0xE0, 0x0F, 0x38,
  0x03, 0x9E, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x1E, 0x03, 0xFF, 0x1F, 0xFC,
  0xFF, 0xE3, 0xD8, 0x8F, 0x60, 0x3D, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xFC,
  0x03, 0xF0, 0x0F, 0xE0, 0x37, 0xA1, 0x9E, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE,
  0x1F, 0xE0, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xF8,
  0x0F, 0x1F, 0xE0, 0xF0, 0xFF, 0x07, 0x0F, 0x38, 0x70, 0x71, 0xC7, 0x83,
  0x9E, 0x78, 0x1C, 0xF3, 0x80, 0xE7, 0xB8, 0xE7, 0xFB, 0xDF, 0xBF, 0xBD,
  0xFE, 0xFD, 0xDE, 0x71, 0x1C, 0xF3, 0x81, 0xE7, 0x1C, 0x0E, 0x39, 0xE0,
  0xE1, 0xCF, 0x0F, 0x0E, 0x78, 0xF0, 0x7F, 0x87, 0x03, 0xF8, 0xF0, 0x0F,
  0x80, 0x00, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0x3C,
  0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x7F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0xF3,
  0xFC, 0x7D, 0xFF, 0x9E, 0xFB, 0xEF, 0xBC, 0x7F, 0xCF, 0x0F, 0xF3, 0xC3,
  0xF8, 0xFD, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0x7E, 0xFF, 0xBD,
  0xCE, 0x73, 0x80, 0x01, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x83, 0xC0,
  0xF0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x07, 0x80, 0x70,
  0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07,
  0x81, 0xE0, 0x78, 0x0F, 0x07, 0xC0, 0x02, 0x00, 0x1E, 0x00, 0xE0, 0xC7,
  0x07, 0xB8, 0x7F, 0xBD, 0xFF, 0xE1, 0xFF, 0x1F, 0x99, 0xFC, 0x1E, 0xF0,
  0x73, 0x81, 0x1E, 0x00, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0xF7, 0x9E, 0xF3, 0xC0, 0x7F, 0x7F, 0x7F,
  0xFF, 0x7F, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0xC0, 0x1F, 0xC0, 0xFF, 0x87,
  0xFE, 0x3E, 0x7C, 0xF1, 0xF7, 0xC7, 0xDE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1E, 0xF0, 0x7B, 0xC3, 0xEF, 0x0F, 0xBE, 0x7C, 0xFB, 0xF1,
  0xFF, 0x87, 0xFC, 0x0F, 0xE0, 0x01, 0xF0, 0x7E, 0x1F, 0xE3, 0xFE, 0xFF,
  0xE7, 0xBC, 0x73, 0xC2, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x60,
  0x03, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0x3F, 0x04, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC,
  0xFF, 0xF8, 0x00, 0xC0, 0x1F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0xC3, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x40, 0x3E, 0xF3, 0xF9, 0xFF, 0xF3,
  0xFF, 0xC3, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x77, 0x81, 0xFE, 0x07, 0xBC, 0x1E, 0x78, 0x78, 0xF0, 0xF3,
  0xE3, 0xC7, 0x9F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x07, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE1,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0x43,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xA0, 0x3E, 0x79, 0xFC, 0xFF, 0xF1,
  0xFF, 0xC1, 0xFF, 0x00, 0x00, 0x1A, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1,
  0xF8, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x60, 0x7B, 0xF0, 0xFF, 0xF3, 0xFF,
  0xE7, 0xE7, 0xCF, 0x87, 0x9F, 0x0F, 0x3E, 0x3E, 0x7C, 0x7C, 0xFD, 0xF0,
  0xFF, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xFB,
  0xFF, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x80, 0x3F, 0xC1, 0xFF, 0x87,
  0xFF, 0x3E, 0x3C, 0xF0, 0xF3, 0xC7, 0xCF, 0x9E, 0x1F, 0xF0, 0x3F, 0x81,
  0xFE, 0x1F, 0xFC, 0x78, 0xF3, 0xC3, 0xEF, 0x07, 0xBC, 0x3E, 0xF8, 0xF3,
  0xFF, 0xC7, 0xFE, 0x0F, 0xF0, 0x01, 0x80, 0x3F, 0x81, 0xFF, 0x0F, 0xFE,
  0x7C, 0x79, 0xF1, 0xF7, 0x87, 0xDE, 0x1F, 0x78, 0x7D, 0xF3, 0xF7, 0xFF,
  0x9F, 0xFE, 0x3F, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0xCF, 0xE3, 0xFF,
  0x0F, 0xF8, 0x3F, 0x80, 0x0E, 0x1F, 0x1F, 0x1E, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0xF8, 0xF8, 0xF8, 0x07, 0x07, 0xC3, 0xE1, 0xE0,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC3, 0xE1, 0xE0,
  0xF0, 0xF0, 0x78, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0x3E, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7C, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x03, 0x80,
  0x0F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x03,
  0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0x80, 0xF8, 0x03, 0x80, 0x00, 0x02, 0x03,
  0xFC, 0xFF, 0xE7, 0xFE, 0x71, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x0F, 0xC1,
  0xF8, 0x3E, 0x03, 0xC0, 0x3C, 0x04, 0x00, 0x00, 0x00, 0x00, 0x78, 0x0F,
  0x80, 0xF8, 0x0F, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0xFE, 0x3F,
  0x07, 0xC0, 0x1E, 0x3C, 0x00, 0x38, 0xE1, 0xFE, 0xF7, 0x8F, 0xF9, 0xDC,
  0x7D, 0xC7, 0x73, 0xC7, 0x1F, 0xCE, 0x1C, 0x7E, 0x38, 0xF1, 0xF9, 0xE3,
  0x8E, 0xE7, 0x8E, 0x3B, 0x8F, 0xFB, 0xCF, 0x3F, 0x7F, 0x1C, 0x79, 0xF0,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0xF0, 0x07, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xDC, 0x00,
  0xF7, 0x80, 0x7D, 0xE0, 0x1E, 0x78, 0x0F, 0x9E, 0x03, 0xC7, 0x81, 0xF1,
  0xE0, 0x78, 0x78, 0x3F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8,
  0xF8, 0x1F, 0x3C, 0x07, 0xDF, 0x01, 0xFF, 0x80, 0x7C, 0x1F, 0xFC, 0x1F,
  0xFE, 0x1F, 0xFE, 0x1E, 0x3F, 0x1E, 0x1F, 0x3E, 0x1E, 0x3E, 0x3E, 0x3F,
  0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xFC, 0x7C, 0x7C, 0x7C, 0x3C, 0x78,
  0x3C, 0x78, 0x7C, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x00,
  0x60, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xE1, 0xFC, 0xF1, 0xF8, 0x10,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x10, 0x7F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF,
  0x83, 0xCF, 0xE1, 0xE1, 0xF1, 0xF0, 0x78, 0xF8, 0x3C, 0x7C, 0x1F, 0x3C,
  0x0F, 0x1E, 0x07, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xC1, 0xF1,
  0xE1, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xE0, 0x00, 0x1F,
  0xFE, 0x3F, 0xF8, 0x7F, 0xF0, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC3, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x80, 0x1F,
  0xFE, 0x3F, 0xF8, 0x7F, 0xF0, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x04, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00,
  0x10, 0x00, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF1, 0xFC, 0x71, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xBE, 0x3F, 0x9E, 0x1F, 0xDF, 0x1F,
  0xEF, 0x8F, 0xF7, 0xC0, 0xF9, 0xE0, 0x78, 0xF8, 0x3C, 0x7F, 0xFE, 0x1F,
  0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0,
  0x7C, 0x78, 0x1E, 0x1E, 0x07, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xFF, 0xFE,
  0x3F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1E,
  0x07, 0x87, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3C, 0x0F, 0x0F, 0x03,
  0xC0, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80,
  0x7C, 0x03, 0xE0, 0x7F, 0xC7, 0xFE, 0x3F, 0xE0, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x83, 0xFE, 0x0F, 0xF0,
  0x3F, 0x80, 0xF8, 0x00, 0x1F, 0x0F, 0xE3, 0xE1, 0xF0, 0x7C, 0x7C, 0x0F,
  0x1F, 0x01, 0xE7, 0xE0, 0x7C, 0xF8, 0x0F, 0xBE, 0x01, 0xFF, 0x80, 0x3F,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0x9F, 0x00, 0xF1,
  0xF0, 0x1E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0x7C, 0x1E, 0x0F, 0x83, 0xC1,
  0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x7E, 0x3F, 0x81, 0xFC, 0x7F,
  0x03, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC7, 0xB8, 0x7F, 0x8F, 0x70,
  0xEF, 0x1E, 0xE3, 0xDE, 0x3D, 0xC7, 0x78, 0x7B, 0x9E, 0xF1, 0xE7, 0x39,
  0xE3, 0xCE, 0xF3, 0xC7, 0x9D, 0xCF, 0x8F, 0x3F, 0x9E, 0x1E, 0x7E, 0x3C,
  0x78, 0xFC, 0x78, 0xF1, 0xF0, 0xF1, 0xE3, 0xE3, 0xC3, 0xC7, 0x87, 0x80,
  0x1F, 0x80, 0xF1, 0xF8, 0x1F, 0x1F, 0xC1, 0xE1, 0xFC, 0x1E, 0x1F, 0xC1,
  0xE3, 0xDE, 0x1E, 0x3D, 0xE3, 0xE3, 0xDE, 0x3C, 0x3D, 0xF3, 0xC3, 0xCF,
  0x3C, 0x78, 0xF3, 0xC7, 0x8F, 0xFC, 0x78, 0x7F, 0x87, 0x87, 0xF8, 0x78,
  0x7F, 0x8F, 0x03, 0xF8, 0xF0, 0x3F, 0x0F, 0x03, 0xF0, 0xF0, 0x3F, 0x00,
  0x00, 0x30, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0x8F, 0x8F,
  0xC1, 0xF3, 0xE0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0x80,
  0x7D, 0xE0, 0x1F, 0xF8, 0x07, 0xBE, 0x03, 0xE7, 0x81, 0xF9, 0xF0, 0x7C,
  0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF8, 0x1F,
  0xFC, 0x1F, 0xFE, 0x1E, 0x7E, 0x1E, 0x1E, 0x3E, 0x1F, 0x3E, 0x1E, 0x3E,
  0x3E, 0x3C, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00,
  0x30, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0x8F, 0x8F, 0xC1,
  0xF3, 0xE0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0x80, 0x7D,
  0xE0, 0x1F, 0xF8, 0x0F, 0xBE, 0x03, 0xE7, 0x81, 0xF9, 0xF0, 0xFC, 0x7F,
  0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x3F, 0xF8,
  0x7F, 0xF8, 0xF1, 0xF1, 0xE1, 0xE7, 0xC3, 0xCF, 0x8F, 0x9F, 0x1F, 0x3F,
  0xFC, 0x7F, 0xF1, 0xFF, 0xC3, 0xFF, 0x87, 0xDF, 0x0F, 0x1E, 0x1E, 0x3E,
  0x7C, 0x7C, 0xF8, 0x7D, 0xE0, 0xFB, 0xC0, 0xF8, 0x00, 0x80, 0x3F, 0xE1,
  0xFF, 0xCF, 0xFE, 0x3E, 0x38, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3F, 0x00,
  0x7E, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x20, 0x7C,
  0xFF, 0xE3, 0xFF, 0x8F, 0xFC, 0x3F, 0xC0, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xC7,
  0x81, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF0, 0x3C, 0x78, 0x1E,
  0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xE3, 0xE1,
  0xF1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0xF8, 0x1F,
  0xFC, 0x0F, 0xBE, 0x0F, 0x8F, 0x07, 0xC7, 0x83, 0xC3, 0xC3, 0xE1, 0xE1,
  0xE0, 0xF1, 0xF0, 0x78, 0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x0F, 0x7C, 0x07,
  0xBC, 0x03, 0xDE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F, 0x07, 0xBE, 0x1F, 0x87,
  0xDF, 0x0F, 0xC3, 0xCF, 0x87, 0xE1, 0xE7, 0xC7, 0xF1, 0xF3, 0xE3, 0xF8,
  0xF1, 0xF3, 0xFC, 0xF8, 0x79, 0xDE, 0x78, 0x3D, 0xEF, 0x3C, 0x1C, 0xF7,
  0xBC, 0x0E, 0xF3, 0xDE, 0x07, 0x79, 0xFE, 0x03, 0xB8, 0xFF, 0x01, 0xFC,
  0x7F, 0x80, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F,
  0x07, 0xE0, 0x00, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0x80, 0xF8, 0xF8, 0x07,
  0xCF, 0x80, 0x3E, 0x7C, 0x00, 0xF7, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7D,
  0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x0F, 0x83,
  0xF0, 0x7C, 0x3F, 0x03, 0xF0, 0xF8, 0x1F, 0x78, 0x3E, 0x7C, 0x7C, 0x7C,
  0x7C, 0x3C, 0xF8, 0x3D, 0xF0, 0x3D, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xFE, 0x00,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0xF0, 0x7E, 0x0F, 0xE0,
  0xF1, 0xE3, 0xC7, 0x87, 0x0E, 0x1E, 0x3C, 0x78, 0xF1, 0xE1, 0xC3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x38, 0x78, 0xF0, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0xFC, 0x07, 0xF0, 0x1D, 0xC0, 0xE7, 0x87, 0x8E, 0x1C, 0x38, 0xF0, 0xE7,
  0x83, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0xFB, 0xE7, 0x8F, 0x1C,
  0x07, 0x9E, 0x3F, 0xBC, 0xFF, 0xF1, 0xFF, 0xE7, 0xC7, 0xCF, 0x8F, 0x9E,
  0x1F, 0x7C, 0x3C, 0xF8, 0x79, 0xF1, 0xF3, 0xE3, 0xE7, 0xEF, 0x87, 0xFF,
  0x0F, 0xFE, 0x0F, 0xBC, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0xDE, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFC,
  0x78, 0xF9, 0xF1, 0xF3, 0xC3, 0xE7, 0x87, 0xCF, 0x0F, 0x9E, 0x1E, 0x7C,
  0x7C, 0xFD, 0xF9, 0xFF, 0xE3, 0xFF, 0x8F, 0x3E, 0x00, 0x07, 0xF8, 0xFF,
  0x8F, 0xFC, 0x7F, 0xE7, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xFB, 0x87, 0xFC, 0x3F, 0xE0, 0x7F, 0x00, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x07, 0xBE,
  0x1F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78,
  0xF8, 0x78, 0xF8, 0x78, 0xF8, 0xF8, 0xF8, 0xF8, 0xFD, 0xF0, 0x7F, 0xF0,
  0x7F, 0xF0, 0x3E, 0xF0, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0x8F, 0x9F, 0x7C,
  0x7D, 0xE1, 0xE7, 0xFF, 0xBF, 0xFC, 0xFF, 0xC3, 0xE0, 0x0F, 0x80, 0x3F,
  0x08, 0x7F, 0xE1, 0xFF, 0x81, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x0F,
  0xFC, 0x0F, 0xFC, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x07, 0xCF, 0x0F, 0xEF, 0x1F, 0xFE, 0x1F, 0xFE, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3C, 0x3E, 0x7C, 0x3C, 0x7C, 0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7E,
  0xF8, 0x7F, 0xF8, 0x3F, 0x78, 0x1E, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0xC1,
  0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xDF, 0x0F, 0x7F, 0x1F, 0xFE,
  0x3F, 0xFC, 0x7C, 0x79, 0xF0, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x0F, 0x9E,
  0x1E, 0x7C, 0x3C, 0xF8, 0xF9, 0xE1, 0xF3, 0xC3, 0xEF, 0x87, 0x80, 0x03,
  0x07, 0xC3, 0xE1, 0xF0, 0x20, 0x00, 0x7C, 0x3E, 0x1F, 0x0F, 0x07, 0x87,
  0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x7C, 0x3E, 0x1E, 0x0F, 0x0F, 0x80, 0x00,
  0x60, 0x0F, 0x01, 0xF0, 0x1F, 0x00, 0x40, 0x00, 0x01, 0xE0, 0x3E, 0x03,
  0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0xFE,
  0x0F, 0xC0, 0xF8, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x3E, 0x3E, 0x3E, 0x1F, 0x3E, 0x0F,
  0x3E, 0x07, 0xBE, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x7C, 0xF0, 0x3E, 0x7C, 0x1E, 0x3E, 0x0F, 0x0F, 0x8F, 0x87,
  0xE0, 0x07, 0x83, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x7C, 0x3E, 0x1F, 0x0F,
  0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x7C, 0x3E, 0x1E, 0x0F, 0x0F,
  0x80, 0x1E, 0x7C, 0x7C, 0x3D, 0xF9, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF1, 0xF1, 0xF1, 0xE7, 0xC3, 0xC3, 0xCF, 0x8F, 0x87, 0x9F, 0x1F, 0x1F,
  0x3C, 0x3C, 0x3E, 0x78, 0x78, 0x7D, 0xF0, 0xF0, 0xF3, 0xE3, 0xE1, 0xE7,
  0x87, 0xC7, 0xCF, 0x0F, 0x0F, 0xBE, 0x1E, 0x1E, 0x00, 0x1E, 0x7C, 0x3D,
  0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xF1, 0xE7, 0xC3, 0xCF, 0x8F, 0x9F, 0x1F,
  0x3C, 0x3E, 0x78, 0x79, 0xF0, 0xF3, 0xE3, 0xE7, 0x87, 0xCF, 0x0F, 0xBE,
  0x1E, 0x00, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x8F, 0xFF, 0x7C, 0x7D, 0xF1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xEF, 0x8F, 0xBE, 0x7C, 0x7F,
  0xF1, 0xFF, 0x81, 0xF8, 0x00, 0x0F, 0x3C, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F,
  0xFF, 0x0F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1F, 0x1E, 0x1F, 0x1E, 0x1F, 0x1E,
  0x1E, 0x3E, 0x3E, 0x3F, 0x7E, 0x3F, 0xFC, 0x3F, 0xF8, 0x7D, 0xF0, 0x7C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07,
  0x9E, 0x3F, 0xBC, 0xFF, 0xF1, 0xFF, 0xE7, 0xC7, 0xCF, 0x8F, 0x9E, 0x1F,
  0x7C, 0x3C, 0xF8, 0x79, 0xF1, 0xF3, 0xE3, 0xE7, 0xEF, 0x87, 0xFF, 0x0F,
  0xFE, 0x0F, 0xFC, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x1E, 0x78, 0xF7, 0x87, 0xFC, 0x3F, 0xE1, 0xF8, 0x1F,
  0x80, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80,
  0x3C, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0xCF, 0xFC, 0x7C, 0x63, 0xC0,
  0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x79, 0x87, 0xCF,
  0xFE, 0x7F, 0xE1, 0xFE, 0x00, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF1, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0,
  0x1F, 0x43, 0xF8, 0x7F, 0x07, 0xE0, 0x3E, 0x1E, 0x7C, 0x7C, 0xF0, 0xF9,
  0xE1, 0xE7, 0xC3, 0xCF, 0x87, 0x9F, 0x1F, 0x3C, 0x3E, 0x78, 0x79, 0xF1,
  0xF3, 0xE3, 0xE7, 0xEF, 0xC7, 0xFF, 0x8F, 0xEE, 0x0F, 0xBC, 0x00, 0xF8,
  0x3F, 0xF0, 0xF9, 0xE1, 0xF3, 0xC7, 0xC7, 0x8F, 0x0F, 0x3E, 0x1E, 0x78,
  0x3D, 0xF0, 0x7B, 0xC0, 0xF7, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x00, 0xF0, 0xF8, 0xFF, 0x8F, 0xC7, 0xFC, 0x7E, 0x3D,
  0xE7, 0xF3, 0xEF, 0x3F, 0x9E, 0x79, 0xF9, 0xF3, 0xDD, 0xCF, 0x1E, 0xEE,
  0x78, 0xFF, 0x77, 0x87, 0xF3, 0xBC, 0x3F, 0x9F, 0xC1, 0xF8, 0xFE, 0x0F,
  0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x8F, 0x8F,
  0x83, 0xEF, 0x81, 0xF7, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x07,
  0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xDF, 0x03, 0xE7, 0x83,
  0xE3, 0xE3, 0xE1, 0xF0, 0x1F, 0x07, 0xC7, 0xC3, 0xE0, 0xF0, 0xF8, 0x3C,
  0x7C, 0x0F, 0x1E, 0x03, 0xCF, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x78,
  0x01, 0xDE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x0F, 0xF0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0xC7, 0xFE, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x7F, 0xF1, 0xFF, 0xCF, 0xFE, 0x00, 0x01, 0xE0, 0x7C, 0x1F, 0x83,
  0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x07, 0xC3, 0xF0, 0x78, 0x0F,
  0x80, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3E, 0x03, 0xE0,
  0x7C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0x03, 0xF0, 0x7E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78,
  0x0F, 0x01, 0xF0, 0x1F, 0x80, 0xE0, 0xFC, 0x3E, 0x07, 0x80, 0xF0, 0x3C,
  0x07, 0x80, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0x3C, 0x07, 0xFE,
  0x7F, 0xFF, 0xF9, 0xFE, 0x80, 0xF0,
};

const GFXglyph NotoSans_ExtraBoldItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 19, 8, 0, -19 },
  { 23, 10, 7, 12, 3, -19 },
  { 32, 18, 19, 17, 0, -19 },
  { 75, 14, 23, 15, 1, -21 },
  { 116, 21, 20, 24, 2, -20 },
  { 169, 18, 20, 19, 1, -20 },
  { 214, 5, 7, 7, 3, -19 },
  { 219, 10, 24, 10, 1, -20 },
  { 249, 11, 24, 10, -2, -20 },
  { 282, 13, 14, 15, 2, -21 },
  { 305, 14, 13, 16, 1, -16 },
  { 328, 6, 6, 8, -1, -3 },
  { 333, 8, 4, 9, 0, -9 },
  { 337, 5, 4, 8, 0, -4 },
  { 340, 15, 20, 12, -1, -20 },
  { 378, 14, 20, 15, 1, -20 },
  { 413, 12, 19, 15, 2, -19 },
  { 442, 16, 20, 15, -1, -20 },
  { 482, 15, 20, 15, 0, -20 },
  { 520, 15, 19, 15, 0, -19 },
  { 556, 15, 19, 15, 0, -19 },
  { 592, 15, 20, 15, 1, -20 },
  { 630, 15, 19, 15, 1, -19 },
  { 666, 14, 20, 15, 1, -20 },
  { 701, 14, 20, 15, 1, -20 },
  { 736, 8, 15, 8, 0, -15 },
  { 751, 9, 18, 8, -1, -15 },
  { 772, 14, 14, 16, 1, -17 },
  { 797, 14, 9, 16, 1, -14 },
  { 813, 14, 14, 16, 1, -17 },
  { 838, 12, 20, 13, 2, -20 },
  { 868, 22, 21, 24, 1, -19 },
  { 926, 18, 19, 18, -2, -19 },
  { 969, 16, 19, 17, 1, -19 },
  { 1007, 17, 20, 17, 1, -20 },
  { 1050, 17, 19, 18, 1, -19 },
  { 1091, 15, 19, 15, 1, -19 },
  { 1127, 15, 19, 15, 1, -19 },
  { 1163, 17, 20, 19, 1, -20 },
  { 1206, 18, 19, 19, 1, -19 },
  { 1249, 13, 19, 11, -1, -19 },
  { 1280, 14, 25, 10, -4, -19 },
  { 1324, 19, 19, 17, 1, -19 },
  { 1370, 11, 19, 14, 1, -19 },
  { 1397, 23, 19, 24, 1, -19 },
  { 1452, 20, 19, 21, 1, -19 },
  { 1500, 18, 20, 20, 1, -20 },
  { 1545, 16, 19, 17, 1, -19 },
  { 1583, 18, 25, 20, 1, -20 },
  { 1640, 15, 19, 17, 1, -19 },
  { 1676, 14, 20, 15, 1, -20 },
  { 1711, 14, 19, 15, 2, -19 },
  { 1745, 17, 19, 19, 2, -19 },
  { 1786, 17, 19, 16, 2, -19 },
  { 1827, 25, 19, 25, 2, -19 },
  { 1887, 21, 19, 17, -2, -19 },
  { 1937, 16, 19, 16, 2, -19 },
  { 1975, 17, 19, 15, -1, -19 },
  { 2016, 12, 24, 9, -1, -20 },
  { 2052, 7, 20, 12, 3, -20 },
  { 2070, 12, 24, 9, -2, -20 },
  { 2106, 14, 12, 15, 0, -19 },
  { 2127, 12, 3, 11, -2, 2 },
  { 2132, 6, 5, 9, 4, -21 },
  { 2136, 15, 15, 16, 1, -15 },
  { 2165, 15, 21, 16, 0, -21 },
  { 2205, 13, 15, 13, 1, -15 },
  { 2230, 16, 21, 16, 1, -21 },
  { 2272, 14, 15, 15, 1, -15 },
  { 2299, 16, 27, 11, -3, -21 },
  { 2353, 16, 21, 16, 0, -15 },
  { 2395, 15, 21, 17, 0, -21 },
  { 2435, 9, 21, 8, 0, -21 },
  { 2459, 12, 27, 8, -3, -21 },
  { 2500, 17, 21, 16, 0, -21 },
  { 2545, 9, 21, 8, 0, -21 },
  { 2569, 23, 15, 25, 0, -15 },
  { 2613, 15, 15, 17, 0, -15 },
  { 2642, 14, 15, 16, 1, -15 },
  { 2669, 16, 21, 16, -1, -15 },
  { 2711, 15, 21, 16, 1, -15 },
  { 2751, 13, 15, 12, 0, -15 },
  { 2776, 13, 15, 13, 0, -15 },
  { 2801, 11, 18, 12, 1, -18 },
  { 2826, 15, 15, 17, 1, -15 },
  { 2855, 15, 15, 14, 1, -15 },
  { 2884, 21, 15, 22, 2, -15 },
  { 2924, 17, 15, 15, -1, -15 },
  { 2956, 18, 21, 14, -2, -15 },
  { 3004, 14, 15, 13, -1, -15 },
  { 3031, 11, 23, 10, 0, -19 },
  { 3063, 3, 26, 15, 6, -20 },
  { 3073, 11, 23, 10, -1, -19 },
  { 3105, 14, 5, 16, 1, -12 },
};

const GFXfont NotoSans_ExtraBoldItalic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic27pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_EXTRABOLDITALIC27PT7B_H_
