#ifndef _NOTOSANS_EXTRABOLDITALIC7PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x80, 0xF0, 0x37, 0xD5, 0xEE, 0x00, 0x76, 0x6D, 0xE0, 0x6E,
  0xCD, 0xCB, 0x4C, 0x72, 0x9B, 0x6F, 0x80, 0xC0, 0x6A, 0x49, 0x80, 0x55,
  0x60, 0xCF, 0x00, 0x2F, 0x20, 0xC0, 0xC0, 0x80, 0x32, 0x44, 0x80, 0x75,
  0x9B, 0xE0, 0x79, 0x2C, 0x71, 0x24, 0xE0, 0x71, 0x63, 0xE0, 0x37, 0x6F,
  0x20, 0x74, 0x63, 0xE0, 0x74, 0xFB, 0x60, 0x73, 0x24, 0xC0, 0x75, 0x6B,
  0xE0, 0x7D, 0xF2, 0xE0, 0x42, 0x42, 0x80, 0x3C, 0x30, 0xF0, 0xF0, 0xC3,
  0xC0, 0xCF, 0x08, 0x39, 0x7B, 0x6F, 0x40, 0xC0, 0x35, 0x5F, 0x90, 0x75,
  0x6D, 0xF0, 0x7A, 0x31, 0x87, 0x00, 0x72, 0xD7, 0xAE, 0x00, 0x74, 0x7C,
  0xE0, 0x74, 0x7C, 0x80, 0x3A, 0x3F, 0xA7, 0x00, 0x4A, 0xDD, 0xA9, 0x00,
  0x69, 0x2C, 0x32, 0x22, 0x6C, 0x80, 0x5B, 0x99, 0xE9, 0x00, 0x49, 0x6E,
  0x6D, 0xB7, 0x7F, 0xA8, 0x6B, 0x5B, 0xB9, 0x00, 0x72, 0x73, 0xB7, 0x00,
  0x75, 0x7C, 0x80, 0x72, 0x73, 0xB7, 0x08, 0x75, 0x7E, 0x90, 0x74, 0x62,
  0xE0, 0xEB, 0x48, 0x4A, 0xD5, 0xA7, 0x00, 0xBA, 0xEC, 0xC0, 0xA6, 0xAE,
  0xBC, 0xB0, 0x5A, 0x98, 0xC9, 0x00, 0xBE, 0xC8, 0x80, 0x72, 0x6C, 0xE0,
  0x69, 0x49, 0x80, 0xAA, 0xC0, 0x69, 0x25, 0x00, 0x26, 0x90, 0xE0, 0xC0,
  0x7D, 0xFE, 0x47, 0x5D, 0xE0, 0x7C, 0x86, 0x17, 0x5B, 0xE0, 0x7D, 0xE6,
  0x37, 0x22, 0x64, 0xC0, 0x7D, 0xFE, 0xAC, 0x47, 0x5D, 0xB0, 0x57, 0x80,
  0x24, 0xB4, 0xB0, 0x42, 0xD9, 0xCB, 0x00, 0x57, 0x80, 0x7D, 0x5D, 0x6F,
  0x75, 0xDB, 0x6D, 0x96, 0x75, 0xDE, 0x88, 0x75, 0xBE, 0x22, 0x6B, 0x40,
  0x79, 0xF0, 0x5D, 0x6C, 0x55, 0xFE, 0xDE, 0x64, 0xB6, 0xEB, 0x94, 0x56,
  0x6A, 0xD6, 0x64, 0x48, 0x6D, 0x70, 0x69, 0x69, 0x80, 0xFE, 0x49, 0xA9,
  0x00, 0xF0,
};

const GFXglyph NotoSans_ExtraBoldItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 2, 2, 3, 1, -5 },
  { 4, 5, 5, 5, 0, -5 },
  { 8, 4, 5, 4, 0, -5 },
  { 11, 6, 5, 6, 0, -5 },
  { 15, 5, 5, 5, 0, -5 },
  { 19, 1, 2, 2, 1, -5 },
  { 20, 3, 6, 2, 0, -5 },
  { 23, 2, 6, 2, 0, -5 },
  { 25, 3, 3, 4, 1, -5 },
  { 27, 4, 3, 4, 0, -4 },
  { 29, 1, 2, 2, 0, -1 },
  { 30, 2, 1, 2, 0, -2 },
  { 31, 1, 1, 2, 0, -1 },
  { 32, 4, 5, 3, 0, -5 },
  { 35, 4, 5, 4, 0, -5 },
  { 38, 3, 5, 4, 1, -5 },
  { 40, 4, 5, 4, 0, -5 },
  { 43, 4, 5, 4, 0, -5 },
  { 46, 4, 5, 4, 0, -5 },
  { 49, 4, 5, 4, 0, -5 },
  { 52, 4, 5, 4, 0, -5 },
  { 55, 4, 5, 4, 0, -5 },
  { 58, 4, 5, 4, 0, -5 },
  { 61, 4, 5, 4, 0, -5 },
  { 64, 2, 4, 2, 0, -4 },
  { 65, 2, 5, 2, 0, -4 },
  { 67, 4, 3, 4, 0, -4 },
  { 69, 4, 3, 4, 0, -4 },
  { 71, 4, 3, 4, 0, -4 },
  { 73, 3, 5, 3, 1, -5 },
  { 75, 6, 6, 6, 0, -5 },
  { 80, 4, 5, 5, 0, -5 },
  { 83, 4, 5, 4, 0, -5 },
  { 86, 5, 5, 4, 0, -5 },
  { 90, 5, 5, 5, 0, -5 },
  { 94, 4, 5, 4, 0, -5 },
  { 97, 4, 5, 4, 0, -5 },
  { 100, 5, 5, 5, 0, -5 },
  { 104, 5, 5, 5, 0, -5 },
  { 108, 3, 5, 3, 0, -5 },
  { 110, 4, 7, 2, -1, -5 },
  { 114, 5, 5, 4, 0, -5 },
  { 118, 3, 5, 4, 0, -5 },
  { 120, 6, 5, 6, 0, -5 },
  { 124, 5, 5, 5, 0, -5 },
  { 128, 5, 5, 5, 0, -5 },
  { 132, 4, 5, 4, 0, -5 },
  { 135, 5, 6, 5, 0, -5 },
  { 139, 4, 5, 4, 0, -5 },
  { 142, 4, 5, 4, 0, -5 },
  { 145, 3, 5, 4, 1, -5 },
  { 147, 5, 5, 5, 0, -5 },
  { 151, 4, 5, 4, 1, -5 },
  { 154, 6, 5, 6, 1, -5 },
  { 158, 5, 5, 4, 0, -5 },
  { 162, 4, 5, 4, 1, -5 },
  { 165, 4, 5, 4, 0, -5 },
  { 168, 3, 6, 2, 0, -5 },
  { 171, 2, 5, 3, 1, -5 },
  { 173, 3, 6, 2, 0, -5 },
  { 176, 4, 3, 4, 0, -5 },
  { 178, 3, 1, 3, -1, 0 },
  { 179, 2, 1, 2, 1, -5 },
  { 180, 4, 4, 4, 0, -4 },
  { 182, 4, 5, 4, 0, -5 },
  { 185, 4, 4, 3, 0, -4 },
  { 187, 4, 5, 4, 0, -5 },
  { 190, 4, 4, 4, 0, -4 },
  { 192, 4, 7, 3, -1, -5 },
  { 196, 4, 6, 4, 0, -4 },
  { 199, 4, 5, 4, 0, -5 },
  { 202, 2, 5, 2, 0, -5 },
  { 204, 3, 7, 2, -1, -5 },
  { 207, 5, 5, 4, 0, -5 },
  { 211, 2, 5, 2, 0, -5 },
  { 213, 6, 4, 6, 0, -4 },
  { 216, 4, 4, 4, 0, -4 },
  { 218, 4, 4, 4, 0, -4 },
  { 220, 4, 6, 4, 0, -4 },
  { 223, 4, 6, 4, 0, -4 },
  { 226, 3, 4, 3, 0, -4 },
  { 228, 3, 4, 3, 0, -4 },
  { 230, 3, 5, 3, 0, -5 },
  { 232, 4, 4, 4, 0, -4 },
  { 234, 4, 4, 4, 0, -4 },
  { 236, 6, 4, 6, 0, -4 },
  { 239, 4, 4, 4, 0, -4 },
  { 241, 4, 6, 4, 0, -4 },
  { 244, 3, 4, 3, 0, -4 },
  { 246, 3, 6, 3, 0, -5 },
  { 249, 1, 7, 4, 1, -5 },
  { 250, 3, 6, 3, 0, -5 },
  { 253, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_ExtraBoldItalic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic7pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_EXTRABOLDITALIC7PT7B_H_
