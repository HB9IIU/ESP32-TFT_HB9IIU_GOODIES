#ifndef _NOTOSANS_EXTRABOLDITALIC68PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF, 0x0F, 0xFC, 0xFF, 0xC3, 0xFF, 0x1F,
  0xF8, 0x7F, 0xE3, 0xFF, 0x0F, 0xFC, 0x7F, 0xC1, 0xFF, 0x8F, 0xF8, 0x3F,
  0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xF8, 0x3F, 0xE1, 0xFF,
  0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC,
  0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xE0,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0x9F, 0x0F, 0x80, 0x7F, 0xF1, 0xF0, 0x18, 0x07, 0xFE, 0x1F, 0x00,
  0x00, 0x7F, 0xE3, 0xE0, 0x00, 0x07, 0xFE, 0x3E, 0x00, 0x00, 0x7F, 0xE3,
  0xE0, 0x00, 0x07, 0xFF, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0x7F, 0xF8, 0x00, 0x01, 0xF3, 0xFF, 0x80, 0x00, 0x3E,
  0x3F, 0xF8, 0x00, 0x03, 0xE1, 0xFF, 0x88, 0x00, 0x3E, 0x3F, 0xF8, 0xE0,
  0x03, 0xE3, 0xFF, 0x8F, 0xC0, 0x3E, 0x7F, 0xF0, 0xFF, 0xC7, 0xDF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x87, 0xFC,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x3F,
  0xE1, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x87, 0xF8, 0x1F, 0xC0, 0xFF,
  0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0xC3, 0xFE, 0x3F, 0xF1, 0xFF, 0x1F, 0xFF,
  0x8F, 0xF9, 0xFF, 0x8F, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xC7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF,
  0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF1, 0xFE, 0x1F, 0xF1, 0xFF, 0x0F, 0xFF, 0x0F, 0xF8, 0xFF, 0xC3, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x1F, 0xF8,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0xC1,
  0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x00,
  0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xFC, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0x87, 0xFF, 0xCF, 0xFF, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x3F, 0xFC,
  0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFD, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xCF, 0xFC, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFE, 0x1F, 0xF0, 0xFF, 0x87,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x40, 0x07, 0xF8, 0x00, 0x38, 0x03, 0xFC, 0x00, 0x1F, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x7B, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC1, 0xF8, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFD,
  0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0x00, 0x1F, 0xFE, 0x7F, 0xC0, 0x07, 0xFE,
  0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xF8, 0x00, 0x3E, 0x07, 0xFC, 0x00, 0x0F,
  0x03, 0xFF, 0x00, 0x03, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xC0, 0x0F, 0xE0, 0xFF, 0x8F, 0xFE, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0x8F, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFE, 0x3F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F,
  0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0x1F, 0xFE,
  0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0xFF, 0xF3,
  0xFF, 0xC0, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x0F,
  0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xF8,
  0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0xE7,
  0xFF, 0x00, 0x1F, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x1F,
  0xFC, 0xFF, 0xF0, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0xF0,
  0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x07, 0xFF, 0x8F,
  0xFF, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0xFF,
  0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xDF, 0xFC, 0x7F, 0xF9, 0xFF, 0x87, 0xFF, 0x3F, 0xF8,
  0x3F, 0xC3, 0xFF, 0x81, 0xF8, 0x3F, 0xF8, 0x1E, 0x07, 0xFF, 0x80, 0x80,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x80,
  0xFF, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFC, 0x0F, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0xFE, 0x00, 0x20,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x40, 0x00,
  0x01, 0xFF, 0xE3, 0x80, 0x00, 0x1F, 0xFF, 0x1F, 0x80, 0x03, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x0F,
  0xFD, 0xFF, 0xC0, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFF,
  0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x1F,
  0xF8, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0x81, 0xFF,
  0x80, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x40, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x40, 0x00, 0x07, 0xFF, 0xC3, 0x80, 0x00, 0x7F, 0xFC, 0x1F, 0x00,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x04, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x83, 0xF8, 0x00, 0x3F,
  0xF8, 0xFF, 0xF0, 0x03, 0xFF, 0x3F, 0xFF, 0x80, 0x3F, 0xF7, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xEF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xF8, 0x07, 0xFF,
  0x8F, 0xFF, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0x8F, 0xFE, 0x00,
  0x7F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xF8, 0xFF,
  0xE0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFF,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFE, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xE1, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F, 0xFC, 0x01, 0xFF, 0xE7, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xBF, 0xFE, 0x03, 0xFF, 0xE1, 0xFF,
  0xF0, 0x3F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0,
  0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0x8F,
  0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x3F,
  0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xC1,
  0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xF0, 0x0F, 0xFF, 0x3F, 0xFC,
  0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x1F, 0xFD, 0xFF,
  0xE0, 0x07, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xF7,
  0xFF, 0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x0F, 0xFF, 0x7F, 0xF8, 0x07, 0xFF,
  0xDF, 0xFE, 0x03, 0xFF, 0xF7, 0xFF, 0xC1, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFB, 0xFF, 0x03, 0xFF,
  0xFD, 0xFF, 0xC0, 0x7F, 0xFE, 0x7F, 0xF0, 0x07, 0xFE, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x02, 0x00, 0x1F, 0xFF, 0xC0, 0xFE, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF,
  0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0x03, 0xFF, 0xC7, 0xC0, 0x0F, 0xFE, 0x18,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0xE1, 0xFF, 0x1F,
  0xF0, 0x07, 0xFF, 0xFF, 0xC1, 0xFE, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFC, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xF9, 0xFE, 0x03, 0xFF, 0xFF,
  0xFC, 0x0F, 0xF3, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xEF, 0xF8, 0x1F,
  0xF8, 0x1F, 0xE0, 0x3F, 0xDF, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x7F, 0xBF,
  0xC0, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x7F, 0x81, 0xFE, 0x01, 0xFF, 0x01,
  0xFF, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xF0, 0x07,
  0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xEF, 0xF0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xDF, 0xE0, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xBF,
  0xC1, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x7F, 0x83, 0xFC, 0x03, 0xFE, 0x03,
  0xFC, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF9, 0xFE, 0x0F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xE3, 0xFC, 0x1F, 0xF0, 0x7F, 0xF0, 0xFF, 0xC7, 0xF8, 0x3F,
  0xFB, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0xFF, 0x7F, 0xFF,
  0xC0, 0x3F, 0xC0, 0x7F, 0xFC, 0x7F, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xF0,
  0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xDF, 0xF0, 0x00,
  0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xDF, 0xF0, 0x00, 0x00,
  0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x00, 0x3F,
  0xF1, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE1,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xE1, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF3,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF7, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF0,
  0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x8F,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x80, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x08,
  0x01, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x7F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x7F, 0xF0,
  0x00, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0xFF,
  0x81, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x0F,
  0xFF, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0xF8,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF1, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x03, 0xE0, 0x1F,
  0xFF, 0xC0, 0x00, 0x38, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0xC7, 0xFF, 0x80, 0x7F,
  0xFF, 0xF3, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0xFF, 0xE3, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x3F, 0xFC, 0x07,
  0xFF, 0xFF, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0xFF, 0xF8,
  0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x01, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE1,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC7,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xCF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xCF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF,
  0xBF, 0xC0, 0x03, 0xFD, 0xFF, 0x80, 0x0F, 0xFB, 0xFC, 0x00, 0x7F, 0xDF,
  0xF8, 0x01, 0xFF, 0xBF, 0xC0, 0x07, 0xFD, 0xFF, 0x80, 0x1F, 0xFB, 0xFC,
  0x00, 0xFF, 0xBF, 0xF0, 0x01, 0xFF, 0xBF, 0xC0, 0x0F, 0xFB, 0xFF, 0x00,
  0x1F, 0xFB, 0xFC, 0x01, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x3F, 0xE0, 0x1F,
  0xF3, 0xFF, 0x00, 0x3F, 0xF3, 0xFE, 0x03, 0xFE, 0x7F, 0xF0, 0x03, 0xFF,
  0x3F, 0xE0, 0x3F, 0xE7, 0xFE, 0x00, 0x3F, 0xF3, 0xFE, 0x07, 0xFC, 0x7F,
  0xE0, 0x03, 0xFF, 0x3F, 0xE0, 0x7F, 0xC7, 0xFE, 0x00, 0x7F, 0xF3, 0xFE,
  0x0F, 0xF8, 0xFF, 0xE0, 0x07, 0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xFE, 0x00,
  0x7F, 0xE3, 0xFE, 0x1F, 0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xE1, 0xFF,
  0x0F, 0xFC, 0x00, 0x7F, 0xE3, 0xFE, 0x3F, 0xE1, 0xFF, 0xC0, 0x0F, 0xFE,
  0x1F, 0xE3, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xC1, 0xFE, 0x7F, 0xC1, 0xFF,
  0x80, 0x0F, 0xFC, 0x1F, 0xE7, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFE,
  0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xEF, 0xF8, 0x3F, 0xF8, 0x01,
  0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xFF, 0xF0,
  0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x1F, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x03,
  0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x00,
  0xFF, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0x80, 0x0F,
  0xFB, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xBF, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0xF9, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x9F, 0xFC, 0x03, 0xFF,
  0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFF, 0x0F, 0xFC, 0x07,
  0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x0F, 0xFE,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x07,
  0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFF,
  0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x07,
  0xFE, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0xFF, 0xC0,
  0x0F, 0xFE, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFD, 0xFF,
  0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFD,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xF3, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF7, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF7,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xEF, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x40, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0xC0,
  0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0x00, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF3, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xF3, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF7,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF7, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xF1, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xC0,
  0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xC1, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x0F, 0xFF, 0x00,
  0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xFE,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF,
  0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0xFF, 0xF8,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x7F, 0xF0,
  0x00, 0x7F, 0xFC, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0x87, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0x80, 0x3F, 0xFC,
  0x00, 0x10, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x80, 0x00, 0x1F, 0xFE, 0x0E, 0x00, 0x01, 0xFF, 0xE0, 0xF8,
  0x00, 0x3F, 0xFC, 0x0F, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xBF, 0xF8, 0x00, 0x03, 0xFF,
  0xDF, 0xFC, 0x00, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x01, 0xFF, 0xE7, 0xFF,
  0x00, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x00, 0xFF, 0xF1, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0x00, 0x7F, 0xF8,
  0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFE,
  0x00, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00,
  0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x0F, 0xFC,
  0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x00,
  0x7F, 0xE7, 0xFF, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x1F, 0xF9,
  0xFF, 0x80, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF3,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF8, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xE3, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xC0, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x1F, 0xF7, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xDF,
  0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0xFF, 0xE0, 0x0F,
  0xFC, 0x0F, 0xF9, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xE7, 0xFC,
  0x1F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x9F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF,
  0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0x0F,
  0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xC7,
  0xFE, 0x1F, 0xF1, 0xFF, 0xC0, 0x01, 0xFF, 0x1F, 0xF0, 0x7F, 0xC7, 0xFE,
  0x00, 0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0xF3, 0xFF,
  0x07, 0xFC, 0xFF, 0xE0, 0x00, 0x7F, 0xCF, 0xF8, 0x1F, 0xF3, 0xFF, 0x00,
  0x01, 0xFF, 0x3F, 0xE0, 0x7F, 0xCF, 0xFC, 0x00, 0x07, 0xFD, 0xFF, 0x01,
  0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xF7, 0xFC, 0x07, 0xFD, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xE0, 0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xBF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF3, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFE, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFC, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF,
  0xF8, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x3F,
  0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFF, 0x00,
  0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x0F, 0xFC,
  0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x7F, 0xF8,
  0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x07,
  0xFC, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x0F, 0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x3F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0x81, 0xFF,
  0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F,
  0xF7, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF1, 0xFF, 0xE1,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0xFF, 0xC0, 0x1F, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0xFE, 0x3F, 0xE0,
  0x1F, 0xFF, 0xFB, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFF,
  0xC3, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xF0,
  0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x01, 0xFF, 0xC3,
  0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x07,
  0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x01, 0xFF, 0x83, 0xFF,
  0xC0, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF,
  0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFB, 0xFF, 0x00, 0x3F,
  0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xF8, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFC,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x87, 0xF0, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xCF, 0xFF,
  0x80, 0x0F, 0xFE, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0x3F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F,
  0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x3F,
  0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFE,
  0x00, 0x7F, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xFC,
  0x3F, 0xF8, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xFC, 0x3F,
  0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xFF, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xCF, 0xFF, 0xF8, 0x03, 0xFE, 0x7F, 0xFF, 0x80, 0x3F, 0xE1, 0xFF,
  0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0x83, 0xE0, 0x7F, 0xFC, 0x00, 0x41, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x06,
  0x0F, 0xFF, 0x80, 0x3C, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xFF,
  0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xC7, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0x80,
  0x7F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xEF, 0xFC,
  0x00, 0x1F, 0xFF, 0xEF, 0xF8, 0x00, 0x0F, 0xFF, 0x8F, 0xF8, 0x00, 0x03,
  0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xC3,
  0xFF, 0xC0, 0x7F, 0xF1, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0x07, 0xFF,
  0x3F, 0xFC, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x7F,
  0xF9, 0xFF, 0xE0, 0x7F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x20, 0xFF, 0xF8, 0x00, 0x30,
  0x1F, 0xFF, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x02, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x20, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xFE, 0x1F, 0xF8, 0x01,
  0xFF, 0xFE, 0x3F, 0xE0, 0x07, 0xFF, 0xFE, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xE3, 0xFF, 0xF0, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x01,
  0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00,
  0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xC0,
  0xFF, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0xC0,
  0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xDF, 0xFC, 0x00, 0x3F,
  0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x00, 0x3F, 0xE1, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x06, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0x80, 0x0F, 0xFF, 0x80, 0x1F,
  0xFD, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x83, 0xF8, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0xFF,
  0xCF, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0x03,
  0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0x83, 0xFF,
  0xC0, 0x1F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFF,
  0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x80,
  0x1F, 0xFC, 0x3F, 0xFC, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x3F,
  0xFC, 0x3F, 0xFC, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xFC,
  0x3F, 0xFC, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xFC, 0x3F,
  0xFC, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x81, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x08, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0x7F, 0xF1, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x9F, 0xFE, 0x00, 0x00, 0x7F,
  0xF7, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF9,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x83, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x1F,
  0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xF8,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x07, 0xFE, 0x7F, 0xFF, 0x83, 0xFF, 0xFC,
  0x01, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x80, 0x7F, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE0, 0x1F, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF,
  0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x83, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F,
  0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F,
  0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F,
  0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xE3, 0xFF, 0xF0, 0x03, 0xFF, 0x3F,
  0xFF, 0xC0, 0x1F, 0xF3, 0xFF, 0xFF, 0x00, 0xFF, 0xBF, 0xFF, 0xF8, 0x07,
  0xFD, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFE, 0x07, 0xFF,
  0xC0, 0x7F, 0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFC,
  0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00,
  0x7F, 0xF8, 0x7F, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x7F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x7F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x7F,
  0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F,
  0xFC, 0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x1F, 0xFE,
  0x7F, 0xF8, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x0F,
  0xFF, 0x7F, 0xF8, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x3F, 0xFB, 0xFF, 0xC0,
  0x07, 0xFF, 0x7F, 0xF8, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x3F, 0xFD, 0xFF,
  0xE0, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x1F, 0xFC,
  0xFF, 0xE0, 0x07, 0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x3F,
  0xFC, 0x7F, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF8,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xF0, 0xFF, 0xE0, 0x00, 0x1F, 0xF3, 0xFF, 0xF0, 0x00, 0x3F, 0xE7,
  0xFF, 0xF8, 0x00, 0x3F, 0xEF, 0xFF, 0xFC, 0x00, 0x3F, 0xEF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x1F,
  0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0xFF,
  0x00, 0x0F, 0xFC, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xFC, 0x00, 0x1F,
  0xFC, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x07, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xC0, 0x1F, 0xFF,
  0xC7, 0xFC, 0x01, 0xFF, 0xFF, 0x3F, 0xE0, 0x1F, 0xFF, 0xFB, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x3F, 0xFF, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x1F, 0xFC,
  0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFF, 0x00,
  0x3F, 0xF8, 0x7F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFC, 0x1F,
  0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x3F,
  0xF8, 0x7F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF8,
  0x3F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0x7F, 0xFF, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF7, 0xFF, 0x00, 0x3F, 0xFF, 0x3F, 0xF0, 0x00, 0xFF,
  0xF3, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x01, 0xC0, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC,
  0xFF, 0xE0, 0x1F, 0xFB, 0xFF, 0xC0, 0x3F, 0xF7, 0xFF, 0x80, 0x7F, 0xDF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x03,
  0xF0, 0x1F, 0xFC, 0x01, 0xE0, 0x3F, 0xF8, 0x00, 0x80, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC4, 0x00,
  0x07, 0xFF, 0x0E, 0x00, 0x0F, 0xFE, 0x1F, 0x00, 0x7F, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x04, 0x07,
  0xFF, 0xDF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xFC,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xE0,
  0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x7F, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x1F,
  0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF7, 0xFE, 0x00, 0xFF,
  0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0xFC, 0x7F, 0xC0, 0x03, 0xFF, 0xE1, 0xFF,
  0x00, 0x07, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x9F, 0xFC, 0x00, 0x7F,
  0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xF8,
  0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x7F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x07,
  0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0x1F,
  0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x07, 0xFC,
  0x3F, 0xF8, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x01, 0xFF, 0x9F, 0xFC, 0x00,
  0x0F, 0xFD, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xBF,
  0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F,
  0xF3, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0xF8,
  0x0F, 0xFE, 0x3F, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xC0, 0x7F,
  0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x01, 0xFD, 0xFE, 0x07, 0xFF, 0x0F, 0xFC,
  0x0F, 0xF7, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xDF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xC1, 0xFE, 0x7F, 0x07, 0xFF, 0x01, 0xFF, 0x07, 0xF9, 0xFC, 0x1F,
  0xFC, 0x07, 0xFC, 0x1F, 0xE7, 0xF0, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0x3F,
  0xC3, 0xFF, 0x80, 0x7F, 0xC3, 0xFC, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x1F,
  0xF3, 0xFC, 0x7F, 0xF0, 0x07, 0xFC, 0x7F, 0x8F, 0xF1, 0xFF, 0x80, 0x1F,
  0xF1, 0xFE, 0x3F, 0xC7, 0xFE, 0x00, 0x7F, 0xCF, 0xF0, 0xFF, 0x3F, 0xF0,
  0x01, 0xFF, 0x3F, 0xC3, 0xFC, 0xFF, 0xC0, 0x07, 0xFC, 0xFF, 0x0F, 0xF7,
  0xFE, 0x00, 0x1F, 0xF7, 0xF8, 0x3F, 0xDF, 0xF8, 0x00, 0x7F, 0xDF, 0xE0,
  0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x7F, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFB, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xDF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE7,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF1,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF3, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF7, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x47, 0xFF, 0xE0, 0x00, 0x33, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xCC, 0x00, 0x07, 0xFF, 0xE2, 0x00, 0x00, 0x3F,
  0xE0,
};

const GFXglyph NotoSans_ExtraBoldItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 21, 50, 20, 1, -49 },
  { 133, 27, 18, 31, 6, -49 },
  { 194, 44, 49, 44, 1, -49 },
  { 464, 36, 56, 38, 2, -52 },
  { 716, 54, 50, 61, 4, -49 },
  { 1054, 47, 50, 49, 1, -49 },
  { 1348, 13, 18, 17, 6, -49 },
  { 1378, 27, 60, 24, 2, -49 },
  { 1581, 27, 61, 24, -5, -50 },
  { 1787, 33, 33, 37, 5, -52 },
  { 1924, 34, 33, 39, 3, -41 },
  { 2065, 17, 17, 20, -3, -8 },
  { 2102, 20, 9, 22, 1, -23 },
  { 2125, 13, 12, 20, 0, -11 },
  { 2145, 38, 50, 30, -3, -49 },
  { 2383, 36, 50, 38, 2, -49 },
  { 2608, 28, 49, 38, 6, -49 },
  { 2780, 39, 49, 38, -2, -49 },
  { 3019, 37, 50, 38, 0, -49 },
  { 3251, 39, 49, 38, -1, -49 },
  { 3490, 37, 50, 38, 1, -49 },
  { 3722, 36, 50, 38, 3, -49 },
  { 3947, 39, 49, 38, 2, -49 },
  { 4186, 36, 50, 38, 2, -49 },
  { 4411, 34, 50, 38, 3, -49 },
  { 4624, 19, 39, 20, 0, -38 },
  { 4717, 23, 47, 20, -4, -38 },
  { 4853, 34, 37, 39, 3, -43 },
  { 5011, 34, 22, 39, 3, -35 },
  { 5105, 34, 37, 39, 3, -43 },
  { 5263, 29, 50, 32, 5, -49 },
  { 5445, 55, 55, 60, 3, -49 },
  { 5824, 44, 49, 44, -4, -49 },
  { 6094, 41, 49, 43, 1, -49 },
  { 6346, 41, 50, 42, 4, -49 },
  { 6603, 43, 49, 46, 1, -49 },
  { 6867, 39, 49, 38, 1, -49 },
  { 7106, 39, 49, 37, 1, -49 },
  { 7345, 42, 50, 47, 4, -49 },
  { 7608, 47, 49, 48, 1, -49 },
  { 7896, 33, 49, 27, -2, -49 },
  { 8099, 35, 64, 24, -11, -49 },
  { 8379, 48, 49, 43, 1, -49 },
  { 8673, 30, 49, 36, 1, -49 },
  { 8857, 60, 49, 61, 1, -49 },
  { 9225, 52, 49, 53, 1, -49 },
  { 9544, 44, 50, 50, 4, -49 },
  { 9819, 41, 49, 42, 1, -49 },
  { 10071, 44, 61, 50, 4, -49 },
  { 10407, 40, 49, 43, 1, -49 },
  { 10652, 36, 50, 37, 1, -49 },
  { 10877, 36, 49, 37, 5, -49 },
  { 11098, 44, 50, 47, 4, -49 },
  { 11373, 41, 49, 41, 6, -49 },
  { 11625, 62, 49, 62, 6, -49 },
  { 12005, 52, 49, 43, -4, -49 },
  { 12324, 40, 49, 40, 6, -49 },
  { 12569, 43, 49, 37, -3, -49 },
  { 12833, 30, 60, 23, -2, -49 },
  { 13058, 18, 50, 30, 7, -49 },
  { 13171, 29, 60, 23, -4, -49 },
  { 13389, 35, 32, 37, 1, -49 },
  { 13529, 30, 7, 29, -6, 5 },
  { 13556, 15, 11, 23, 10, -52 },
  { 13577, 37, 39, 41, 3, -38 },
  { 13758, 37, 53, 41, 1, -52 },
  { 14004, 31, 39, 34, 3, -38 },
  { 14156, 40, 53, 41, 3, -52 },
  { 14421, 34, 39, 39, 3, -38 },
  { 14587, 41, 68, 27, -7, -52 },
  { 14936, 39, 54, 41, 1, -38 },
  { 15200, 37, 52, 42, 1, -52 },
  { 15441, 22, 52, 21, 1, -52 },
  { 15584, 32, 68, 21, -9, -52 },
  { 15856, 43, 52, 40, 1, -52 },
  { 16136, 22, 52, 21, 1, -52 },
  { 16279, 58, 38, 62, 1, -38 },
  { 16555, 37, 38, 42, 1, -38 },
  { 16731, 35, 39, 40, 3, -38 },
  { 16902, 40, 54, 41, -2, -38 },
  { 17172, 37, 54, 41, 3, -38 },
  { 17422, 31, 38, 29, 1, -38 },
  { 17570, 31, 39, 33, 1, -38 },
  { 17722, 27, 46, 29, 3, -45 },
  { 17878, 38, 38, 42, 3, -37 },
  { 18059, 37, 37, 36, 3, -37 },
  { 18231, 54, 37, 55, 4, -37 },
  { 18481, 45, 37, 37, -4, -37 },
  { 18690, 44, 53, 36, -4, -37 },
  { 18982, 34, 37, 32, -1, -37 },
  { 19140, 29, 60, 24, 0, -49 },
  { 19358, 8, 66, 38, 15, -51 },
  { 19424, 29, 60, 24, -4, -49 },
  { 19642, 34, 12, 39, 3, -30 },
};

const GFXfont NotoSans_ExtraBoldItalic68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic68pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_EXTRABOLDITALIC68PT7B_H_
