#ifndef _NOTOSANS_EXTRABOLDITALIC34PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C,
  0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x00,
  0x00, 0x00, 0x20, 0x3E, 0x07, 0xE1, 0xFC, 0x3F, 0x03, 0xE0, 0x7C, 0xFB,
  0xE7, 0xDF, 0x3E, 0xF1, 0xE7, 0x8F, 0x3C, 0x7B, 0xE7, 0xDE, 0x3C, 0xF1,
  0xE0, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x78,
  0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x81, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7,
  0x80, 0x1E, 0x3C, 0x27, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF2,
  0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0x78,
  0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x9F, 0x00, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x0F, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF8, 0x7D,
  0xC6, 0x3F, 0x70, 0x0F, 0xDC, 0x03, 0xF6, 0x00, 0x7F, 0x80, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x77, 0xC0,
  0x1D, 0xF3, 0x06, 0x7C, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF,
  0xE0, 0x0F, 0xC0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0x83, 0xF8, 0x01, 0xE0, 0xFF, 0x80, 0x78, 0x1F, 0xF8, 0x1F, 0x07,
  0xDF, 0x03, 0xC0, 0xF1, 0xE0, 0xF0, 0x3E, 0x3C, 0x3C, 0x07, 0xCF, 0x8F,
  0x80, 0xF1, 0xF1, 0xE0, 0x1E, 0x3E, 0x78, 0x03, 0xC7, 0x9E, 0x3E, 0x7D,
  0xF7, 0xDF, 0xEF, 0xFC, 0xF7, 0xFE, 0xFF, 0xBC, 0xFF, 0xDF, 0xEF, 0xBE,
  0x78, 0x63, 0xE7, 0x8F, 0x00, 0x79, 0xF1, 0xE0, 0x1E, 0x3E, 0x3C, 0x07,
  0xC7, 0xCF, 0x81, 0xF0, 0xF9, 0xF0, 0x3C, 0x1F, 0x3C, 0x0F, 0x03, 0xEF,
  0x83, 0xE0, 0x7F, 0xE0, 0xF8, 0x07, 0xFC, 0x3E, 0x00, 0x7E, 0x00, 0x00,
  0x3C, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7E,
  0xFC, 0x01, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0xCF,
  0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x87,
  0xE7, 0xFF, 0x0F, 0x9F, 0xFF, 0x3F, 0x7F, 0x7E, 0x7E, 0xFC, 0x7F, 0xF9,
  0xF8, 0x7F, 0xE3, 0xF0, 0xFF, 0xC7, 0xE0, 0xFF, 0x0F, 0xE3, 0xFC, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xF3, 0xF8, 0x7D,
  0xF7, 0xDE, 0x79, 0xEF, 0xBC, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80,
  0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xC0, 0x01, 0xF0,
  0x01, 0xE0, 0x41, 0xE0, 0x71, 0xE0, 0xFD, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xE1, 0x3F, 0xE0, 0x7C, 0xF0, 0x7C, 0xF0,
  0x18, 0xF8, 0x08, 0xF8, 0x00, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x1F, 0x8F, 0x87, 0xC7, 0xC3, 0xE1, 0xE1, 0xF1, 0xF0, 0x7F,
  0xDF, 0xF7, 0xFF, 0xFF, 0x10, 0xFB, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xE7, 0xE3,
  0xF0, 0xFC, 0xFC, 0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xF8,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F,
  0xBF, 0x0F, 0xCF, 0xC3, 0xF3, 0xF1, 0xFC, 0xFE, 0xFE, 0x1F, 0xFF, 0x07,
  0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x7F,
  0xC7, 0xFE, 0x3F, 0xFB, 0xFF, 0xEF, 0xFF, 0x9F, 0x7E, 0x71, 0xF0, 0x87,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07,
  0xE0, 0x00, 0x1C, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF,
  0xFE, 0x0F, 0x8F, 0xC0, 0xC1, 0xF8, 0x10, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF,
  0x80, 0x00, 0x38, 0x00, 0x7F, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x0E, 0x1F, 0x81, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x01, 0xFF,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x40, 0x0F,
  0xCF, 0x87, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xEF, 0x80, 0xFB,
  0xF0, 0x3E, 0x7E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x7C, 0x7E, 0x1F, 0x0F,
  0xC7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF2, 0x00, 0xFE, 0x7C, 0x7F, 0x8F, 0xFF, 0xF1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xA0, 0x1F, 0xF8,
  0x07, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xCF, 0x81, 0xFF, 0xF8, 0x3E, 0xFF, 0x87,
  0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0x87, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F,
  0x83, 0xF3, 0xF0, 0x7E, 0x3E, 0x1F, 0x87, 0xE7, 0xF0, 0xFF, 0xFC, 0x0F,
  0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0xF1, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xC0,
  0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0xC7, 0xE3, 0xF1, 0xF0, 0x7C, 0x7C,
  0x3F, 0x1F, 0x8F, 0x87, 0xE7, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x07, 0xF8,
  0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xF8, 0xFC, 0xFC, 0x1F, 0x3F, 0x07, 0xCF,
  0x81, 0xF3, 0xE0, 0x7C, 0xFC, 0x3F, 0x3F, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF,
  0xF0, 0x1F, 0xF0, 0x00, 0x00, 0xE0, 0x0F, 0xF8, 0x1F, 0xFE, 0x3F, 0xFE,
  0x7F, 0xFF, 0x7E, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x3F, 0xFC, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xBF,
  0x0E, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x87, 0xF8, 0xFF, 0xF0,
  0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x07, 0x83, 0xF1, 0xFC, 0x7F, 0x1F,
  0x83, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x07,
  0xC3, 0xF8, 0xFE, 0x3F, 0x07, 0xC0, 0x01, 0xE0, 0x3F, 0x07, 0xF0, 0x7F,
  0x07, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00,
  0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x00,
  0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x01,
  0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xE0,
  0x00, 0x80, 0x00, 0x03, 0x00, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFD,
  0xC3, 0xF4, 0x07, 0xC0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x01,
  0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0x1E, 0x1F, 0x07, 0xE1, 0xF3,
  0xE1, 0xFF, 0x8F, 0x3C, 0x3F, 0xF8, 0xF7, 0xC7, 0xEF, 0x8F, 0x78, 0xF8,
  0x78, 0xF7, 0x8F, 0x0F, 0x0F, 0x78, 0xF0, 0xF0, 0xF7, 0x9E, 0x0F, 0x0F,
  0xF1, 0xE1, 0xF1, 0xEF, 0x1E, 0x1E, 0x1E, 0xF1, 0xE3, 0xE3, 0xC7, 0x9F,
  0xFF, 0xFC, 0x78, 0xFF, 0xFF, 0x87, 0x87, 0xE7, 0xF0, 0x7C, 0x30, 0x38,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x10, 0x01, 0xFE, 0x3F, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x3F, 0x3C, 0x00, 0xF8, 0xF8, 0x07,
  0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x83,
  0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x8F, 0xC0, 0x3F, 0x3F, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0,
  0x0F, 0xFF, 0x00, 0x3F, 0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x0F, 0xC7, 0xF0, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F,
  0x1F, 0x87, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFF,
  0x83, 0xFF, 0xFC, 0x3E, 0x0F, 0xC3, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0,
  0xFC, 0x7E, 0x1F, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF,
  0xFE, 0x0F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF0,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFE, 0x1E, 0x3F, 0x80, 0x43, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x10, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFD, 0xFF, 0x07, 0xC1, 0xFC, 0x7E,
  0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xC0, 0x7E,
  0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x0F, 0xC7, 0xC0,
  0x7E, 0x7E, 0x07, 0xF3, 0xF0, 0x7F, 0x1F, 0x87, 0xF8, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xE0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE1, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xF8, 0x78, 0xFF, 0x00, 0x87, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x7F, 0xEF,
  0xC3, 0xFF, 0x7E, 0x1F, 0xFB, 0xF0, 0xFF, 0x9F, 0x8F, 0xFC, 0xFC, 0x07,
  0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF1, 0xFC, 0x0F, 0x87, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0xE0,
  0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xE0, 0xFC, 0x0F,
  0xC1, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xF8,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC,
  0x07, 0xC1, 0xF8, 0x1F, 0x83, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80,
  0xFC, 0x3F, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0x83,
  0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x27, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x07,
  0xFC, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0xFF, 0x0F, 0xC1, 0xFC, 0x0F, 0xC1,
  0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC7, 0xF0, 0x0F, 0x8F, 0xE0, 0x1F, 0x9F,
  0xC0, 0x1F, 0x9F, 0x80, 0x1F, 0xBF, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3E, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F,
  0x80, 0x7C, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F,
  0xFE, 0x07, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0xFF,
  0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1,
  0xF7, 0x83, 0xFF, 0x07, 0xDE, 0x0F, 0x7C, 0x1F, 0x78, 0x7D, 0xF0, 0x7D,
  0xE1, 0xEF, 0x81, 0xF7, 0x8F, 0xBE, 0x0F, 0x9E, 0x3C, 0xF8, 0x3E, 0x78,
  0xF3, 0xE0, 0xF9, 0xE7, 0x9F, 0x83, 0xE7, 0x9E, 0x7C, 0x0F, 0x9E, 0xF9,
  0xF0, 0x7C, 0x7B, 0xC7, 0xC1, 0xF1, 0xFF, 0x1F, 0x07, 0xC7, 0xF8, 0xFC,
  0x1F, 0x1F, 0xE3, 0xE0, 0xFC, 0x7F, 0x0F, 0x83, 0xE1, 0xFC, 0x3E, 0x0F,
  0x87, 0xE0, 0xF8, 0x3E, 0x1F, 0x87, 0xC0, 0x07, 0xF0, 0x0F, 0x87, 0xF8,
  0x07, 0xC3, 0xFC, 0x03, 0xE1, 0xFF, 0x03, 0xF0, 0xFF, 0x81, 0xF0, 0x7F,
  0xC0, 0xF8, 0x7F, 0xF0, 0x7C, 0x3E, 0xF8, 0x3E, 0x1F, 0x7C, 0x3F, 0x0F,
  0xBF, 0x1F, 0x07, 0xCF, 0x8F, 0x87, 0xC7, 0xC7, 0xC3, 0xE3, 0xE3, 0xE1,
  0xF1, 0xFB, 0xF0, 0xF8, 0x7D, 0xF0, 0x7C, 0x3E, 0xF8, 0x7C, 0x1F, 0xFC,
  0x3E, 0x07, 0xFE, 0x1F, 0x03, 0xFE, 0x0F, 0x81, 0xFF, 0x0F, 0xC0, 0x7F,
  0x87, 0xC0, 0x3F, 0xC3, 0xE0, 0x1F, 0xE1, 0xF0, 0x0F, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x7F, 0x8F, 0xE3, 0xF8, 0x1F, 0xCF, 0xC0, 0x3F, 0x7F, 0x00, 0xFD, 0xF8,
  0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0xCF,
  0xC0, 0x7F, 0x3F, 0x83, 0xF8, 0x7F, 0xBF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xCF, 0xF0, 0xF8, 0x3F, 0x1F, 0x83,
  0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x7F, 0x1F, 0x0F, 0xE3, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFE, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFF,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0x8F, 0xE3,
  0xF8, 0x1F, 0xCF, 0xC0, 0x3F, 0x7F, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F,
  0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0xCF, 0xC0, 0x7F, 0x3F,
  0x83, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x01,
  0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFC, 0xFE, 0x1F, 0x0F, 0xC7,
  0xE0, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7F, 0xFF, 0x1F,
  0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xF3, 0xF0, 0x7E,
  0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8,
  0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7F, 0x00, 0x70, 0x00, 0xFF, 0xE0, 0x7F,
  0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xE1, 0xC3, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE2, 0x01, 0xF8, 0xF9, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0,
  0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0x81, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0xFC,
  0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0x87, 0xE0, 0x7E, 0x1F, 0x01, 0xF8, 0xFC,
  0x07, 0xE3, 0xF0, 0x1F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xF8, 0x0F,
  0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87,
  0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC1,
  0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x7E, 0xF8, 0x07, 0xEF, 0xC0,
  0x7C, 0xFC, 0x0F, 0xCF, 0xC0, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF0, 0xFC,
  0x3F, 0x07, 0xC3, 0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xC0, 0x7C, 0xFC, 0x07,
  0xCF, 0x80, 0x7D, 0xF8, 0x07, 0xDF, 0x00, 0x7D, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x7F, 0xF0, 0x1F, 0x80, 0xFB, 0xE0,
  0x3F, 0x03, 0xF7, 0xC0, 0xFE, 0x07, 0xCF, 0x81, 0xFC, 0x1F, 0x9F, 0x07,
  0xF8, 0x3F, 0x3E, 0x0F, 0xF0, 0x7C, 0x7C, 0x3F, 0xE1, 0xF8, 0xF8, 0x7B,
  0xC3, 0xE1, 0xF0, 0xF7, 0x8F, 0xC3, 0xE3, 0xEF, 0x1F, 0x07, 0xC7, 0x9E,
  0x3E, 0x0F, 0x9F, 0x3C, 0xFC, 0x1F, 0x3E, 0x79, 0xF0, 0x3E, 0xF8, 0xF7,
  0xE0, 0x7D, 0xF1, 0xEF, 0x80, 0xFB, 0xC3, 0xDF, 0x01, 0xFF, 0x87, 0xFC,
  0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xE1,
  0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0xDF, 0x80, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xDF, 0x80, 0x07, 0xF7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xFC,
  0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0xFE, 0x07,
  0xF0, 0x1F, 0x83, 0xF8, 0x07, 0xF0, 0xFC, 0x07, 0xFF, 0xC0, 0xFE, 0x7C,
  0x0F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F, 0x87, 0xE3, 0xF0, 0x3E, 0x7E, 0x03,
  0xE7, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x01, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xF0, 0xF0, 0xF8, 0xF8,
  0xF8, 0xF8, 0x78, 0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x1E, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC1, 0xFF, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x3F, 0xE0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3D, 0xE0, 0x1F, 0x3C, 0x07, 0x8F,
  0x03, 0xE3, 0xC0, 0xF0, 0xF0, 0x78, 0x1E, 0x3E, 0x07, 0x8F, 0x01, 0xE7,
  0x80, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x7C,
  0x7C, 0x3E, 0x1F, 0x03, 0xE3, 0xE0, 0xFE, 0x7C, 0x3F, 0xEF, 0x0F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF3, 0xF0, 0x7C, 0x7E, 0x0F,
  0x8F, 0xC1, 0xF1, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF1, 0xF8, 0x7E,
  0x1F, 0x9F, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFB, 0xC0, 0x7E, 0xF8,
  0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x78, 0x1F, 0xFF, 0x07, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFF, 0x3F, 0x8F, 0xCF, 0xC3, 0xF3, 0xE0, 0xFC, 0xF8,
  0x3F, 0x3E, 0x0F, 0xDF, 0x83, 0xF7, 0xE1, 0xF9, 0xF0, 0x7E, 0x7E, 0x3F,
  0xBF, 0x9F, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3C, 0x7E, 0x00,
  0x01, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0x02,
  0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x04, 0x7F, 0x38, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x0F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x3E, 0x7E, 0x07, 0xF7,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x7E, 0x0F, 0x87, 0xE0, 0xF8, 0x7C, 0x0F, 0x87, 0xC1, 0xF8, 0xFC,
  0x1F, 0x8F, 0xC1, 0xF0, 0xFC, 0x3F, 0x07, 0xE7, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xE0, 0x3F, 0xDE, 0x01, 0xF9, 0xE0, 0x00, 0xFC, 0x01, 0xFF, 0xC0,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x8F, 0x8F, 0xC3, 0xF7, 0xE0, 0xF9, 0xF8,
  0x7E, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x61, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x80,
  0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x03, 0xFB, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x6F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0xFE,
  0x7C, 0x3F, 0xEF, 0x8F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3,
  0xF3, 0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF0, 0x7E, 0x7E, 0x0F,
  0xCF, 0xC1, 0xF1, 0xF8, 0x7E, 0x1F, 0x9F, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF,
  0x07, 0xF7, 0xC0, 0x7C, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE1, 0x01, 0xF8,
  0x38, 0x7F, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x7C, 0x1F, 0xFF, 0x87, 0xFF, 0xF1,
  0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0x8F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xF8,
  0x3F, 0x3E, 0x0F, 0xDF, 0x83, 0xE7, 0xE0, 0xF9, 0xF8, 0x7E, 0x7C, 0x1F,
  0xBF, 0x07, 0xEF, 0xC1, 0xF3, 0xF0, 0xFC, 0xF8, 0x3F, 0x3E, 0x0F, 0xC0,
  0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x07, 0x80, 0x00, 0x00, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0xBF, 0x80, 0xFF, 0x80, 0xFF,
  0x00, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x7F, 0x1F, 0x87, 0xF0, 0xFC, 0x7F, 0x07, 0xC7, 0xF0, 0x3E, 0x3F,
  0x03, 0xF3, 0xF0, 0x1F, 0xBF, 0x00, 0xFB, 0xF0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xC7, 0xE0,
  0x7E, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xF8, 0x3F, 0x87, 0xC0,
  0xFC, 0x00, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x1F, 0x1F, 0x07, 0xC1, 0xF7, 0xF8, 0xFE,
  0x1F, 0xFF, 0x9F, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xF8,
  0xFE, 0x1F, 0x3F, 0x0F, 0xE1, 0xF3, 0xF0, 0xFC, 0x1F, 0x3F, 0x0F, 0xC3,
  0xF3, 0xE0, 0xFC, 0x3F, 0x7E, 0x0F, 0x83, 0xF7, 0xE1, 0xF8, 0x3E, 0x7E,
  0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x7E, 0xFC, 0x1F, 0x07, 0xEF, 0xC1, 0xF0,
  0x7E, 0xFC, 0x3F, 0x07, 0xCF, 0x83, 0xF0, 0x7C, 0xF8, 0x3F, 0x0F, 0xC0,
  0x1F, 0x1F, 0x07, 0xDF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xCF,
  0xE3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3E, 0x0F, 0xCF, 0x83, 0xF7, 0xE0,
  0xF9, 0xF8, 0x3E, 0x7E, 0x1F, 0x9F, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0x7C,
  0xFC, 0x3F, 0x3E, 0x0F, 0xCF, 0x83, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x80,
  0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xC3, 0xF7, 0xE0, 0xFD, 0xF8,
  0x3F, 0x7E, 0x0F, 0xDF, 0x03, 0xF7, 0xC0, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F,
  0x9F, 0x0F, 0xE7, 0xE7, 0xF1, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFE, 0x00,
  0xFF, 0x00, 0x07, 0xCF, 0x80, 0x7D, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xF0, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3F, 0x0F, 0x83,
  0xF0, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x7E, 0x1F, 0x07, 0xE1, 0xF8,
  0xFE, 0x3F, 0x9F, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xEF, 0xF0, 0x3E,
  0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE3,
  0xE0, 0xFF, 0x7C, 0x3F, 0xEF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7E, 0x1F,
  0x8F, 0xC3, 0xF3, 0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x7E,
  0x7E, 0x0F, 0xCF, 0xC1, 0xF1, 0xF8, 0x7E, 0x1F, 0x9F, 0xC3, 0xFF, 0xF8,
  0x7F, 0xFF, 0x07, 0xF7, 0xC0, 0x7C, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0x1F, 0x1E, 0x3E, 0xFC, 0x7D, 0xF0, 0xFF, 0xE1, 0xFF,
  0xC7, 0xFC, 0x8F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xE0, 0x00, 0x03, 0xF8, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F,
  0x0E, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0xC0, 0xFC, 0xFF, 0xFC, 0xFF,
  0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x01, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0xFC, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0xFF, 0xF8, 0x7C, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE2, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0x07,
  0xCF, 0xC3, 0xF3, 0xE0, 0xFC, 0xF8, 0x3F, 0x7E, 0x0F, 0x9F, 0x83, 0xE7,
  0xE1, 0xF9, 0xF0, 0x7E, 0x7C, 0x1F, 0xBF, 0x07, 0xCF, 0xC3, 0xF3, 0xF0,
  0xFC, 0xF8, 0x3F, 0x3E, 0x1F, 0xCF, 0xCF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE,
  0x1F, 0xEF, 0x83, 0xF3, 0xE0, 0xF8, 0x0F, 0xFE, 0x07, 0xEF, 0x81, 0xFB,
  0xE0, 0xFC, 0xF8, 0x3F, 0x3E, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3, 0xF0, 0x7C,
  0xF8, 0x1F, 0x7E, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0xF8, 0x3F, 0x07, 0xFF, 0x07, 0xE0, 0xFF, 0xE1, 0xFC, 0x1F, 0x7C, 0x3F,
  0x87, 0xEF, 0x87, 0xF0, 0xF9, 0xF1, 0xFE, 0x3F, 0x3E, 0x3F, 0xC7, 0xC7,
  0xCF, 0x79, 0xF8, 0xF9, 0xEF, 0x3E, 0x1F, 0x3D, 0xE7, 0xC3, 0xEF, 0x3D,
  0xF0, 0x7D, 0xE7, 0xBE, 0x07, 0xBC, 0xFF, 0x80, 0xFF, 0x1F, 0xF0, 0x1F,
  0xE3, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xC1, 0xFC,
  0x01, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0xFE, 0x0F, 0xC3, 0xF8, 0x1F,
  0x8F, 0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xF7, 0xE0,
  0x0F, 0xCF, 0xC0, 0x3F, 0x8F, 0xC0, 0xFE, 0x1F, 0x83, 0xF8, 0x3F, 0x80,
  0x0F, 0x80, 0xFC, 0x3E, 0x07, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0xFC, 0x0F,
  0xC3, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x01, 0xF3, 0xF0, 0x07, 0xCF,
  0xC0, 0x1F, 0x3E, 0x00, 0x7D, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x0B, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0x7C,
  0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0x80,
  0x3F, 0x80, 0xFE, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x1F, 0x80, 0x7F, 0x01,
  0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xC0, 0xFF, 0x07, 0xF8,
  0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0,
  0x1F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0x80, 0x7E,
};

const GFXglyph NotoSans_ExtraBoldItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 11, 24, 10, 0, -24 },
  { 34, 13, 9, 15, 3, -24 },
  { 49, 22, 24, 22, 0, -24 },
  { 115, 18, 28, 19, 1, -26 },
  { 178, 27, 25, 30, 2, -25 },
  { 263, 23, 25, 24, 1, -25 },
  { 335, 6, 9, 8, 3, -24 },
  { 342, 13, 30, 12, 1, -25 },
  { 391, 13, 30, 12, -2, -25 },
  { 440, 16, 17, 19, 3, -26 },
  { 474, 16, 16, 20, 2, -20 },
  { 506, 9, 8, 10, -2, -4 },
  { 515, 10, 4, 11, 0, -11 },
  { 520, 7, 6, 10, 0, -6 },
  { 526, 19, 25, 15, -2, -25 },
  { 586, 18, 25, 19, 1, -25 },
  { 643, 14, 24, 19, 3, -24 },
  { 685, 19, 25, 19, -1, -25 },
  { 745, 19, 25, 19, 0, -25 },
  { 805, 19, 24, 19, 0, -24 },
  { 862, 19, 24, 19, 0, -24 },
  { 919, 19, 25, 19, 1, -25 },
  { 979, 20, 24, 19, 1, -24 },
  { 1039, 18, 25, 19, 1, -25 },
  { 1096, 16, 25, 19, 2, -25 },
  { 1146, 10, 19, 10, 0, -19 },
  { 1170, 12, 23, 10, -2, -19 },
  { 1205, 16, 18, 20, 2, -21 },
  { 1241, 16, 11, 20, 2, -17 },
  { 1263, 16, 18, 20, 2, -21 },
  { 1299, 14, 25, 16, 3, -25 },
  { 1343, 28, 27, 30, 1, -24 },
  { 1438, 22, 24, 22, -2, -24 },
  { 1504, 20, 24, 21, 1, -24 },
  { 1564, 20, 25, 21, 2, -25 },
  { 1627, 21, 24, 23, 1, -24 },
  { 1690, 19, 24, 19, 1, -24 },
  { 1747, 19, 24, 19, 1, -24 },
  { 1804, 21, 25, 24, 2, -25 },
  { 1870, 23, 24, 24, 1, -24 },
  { 1939, 17, 24, 14, -1, -24 },
  { 1990, 17, 31, 12, -5, -24 },
  { 2056, 24, 24, 22, 1, -24 },
  { 2128, 15, 24, 18, 1, -24 },
  { 2173, 30, 24, 30, 1, -24 },
  { 2263, 25, 24, 26, 1, -24 },
  { 2338, 22, 25, 25, 2, -25 },
  { 2407, 20, 24, 21, 1, -24 },
  { 2467, 22, 31, 25, 2, -25 },
  { 2553, 19, 24, 22, 1, -24 },
  { 2610, 18, 25, 18, 1, -25 },
  { 2667, 18, 24, 18, 3, -24 },
  { 2721, 22, 24, 24, 2, -24 },
  { 2787, 20, 24, 20, 3, -24 },
  { 2847, 31, 24, 31, 3, -24 },
  { 2940, 26, 24, 22, -2, -24 },
  { 3018, 20, 24, 20, 3, -24 },
  { 3078, 21, 24, 18, -1, -24 },
  { 3141, 15, 31, 12, -1, -25 },
  { 3200, 8, 25, 15, 4, -25 },
  { 3225, 14, 31, 12, -2, -25 },
  { 3280, 18, 16, 19, 0, -24 },
  { 3316, 15, 3, 14, -3, 3 },
  { 3322, 8, 5, 11, 5, -26 },
  { 3327, 19, 19, 20, 1, -19 },
  { 3373, 18, 26, 20, 1, -26 },
  { 3432, 16, 19, 17, 1, -19 },
  { 3470, 20, 26, 20, 1, -26 },
  { 3535, 18, 19, 19, 1, -19 },
  { 3578, 21, 34, 13, -4, -26 },
  { 3668, 19, 27, 20, 1, -19 },
  { 3733, 18, 26, 21, 1, -26 },
  { 3792, 10, 26, 11, 1, -26 },
  { 3825, 16, 34, 11, -4, -26 },
  { 3893, 21, 26, 20, 1, -26 },
  { 3962, 12, 26, 11, 0, -26 },
  { 4001, 28, 19, 31, 1, -19 },
  { 4068, 18, 19, 21, 1, -19 },
  { 4111, 18, 19, 20, 1, -19 },
  { 4154, 20, 27, 20, -1, -19 },
  { 4222, 19, 27, 20, 1, -19 },
  { 4287, 15, 19, 15, 1, -19 },
  { 4323, 16, 19, 17, 0, -19 },
  { 4361, 14, 23, 15, 1, -23 },
  { 4402, 18, 19, 21, 2, -19 },
  { 4445, 18, 19, 18, 2, -19 },
  { 4488, 27, 19, 27, 2, -19 },
  { 4553, 23, 19, 19, -2, -19 },
  { 4608, 22, 27, 18, -2, -19 },
  { 4683, 18, 19, 16, -1, -19 },
  { 4726, 14, 29, 12, 0, -24 },
  { 4777, 4, 34, 19, 7, -26 },
  { 4794, 14, 29, 12, -2, -24 },
  { 4845, 16, 6, 20, 2, -15 },
};

const GFXfont NotoSans_ExtraBoldItalic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic34pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_EXTRABOLDITALIC34PT7B_H_
