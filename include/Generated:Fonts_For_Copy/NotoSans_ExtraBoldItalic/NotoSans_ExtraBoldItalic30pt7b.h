#ifndef _NOTOSANS_EXTRABOLDITALIC30PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x1F, 0x0F,
  0xC3, 0xF0, 0x78, 0x00, 0x79, 0xF7, 0x9E, 0xF9, 0xEF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xE3, 0xC0, 0x00, 0xF3, 0xC0, 0x0E, 0x38, 0x01, 0xE3, 0x80, 0x1E,
  0x78, 0x01, 0xC7, 0x83, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE0, 0x78, 0xE0, 0x07, 0x9E, 0x00, 0x71, 0xE0, 0x7F, 0xFF, 0xC7,
  0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0xE3, 0x80, 0x1E, 0x38, 0x01, 0xE7, 0x80,
  0x1C, 0x78, 0x01, 0xC7, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x70,
  0x01, 0xF0, 0x07, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x3E, 0xCE, 0x3E, 0xC0,
  0x3E, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC,
  0x01, 0xFC, 0x03, 0xBC, 0x83, 0x3C, 0xC3, 0x7C, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF0, 0x3F, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x04, 0x3F, 0x80, 0x78, 0x3F, 0xC0, 0xF0, 0x7F, 0xC0, 0xE0, 0xFB, 0xC1,
  0xE0, 0xF3, 0xC3, 0xC0, 0xF3, 0xC7, 0x80, 0xF3, 0xC7, 0x00, 0xF3, 0xCF,
  0x00, 0xF7, 0xDE, 0x7C, 0xFF, 0xBD, 0xFE, 0xFF, 0xB9, 0xFE, 0x7F, 0x7B,
  0xCF, 0x1C, 0xF3, 0xCF, 0x01, 0xE7, 0x8F, 0x01, 0xE7, 0x8F, 0x03, 0xC7,
  0x8E, 0x07, 0x87, 0x9E, 0x0F, 0x07, 0x9E, 0x0F, 0x07, 0xFC, 0x1E, 0x03,
  0xFC, 0x3C, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00,
  0xFF, 0xF0, 0x0F, 0x9F, 0x00, 0xF1, 0xF0, 0x0F, 0x1F, 0x00, 0xF3, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF1, 0xF3, 0xFE, 0x1F, 0x7F, 0xF3,
  0xEF, 0xDF, 0x3E, 0xF8, 0xFF, 0xCF, 0x8F, 0xFC, 0xF8, 0x7F, 0x8F, 0x83,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFE, 0x7E, 0x7B,
  0xFF, 0xEF, 0x7B, 0x80, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x01,
  0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F,
  0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C,
  0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x83, 0x0E, 0x07, 0x9C, 0x0F,
  0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x3F, 0x80, 0xFF, 0x83, 0xEF,
  0x01, 0x8F, 0x01, 0x1E, 0x00, 0x20, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x3E, 0x79, 0xF3, 0xCF, 0x9E, 0x3C, 0x00, 0x7F, 0xBF, 0xDF, 0xFF, 0xE0,
  0x39, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0x00, 0xE0, 0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x1F, 0x3E, 0x3E, 0x3E,
  0x3E, 0x1F, 0x7C, 0x1F, 0x7C, 0x3F, 0x7C, 0x3F, 0xFC, 0x3E, 0xF8, 0x3E,
  0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8,
  0xFF, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0xC0, 0x00, 0xF8, 0x1F, 0xC3,
  0xFE, 0x3F, 0xEF, 0xFF, 0x3F, 0xF9, 0xE7, 0xC6, 0x3E, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x01, 0xFF, 0x01,
  0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x38, 0x7C, 0x08, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xFF, 0x8F,
  0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF0, 0x00, 0xF0, 0x07, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x0F, 0x3F, 0x04, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0xC0, 0x7E, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8,
  0x7F, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0x7C, 0x0F, 0xBE, 0x0F, 0x9E, 0x07,
  0x9F, 0x07, 0x8F, 0x87, 0x87, 0xC7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE,
  0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x07,
  0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x81, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0xC0, 0x7E, 0x7F,
  0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x3E, 0x01, 0xFF,
  0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xE1, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7D, 0xF0, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFE, 0xFC, 0x7E, 0xFC, 0x3E,
  0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xFC, 0x7C, 0x7F, 0xFC, 0x7F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xE0, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x1F, 0x3E,
  0x1F, 0x3E, 0x1F, 0x1E, 0x3E, 0x1F, 0x7E, 0x1F, 0xFC, 0x0F, 0xF0, 0x1F,
  0xF0, 0x3F, 0xF8, 0x7C, 0xFC, 0xF8, 0x7C, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8,
  0x7C, 0xFD, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x1F, 0xE0, 0x01, 0xE0, 0x1F,
  0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xF7, 0xEF, 0xC7, 0xDF, 0x0F, 0xBE, 0x1F,
  0x7C, 0x3E, 0xF8, 0x7D, 0xFB, 0xFB, 0xFF, 0xF3, 0xFF, 0xE7, 0xF7, 0x83,
  0x9F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0xFC,
  0x1F, 0xE0, 0x00, 0x06, 0x0F, 0x87, 0xE3, 0xE1, 0xF0, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x83, 0xE3, 0xF1, 0xF8, 0xF8, 0x00, 0x01,
  0x80, 0xF8, 0x1F, 0x83, 0xE0, 0x7C, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0x81,
  0xF0, 0x3C, 0x0F, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3E, 0x03, 0xFC, 0x1F, 0xE1,
  0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0x3C, 0x00, 0x60, 0x00, 0x07, 0x81, 0xFF,
  0x3F, 0xFC, 0xFF, 0xF7, 0xDF, 0x90, 0x7C, 0x03, 0xE0, 0x3F, 0x03, 0xF0,
  0x7F, 0x07, 0xF0, 0x3E, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xF8, 0x03,
  0xE0, 0xF8, 0x00, 0x78, 0xF8, 0x3E, 0x3C, 0x78, 0x7F, 0xCE, 0x78, 0xFF,
  0xC7, 0xBC, 0x78, 0xE3, 0xDC, 0x78, 0xF1, 0xEE, 0x38, 0x78, 0xFF, 0x3C,
  0x38, 0x77, 0x9E, 0x1C, 0x7B, 0xCF, 0x1E, 0x3D, 0xE7, 0x9F, 0x3C, 0xF3,
  0xFF, 0xFC, 0x38, 0xFD, 0xFC, 0x1E, 0x3C, 0x7C, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x04, 0x00, 0xFC, 0x3C, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0xFC, 0x00, 0x7B, 0xC0, 0x0F, 0xBC, 0x00, 0xF3, 0xC0, 0x1F, 0x3C,
  0x01, 0xE3, 0xC0, 0x3E, 0x3E, 0x03, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0x03, 0xE3, 0xE0,
  0x1E, 0x7E, 0x01, 0xE7, 0xC0, 0x1E, 0xFC, 0x01, 0xF0, 0x0F, 0xFE, 0x07,
  0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E,
  0x7E, 0x3F, 0x3F, 0xFF, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xC7, 0xE3,
  0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x7E, 0x7C, 0x7F, 0x7F, 0xFF, 0x3F,
  0xFF, 0x1F, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xE0, 0xFF,
  0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xC0, 0x47, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x03, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF,
  0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0x0F, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C,
  0xFC, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x7E,
  0x07, 0xDF, 0x03, 0xF7, 0xC1, 0xF9, 0xF0, 0xFE, 0x7C, 0xFF, 0x3F, 0xFF,
  0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0,
  0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xF8, 0x7F, 0xF8, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0xFF,
  0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xE0, 0x27, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x87, 0xFB, 0xE1, 0xFE, 0xF8,
  0xFF, 0xBE, 0x3F, 0xEF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3F, 0x07,
  0xC7, 0xFF, 0xF1, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0x81,
  0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF1, 0xF0, 0x3F, 0x1F, 0x03, 0xE1, 0xF0,
  0x3E, 0x1F, 0x03, 0xE3, 0xF0, 0x3E, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x7E, 0x07, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F, 0x87,
  0xC0, 0xF8, 0x7C, 0x0F, 0x8F, 0x81, 0xF8, 0xF8, 0x1F, 0x0F, 0x81, 0xF0,
  0xF8, 0x1F, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x7F,
  0x81, 0xFF, 0x87, 0xFF, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF,
  0x00, 0x18, 0x00, 0x0F, 0x83, 0xF8, 0x7C, 0x3F, 0x03, 0xE3, 0xF0, 0x3E,
  0x1F, 0x01, 0xF1, 0xF8, 0x0F, 0x9F, 0x80, 0x7D, 0xF8, 0x07, 0xFF, 0x80,
  0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x80, 0x3E, 0x7E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7E, 0x07,
  0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x00, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xE0,
  0x1F, 0xC3, 0xF8, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x81, 0xFE, 0x1F,
  0xE0, 0x7F, 0x87, 0xF8, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x87, 0xBC,
  0x3F, 0xE1, 0xFF, 0x0F, 0xB8, 0xF7, 0xC3, 0xCE, 0x3D, 0xF0, 0xF3, 0x9E,
  0x78, 0x7C, 0xE7, 0x9E, 0x1F, 0x3B, 0xCF, 0x87, 0xCE, 0xF3, 0xE1, 0xE3,
  0xF8, 0xF8, 0x78, 0xFE, 0x3C, 0x3E, 0x3F, 0x0F, 0x0F, 0x8F, 0xC7, 0xC3,
  0xC3, 0xE1, 0xF0, 0xF0, 0xF8, 0x78, 0x00, 0x0F, 0xC0, 0x3C, 0x3F, 0x81,
  0xF0, 0xFE, 0x07, 0xC7, 0xF8, 0x1F, 0x1F, 0xF0, 0x78, 0x7F, 0xC3, 0xE1,
  0xEF, 0x0F, 0x8F, 0xBC, 0x3E, 0x3E, 0xF8, 0xF0, 0xFB, 0xE3, 0xC3, 0xC7,
  0x9F, 0x0F, 0x1F, 0x7C, 0x7C, 0x7D, 0xF1, 0xF0, 0xF7, 0x87, 0xC3, 0xFE,
  0x1E, 0x0F, 0xF8, 0x78, 0x1F, 0xE3, 0xE0, 0x7F, 0x8F, 0x81, 0xFC, 0x3E,
  0x07, 0xF0, 0xF0, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x7F, 0xE0, 0x3F, 0xFE,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7E, 0x0F, 0xDF, 0x80, 0xFB, 0xE0, 0x1F,
  0x7C, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x7E, 0xF8, 0x1F, 0x9F, 0x87, 0xF1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x0F, 0xFC,
  0x07, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C,
  0x3E, 0x7E, 0x1F, 0x3E, 0x1F, 0x9F, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xC7,
  0xFF, 0x83, 0xFE, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xE0,
  0x3F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7E, 0x0F, 0xDF, 0x80, 0xFB,
  0xE0, 0x1F, 0x7C, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x7E, 0xF8, 0x1F, 0x9F,
  0x87, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xF1, 0xF0, 0xF8, 0xF8,
  0x7C, 0x7C, 0x3E, 0x7E, 0x3F, 0x3E, 0x1F, 0x1F, 0xFF, 0x8F, 0xFF, 0x87,
  0xFF, 0x87, 0xFF, 0x83, 0xE7, 0xC1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7E,
  0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xEF, 0x81, 0xF0, 0x00, 0xE0, 0x0F,
  0xFC, 0x3F, 0xF8, 0xFF, 0xF3, 0xFB, 0xC7, 0xC0, 0x8F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x7C, 0x80, 0xF9, 0x83, 0xF3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFE,
  0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x03, 0xE3,
  0xE0, 0x7C, 0xFC, 0x1F, 0x9F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F,
  0x81, 0xF3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x7E,
  0x0F, 0xCF, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC1, 0xF8, 0xFC,
  0x7E, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0xF8,
  0x07, 0xEF, 0x01, 0xF9, 0xF0, 0x3E, 0x3E, 0x0F, 0xC7, 0xC1, 0xF0, 0xF8,
  0x3E, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF3,
  0xE0, 0x3E, 0x7C, 0x07, 0xDF, 0x00, 0x7B, 0xE0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x0F, 0x81, 0xF7, 0x81, 0xF8, 0x3E, 0x78, 0x1F, 0x83, 0xE7,
  0x83, 0xF8, 0x7C, 0x78, 0x3F, 0x87, 0xC7, 0x87, 0xF8, 0x7C, 0x78, 0x7F,
  0x8F, 0x87, 0x87, 0x78, 0xF8, 0x78, 0xF7, 0x9F, 0x07, 0x8F, 0x79, 0xF0,
  0x79, 0xE7, 0x9E, 0x07, 0x9E, 0x7B, 0xE0, 0x7B, 0xE7, 0xBC, 0x07, 0xBC,
  0x7F, 0xC0, 0x7B, 0xC7, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8,
  0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x07, 0xC1, 0xF8, 0x0F, 0x83, 0xE0,
  0x0F, 0x8F, 0x80, 0x1F, 0x3F, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFB, 0xE0, 0x07, 0xE7,
  0xC0, 0x0F, 0x8F, 0xC0, 0x3E, 0x0F, 0x80, 0xFC, 0x1F, 0x03, 0xF0, 0x3F,
  0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x1F, 0xFC, 0x1F, 0xBE, 0x0F, 0x8F, 0x8F,
  0x87, 0xCF, 0xC3, 0xE7, 0xC1, 0xF7, 0xC0, 0x7B, 0xE0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF,
  0x0F, 0xFF, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x78, 0x03,
  0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0xC0, 0xF0,
  0xF8, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x0F, 0x03, 0xF8, 0x3F,
  0xC1, 0xFC, 0x0F, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x0F, 0xE0,
  0x7F, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF8, 0x07, 0xB8, 0x07, 0xBC, 0x0F, 0x1C, 0x1E, 0x1C, 0x1E,
  0x1E, 0x3C, 0x1E, 0x38, 0x0E, 0x78, 0x0F, 0xF0, 0x0F, 0x7F, 0xFD, 0xFF,
  0xEF, 0xFF, 0x80, 0xFC, 0xF8, 0xF0, 0xF0, 0xE0, 0x03, 0x80, 0x87, 0xF7,
  0x87, 0xFF, 0xC7, 0xFF, 0xE3, 0xF3, 0xF3, 0xF1, 0xF9, 0xF0, 0xF8, 0xF8,
  0x7C, 0x7C, 0x3E, 0x7E, 0x1F, 0x3E, 0x0F, 0x1F, 0x0F, 0x8F, 0xCF, 0xC7,
  0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0x78, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x70,
  0x1F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0x87, 0xE7, 0xE3, 0xE1, 0xF1, 0xF0,
  0xF9, 0xF0, 0x7C, 0xF8, 0x7E, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x1F, 0x9F,
  0x8F, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0xDF, 0xC3, 0xE7, 0xC0, 0x01, 0xF0,
  0x1F, 0xF1, 0xFF, 0xCF, 0xFE, 0x3F, 0x19, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x11, 0xFF, 0xC7, 0xFF,
  0x0F, 0xFC, 0x1F, 0xE0, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x38, 0xF8, 0x3F, 0xBC, 0x1F, 0xFF,
  0x0F, 0xFF, 0xC3, 0xF3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x3C, 0x3F, 0x1F, 0x0F, 0xC7, 0xC1, 0xFF,
  0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x03, 0xF7, 0x80, 0x01, 0xF0, 0x0F, 0xF8,
  0x3F, 0xF8, 0xFF, 0xF3, 0xE3, 0xEF, 0xC7, 0xDF, 0x0F, 0xBF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xE3, 0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0x8F, 0xCF, 0x1F, 0xFE,
  0x1F, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x0F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0x80, 0x9F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xC0, 0x41, 0xFD, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x9F, 0x8F,
  0xC7, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x87, 0xC7, 0xC1,
  0xF1, 0xF0, 0xF8, 0x7E, 0x7E, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFE, 0xF0,
  0x1F, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC2, 0x03, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x70, 0x1E, 0xFE, 0x0F,
  0xFF, 0x0F, 0xFF, 0xC7, 0xF7, 0xE3, 0xF1, 0xF1, 0xF0, 0xF9, 0xF8, 0x7C,
  0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x9F, 0x07, 0xCF, 0x87,
  0xC7, 0xC3, 0xE3, 0xE1, 0xF3, 0xF0, 0xF8, 0x03, 0xC1, 0xF0, 0x7C, 0x1F,
  0x03, 0x00, 0x00, 0x00, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F,
  0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC0,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x0F, 0xF8, 0x3F,
  0xC0, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x08, 0x7C, 0x3E,
  0x1F, 0x0F, 0x83, 0xE3, 0xE0, 0x7C, 0xF8, 0x0F, 0xBE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xDF, 0x81,
  0xF1, 0xF0, 0x3E, 0x3F, 0x07, 0xC7, 0xE0, 0xF8, 0x7C, 0x3F, 0x0F, 0xC0,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x87,
  0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1,
  0xF0, 0x7C, 0x1F, 0x0F, 0xC0, 0x00, 0x1C, 0x0E, 0x03, 0xDF, 0xCF, 0xE0,
  0xFF, 0xF7, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xDF, 0xEF, 0xC7, 0xE3, 0xF1,
  0xF1, 0xF0, 0xF8, 0x7C, 0xFC, 0x3E, 0x1F, 0x3E, 0x1F, 0x07, 0xCF, 0x87,
  0xC3, 0xE3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3E, 0x7C, 0x1F, 0x0F, 0x9F,
  0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0x7C, 0xFC, 0x3E, 0x1F,
  0x00, 0x00, 0x1C, 0x07, 0xBF, 0x83, 0xFF, 0xC3, 0xFF, 0xF1, 0xFD, 0xF8,
  0xFC, 0x7C, 0x7C, 0x3E, 0x7E, 0x1F, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x87,
  0xC7, 0xC3, 0xE7, 0xC1, 0xF3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0xFC,
  0x3E, 0x00, 0x01, 0xE0, 0x07, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x3F, 0x3E,
  0x7E, 0x3F, 0x7C, 0x1F, 0x7C, 0x3F, 0xFC, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E,
  0xF8, 0x7E, 0xFC, 0x7C, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0,
  0x00, 0x1E, 0x01, 0xEF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xCF, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x7C, 0x1F, 0x1F, 0x0F, 0xC7, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x7E, 0x3F, 0x1F, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xF7, 0xF0,
  0x3C, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x03, 0x80, 0x87, 0xF7, 0x87, 0xFF,
  0xC7, 0xFF, 0xE3, 0xF3, 0xF3, 0xF1, 0xF9, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C,
  0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x1F, 0x0F, 0x8F, 0xC7, 0xC3, 0xFF, 0xE1,
  0xFF, 0xF0, 0xFE, 0xF0, 0x3E, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x1C, 0x3D,
  0xF0, 0xFF, 0xC7, 0xFE, 0x1F, 0xF8, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x3F, 0xF1, 0xFF, 0xCF, 0xFE, 0x3E, 0x18,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x00, 0x7E,
  0x81, 0xFB, 0xEF, 0xCF, 0xFF, 0x3F, 0xF8, 0x7F, 0xC0, 0x07, 0x80, 0x78,
  0x0F, 0x00, 0xF0, 0x7F, 0xF7, 0xFF, 0xFF, 0xF3, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7F, 0x87, 0xF8,
  0x7F, 0x83, 0xF8, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8,
  0xFC, 0xF9, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0x78, 0x7E, 0x78, 0xF8,
  0x1F, 0xBC, 0x1F, 0x1F, 0x0F, 0x8F, 0x8F, 0x87, 0xC7, 0xC3, 0xE7, 0xC1,
  0xF3, 0xE0, 0xFB, 0xE0, 0x3D, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xF0, 0xFC, 0x3F,
  0xF0, 0xFC, 0x3E, 0xF0, 0xFC, 0x7C, 0xF1, 0xFC, 0x7C, 0xF1, 0xDC, 0x78,
  0xF3, 0xDC, 0xF8, 0xF3, 0xDC, 0xF0, 0xF3, 0x9D, 0xF0, 0xF7, 0xBD, 0xE0,
  0xF7, 0x3D, 0xE0, 0xF7, 0x3F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFE, 0x3F, 0xC0,
  0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0,
  0x7C, 0x7E, 0x07, 0xEF, 0xC0, 0x3E, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC,
  0x00, 0xFB, 0xE0, 0x1F, 0xBE, 0x03, 0xF3, 0xF0, 0x3E, 0x1F, 0x0F, 0xE1,
  0xF8, 0x1F, 0x03, 0xF0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0xF8, 0x0F,
  0x8F, 0x80, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0x7B, 0xE0, 0x07, 0xBE, 0x00,
  0x7B, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x10, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7F,
  0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0xFC,
  0x0F, 0xC0, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x0F,
  0xC1, 0xFC, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1E, 0x01, 0xF0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00,
  0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0x80, 0x3E, 0x01, 0xF8, 0x1F, 0xC0, 0x1E, 0x01, 0xF0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xF0, 0x0F, 0x81,
  0xF8, 0x1F, 0xC1, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0x00, 0x00, 0x3F, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xF8, 0x0F, 0xC0,
};

const GFXglyph NotoSans_ExtraBoldItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 21, 9, 0, -21 },
  { 28, 12, 7, 14, 3, -21 },
  { 39, 20, 21, 19, 0, -21 },
  { 92, 16, 25, 17, 1, -23 },
  { 142, 24, 22, 27, 2, -22 },
  { 208, 20, 22, 22, 1, -22 },
  { 263, 5, 7, 7, 3, -21 },
  { 268, 12, 27, 11, 1, -22 },
  { 309, 12, 27, 11, -2, -22 },
  { 350, 15, 15, 16, 2, -23 },
  { 379, 15, 15, 17, 1, -18 },
  { 408, 7, 7, 9, -1, -3 },
  { 415, 9, 4, 10, 0, -10 },
  { 420, 6, 5, 9, 0, -5 },
  { 424, 16, 22, 13, -1, -22 },
  { 468, 16, 22, 17, 1, -22 },
  { 512, 13, 21, 17, 2, -21 },
  { 547, 17, 22, 17, -1, -22 },
  { 594, 16, 22, 17, 0, -22 },
  { 638, 17, 21, 17, 0, -21 },
  { 683, 17, 21, 17, 0, -21 },
  { 728, 16, 22, 17, 1, -22 },
  { 772, 17, 21, 17, 1, -21 },
  { 817, 16, 22, 17, 1, -22 },
  { 861, 15, 22, 17, 1, -22 },
  { 903, 9, 17, 9, 0, -17 },
  { 923, 11, 21, 9, -2, -17 },
  { 952, 15, 16, 17, 1, -19 },
  { 982, 15, 9, 17, 1, -15 },
  { 999, 15, 16, 17, 1, -19 },
  { 1029, 13, 22, 14, 2, -22 },
  { 1065, 25, 25, 26, 1, -22 },
  { 1144, 20, 21, 20, -2, -21 },
  { 1197, 17, 21, 19, 1, -21 },
  { 1242, 18, 22, 19, 2, -22 },
  { 1292, 18, 21, 20, 1, -21 },
  { 1340, 16, 21, 17, 1, -21 },
  { 1382, 16, 21, 17, 1, -21 },
  { 1424, 18, 22, 21, 2, -22 },
  { 1474, 20, 21, 21, 1, -21 },
  { 1527, 15, 21, 12, -1, -21 },
  { 1567, 16, 28, 11, -5, -21 },
  { 1623, 21, 21, 19, 1, -21 },
  { 1679, 13, 21, 16, 1, -21 },
  { 1714, 26, 21, 27, 1, -21 },
  { 1783, 22, 21, 23, 1, -21 },
  { 1841, 19, 22, 22, 2, -22 },
  { 1894, 17, 21, 18, 1, -21 },
  { 1939, 19, 27, 22, 2, -22 },
  { 2004, 17, 21, 19, 1, -21 },
  { 2049, 15, 22, 16, 1, -22 },
  { 2091, 16, 21, 16, 2, -21 },
  { 2133, 19, 21, 21, 2, -21 },
  { 2183, 19, 21, 18, 2, -21 },
  { 2233, 28, 21, 27, 2, -21 },
  { 2307, 23, 21, 19, -2, -21 },
  { 2368, 17, 21, 17, 3, -21 },
  { 2413, 19, 21, 16, -1, -21 },
  { 2463, 13, 27, 10, -1, -22 },
  { 2507, 8, 22, 13, 3, -22 },
  { 2529, 13, 27, 10, -2, -22 },
  { 2573, 16, 14, 16, 0, -21 },
  { 2601, 14, 3, 13, -3, 2 },
  { 2607, 7, 5, 10, 4, -23 },
  { 2612, 17, 17, 18, 1, -17 },
  { 2649, 17, 23, 18, 0, -23 },
  { 2698, 14, 17, 15, 1, -17 },
  { 2728, 18, 23, 18, 1, -23 },
  { 2780, 15, 17, 17, 1, -17 },
  { 2812, 18, 30, 12, -3, -23 },
  { 2880, 18, 24, 18, 0, -17 },
  { 2934, 17, 23, 18, 0, -23 },
  { 2983, 10, 23, 9, 0, -23 },
  { 3012, 14, 30, 9, -4, -23 },
  { 3065, 19, 23, 18, 0, -23 },
  { 3120, 10, 23, 9, 0, -23 },
  { 3149, 26, 17, 27, 0, -17 },
  { 3205, 17, 17, 18, 0, -17 },
  { 3242, 16, 17, 18, 1, -17 },
  { 3276, 18, 24, 18, -1, -17 },
  { 3330, 17, 24, 18, 1, -17 },
  { 3381, 14, 17, 13, 0, -17 },
  { 3411, 14, 17, 15, 0, -17 },
  { 3441, 12, 20, 13, 1, -20 },
  { 3471, 16, 16, 18, 2, -16 },
  { 3503, 17, 16, 16, 1, -16 },
  { 3537, 24, 16, 24, 2, -16 },
  { 3585, 20, 16, 16, -2, -16 },
  { 3625, 20, 23, 16, -2, -16 },
  { 3683, 16, 16, 14, -1, -16 },
  { 3715, 13, 26, 11, 0, -21 },
  { 3758, 3, 30, 17, 7, -23 },
  { 3770, 13, 26, 11, -2, -21 },
  { 3813, 15, 5, 17, 1, -13 },
};

const GFXfont NotoSans_ExtraBoldItalic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic30pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_EXTRABOLDITALIC30PT7B_H_
