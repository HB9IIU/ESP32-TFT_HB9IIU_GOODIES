#ifndef _NOTOSANS_EXTRABOLDITALIC11PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x36, 0x66, 0x40, 0xCC, 0xDF, 0xB0, 0x16, 0x29, 0xF9, 0x62, 0x9F,
  0xD6, 0x28, 0x19, 0xF7, 0x1C, 0x18, 0x7F, 0x9C, 0x20, 0x63, 0xB6, 0xAC,
  0xAB, 0xF7, 0x35, 0x25, 0xC7, 0x1C, 0x3C, 0x2C, 0x38, 0x7B, 0xDE, 0xCC,
  0x7E, 0xF8, 0x19, 0x98, 0x84, 0x63, 0x18, 0x43, 0x00, 0x30, 0x84, 0x31,
  0x08, 0xC6, 0x66, 0x00, 0x37, 0x1F, 0xE5, 0x00, 0x21, 0x3F, 0xF2, 0x10,
  0x78, 0xFC, 0xF0, 0x0C, 0x61, 0x0C, 0x21, 0x8C, 0x30, 0x39, 0xF6, 0xD3,
  0xCF, 0x3D, 0x9C, 0x3B, 0xBC, 0x63, 0x11, 0x8C, 0x39, 0xF0, 0xC2, 0x39,
  0xCF, 0xBE, 0x39, 0xF0, 0xCE, 0x38, 0x39, 0xBE, 0x0C, 0x73, 0xCA, 0x5B,
  0xF1, 0x86, 0x3C, 0xF6, 0x1E, 0x5C, 0x39, 0xBC, 0x1C, 0xF6, 0x16, 0x6F,
  0x37, 0x9E, 0x7E, 0xF8, 0x30, 0xC3, 0x86, 0x18, 0x70, 0x39, 0xB6, 0xCE,
  0x7B, 0x3C, 0xDE, 0x77, 0xF7, 0xBF, 0x8A, 0xDC, 0x6C, 0x0D, 0x80, 0x33,
  0x00, 0x06, 0xC0, 0x09, 0xF9, 0x83, 0x84, 0xFF, 0xC1, 0xF0, 0x86, 0x0C,
  0x7E, 0x40, 0xF7, 0xC4, 0xE4, 0x43, 0x18, 0x1F, 0x18, 0xDB, 0xAB, 0x55,
  0x6E, 0xBD, 0x6C, 0xC4, 0x3E, 0x00, 0x0E, 0x1C, 0x78, 0xB3, 0x67, 0xD8,
  0xF1, 0x3C, 0x7D, 0x9B, 0xE7, 0xCD, 0x9F, 0x7C, 0x3D, 0xFC, 0x30, 0xC3,
  0x0C, 0x9E, 0x3C, 0x7D, 0x9B, 0x36, 0x6C, 0xDF, 0x7C, 0x3C, 0xF6, 0x1F,
  0x79, 0x87, 0xBE, 0x3C, 0xF6, 0x1F, 0x79, 0x84, 0x30, 0x3E, 0xFB, 0x06,
  0xED, 0xD9, 0xB7, 0x3C, 0x33, 0x23, 0x66, 0x7E, 0x7E, 0x66, 0x44, 0xCC,
  0x79, 0x8C, 0x46, 0x31, 0x9E, 0x0C, 0x30, 0x86, 0x18, 0x61, 0x8C, 0x33,
  0xC0, 0x37, 0x26, 0x6C, 0x78, 0x78, 0x78, 0x4C, 0xCC, 0x31, 0x18, 0xC6,
  0x31, 0xFF, 0x31, 0xCC, 0x77, 0x39, 0xCE, 0x77, 0x97, 0x65, 0xDB, 0x64,
  0x31, 0x98, 0x9E, 0xCF, 0x66, 0xB2, 0x71, 0x39, 0x8C, 0x3C, 0xFB, 0x1E,
  0x3C, 0x79, 0xB7, 0x3C, 0x3C, 0x7D, 0x9B, 0x77, 0xCC, 0x10, 0x60, 0x3C,
  0xFB, 0x1E, 0x3C, 0x79, 0xB7, 0x3C, 0x18, 0x38, 0x3C, 0x79, 0x9B, 0x67,
  0x8F, 0x13, 0x66, 0x3D, 0xF6, 0x1C, 0x38, 0x6D, 0xBC, 0xFF, 0xE2, 0x18,
  0x61, 0x86, 0x30, 0x66, 0x8B, 0x36, 0x6C, 0xD9, 0xB6, 0x78, 0xCF, 0x9B,
  0x66, 0xCD, 0x1E, 0x38, 0x70, 0xCC, 0xF3, 0x2D, 0xDB, 0x76, 0xFF, 0x3B,
  0xCE, 0xE3, 0x38, 0x33, 0x8D, 0x87, 0x83, 0x81, 0xC1, 0xA1, 0xD9, 0xCC,
  0xCF, 0x65, 0x9C, 0x61, 0x86, 0x18, 0x7D, 0xF1, 0x8E, 0x31, 0x8F, 0xBE,
  0x39, 0x18, 0xC4, 0x23, 0x18, 0xC7, 0x00, 0xD9, 0x24, 0xDB, 0x38, 0xC4,
  0x21, 0x18, 0xC4, 0x27, 0x00, 0x10, 0x62, 0x9A, 0xCC, 0xF8, 0xC0, 0x35,
  0xB6, 0xF3, 0x79, 0xE0, 0x30, 0x87, 0xDB, 0x6D, 0x3F, 0xFE, 0x3D, 0xA6,
  0x30, 0x69, 0xE0, 0x06, 0x0C, 0xD3, 0x66, 0xD9, 0x9E, 0x3C, 0x3D, 0xB7,
  0xFC, 0x69, 0xE0, 0x1C, 0x63, 0xCC, 0x30, 0xC3, 0x08, 0x63, 0x8C, 0x00,
  0x35, 0xB6, 0xF3, 0x79, 0xA1, 0xBE, 0x60, 0x30, 0x87, 0xDB, 0x6D, 0xBC,
  0xF2, 0x30, 0x66, 0x66, 0xCC, 0x18, 0x0C, 0x63, 0x18, 0x8C, 0x67, 0x20,
  0x30, 0x41, 0xBB, 0x67, 0x8F, 0x36, 0x66, 0x32, 0x66, 0x66, 0xCC, 0x7D,
  0x9B, 0xB6, 0xC9, 0xB6, 0xCD, 0xB2, 0x60, 0x7D, 0xB6, 0xDB, 0xCF, 0x20,
  0x39, 0xB6, 0xF3, 0x7D, 0xE0, 0x7D, 0xB6, 0xD3, 0xFF, 0xEC, 0x30, 0x80,
  0x3D, 0xB6, 0xF3, 0x79, 0xA1, 0x86, 0x18, 0x7B, 0xD8, 0xCC, 0x60, 0x7B,
  0x5C, 0x79, 0xF8, 0x33, 0xF8, 0xC6, 0x39, 0xC0, 0xCF, 0x6D, 0xA6, 0xFB,
  0xC0, 0x9C, 0xED, 0xEE, 0x60, 0x9B, 0xBB, 0xAE, 0xAE, 0xCC, 0xCC, 0x37,
  0x3C, 0x1C, 0x38, 0x3C, 0xEC, 0x66, 0x4C, 0xF1, 0xE3, 0x87, 0x0C, 0x70,
  0xC0, 0x78, 0xCC, 0xCC, 0xF8, 0x19, 0x88, 0x4E, 0x61, 0x88, 0x63, 0x00,
  0xFF, 0xFF, 0xFC, 0x31, 0x84, 0x61, 0x9C, 0x84, 0xE6, 0x00, 0xCF, 0xC0,
};

const GFXglyph NotoSans_ExtraBoldItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 8, 3, 0, -8 },
  { 5, 4, 3, 5, 1, -8 },
  { 7, 7, 8, 7, 0, -8 },
  { 14, 6, 9, 6, 0, -8 },
  { 21, 8, 8, 10, 1, -8 },
  { 29, 8, 8, 8, 0, -8 },
  { 37, 2, 3, 3, 1, -8 },
  { 38, 5, 10, 4, 0, -8 },
  { 45, 5, 10, 4, -1, -8 },
  { 52, 5, 5, 6, 1, -8 },
  { 56, 5, 6, 6, 1, -7 },
  { 60, 3, 2, 3, -1, -1 },
  { 61, 3, 2, 4, 0, -4 },
  { 62, 2, 2, 3, 0, -2 },
  { 63, 6, 8, 5, 0, -8 },
  { 69, 6, 8, 6, 0, -8 },
  { 75, 5, 8, 6, 1, -8 },
  { 80, 6, 8, 6, 0, -8 },
  { 86, 6, 8, 6, 0, -8 },
  { 92, 6, 8, 6, 0, -8 },
  { 98, 6, 8, 6, 0, -8 },
  { 104, 6, 8, 6, 0, -8 },
  { 110, 7, 8, 6, 0, -8 },
  { 117, 6, 8, 6, 0, -8 },
  { 123, 5, 8, 6, 1, -8 },
  { 128, 3, 6, 3, 0, -6 },
  { 131, 4, 7, 3, -1, -6 },
  { 135, 5, 6, 6, 1, -7 },
  { 139, 5, 4, 6, 1, -6 },
  { 142, 5, 6, 6, 1, -7 },
  { 146, 5, 8, 5, 1, -8 },
  { 151, 9, 9, 10, 0, -8 },
  { 162, 7, 8, 7, -1, -8 },
  { 169, 7, 8, 7, 0, -8 },
  { 176, 6, 8, 7, 1, -8 },
  { 182, 7, 8, 7, 0, -8 },
  { 189, 6, 8, 6, 0, -8 },
  { 195, 6, 8, 6, 0, -8 },
  { 201, 7, 8, 8, 1, -8 },
  { 208, 8, 8, 8, 0, -8 },
  { 216, 5, 8, 4, 0, -8 },
  { 221, 6, 10, 4, -2, -8 },
  { 229, 8, 8, 7, 0, -8 },
  { 237, 5, 8, 6, 0, -8 },
  { 242, 10, 8, 10, 0, -8 },
  { 252, 9, 8, 9, 0, -8 },
  { 261, 7, 8, 8, 1, -8 },
  { 268, 7, 8, 7, 0, -8 },
  { 275, 7, 10, 8, 1, -8 },
  { 284, 7, 8, 7, 0, -8 },
  { 291, 6, 8, 6, 0, -8 },
  { 297, 6, 8, 6, 1, -8 },
  { 303, 7, 8, 8, 1, -8 },
  { 310, 7, 8, 7, 1, -8 },
  { 317, 10, 8, 10, 1, -8 },
  { 327, 9, 8, 7, -1, -8 },
  { 336, 6, 8, 6, 1, -8 },
  { 342, 6, 8, 6, 0, -8 },
  { 348, 5, 10, 4, 0, -8 },
  { 355, 3, 8, 5, 1, -8 },
  { 358, 5, 10, 4, -1, -8 },
  { 365, 6, 5, 6, 0, -8 },
  { 369, 5, 1, 5, -1, 1 },
  { 370, 2, 1, 4, 2, -8 },
  { 371, 6, 6, 7, 0, -6 },
  { 376, 6, 8, 7, 0, -8 },
  { 382, 6, 6, 5, 0, -6 },
  { 387, 7, 8, 7, 0, -8 },
  { 394, 6, 6, 6, 0, -6 },
  { 399, 6, 11, 4, -1, -8 },
  { 408, 6, 9, 7, 0, -6 },
  { 415, 6, 8, 7, 0, -8 },
  { 421, 4, 8, 3, 0, -8 },
  { 425, 5, 11, 3, -1, -8 },
  { 432, 7, 8, 7, 0, -8 },
  { 439, 4, 8, 3, 0, -8 },
  { 443, 10, 6, 10, 0, -6 },
  { 451, 6, 6, 7, 0, -6 },
  { 456, 6, 6, 7, 0, -6 },
  { 461, 6, 9, 7, 0, -6 },
  { 468, 6, 9, 7, 0, -6 },
  { 475, 5, 6, 5, 0, -6 },
  { 479, 5, 6, 5, 0, -6 },
  { 483, 5, 7, 5, 0, -7 },
  { 488, 6, 6, 7, 1, -6 },
  { 493, 5, 6, 6, 1, -6 },
  { 497, 8, 6, 9, 1, -6 },
  { 503, 8, 6, 6, -1, -6 },
  { 509, 7, 9, 6, -1, -6 },
  { 517, 5, 6, 5, 0, -6 },
  { 521, 5, 10, 4, 0, -8 },
  { 528, 2, 11, 6, 2, -8 },
  { 531, 5, 10, 4, -1, -8 },
  { 538, 5, 2, 6, 1, -5 },
};

const GFXfont NotoSans_ExtraBoldItalic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic11pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_EXTRABOLDITALIC11PT7B_H_
