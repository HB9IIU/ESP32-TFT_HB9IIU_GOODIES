#ifndef _NOTOSANS_EXTRABOLDITALIC23PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x40,
  0x00, 0x70, 0xF8, 0xF8, 0xF0, 0x73, 0xBB, 0xDD, 0xDC, 0xEE, 0x77, 0x30,
  0x03, 0x9C, 0x06, 0x30, 0x1C, 0xE0, 0x39, 0xC3, 0xFF, 0xE7, 0xFF, 0xCF,
  0xFF, 0x87, 0x38, 0x0C, 0x61, 0xFF, 0xFB, 0xFF, 0xF0, 0xE6, 0x01, 0x9C,
  0x07, 0x38, 0x0E, 0x70, 0x19, 0xC0, 0x01, 0x80, 0x7C, 0x1F, 0xF3, 0xFE,
  0x7B, 0x27, 0xB0, 0x7A, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x5E,
  0x8D, 0xEF, 0xFC, 0xFF, 0xCF, 0xF0, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x87,
  0xE0, 0xE1, 0xFC, 0x1C, 0x39, 0x87, 0x07, 0x39, 0xC1, 0xCE, 0x70, 0x39,
  0xCE, 0x07, 0x3B, 0xBE, 0xFE, 0xEF, 0xCF, 0xDB, 0xFC, 0xE7, 0x73, 0x81,
  0xCE, 0x70, 0x71, 0xCE, 0x0C, 0x3B, 0x83, 0x87, 0x70, 0xE0, 0xFC, 0x38,
  0x0F, 0x00, 0x01, 0xC0, 0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0x78, 0x0E, 0x78,
  0x0E, 0x78, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0x8F, 0x3F, 0xCF, 0x7B, 0xDE,
  0x79, 0xFE, 0xF0, 0xFC, 0xF8, 0xF8, 0x7F, 0xF8, 0x7F, 0xFC, 0x3F, 0xBE,
  0x77, 0x7E, 0xEE, 0x07, 0x87, 0x83, 0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xE0,
  0x70, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x1C,
  0x0E, 0x07, 0x00, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x0F,
  0x0F, 0x0F, 0x00, 0x04, 0x00, 0xE0, 0x1C, 0x33, 0x0F, 0xE1, 0xFF, 0xC7,
  0xF9, 0xF1, 0x7F, 0x1E, 0xE0, 0x8E, 0x01, 0x00, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00,
  0x3C, 0xE7, 0x9C, 0xF3, 0x80, 0x7E, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x78,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0xFC, 0x1F, 0xE3, 0xDE, 0x78, 0xF7, 0x8F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF3, 0xEF, 0x3C, 0xFF,
  0x87, 0xF8, 0x3E, 0x00, 0x07, 0xC7, 0xE3, 0xFB, 0xFE, 0xF7, 0x99, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0,
  0x01, 0xC0, 0x3F, 0x87, 0xFE, 0x1F, 0xF0, 0xC7, 0x80, 0x3C, 0x01, 0xE0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xFF,
  0xCF, 0xFE, 0xFF, 0xF0, 0x03, 0x80, 0xFF, 0x0F, 0xFC, 0x3B, 0xE1, 0x07,
  0x80, 0x38, 0x03, 0xC1, 0xFC, 0x0F, 0x80, 0x7F, 0x04, 0x78, 0x01, 0xE0,
  0x0F, 0x40, 0xF3, 0xFF, 0x9F, 0xF8, 0xFF, 0x80, 0x00, 0xF8, 0x0F, 0x80,
  0x7C, 0x07, 0xE0, 0x7F, 0x07, 0x70, 0x7B, 0x87, 0xBC, 0x39, 0xE3, 0x8F,
  0x3F, 0xFD, 0xFF, 0xEF, 0xFF, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x0F, 0xF8,
  0x7F, 0xC7, 0xFC, 0x3C, 0x01, 0xC0, 0x1F, 0x80, 0xFF, 0x07, 0xFC, 0x1B,
  0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE8, 0x1E, 0x7F, 0xF3, 0xFF, 0x0F, 0xE0,
  0x01, 0xF0, 0x7F, 0x1F, 0xF3, 0xF3, 0x3C, 0x07, 0x80, 0x73, 0x87, 0xFC,
  0xFF, 0xEF, 0x9E, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0x3E, 0xFF, 0xC7, 0xF8,
  0x3F, 0x00, 0x3F, 0xFB, 0xFF, 0xDF, 0xFC, 0x03, 0xE0, 0x1E, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E,
  0x01, 0xE0, 0x1E, 0x00, 0x07, 0x81, 0xFE, 0x3F, 0xE3, 0xCF, 0x38, 0xF3,
  0x8F, 0x3D, 0xE3, 0xFC, 0x1F, 0x87, 0xFC, 0xFB, 0xCF, 0x1E, 0xE1, 0xEE,
  0x1E, 0xFF, 0xCF, 0xFC, 0x3F, 0x00, 0x07, 0x03, 0xF8, 0xFF, 0xBE, 0xF7,
  0x8F, 0xE1, 0xFC, 0x3F, 0x8F, 0xFF, 0xEF, 0xFC, 0xFF, 0x80, 0xF0, 0x3C,
  0x0F, 0xBF, 0xE7, 0xF8, 0xFC, 0x00, 0x1C, 0x7C, 0xF9, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xE3, 0xC7, 0x8F, 0x00, 0x0E, 0x1F, 0x1F, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x78, 0x70, 0xF0, 0xE0, 0x00, 0x20,
  0x0C, 0x07, 0x83, 0xF1, 0xF8, 0xFC, 0x3E, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0x80, 0x70, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x03, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0x78, 0x1F, 0x1F, 0xCF, 0xE3, 0xE0, 0x70, 0x08, 0x00, 0x1E, 0x3F, 0xEF,
  0xF9, 0xDF, 0x43, 0xC1, 0xE0, 0xF8, 0x7C, 0x3E, 0x1E, 0x07, 0x00, 0x00,
  0x00, 0x18, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x7F, 0xC0,
  0x3F, 0xFE, 0x0F, 0x01, 0xE3, 0x80, 0x1C, 0xE1, 0xF9, 0x9C, 0xFF, 0x3B,
  0x1C, 0xE7, 0xE7, 0x18, 0xFC, 0xE7, 0x1B, 0xB8, 0xE7, 0x77, 0x1C, 0xEE,
  0x7F, 0xF9, 0xCF, 0xBE, 0x1C, 0xE3, 0x03, 0x80, 0x00, 0x3C, 0x18, 0x03,
  0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0xC0, 0x3B, 0x80, 0xF7, 0x81, 0xCF, 0x07, 0x9E, 0x1E, 0x3C, 0x3F, 0xF8,
  0xFF, 0xF1, 0xFF, 0xE7, 0x81, 0xCF, 0x03, 0xBC, 0x07, 0x78, 0x0F, 0x0F,
  0xF8, 0x3F, 0xF1, 0xFF, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF3, 0xFF, 0x8F,
  0xF8, 0x3F, 0xF0, 0xF1, 0xE3, 0xC7, 0x9E, 0x1E, 0x78, 0xF9, 0xFF, 0xC7,
  0xFE, 0x3F, 0xF0, 0x01, 0xE0, 0x1F, 0xF1, 0xFF, 0xC7, 0xFE, 0x3E, 0x09,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x87, 0xFE, 0x0F, 0xF8, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F,
  0xF8, 0x7F, 0xF0, 0xF1, 0xF1, 0xE1, 0xE3, 0xC3, 0xCF, 0x07, 0x9E, 0x0F,
  0x3C, 0x1E, 0x78, 0x78, 0xF0, 0xF3, 0xC3, 0xE7, 0x8F, 0x8F, 0xFE, 0x1F,
  0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC7, 0xFE, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0xFF, 0xC7, 0xFC, 0x3F, 0xE1, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x3F, 0xF1, 0xFF, 0x1F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC7, 0xFE, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0xFF, 0xC7, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0xE3, 0xE0, 0x4F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF9, 0xFD,
  0xE3, 0xFB, 0xC7, 0xE7, 0x83, 0xCF, 0x87, 0x8F, 0x0F, 0x1F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF0, 0x0F, 0x0F, 0x0E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E,
  0x1E, 0x1E, 0x1E, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x3C, 0x3C, 0x3C,
  0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x38, 0x78, 0x78, 0xF0, 0x78, 0x0F,
  0xF1, 0xFE, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x07, 0xF8, 0x7F, 0x0F, 0xF0, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F,
  0x89, 0xF0, 0xFF, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0x1F, 0x87, 0x0F, 0x07,
  0x8F, 0x03, 0xCF, 0x01, 0xEF, 0x80, 0xFF, 0x80, 0xF7, 0x80, 0x7F, 0x80,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0x78, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7,
  0x81, 0xE1, 0xE1, 0xE0, 0xF0, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xFF,
  0xDF, 0xF7, 0xFE, 0x0F, 0x81, 0xF8, 0x7C, 0x1F, 0x87, 0xE0, 0xFC, 0x3F,
  0x0F, 0xE1, 0xF8, 0x7F, 0x0F, 0xC7, 0x70, 0xF6, 0x3B, 0x87, 0xB1, 0xFC,
  0x3D, 0x9D, 0xE1, 0xCC, 0xEF, 0x0E, 0x6E, 0x70, 0xF3, 0x73, 0x87, 0x9F,
  0x3C, 0x38, 0xF9, 0xE1, 0xC7, 0x8E, 0x1E, 0x3C, 0x70, 0x0F, 0x83, 0xC3,
  0xE0, 0xE1, 0xF8, 0x38, 0x7F, 0x0E, 0x1F, 0xC7, 0x87, 0x71, 0xE3, 0xDE,
  0x70, 0xF7, 0x9C, 0x3C, 0xE7, 0x0E, 0x3F, 0xC3, 0x8F, 0xF1, 0xE1, 0xF8,
  0x78, 0x7E, 0x1E, 0x1F, 0x87, 0x07, 0xE3, 0xC0, 0xF8, 0x01, 0xE0, 0x0F,
  0xF0, 0x7F, 0xF0, 0xFF, 0xF3, 0xE1, 0xEF, 0x83, 0xDE, 0x07, 0xBC, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xEF, 0x83, 0xCF, 0x1F, 0x1F,
  0xFE, 0x1F, 0xF8, 0x1F, 0xC0, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF3, 0xC7, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0x83, 0xC0,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x0F,
  0xF0, 0x7F, 0xF0, 0xFF, 0xF3, 0xE1, 0xEF, 0x83, 0xDE, 0x07, 0xBC, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xEF, 0x87, 0xCF, 0x1F, 0x1F,
  0xFC, 0x1F, 0xF0, 0x1F, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF3,
  0xC7, 0x8F, 0xFE, 0x3F, 0xF0, 0xFF, 0x83, 0xDE, 0x1E, 0x78, 0x78, 0xF1,
  0xE3, 0xC7, 0x87, 0xBC, 0x1E, 0x03, 0xC0, 0x7F, 0xC7, 0xFC, 0x3F, 0xE3,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03,
  0xC0, 0x1E, 0x61, 0xF3, 0xFF, 0x1F, 0xF8, 0x7F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE1, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x1E, 0x1E, 0x78,
  0x3C, 0xF0, 0x79, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x9E, 0x0F, 0x3C, 0x1C,
  0x78, 0x78, 0xF0, 0xF1, 0xC1, 0xE7, 0x83, 0xC7, 0x8F, 0x0F, 0xFE, 0x1F,
  0xF8, 0x0F, 0xC0, 0xF0, 0x7F, 0xC1, 0xEF, 0x0F, 0x3C, 0x3C, 0xF1, 0xE3,
  0xC7, 0x8F, 0x3C, 0x1C, 0xF0, 0x73, 0x81, 0xDE, 0x07, 0x70, 0x1F, 0xC0,
  0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF0, 0xF0, 0x7F, 0x87, 0x87,
  0xBC, 0x7C, 0x3D, 0xE3, 0xE1, 0xCF, 0x1F, 0x1E, 0x79, 0xF8, 0xE3, 0xCF,
  0xCF, 0x1E, 0xEE, 0x78, 0xF7, 0x73, 0x87, 0xFB, 0xBC, 0x3B, 0x9D, 0xC1,
  0xDC, 0xFE, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xE1, 0xF8, 0x1F, 0x0F,
  0x80, 0x1F, 0x0F, 0x87, 0x87, 0x83, 0xC7, 0x80, 0xF7, 0x80, 0x7B, 0xC0,
  0x3F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x03, 0xCF, 0x03, 0xC7, 0x83, 0xE3, 0xC1, 0xE0, 0xF1, 0xE0, 0x78, 0xF0,
  0x7F, 0x87, 0x9E, 0x78, 0xF3, 0xC7, 0xBC, 0x1F, 0xC0, 0xFE, 0x07, 0xE0,
  0x3E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x07, 0xC1, 0xF0, 0xFC, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0xE1, 0xF0, 0xFC, 0x00, 0xF1, 0xC7,
  0x1C, 0x71, 0xC7, 0x8E, 0x38, 0xE3, 0x8E, 0x3C, 0x71, 0xC7, 0x1C, 0x07,
  0xC1, 0xF0, 0xFC, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0,
  0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x87, 0xE1, 0xF0,
  0xFC, 0x00, 0x01, 0x80, 0x3C, 0x07, 0xC0, 0x6C, 0x0E, 0xC1, 0xCE, 0x1C,
  0xE3, 0x86, 0x70, 0x7F, 0x07, 0xFF, 0xFF, 0xF0, 0xF3, 0xCE, 0x30, 0x0E,
  0x71, 0xF7, 0x3F, 0xF7, 0xDF, 0x78, 0xFF, 0x0E, 0xF0, 0xEF, 0x1E, 0xF1,
  0xEF, 0x3E, 0xFF, 0xC7, 0xFC, 0x7D, 0xC0, 0x0F, 0x00, 0x70, 0x07, 0x80,
  0x3C, 0x01, 0xEE, 0x0E, 0xF8, 0x7F, 0xE7, 0xDF, 0x3C, 0x79, 0xE3, 0xCE,
  0x1E, 0x70, 0xE7, 0x8F, 0x3C, 0xF9, 0xFF, 0x8F, 0xFC, 0xF7, 0x80, 0x07,
  0x83, 0xFC, 0xFF, 0x3E, 0x67, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x13, 0xFE, 0x3F, 0xC3, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0xE7, 0x0F, 0xB8, 0xFF, 0xCF, 0xBE, 0x78, 0xF7, 0x87, 0x3C, 0x39, 0xE3,
  0xCF, 0x1E, 0x79, 0xF3, 0xFF, 0x0F, 0xF8, 0x7D, 0xC0, 0x07, 0x81, 0xFE,
  0x3F, 0xE7, 0x8F, 0x78, 0xEF, 0x3E, 0xFF, 0xCF, 0xF8, 0xF0, 0x0F, 0x04,
  0xFF, 0xC7, 0xFC, 0x3F, 0x80, 0x00, 0x70, 0x0F, 0xC0, 0x7E, 0x07, 0x90,
  0x3C, 0x03, 0xF8, 0x7F, 0xC3, 0xFC, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x08, 0x00, 0x07, 0x3C, 0x3E, 0xE1,
  0xFF, 0x8F, 0xBE, 0x3C, 0x79, 0xE1, 0xC7, 0x87, 0x1E, 0x3C, 0x78, 0xF1,
  0xE7, 0xC7, 0xFE, 0x0F, 0xF8, 0x3D, 0xE0, 0x07, 0x80, 0x1C, 0x39, 0xF0,
  0xFF, 0x83, 0xFC, 0x00, 0x80, 0x00, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C,
  0x01, 0xEE, 0x0E, 0xF8, 0x7F, 0xE7, 0xCF, 0x3C, 0x79, 0xE3, 0xCF, 0x1E,
  0x70, 0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0xCE, 0x1E, 0xF1, 0xE0, 0x06, 0x0F,
  0x0F, 0x0E, 0x00, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78,
  0x78, 0x78, 0x78, 0xF0, 0x00, 0xC0, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0x07,
  0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x0F, 0xE1, 0xF8, 0x3E, 0x01,
  0x00, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE3, 0xE3, 0xCF,
  0x87, 0x3E, 0x1E, 0x78, 0x3D, 0xE0, 0x7F, 0x80, 0xFE, 0x01, 0xFE, 0x07,
  0xFC, 0x0F, 0x3C, 0x1E, 0x78, 0x38, 0xF8, 0xF0, 0xF0, 0x0F, 0x0E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x78,
  0x78, 0xF0, 0x1C, 0xE1, 0xC1, 0xDF, 0x3E, 0x1F, 0xFF, 0xF3, 0xE7, 0xCF,
  0x3C, 0x78, 0xF3, 0xC7, 0x8F, 0x3C, 0x78, 0xF3, 0x87, 0x0E, 0x78, 0xF1,
  0xE7, 0x8F, 0x1E, 0x78, 0xF1, 0xE7, 0x0F, 0x1E, 0xF1, 0xE3, 0xC0, 0x1C,
  0xE0, 0xEF, 0x87, 0xFE, 0x7C, 0xF3, 0xC7, 0x9E, 0x3C, 0xF1, 0xE7, 0x0E,
  0x78, 0xF3, 0xC7, 0x9E, 0x3C, 0xE1, 0xEF, 0x1E, 0x00, 0x07, 0x81, 0xFC,
  0x3F, 0xE7, 0xDF, 0x78, 0xFF, 0x0F, 0xF0, 0xFF, 0x0E, 0xF1, 0xEF, 0x1E,
  0xFF, 0xC7, 0xF8, 0x3F, 0x00, 0x0E, 0x70, 0x3F, 0xE0, 0xFF, 0x87, 0xDF,
  0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0xC7, 0x0F, 0x3C, 0x78, 0xF1, 0xE3, 0xFF,
  0x0F, 0xFC, 0x7B, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x0E, 0x71, 0xF7, 0x3F, 0xF7, 0xDF, 0x78, 0xFF, 0x0E,
  0xF0, 0xEF, 0x1E, 0xF1, 0xEF, 0x3E, 0xFF, 0xC7, 0xFC, 0x7F, 0xC0, 0x3C,
  0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x1C, 0xE3, 0xB8, 0x7F,
  0x1F, 0xE3, 0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x0F, 0x00, 0x0F, 0x87, 0xFC, 0xFF, 0x1E, 0x23, 0xC0, 0x7E, 0x0F, 0xE0,
  0x7C, 0x07, 0xD0, 0x7B, 0xFE, 0x7F, 0xCF, 0xF0, 0x0E, 0x0E, 0x0F, 0xFF,
  0xFF, 0xF9, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0xE7, 0xF1,
  0xF8, 0x3C, 0x79, 0xC3, 0xDE, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0x79, 0xC3,
  0x9E, 0x3C, 0xF1, 0xE7, 0x9F, 0x3F, 0xF8, 0xFF, 0x87, 0xDC, 0x00, 0xF0,
  0xFF, 0x0F, 0xF1, 0xEF, 0x1E, 0x73, 0xC7, 0x3C, 0x77, 0x87, 0x78, 0x77,
  0x07, 0xF0, 0x7E, 0x07, 0xC0, 0x3C, 0x00, 0xF1, 0xE1, 0xFE, 0x3C, 0x7B,
  0xCF, 0x8F, 0x79, 0xF1, 0xCF, 0x36, 0x78, 0xEE, 0xCE, 0x1D, 0xDB, 0xC3,
  0xF3, 0x70, 0x7E, 0x6E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3C, 0x07,
  0x87, 0x80, 0x1E, 0x3E, 0x3C, 0x78, 0x39, 0xE0, 0x7F, 0x80, 0xFF, 0x00,
  0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0xF7, 0x83, 0xC7,
  0x8F, 0x8F, 0x00, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0xF0, 0xF1, 0xE0, 0xE7,
  0x81, 0xCF, 0x03, 0xBC, 0x07, 0x78, 0x0E, 0xE0, 0x1F, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0x80, 0x00, 0x1F, 0xE7, 0xFC, 0xFF, 0x81, 0xE0, 0x78, 0x1F, 0x07,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFE, 0x7F, 0xCF, 0xF8, 0x07, 0xC1, 0xE0,
  0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0xFC, 0x3C, 0x0F, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x0F, 0x83, 0xC1, 0xE0,
  0xF0, 0x70, 0x38, 0x1C, 0x0F, 0x83, 0xC3, 0xE3, 0xC1, 0xC1, 0xE0, 0xE0,
  0x70, 0x78, 0x7C, 0x3C, 0x18, 0x00, 0x7C, 0x3F, 0xFF, 0xFF, 0xC1, 0xE0,
};

const GFXglyph NotoSans_ExtraBoldItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 16, 7, 0, -16 },
  { 17, 9, 6, 10, 2, -16 },
  { 24, 15, 16, 15, 0, -16 },
  { 54, 12, 18, 13, 1, -17 },
  { 81, 19, 17, 20, 1, -17 },
  { 122, 16, 17, 17, 0, -17 },
  { 156, 4, 6, 6, 2, -16 },
  { 159, 9, 21, 8, 1, -17 },
  { 183, 9, 21, 8, -2, -17 },
  { 207, 11, 12, 13, 2, -18 },
  { 224, 11, 11, 13, 1, -14 },
  { 240, 6, 6, 7, -1, -3 },
  { 245, 7, 3, 8, 0, -8 },
  { 248, 4, 4, 7, 0, -4 },
  { 250, 13, 17, 10, -1, -17 },
  { 278, 12, 17, 13, 1, -17 },
  { 304, 10, 16, 13, 2, -16 },
  { 324, 13, 17, 13, -1, -17 },
  { 352, 13, 17, 13, 0, -17 },
  { 380, 13, 16, 13, 0, -16 },
  { 406, 13, 16, 13, 0, -16 },
  { 432, 12, 17, 13, 1, -17 },
  { 458, 13, 16, 13, 1, -16 },
  { 484, 12, 17, 13, 1, -17 },
  { 510, 11, 17, 13, 1, -17 },
  { 534, 7, 13, 7, 0, -13 },
  { 546, 8, 16, 7, -1, -13 },
  { 562, 11, 13, 13, 1, -15 },
  { 580, 11, 8, 13, 1, -12 },
  { 591, 11, 13, 13, 1, -15 },
  { 609, 10, 17, 11, 2, -17 },
  { 631, 19, 19, 20, 1, -17 },
  { 677, 15, 16, 15, -1, -16 },
  { 707, 14, 16, 14, 0, -16 },
  { 735, 14, 17, 14, 1, -17 },
  { 765, 15, 16, 16, 0, -16 },
  { 795, 13, 16, 13, 0, -16 },
  { 821, 13, 16, 13, 0, -16 },
  { 847, 15, 17, 16, 1, -17 },
  { 879, 16, 16, 16, 0, -16 },
  { 911, 12, 16, 9, -1, -16 },
  { 935, 12, 21, 8, -4, -16 },
  { 967, 17, 16, 15, 0, -16 },
  { 1001, 11, 16, 12, 0, -16 },
  { 1023, 21, 16, 21, 0, -16 },
  { 1065, 18, 16, 18, 0, -16 },
  { 1101, 15, 17, 17, 1, -17 },
  { 1133, 14, 16, 14, 0, -16 },
  { 1161, 15, 21, 17, 1, -17 },
  { 1201, 14, 16, 15, 0, -16 },
  { 1229, 13, 17, 12, 0, -17 },
  { 1257, 12, 16, 12, 2, -16 },
  { 1281, 15, 16, 16, 1, -16 },
  { 1311, 14, 16, 14, 2, -16 },
  { 1339, 21, 16, 21, 2, -16 },
  { 1381, 17, 16, 15, -1, -16 },
  { 1415, 13, 16, 13, 2, -16 },
  { 1441, 15, 16, 12, -1, -16 },
  { 1471, 10, 21, 8, -1, -17 },
  { 1498, 6, 17, 10, 2, -17 },
  { 1511, 10, 21, 8, -2, -17 },
  { 1538, 12, 10, 13, 0, -16 },
  { 1553, 10, 2, 10, -2, 2 },
  { 1556, 5, 4, 8, 3, -18 },
  { 1559, 12, 13, 14, 1, -13 },
  { 1579, 13, 17, 14, 0, -17 },
  { 1607, 11, 13, 11, 1, -13 },
  { 1625, 13, 17, 14, 1, -17 },
  { 1653, 12, 13, 13, 1, -13 },
  { 1673, 13, 24, 9, -2, -18 },
  { 1712, 14, 19, 14, 0, -13 },
  { 1746, 13, 17, 14, 0, -17 },
  { 1774, 8, 18, 7, 0, -18 },
  { 1792, 11, 24, 7, -3, -18 },
  { 1825, 15, 17, 14, 0, -17 },
  { 1857, 8, 17, 7, 0, -17 },
  { 1874, 20, 13, 21, 0, -13 },
  { 1907, 13, 13, 14, 0, -13 },
  { 1929, 12, 13, 14, 1, -13 },
  { 1949, 14, 19, 14, -1, -13 },
  { 1983, 12, 19, 14, 1, -13 },
  { 2012, 11, 13, 10, 0, -13 },
  { 2030, 11, 13, 11, 0, -13 },
  { 2048, 9, 15, 10, 1, -15 },
  { 2065, 13, 13, 14, 1, -13 },
  { 2087, 12, 13, 12, 1, -13 },
  { 2107, 19, 13, 18, 1, -13 },
  { 2138, 15, 13, 13, -1, -13 },
  { 2163, 15, 19, 12, -2, -13 },
  { 2199, 11, 13, 11, 0, -13 },
  { 2217, 10, 20, 8, 0, -16 },
  { 2242, 3, 22, 13, 5, -17 },
  { 2251, 9, 20, 8, -1, -16 },
  { 2274, 11, 4, 13, 1, -10 },
};

const GFXfont NotoSans_ExtraBoldItalic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic23pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_EXTRABOLDITALIC23PT7B_H_
