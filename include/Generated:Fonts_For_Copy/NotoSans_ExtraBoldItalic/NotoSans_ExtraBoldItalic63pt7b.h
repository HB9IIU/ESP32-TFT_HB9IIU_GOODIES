#ifndef _NOTOSANS_EXTRABOLDITALIC63PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xC0, 0x00, 0x3F, 0xF1, 0xFF, 0x9F,
  0xF0, 0xFF, 0x8F, 0xF8, 0x7F, 0xC7, 0xFC, 0x3F, 0xE3, 0xFC, 0x3F, 0xE3,
  0xFE, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC,
  0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F,
  0x87, 0xF8, 0x3F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xF3, 0xE1, 0xF0, 0x3F, 0xF1, 0xF0, 0x10, 0x1F, 0xF8, 0xF8,
  0x00, 0x0F, 0xFC, 0x78, 0x00, 0x07, 0xFE, 0x7C, 0x00, 0x03, 0xFF, 0xBE,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x0F, 0x7F, 0xF0, 0x00, 0x07, 0x9F, 0xF8, 0x00, 0x07, 0xC7, 0xFC, 0x00,
  0x03, 0xE3, 0xFE, 0x20, 0x01, 0xF1, 0xFF, 0x1C, 0x00, 0xF1, 0xFF, 0x8F,
  0x80, 0xF9, 0xFF, 0xC7, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x1F,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC3, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0,
  0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x83, 0xFC,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x7F,
  0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07,
  0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0xFF, 0x8F, 0xF8, 0x1E, 0x03, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xF0, 0xFF,
  0x1F, 0xF1, 0xFE, 0x3F, 0xFE, 0x3F, 0xEF, 0xFC, 0xFF, 0x1F, 0xFF, 0xCF,
  0xFF, 0xFE, 0x7F, 0xCF, 0xFF, 0xFB, 0xFF, 0xFF, 0x1F, 0xE7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xCF, 0xF1, 0xFF, 0xFF, 0xDF, 0xFF, 0xE7, 0xF8, 0xFF, 0xDF,
  0xF3, 0xFF, 0xF3, 0xFE, 0x3F, 0xE3, 0xFC, 0x3F, 0xF0, 0xFF, 0x1F, 0xF0,
  0xFF, 0x01, 0xC0, 0x7F, 0x87, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x3F,
  0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x03,
  0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0,
  0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0xFF,
  0xE0, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE7, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFE,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x1F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xF8, 0x3F, 0xF8,
  0xFF, 0xF3, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F,
  0xFF, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF3, 0xFE, 0x3F, 0xE3,
  0xFE, 0x3F, 0xC7, 0xFC, 0x7F, 0xC7, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x06, 0x01, 0xFE, 0x00, 0x1F, 0x03, 0xFC, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0xFF, 0xCF, 0xE0, 0x01, 0xFF, 0xDF, 0xC0, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xCF, 0xF0, 0x1F, 0xFF, 0xC0, 0x20, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0x00, 0x1F, 0xF8, 0xFF, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x1F, 0xC3, 0xFE, 0x00, 0x1F, 0x03, 0xFC, 0x00, 0x0C,
  0x07, 0xFC, 0x00, 0x08, 0x0F, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC,
  0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0x0F, 0xC3, 0xFF, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xE7, 0xFC, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xC3, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F,
  0xF8, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F, 0xF8, 0x07,
  0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x9F, 0xFC, 0x01, 0xFF, 0xCF, 0xFE, 0x00,
  0xFF, 0xEF, 0xFE, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x3F, 0xFB, 0xFF, 0x80,
  0x1F, 0xFD, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xE0,
  0x07, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xDF, 0xFC,
  0x00, 0xFF, 0xEF, 0xFE, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x7F, 0xF3, 0xFF,
  0x80, 0x3F, 0xF9, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F,
  0xF0, 0x0F, 0xFE, 0x3F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFF, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x8F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0x87, 0xFF, 0xBF, 0xF0, 0x7F, 0xE7, 0xFE, 0x0F, 0xF8, 0xFF, 0xC0,
  0xFC, 0x3F, 0xF8, 0x1F, 0x07, 0xFE, 0x01, 0x80, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0x3F, 0xFF, 0x00, 0x3F, 0x80, 0xFF, 0xF0, 0x01, 0xF0, 0x07, 0xFF, 0x00,
  0x1C, 0x00, 0x7F, 0xF0, 0x00, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F,
  0x80, 0xFF, 0xF0, 0x03, 0x80, 0x1F, 0xFC, 0x00, 0x80, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF2, 0x00, 0x00, 0x3F, 0xF8, 0xE0, 0x00, 0x1F, 0xFE, 0x3F, 0x80, 0x1F,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFD, 0xFF, 0x80,
  0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x01, 0xFF, 0x3F,
  0xF0, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x7F,
  0xC7, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x7F, 0xE0, 0x07, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x0F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFB, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x08, 0x00, 0x03, 0xFF, 0xC3, 0x80, 0x01, 0xFF, 0xF0,
  0xFC, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00,
  0x81, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x3C, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xF9, 0xFF,
  0xF8, 0x0F, 0xFD, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFC, 0x07, 0xFF, 0x1F, 0xFC,
  0x03, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xE3, 0xFF,
  0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F,
  0xE0, 0x0F, 0xFE, 0x3F, 0xF0, 0x0F, 0xFE, 0x1F, 0xF8, 0x07, 0xFF, 0x0F,
  0xFE, 0x07, 0xFF, 0x87, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0x81, 0xFF, 0x80,
  0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0,
  0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFC, 0x0F, 0xFE,
  0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0x8F, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE3,
  0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFC,
  0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x1F, 0xF8, 0x01, 0xFF,
  0x8F, 0xFC, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F,
  0xF8, 0xFF, 0xE0, 0x3F, 0xF9, 0xFF, 0xC0, 0x7F, 0xF7, 0xFF, 0x00, 0x7F,
  0xEF, 0xFE, 0x00, 0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFF,
  0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xFD, 0xFF, 0x80, 0x3F, 0xFB,
  0xFF, 0x00, 0xFF, 0xF7, 0xFF, 0x01, 0xFF, 0xEF, 0xFE, 0x07, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xBF, 0xF0, 0xFF, 0xFF, 0x7F, 0xE0, 0xFF,
  0xFD, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x00, 0x0E, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x18, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xC7, 0xF0, 0x1F, 0xFC, 0x78, 0x03, 0xFF, 0x88, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFC, 0x1F,
  0xE0, 0x0F, 0xFF, 0xFC, 0x7F, 0x87, 0xF8, 0x07, 0xFF, 0xFF, 0x07, 0xF0,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0x3F, 0xC0, 0x7F, 0xFF, 0xFC, 0x1F,
  0xE7, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFD, 0xFE, 0x07, 0xFE, 0x0F, 0xE0,
  0x7F, 0xBF, 0xC0, 0xFF, 0x81, 0xFC, 0x0F, 0xF7, 0xF0, 0x3F, 0xE0, 0x7F,
  0x81, 0xFE, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xFF, 0xC1, 0xFE, 0x01,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xC0, 0x3F, 0x80, 0xFF, 0xFE, 0x07, 0xF0,
  0x0F, 0xF0, 0x1F, 0xDF, 0xC1, 0xFE, 0x01, 0xFE, 0x03, 0xFB, 0xF8, 0x3F,
  0xC0, 0x3F, 0x80, 0xFF, 0x7F, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xCF, 0xE0,
  0xFF, 0x01, 0xFE, 0x07, 0xF9, 0xFC, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x3F,
  0x83, 0xFC, 0x0F, 0xF8, 0x3F, 0xC7, 0xF0, 0x7F, 0x83, 0xFF, 0x0F, 0xF8,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x83, 0xFC, 0x1F, 0xFF, 0xDF, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xF3, 0xFF,
  0xF8, 0x07, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x03,
  0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x07, 0xFE,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xF8,
  0x00, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x1F,
  0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xF8,
  0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x01,
  0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xFC,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF0,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x3F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0x3F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x7F, 0xC0, 0x3F, 0xFF, 0x00, 0x3E, 0x01, 0xFF, 0xF0, 0x00, 0x18,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0x00, 0x3F, 0xFE, 0x00, 0x3C, 0x00, 0xFF,
  0xFE, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x7F,
  0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x07,
  0xFE, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x1F, 0xFC,
  0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xF8, 0x01, 0xFF,
  0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x07, 0xF8, 0x03, 0xFF, 0xF8, 0x00,
  0x78, 0x07, 0xFF, 0xE0, 0x00, 0x10, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0xFC, 0x7F, 0xF0, 0x0F, 0xFF, 0xFC, 0x7F, 0xF0, 0x0F, 0xFF,
  0xF8, 0x7F, 0xF0, 0x1F, 0xFF, 0xF8, 0x7F, 0xF0, 0x1F, 0xFF, 0xF8, 0x7F,
  0xF0, 0x1F, 0xFF, 0xF8, 0x7F, 0xE0, 0x1F, 0xFF, 0xF8, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xF0,
  0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x00, 0xFF,
  0xE0, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F,
  0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xC1, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x7F, 0xF8, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xF1, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x9F, 0xFE, 0x00, 0x00,
  0x1F, 0xFD, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x07,
  0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0x7F,
  0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0x7F, 0x00, 0x1F, 0xEF, 0xF8, 0x01,
  0xFF, 0x7F, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0x7F, 0x00, 0x3F, 0xDF,
  0xF8, 0x01, 0xFF, 0x7F, 0x00, 0x3F, 0xDF, 0xF0, 0x03, 0xFF, 0x7F, 0x00,
  0x7F, 0x9F, 0xF0, 0x03, 0xFE, 0x7F, 0x00, 0x7F, 0xBF, 0xF0, 0x03, 0xFE,
  0x7F, 0x00, 0xFF, 0x3F, 0xF0, 0x03, 0xFE, 0x7F, 0x80, 0xFF, 0x3F, 0xE0,
  0x07, 0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0xE0, 0x07, 0xFE, 0x7F, 0x81, 0xFE,
  0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0x83, 0xFC, 0x7F, 0xE0, 0x07, 0xFC, 0x7F,
  0x83, 0xFC, 0x7F, 0xE0, 0x07, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0xC0, 0x0F,
  0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0x8F, 0xF0, 0xFF,
  0xC0, 0x0F, 0xFC, 0x7F, 0x8F, 0xF0, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0x9F,
  0xE0, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0x9F, 0xE0, 0xFF, 0x80, 0x1F, 0xF8,
  0x7F, 0xBF, 0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xBF, 0xC1, 0xFF, 0x80,
  0x1F, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xFF, 0x81,
  0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xF0, 0x7F,
  0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xFE, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xFC,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x7F, 0xE0, 0x1F,
  0xF8, 0x01, 0xFF, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x1F,
  0xF8, 0x03, 0xFE, 0x3F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x3F, 0xF0, 0x3F,
  0xF0, 0x03, 0xFE, 0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x3F,
  0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x3F,
  0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xFC, 0x0F, 0xFC, 0x7F,
  0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0x07, 0xFC, 0x7F,
  0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0x7F,
  0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xF8,
  0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x00, 0x1F,
  0xFC, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x9F, 0xFE, 0x00, 0x01, 0xFF, 0xCF, 0xFE, 0x00,
  0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x00, 0x3F,
  0xFB, 0xFF, 0x80, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00,
  0x03, 0xFF, 0xDF, 0xF8, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0xFF,
  0xEF, 0xFE, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x7F, 0xF3, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x1F, 0xFE,
  0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFF,
  0xF8, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x81,
  0xFF, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x3F,
  0xFE, 0x07, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x00,
  0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x00, 0x1F, 0xFC,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x9F, 0xFE, 0x00, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x00,
  0xFF, 0xE7, 0xFF, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x00, 0x3F, 0xFB,
  0xFF, 0x80, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x03,
  0xFF, 0xDF, 0xF8, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0xFF, 0xEF,
  0xFE, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x7F, 0xF0, 0x00, 0x3F,
  0xFC, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x0F,
  0xFF, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFE,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0xF0, 0x07,
  0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFE, 0x07,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x1F,
  0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF,
  0xC0, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF0,
  0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xF8,
  0xFF, 0xC0, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xF8, 0x3F, 0x80, 0x3F, 0xF8, 0x01, 0xC0, 0x1F, 0xFC, 0x00,
  0x10, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x08, 0x00,
  0x03, 0xFF, 0x03, 0x80, 0x01, 0xFF, 0xC0, 0xF8, 0x00, 0xFF, 0xF0, 0x3F,
  0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xFC,
  0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x7F, 0xFE, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xEF,
  0xFE, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x00,
  0x7F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xFE, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0xFF, 0xC0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00,
  0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFB, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xC0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0x07, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xF0,
  0x07, 0xFF, 0xF0, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xBF,
  0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x1F, 0xEF, 0xF0, 0x3F, 0xF8, 0x07, 0xFC,
  0x0F, 0xFB, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFF,
  0x00, 0x7F, 0xC1, 0xFF, 0x3F, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xCF,
  0xF0, 0x7F, 0xE0, 0x07, 0xFC, 0x1F, 0xE3, 0xFC, 0x3F, 0xF0, 0x01, 0xFF,
  0x0F, 0xF8, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFE,
  0x00, 0x1F, 0xF1, 0xFF, 0x0F, 0xF1, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xC3,
  0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0xFF, 0x3F, 0xF0, 0x00, 0x7F,
  0xCF, 0xF8, 0x3F, 0xCF, 0xFC, 0x00, 0x1F, 0xF3, 0xFC, 0x0F, 0xF3, 0xFE,
  0x00, 0x07, 0xFD, 0xFF, 0x03, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0x80,
  0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xDF, 0xE0, 0x3F, 0xDF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFB, 0xFF, 0x80, 0x07, 0xFF,
  0x9F, 0xFC, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0xC3, 0xFF, 0x00,
  0x1F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFE, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x7F,
  0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF,
  0xC3, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0x80,
  0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0xFF, 0x3F, 0xC0,
  0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x83, 0xF8,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x3F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x03,
  0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x3F, 0x8F, 0xF8, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xF8, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xE1, 0xFF, 0x87, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x81,
  0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x1F, 0xFE,
  0x1F, 0xF0, 0x0F, 0xFF, 0xC7, 0xF8, 0x07, 0xFF, 0xFB, 0xFE, 0x03, 0xFF,
  0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x9F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC3,
  0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xF8, 0x07, 0xFE,
  0x1F, 0xFC, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x1F,
  0xF8, 0xFF, 0xE0, 0x07, 0xFE, 0x3F, 0xF8, 0x03, 0xFF, 0x0F, 0xFE, 0x00,
  0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0,
  0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE0, 0xFF,
  0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x7F, 0x80, 0x3F, 0xFF, 0xBF,
  0xE0, 0x07, 0xFF, 0xCF, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE1,
  0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF9, 0xFF, 0xF0,
  0x7F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF,
  0xC1, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xF0, 0x07,
  0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0x80,
  0x1F, 0xFC, 0x7F, 0xE0, 0x07, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xE0, 0x1F, 0xFC, 0x3F,
  0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xE7, 0xFF, 0xF0, 0x0F, 0xF8, 0xFF, 0xF8, 0x03, 0xFC, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0x87, 0xC1, 0xFF, 0xF0, 0x06, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x38, 0x3F, 0xFC, 0x07, 0xC1, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0xE0, 0x01,
  0xFF, 0xE7, 0xFF, 0x00, 0x1F, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0xFD, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x8F, 0xFF, 0x80,
  0x7F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x07,
  0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x03, 0xFE,
  0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xE0,
  0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F,
  0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFD, 0xFE, 0x00, 0x1F, 0xFF,
  0xCF, 0xF0, 0x00, 0x7F, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xC7, 0xFF,
  0x1F, 0xFE, 0x07, 0xFE, 0x3F, 0xF8, 0x0F, 0xFC, 0xFF, 0xE0, 0x1F, 0xF9,
  0xFF, 0xC0, 0x3F, 0xF7, 0xFF, 0x00, 0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0x9F,
  0xF8, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x83, 0xFF, 0xC0,
  0x07, 0x07, 0xFF, 0xC0, 0x7E, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x10, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0E, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0xE1, 0xFF, 0x00, 0x3F,
  0xFF, 0x1F, 0xF0, 0x07, 0xFF, 0xFB, 0xFE, 0x00, 0xFF, 0xFF, 0xBF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xE7, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x81,
  0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x1F,
  0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF8,
  0x03, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC,
  0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xF9, 0xFF, 0x80, 0x01, 0xFE,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x08, 0x00, 0x07, 0xFE,
  0x00, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE1, 0xFE, 0x00, 0x1F, 0xF9,
  0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F,
  0xF0, 0xFF, 0xF0, 0x0F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x0F, 0xFE, 0x01,
  0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xF0,
  0x07, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xE1, 0xFF,
  0x80, 0x3F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x0F,
  0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x1F, 0xFC,
  0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0xFF,
  0xE1, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFE, 0x3F, 0xF8, 0x03,
  0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x1F,
  0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x03, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFF,
  0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xFE,
  0x00, 0x3F, 0xF0, 0x7F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0xE0, 0x01, 0xFF,
  0xC7, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xF8,
  0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00, 0x7F,
  0xEF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x07,
  0xFF, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x1F,
  0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0xC0,
  0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x01,
  0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0x1F, 0xE3, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x7F, 0x9F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x03, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0x0F, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xF8,
  0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xE0,
  0x1F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xE1, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x0F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0xFF,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x7F, 0x87, 0xFF, 0x80, 0x1F, 0xE3, 0xFF, 0xF0, 0x07, 0xF9, 0xFF,
  0xFE, 0x03, 0xFE, 0xFF, 0xFF, 0x80, 0xFF, 0xBF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF3, 0xFF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x07,
  0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFC,
  0x3F, 0xF8, 0x07, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x7F,
  0xE1, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x03,
  0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xE0,
  0x0F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF,
  0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x1F,
  0xFC, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x3F, 0xF8,
  0xFF, 0xE0, 0x0F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x1F,
  0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x3F, 0xF8, 0x07,
  0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x0F,
  0xFE, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xC0, 0x1F,
  0xFC, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xF0, 0x7F,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xFC, 0x00, 0x0F,
  0xF3, 0xFF, 0xF0, 0x00, 0x7F, 0xBF, 0xFF, 0xC0, 0x07, 0xFD, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xC0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F,
  0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF,
  0xC0, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0xC0,
  0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F,
  0xFE, 0x01, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0xF8, 0x00, 0xFF, 0xC7,
  0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x18, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xFE,
  0x1F, 0xF0, 0x0F, 0xFF, 0xC7, 0xF8, 0x07, 0xFF, 0xFB, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC3,
  0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xF8, 0x07, 0xFE,
  0x1F, 0xFC, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x1F,
  0xF8, 0xFF, 0xE0, 0x07, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0x0F, 0xFE, 0x00,
  0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0,
  0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0, 0xFF,
  0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x7F,
  0xE0, 0x07, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x07, 0x83,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x07, 0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFE, 0x3F,
  0xF0, 0x1F, 0xE7, 0xFF, 0x03, 0xFE, 0x7F, 0xF0, 0x3F, 0xEF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xE0, 0xFC, 0x1F, 0xFC, 0x03,
  0xC1, 0xFF, 0xC0, 0x08, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x88, 0x00, 0x1F, 0xF8,
  0xE0, 0x03, 0xFF, 0x8F, 0xE0, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFA,
  0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE,
  0x0C, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x00,
  0x7F, 0xE0, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x83, 0xFF,
  0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x83,
  0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFC, 0x01, 0xFF,
  0xC1, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x0F, 0xFE, 0x00,
  0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF0, 0x07, 0xFF, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF8, 0x07, 0xFF, 0x07,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xDF, 0xF0, 0x1F, 0xFF, 0xFB, 0xFC, 0x03, 0xFF,
  0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0x9F, 0xF0, 0x03, 0xFF, 0xE3, 0xFE, 0x00,
  0x3F, 0xF0, 0x7F, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x00,
  0x1F, 0xFC, 0xFF, 0xE0, 0x07, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x87, 0xFE,
  0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0,
  0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x3F, 0xF8, 0x03, 0xFE, 0x0F, 0xFC,
  0x00, 0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x0F, 0xF8, 0xFF,
  0xE0, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0x9F, 0xFC, 0x00, 0x3F, 0xE7,
  0xFE, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0xC0, 0x00, 0x7F,
  0xBF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xEF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFB, 0xFE, 0x00, 0xFF,
  0xF0, 0x0F, 0xFE, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0x3F, 0xE0, 0x1F,
  0xFF, 0x01, 0xFF, 0xCF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xE3, 0xFE, 0x03,
  0xFF, 0xF0, 0x3F, 0xF8, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFC, 0x3F, 0xE0,
  0x7F, 0x7F, 0x03, 0xFF, 0x0F, 0xF8, 0x1F, 0xDF, 0xC1, 0xFF, 0x83, 0xFE,
  0x0F, 0xF7, 0xF0, 0x7F, 0xE0, 0xFF, 0x83, 0xF9, 0xFC, 0x3F, 0xF0, 0x3F,
  0xE0, 0xFE, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x7F, 0xBF, 0xC7, 0xFE, 0x03,
  0xFE, 0x1F, 0xCF, 0xF1, 0xFF, 0x80, 0xFF, 0x8F, 0xF3, 0xFC, 0x7F, 0xC0,
  0x3F, 0xE3, 0xFC, 0xFF, 0x3F, 0xF0, 0x0F, 0xF9, 0xFE, 0x3F, 0xCF, 0xF8,
  0x01, 0xFE, 0x7F, 0x8F, 0xF7, 0xFE, 0x00, 0x7F, 0x9F, 0xC3, 0xFD, 0xFF,
  0x00, 0x1F, 0xEF, 0xF0, 0xFF, 0x7F, 0xC0, 0x07, 0xFB, 0xFC, 0x3F, 0xFF,
  0xF0, 0x01, 0xFE, 0xFE, 0x0F, 0xEF, 0xF8, 0x00, 0x7F, 0xFF, 0x83, 0xFB,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x7F,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC3, 0xFF, 0xC0,
  0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x00, 0x1F,
  0xF9, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x00,
  0x7F, 0xF1, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xFC, 0x00,
  0x03, 0xFE, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00, 0x3F, 0xF1, 0xFF,
  0x80, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xBF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x67,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x02, 0x3F, 0xFC,
  0x00, 0x0D, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFD, 0xC0, 0x03, 0xFF, 0xF2, 0x00, 0x01, 0xFF,
  0x80,
};

const GFXglyph NotoSans_ExtraBoldItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 20, 46, 19, 1, -45 },
  { 116, 25, 16, 29, 6, -45 },
  { 166, 40, 45, 41, 1, -45 },
  { 391, 33, 52, 36, 2, -48 },
  { 606, 50, 47, 56, 4, -46 },
  { 900, 44, 47, 45, 1, -46 },
  { 1159, 12, 16, 16, 6, -45 },
  { 1183, 25, 56, 22, 2, -46 },
  { 1358, 24, 56, 22, -4, -46 },
  { 1526, 31, 31, 34, 5, -48 },
  { 1647, 31, 31, 36, 3, -38 },
  { 1768, 16, 15, 19, -3, -7 },
  { 1798, 18, 8, 21, 1, -21 },
  { 1816, 12, 11, 19, 0, -10 },
  { 1833, 35, 46, 28, -3, -45 },
  { 2035, 33, 47, 36, 2, -46 },
  { 2229, 27, 45, 36, 5, -45 },
  { 2381, 36, 46, 36, -2, -46 },
  { 2588, 34, 47, 36, 0, -46 },
  { 2788, 36, 45, 36, -1, -45 },
  { 2991, 34, 46, 36, 1, -45 },
  { 3187, 33, 47, 36, 3, -46 },
  { 3381, 36, 45, 36, 2, -45 },
  { 3584, 33, 47, 36, 2, -46 },
  { 3778, 31, 47, 36, 3, -46 },
  { 3961, 18, 36, 19, 0, -35 },
  { 4042, 21, 43, 19, -3, -35 },
  { 4155, 31, 34, 36, 3, -40 },
  { 4287, 31, 20, 36, 3, -32 },
  { 4365, 31, 34, 36, 3, -40 },
  { 4497, 27, 47, 30, 5, -46 },
  { 4656, 51, 51, 55, 3, -45 },
  { 4982, 41, 45, 41, -4, -45 },
  { 5213, 38, 45, 39, 1, -45 },
  { 5427, 38, 47, 39, 3, -46 },
  { 5651, 40, 45, 43, 1, -45 },
  { 5876, 36, 45, 35, 1, -45 },
  { 6079, 36, 45, 35, 1, -45 },
  { 6282, 40, 47, 44, 3, -46 },
  { 6517, 44, 45, 45, 1, -45 },
  { 6765, 31, 45, 25, -2, -45 },
  { 6940, 32, 59, 22, -10, -45 },
  { 7176, 45, 45, 40, 1, -45 },
  { 7430, 28, 45, 33, 1, -45 },
  { 7588, 56, 45, 56, 1, -45 },
  { 7903, 48, 45, 49, 1, -45 },
  { 8173, 41, 47, 46, 3, -46 },
  { 8414, 38, 45, 39, 1, -45 },
  { 8628, 41, 57, 46, 3, -46 },
  { 8921, 37, 45, 40, 1, -45 },
  { 9130, 34, 47, 34, 1, -46 },
  { 9330, 33, 45, 34, 5, -45 },
  { 9516, 40, 46, 44, 4, -45 },
  { 9746, 38, 45, 38, 5, -45 },
  { 9960, 58, 45, 58, 5, -45 },
  { 10287, 49, 45, 40, -4, -45 },
  { 10563, 37, 45, 37, 5, -45 },
  { 10772, 39, 45, 34, -2, -45 },
  { 10992, 27, 56, 22, -1, -46 },
  { 11181, 16, 46, 28, 7, -45 },
  { 11273, 27, 56, 22, -4, -46 },
  { 11462, 33, 29, 34, 0, -45 },
  { 11582, 28, 6, 27, -6, 5 },
  { 11603, 14, 10, 21, 9, -48 },
  { 11621, 34, 36, 38, 3, -35 },
  { 11774, 34, 49, 38, 1, -48 },
  { 11983, 29, 36, 31, 3, -35 },
  { 12114, 37, 49, 38, 3, -48 },
  { 12341, 31, 36, 36, 3, -35 },
  { 12481, 38, 63, 25, -7, -48 },
  { 12781, 36, 50, 38, 1, -35 },
  { 13006, 34, 48, 39, 1, -48 },
  { 13210, 20, 48, 20, 1, -48 },
  { 13330, 29, 63, 20, -8, -48 },
  { 13559, 39, 48, 37, 1, -48 },
  { 13793, 21, 48, 20, 1, -48 },
  { 13919, 54, 35, 58, 1, -35 },
  { 14156, 34, 35, 39, 1, -35 },
  { 14305, 32, 36, 37, 3, -35 },
  { 14449, 37, 50, 38, -2, -35 },
  { 14681, 34, 50, 38, 3, -35 },
  { 14894, 28, 35, 27, 1, -35 },
  { 15017, 28, 36, 31, 1, -35 },
  { 15143, 26, 43, 27, 2, -42 },
  { 15283, 35, 36, 39, 3, -35 },
  { 15441, 34, 35, 33, 3, -35 },
  { 15590, 50, 35, 51, 4, -35 },
  { 15809, 41, 35, 35, -3, -35 },
  { 15989, 41, 50, 33, -4, -35 },
  { 16246, 32, 35, 30, -1, -35 },
  { 16386, 27, 55, 22, 0, -45 },
  { 16572, 7, 62, 35, 14, -48 },
  { 16627, 26, 55, 22, -3, -45 },
  { 16806, 31, 11, 36, 3, -28 },
};

const GFXfont NotoSans_ExtraBoldItalic63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic63pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_EXTRABOLDITALIC63PT7B_H_
