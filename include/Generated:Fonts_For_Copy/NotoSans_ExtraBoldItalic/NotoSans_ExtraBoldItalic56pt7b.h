#ifndef _NOTOSANS_EXTRABOLDITALIC56PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0,
  0x1F, 0xF8, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xE3,
  0xFC, 0xFF, 0x0F, 0xF3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0x87, 0xF9,
  0xFE, 0x1F, 0xE7, 0xF8, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xF8, 0x7E, 0x0F, 0xE3, 0xF8, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x03,
  0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x1F,
  0xC1, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00,
  0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFC,
  0xF0, 0x70, 0x1F, 0xE3, 0xC0, 0x40, 0xFF, 0x8F, 0x00, 0x03, 0xFE, 0x7C,
  0x00, 0x0F, 0xFD, 0xE0, 0x00, 0x1F, 0xF7, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xEF, 0xFC, 0x00, 0x07,
  0x9F, 0xF0, 0x00, 0x1E, 0x7F, 0xC0, 0x00, 0xF1, 0xFF, 0x30, 0x03, 0xC7,
  0xFC, 0xF8, 0x0F, 0x3F, 0xE3, 0xFE, 0x3D, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x0F,
  0xFF, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0xFE,
  0x00, 0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0x80,
  0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x7F,
  0x00, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x3F, 0x80,
  0x03, 0xFC, 0x3F, 0xC3, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x3F, 0x80, 0x00,
  0xFE, 0x0F, 0xE3, 0xFC, 0x0C, 0x07, 0xF0, 0xFF, 0x1F, 0xC7, 0xFE, 0x3F,
  0xCF, 0xF1, 0xFC, 0x7F, 0xF9, 0xFF, 0xFF, 0x9F, 0xC7, 0xFF, 0xE7, 0xFF,
  0xF9, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0xCF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFC,
  0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xCF, 0xE3, 0xFC, 0x7F, 0x0F, 0xF8, 0xFF,
  0x1F, 0xC3, 0xF8, 0x06, 0x07, 0xF1, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F,
  0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x83, 0xF8,
  0x3F, 0x80, 0x03, 0xF8, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0x81, 0xFE, 0x1F,
  0xE0, 0x03, 0xF8, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x07, 0xF0,
  0x01, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xC0, 0x1F, 0xE7, 0xF8, 0x01,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x01,
  0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xE1, 0xFF, 0x80, 0x00,
  0x3F, 0xE7, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x3F, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xFF,
  0x80, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFC,
  0x3F, 0xFB, 0xFF, 0x1F, 0xF8, 0xFF, 0xE7, 0xFE, 0x3F, 0xE1, 0xFF, 0x87,
  0xFE, 0xFF, 0x83, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xFC, 0x0F, 0xFF, 0xFC,
  0x1F, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xF0, 0x0F, 0xFF, 0xE0, 0x7F, 0xE0,
  0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0xF0, 0x7F, 0xF0, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x3F, 0xE7, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0xFF,
  0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xE1, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x01, 0x00, 0xFE, 0x00, 0x18, 0x0F, 0xE0, 0x03, 0xE0, 0xFE,
  0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xFE, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0x02,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xF7, 0xF0, 0x03, 0xFE,
  0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x00, 0x7C, 0x3F, 0xC0, 0x03, 0x83, 0xFC,
  0x00, 0x10, 0x1F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC3, 0xFE, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF,
  0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0x1F, 0x87, 0xF9, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x7F,
  0x83, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC7, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0x00, 0xFF,
  0x9F, 0xF8, 0x07, 0xFC, 0xFF, 0xC0, 0x3F, 0xEF, 0xFC, 0x03, 0xFF, 0x7F,
  0xE0, 0x1F, 0xFB, 0xFF, 0x00, 0xFF, 0xDF, 0xF0, 0x07, 0xFE, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFB, 0xFF, 0x00, 0x7F,
  0xDF, 0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xF7, 0xFC, 0x01, 0xFF, 0xBF,
  0xE0, 0x0F, 0xF9, 0xFF, 0x00, 0xFF, 0xCF, 0xF8, 0x07, 0xFE, 0x7F, 0xC0,
  0x7F, 0xE3, 0xFE, 0x03, 0xFF, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF,
  0x87, 0xFF, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE3, 0xFF, 0x7F, 0xC7, 0xFC, 0xFF, 0x87,
  0xE3, 0xFE, 0x0F, 0x07, 0xFC, 0x0C, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xDF, 0xFE, 0x01, 0xFC, 0x0F, 0xFC, 0x01, 0xE0, 0x0F, 0xF8,
  0x01, 0x80, 0x1F, 0xF0, 0x02, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x00, 0xFC, 0x1F, 0xFC, 0x01, 0xC0, 0x3F, 0xF0, 0x04, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0x20, 0x00, 0x0F, 0xFC, 0xE0, 0x00, 0x7F, 0xF3,
  0xF0, 0x07, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x3F,
  0xCF, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x9F, 0xF0, 0x01, 0xFF,
  0x1F, 0xF0, 0x01, 0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xF8,
  0x3F, 0xE0, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x20, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x88, 0x00, 0x0F, 0xFE, 0x30, 0x00,
  0x7F, 0xF0, 0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x08, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x3F, 0xE7, 0xFF, 0x00, 0xFF, 0x3F, 0xFE, 0x07, 0xFD, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0x87, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0xFF, 0xE0, 0x3F, 0xE3, 0xFF, 0x00,
  0xFF, 0xCF, 0xFC, 0x03, 0xFE, 0x3F, 0xF0, 0x0F, 0xF8, 0xFF, 0xC0, 0x3F,
  0xE3, 0xFE, 0x00, 0xFF, 0x8F, 0xFC, 0x07, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0,
  0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1,
  0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x1F, 0xE0, 0x3F,
  0xE0, 0xFF, 0x80, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFC, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x1F,
  0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0xCF, 0xF8,
  0x01, 0xFF, 0x3F, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0x81,
  0xFF, 0x87, 0xFF, 0x9F, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F,
  0xF8, 0x7F, 0xEF, 0xFE, 0x0F, 0xFD, 0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x1F,
  0xF7, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFD, 0xFE, 0x1F, 0xFF, 0x7F, 0xC1, 0xFF, 0xCF, 0xF8,
  0x1F, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x10,
  0x0F, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFE, 0x03, 0xFF,
  0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x03, 0xFC,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x1C, 0x00, 0x00, 0x1F,
  0x80, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0x83, 0xFF, 0x1C, 0x01, 0xFF,
  0x10, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x80,
  0x06, 0x00, 0x3F, 0x83, 0xFC, 0x03, 0xFF, 0xE0, 0xFE, 0x0F, 0xE0, 0x3F,
  0xFF, 0xE1, 0xF8, 0x7F, 0x01, 0xFF, 0xFF, 0x87, 0xF1, 0xFC, 0x0F, 0xFF,
  0xFC, 0x1F, 0xCF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0x3F, 0x83, 0xFE, 0x1F,
  0xC1, 0xFC, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x01, 0xF8,
  0x1F, 0xDF, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x7E, 0x0F, 0xE0, 0x3F, 0x81,
  0xFD, 0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xE7, 0xE0, 0xFE, 0x03, 0xF0, 0x1F,
  0xBF, 0x87, 0xF0, 0x1F, 0xC0, 0xFE, 0xFE, 0x1F, 0xC0, 0x7F, 0x03, 0xFB,
  0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xCF, 0xE1, 0xFC, 0x0F, 0xF0, 0x7F, 0x3F,
  0x87, 0xF0, 0x7F, 0x83, 0xF8, 0xFE, 0x1F, 0xE3, 0xFF, 0x3F, 0xE1, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xC1,
  0xFF, 0xEF, 0xFF, 0xC0, 0x7F, 0x03, 0xFF, 0x1F, 0xFE, 0x00, 0xFE, 0x07,
  0xF8, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xE7,
  0xF8, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x07,
  0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE1,
  0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x03,
  0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F,
  0xF8, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFE,
  0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0xC0, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xF1, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0x80, 0xFF,
  0xF0, 0x00, 0x60, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x80, 0x7F, 0xF8, 0x01, 0xC0,
  0x1F, 0xFF, 0x87, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xFC, 0x0F,
  0xFC, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xF0, 0x01,
  0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0x1F,
  0xF8, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x03, 0xFE,
  0x1F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x07,
  0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xE0,
  0x0F, 0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x7F, 0x80, 0xFF, 0xF8,
  0x00, 0xE0, 0x3F, 0xFC, 0x00, 0x04, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x81, 0xFF, 0xFE, 0x3F, 0xF0, 0x3F, 0xFF, 0xCF, 0xFC, 0x07,
  0xFF, 0xF9, 0xFF, 0x80, 0xFF, 0xFF, 0x3F, 0xF0, 0x3F, 0xFF, 0xC7, 0xFE,
  0x07, 0xFF, 0xF8, 0xFF, 0xC0, 0xFF, 0xFF, 0x1F, 0xF8, 0x1F, 0xFF, 0xE3,
  0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x3F,
  0xE1, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0x3F, 0xE0, 0x7F, 0xF0, 0x07, 0xFC, 0x0F, 0xFF, 0xC7, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF8,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x01,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x01,
  0xFF, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0x01, 0xFF, 0x03,
  0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x3F, 0xE3, 0xFF, 0x80, 0x00, 0x7F, 0xC7,
  0xFE, 0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xF1, 0xFF, 0x80,
  0x00, 0x7F, 0xC3, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x01, 0xFF,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xF8, 0x00, 0x7F,
  0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F,
  0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xBF,
  0x00, 0x3F, 0xBF, 0xC0, 0x3F, 0xDF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xEF,
  0xE0, 0x1F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF0, 0x1F, 0xEF, 0xF0, 0x0F, 0xFB,
  0xF8, 0x0F, 0xE7, 0xF8, 0x07, 0xF9, 0xFC, 0x0F, 0xF7, 0xFC, 0x03, 0xFC,
  0xFE, 0x07, 0xF3, 0xFE, 0x01, 0xFE, 0x7F, 0x07, 0xF9, 0xFE, 0x01, 0xFF,
  0x3F, 0x83, 0xF8, 0xFF, 0x00, 0xFF, 0x9F, 0xC1, 0xFC, 0xFF, 0x80, 0x7F,
  0xCF, 0xE1, 0xFC, 0x7F, 0xC0, 0x3F, 0xC7, 0xF0, 0xFE, 0x3F, 0xE0, 0x1F,
  0xE3, 0xF8, 0xFE, 0x1F, 0xE0, 0x1F, 0xF1, 0xFC, 0x7F, 0x1F, 0xF0, 0x0F,
  0xF8, 0xFE, 0x7F, 0x0F, 0xF8, 0x07, 0xF8, 0x7F, 0x3F, 0x87, 0xFC, 0x03,
  0xFC, 0x3F, 0xBF, 0x83, 0xFC, 0x01, 0xFE, 0x1F, 0xDF, 0xC1, 0xFE, 0x01,
  0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0x80,
  0x7F, 0x83, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0xC1, 0xFF, 0xF0, 0x3F, 0xC0,
  0x1F, 0xE0, 0xFF, 0xF0, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0xF8, 0x1F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xFC, 0x07, 0xFC,
  0x03, 0xFC, 0x0F, 0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFE,
  0x01, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xE0, 0x1F, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0xE0,
  0x07, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xDF, 0xE0, 0x1F, 0xF0, 0x07, 0xFB, 0xFE, 0x03, 0xFE, 0x00, 0xFF,
  0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE7, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0xFF,
  0x83, 0xFE, 0x00, 0xFF, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xE1, 0xFE, 0x0F,
  0xF8, 0x07, 0xFC, 0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x3F, 0xC0,
  0x1F, 0xF0, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x0F, 0xF9, 0xFF, 0x00, 0x7F,
  0x81, 0xFF, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE7, 0xF8, 0x03, 0xFE, 0x03,
  0xFE, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xDF, 0xE0, 0x0F, 0xF0, 0x0F, 0xFB,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xF0,
  0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xE3, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF,
  0x1F, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0x1F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x1F, 0xF7, 0xFE,
  0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x03, 0xFF,
  0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x0F, 0xFC,
  0xFF, 0xC0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x03,
  0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF,
  0xE3, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F,
  0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07,
  0xFC, 0x0F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x03,
  0xFF, 0x83, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xF7, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x3F, 0xF1, 0xFF,
  0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00,
  0x1F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00,
  0x7F, 0xEF, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xCF, 0xFC,
  0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xF0,
  0x7F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x3F, 0xFE, 0x01,
  0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFF,
  0x03, 0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x7F,
  0xE0, 0x07, 0xFE, 0x3F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07,
  0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0,
  0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8,
  0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0xC3, 0xFE,
  0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x87, 0xE0, 0x1F, 0xF8, 0x03,
  0x80, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x30, 0x00, 0x7F, 0xE0, 0xF0,
  0x01, 0xFF, 0x83, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x3F,
  0xF0, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0x83, 0xFF, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF,
  0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0xC1,
  0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F,
  0xC1, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF, 0x07, 0xFC, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x87,
  0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xF8, 0x01, 0xFF,
  0x83, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x01,
  0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFE, 0x07, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xFB, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x7F, 0xEF,
  0xF8, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x3F, 0xF1,
  0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xFC,
  0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xFE, 0x07, 0xF8, 0x03, 0xFE,
  0x03, 0xFC, 0x03, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x81, 0xFF,
  0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F,
  0xC0, 0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x3F,
  0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xCF,
  0xF8, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x07, 0xFB,
  0xFE, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x7F,
  0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xEF, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xF9,
  0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x3F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xC7, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xFC, 0x03,
  0xFE, 0x1F, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0xF0,
  0x1F, 0xF8, 0x7F, 0xC0, 0x7F, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xC1, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0x7F, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x83,
  0xFB, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0x7F, 0x83, 0xFE, 0x03, 0xFE,
  0x1F, 0xEF, 0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xF9, 0xFE, 0x1F, 0xF0, 0x0F,
  0xF8, 0xFF, 0x3F, 0xC7, 0xFC, 0x01, 0xFE, 0x1F, 0xC7, 0xF8, 0xFF, 0x80,
  0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x1F, 0xE7, 0xFC,
  0x00, 0xFF, 0x3F, 0xC3, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x7F, 0xBF,
  0xE0, 0x01, 0xFC, 0xFE, 0x0F, 0xF7, 0xFC, 0x00, 0x3F, 0xBF, 0xC0, 0xFE,
  0xFF, 0x00, 0x07, 0xF7, 0xF0, 0x1F, 0xFF, 0xE0, 0x00, 0xFE, 0xFE, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x8F, 0xFE,
  0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x00, 0x3F, 0xF3, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x87, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x07,
  0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0x87, 0xFC,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0x07,
  0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x3F, 0xF0, 0x00,
  0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xDF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xE7, 0xE0, 0x00,
  0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x7F,
  0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x80,
  0x7E, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x0F,
  0xC1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFE, 0x7F, 0x80, 0x03, 0xFB,
  0xFC, 0x00, 0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0xFF,
  0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE,
  0x03, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0xE3, 0xFC, 0x07, 0xFF,
  0xC7, 0xF0, 0x1F, 0xFF, 0xDF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF,
  0x87, 0xFE, 0x01, 0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x07, 0xFC,
  0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xE1, 0xFF, 0x80, 0x7F, 0xC3,
  0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xF7, 0xF8, 0x03, 0xFF, 0xCF, 0xF0, 0x01, 0xFE,
  0x1F, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x3F, 0x80, 0x0F, 0xF9, 0xFF, 0x80, 0x3F,
  0xEF, 0xFF, 0x00, 0xFF, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xC7, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x3F, 0xF0, 0x1F, 0xF0, 0xFF, 0xC0, 0x7F, 0xC3, 0xFE, 0x01, 0xFF,
  0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0xC7,
  0xFC, 0x03, 0xFF, 0x1F, 0xF0, 0x0F, 0xFC, 0x7F, 0x80, 0x3F, 0xE3, 0xFE,
  0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFE, 0x3F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0,
  0xFF, 0xC3, 0xFF, 0x07, 0xFF, 0x1F, 0xFE, 0x3F, 0xF8, 0x7F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0,
  0xFF, 0x3F, 0xFF, 0x03, 0xFC, 0x7F, 0xF0, 0x0F, 0xE0, 0xFF, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xF8, 0x7C, 0x1F, 0xFC, 0x01, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0xC1, 0xFF, 0xC1, 0xF0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0x3F, 0xF0, 0x07, 0xFF, 0xDF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xC7, 0xFF, 0x01, 0xFF, 0xC1,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8,
  0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x03, 0xFE,
  0x01, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC0, 0xFF,
  0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x7F, 0x80,
  0x0F, 0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0x1F, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFE,
  0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x1F, 0xF8, 0x0F, 0xF1, 0xFF, 0x01, 0xFF,
  0x3F, 0xF0, 0x1F, 0xF3, 0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0x07, 0xFE, 0x00,
  0x70, 0x7F, 0xFC, 0x7F, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x8C, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x87, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0x00,
  0xFF, 0xF8, 0xFE, 0x01, 0xFF, 0xFD, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x3F, 0xFC, 0x0F,
  0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F,
  0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x3F,
  0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F,
  0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F,
  0xF0, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x7F, 0xC0, 0x0F,
  0xFE, 0x7F, 0xC0, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x80,
  0x03, 0xFF, 0x00, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE1,
  0xFC, 0x00, 0x7F, 0xCF, 0xFE, 0x00, 0xFF, 0xBF, 0xFE, 0x01, 0xFE, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFC, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC0, 0xFF,
  0xC3, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC,
  0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xE1,
  0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x1F,
  0xF8, 0x0F, 0xFC, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF,
  0x80, 0x7F, 0xC3, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x0F, 0xF8,
  0x07, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0xC0,
  0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x87,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x07, 0xFC,
  0x03, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x07,
  0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xE0,
  0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x1F, 0xF9, 0xFF,
  0x80, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFB, 0xFF,
  0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF0,
  0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x1F, 0xF0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x7F, 0xF0, 0x3F, 0xF8, 0x03,
  0xF8, 0xFF, 0xF8, 0x7F, 0xFC, 0x03, 0xF9, 0xFF, 0xF8, 0xFF, 0xFC, 0x07,
  0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x8F, 0xFF, 0xC7, 0xFE, 0x07,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFE, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x3F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF,
  0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0xFF,
  0xE0, 0x0F, 0xE3, 0xFF, 0xE0, 0x1F, 0xCF, 0xFF, 0xC0, 0x7F, 0xBF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xC7, 0xFE,
  0x07, 0xFF, 0x07, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF0,
  0x7F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x87,
  0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F,
  0xE0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0x80, 0xFF, 0xC3, 0xFE,
  0x01, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xF0,
  0x0F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x00,
  0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x0F,
  0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x1F, 0xF9, 0xFF, 0x80, 0xFF, 0xCF, 0xFC, 0x07, 0xFE, 0x7F, 0xC0,
  0x3F, 0xF7, 0xFE, 0x01, 0xFF, 0xBF, 0xF0, 0x0F, 0xFD, 0xFF, 0x00, 0x7F,
  0xEF, 0xF8, 0x03, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xBF,
  0xF0, 0x0F, 0xFD, 0xFF, 0x80, 0x7F, 0xEF, 0xFC, 0x03, 0xFE, 0x7F, 0xE0,
  0x3F, 0xF1, 0xFF, 0x03, 0xFF, 0x8F, 0xFC, 0x3F, 0xF8, 0x7F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x05,
  0x00, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x3F, 0x8F, 0xFE, 0x00, 0x1F,
  0xCF, 0xFF, 0x80, 0x0F, 0xEF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC7, 0xFF, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xFC,
  0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFF,
  0x81, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x7F,
  0xE0, 0x7F, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xFE, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0xFF, 0xFE, 0x01, 0xFF, 0x7F,
  0xFE, 0x00, 0xFF, 0x9F, 0xFC, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xE0,
  0x20, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0xE3, 0xFC,
  0x07, 0xFF, 0xE7, 0xF0, 0x1F, 0xFF, 0xDF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF,
  0x80, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x1F, 0xF8,
  0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80,
  0x7F, 0xC3, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x0F, 0xFC, 0x07,
  0xFE, 0x1F, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xEF, 0xF8, 0x01, 0xFF, 0x9F, 0xF0,
  0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x40, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x1F, 0x81, 0xFE,
  0x3F, 0xC0, 0xFF, 0x3F, 0xE0, 0x7F, 0xBF, 0xE0, 0x7F, 0xBF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x7F, 0xF1, 0xF8, 0x3F, 0xF0, 0x1C, 0x1F, 0xF0, 0x02,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF2, 0x00, 0x1F, 0xF1, 0xC0, 0x1F, 0xF8, 0xFF,
  0x7F, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x10, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x08,
  0x00, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80,
  0x7F, 0xC7, 0xFE, 0x03, 0xFF, 0x1F, 0xF0, 0x0F, 0xFC, 0x7F, 0xC0, 0x3F,
  0xE1, 0xFF, 0x00, 0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x3F, 0xF0, 0x1F, 0xF8,
  0xFF, 0x80, 0x7F, 0xE3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x7F,
  0xE0, 0x1F, 0xF1, 0xFF, 0x80, 0xFF, 0xC7, 0xFC, 0x03, 0xFE, 0x1F, 0xF0,
  0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE3, 0xFF, 0x01, 0xFF, 0x8F, 0xF8, 0x07,
  0xFE, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0xC3, 0xFE, 0x07, 0xFF,
  0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xDF, 0xE0, 0x7F,
  0xFE, 0x7F, 0x80, 0xFF, 0xF1, 0xFC, 0x01, 0xFF, 0x07, 0xF0, 0x00, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xEF, 0xF8, 0x01,
  0xFF, 0xBF, 0xE0, 0x0F, 0xFC, 0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x01, 0xFF,
  0x8F, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0xF0, 0x7F, 0x80, 0xFF, 0x81,
  0xFE, 0x07, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0xC0, 0x7F,
  0xC3, 0xFE, 0x01, 0xFF, 0x1F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF3,
  0xFF, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0xFF, 0x7F, 0xC0, 0x03, 0xFD, 0xFF,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xBF, 0xE0,
  0x3F, 0xF8, 0x07, 0xFD, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xCF, 0xF8, 0x0F,
  0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0xF0, 0x3F, 0xF3, 0xFE, 0x07, 0xFF,
  0x81, 0xFF, 0x0F, 0xF0, 0x7F, 0xFC, 0x0F, 0xF8, 0x7F, 0x83, 0xF7, 0xE0,
  0xFF, 0x83, 0xFC, 0x1F, 0xBF, 0x07, 0xFC, 0x1F, 0xE1, 0xFD, 0xF8, 0x7F,
  0xC0, 0xFF, 0x0F, 0xCF, 0xC3, 0xFE, 0x07, 0xF8, 0xFE, 0xFE, 0x3F, 0xE0,
  0x3F, 0xC7, 0xF7, 0xF1, 0xFF, 0x01, 0xFE, 0x3F, 0x3F, 0x8F, 0xF0, 0x0F,
  0xF3, 0xF9, 0xFC, 0xFF, 0x80, 0x7F, 0x9F, 0xCF, 0xE7, 0xF8, 0x03, 0xFD,
  0xFC, 0x7F, 0x7F, 0xC0, 0x1F, 0xEF, 0xE3, 0xFB, 0xFC, 0x00, 0xFF, 0x7E,
  0x1F, 0xDF, 0xE0, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x87,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x7F, 0xFC,
  0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07,
  0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x00, 0xFF,
  0x8F, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x07, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x07, 0xFE, 0x3F,
  0xF0, 0x00, 0x7F, 0xF0, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x0F,
  0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x0F,
  0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x01,
  0xFE, 0x3F, 0xE0, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xF0,
  0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0xFF,
  0x7F, 0xC0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x27, 0xFF, 0x00, 0x05, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xD0, 0x00, 0x3F, 0xE0,
};

const GFXglyph NotoSans_ExtraBoldItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 18, 41, 17, 0, -40 },
  { 94, 22, 14, 25, 5, -40 },
  { 133, 36, 40, 36, 1, -40 },
  { 313, 30, 46, 32, 1, -43 },
  { 486, 45, 42, 50, 3, -41 },
  { 723, 39, 42, 40, 1, -41 },
  { 928, 11, 14, 14, 5, -40 },
  { 948, 22, 49, 20, 2, -40 },
  { 1083, 22, 50, 20, -4, -41 },
  { 1221, 28, 28, 30, 4, -43 },
  { 1319, 27, 27, 32, 3, -33 },
  { 1411, 14, 14, 17, -3, -7 },
  { 1436, 16, 8, 18, 1, -19 },
  { 1452, 11, 10, 17, 0, -9 },
  { 1466, 31, 40, 25, -2, -40 },
  { 1621, 29, 42, 32, 2, -41 },
  { 1774, 23, 40, 32, 5, -40 },
  { 1889, 31, 41, 32, -1, -41 },
  { 2048, 30, 42, 32, 0, -41 },
  { 2206, 32, 40, 32, -1, -40 },
  { 2366, 30, 41, 32, 1, -40 },
  { 2520, 30, 42, 32, 2, -41 },
  { 2678, 32, 40, 32, 2, -40 },
  { 2838, 30, 42, 32, 1, -41 },
  { 2996, 27, 42, 32, 3, -41 },
  { 3138, 16, 32, 17, 0, -31 },
  { 3202, 19, 38, 17, -3, -31 },
  { 3293, 27, 30, 32, 3, -35 },
  { 3395, 27, 18, 32, 3, -29 },
  { 3456, 27, 30, 32, 3, -35 },
  { 3558, 24, 42, 26, 4, -41 },
  { 3684, 46, 45, 49, 2, -40 },
  { 3943, 36, 40, 36, -3, -40 },
  { 4123, 33, 40, 35, 1, -40 },
  { 4288, 34, 42, 35, 3, -41 },
  { 4467, 35, 40, 38, 1, -40 },
  { 4642, 32, 40, 31, 1, -40 },
  { 4802, 32, 40, 31, 1, -40 },
  { 4962, 35, 42, 39, 3, -41 },
  { 5146, 39, 40, 40, 1, -40 },
  { 5341, 28, 40, 23, -2, -40 },
  { 5481, 29, 52, 20, -9, -40 },
  { 5670, 39, 40, 36, 1, -40 },
  { 5865, 25, 40, 29, 1, -40 },
  { 5990, 49, 40, 50, 1, -40 },
  { 6235, 43, 40, 43, 1, -40 },
  { 6450, 36, 42, 41, 3, -41 },
  { 6639, 33, 40, 35, 1, -40 },
  { 6804, 36, 51, 41, 3, -41 },
  { 7034, 33, 40, 36, 1, -40 },
  { 7199, 30, 42, 30, 1, -41 },
  { 7357, 30, 40, 30, 4, -40 },
  { 7507, 35, 41, 39, 4, -40 },
  { 7687, 33, 40, 34, 5, -40 },
  { 7852, 51, 40, 51, 5, -40 },
  { 8107, 43, 40, 36, -3, -40 },
  { 8322, 33, 40, 33, 5, -40 },
  { 8487, 35, 40, 30, -2, -40 },
  { 8662, 24, 49, 19, -1, -40 },
  { 8809, 14, 40, 25, 6, -40 },
  { 8879, 24, 49, 19, -4, -40 },
  { 9026, 30, 26, 30, 0, -40 },
  { 9124, 25, 6, 24, -5, 4 },
  { 9143, 13, 9, 19, 8, -43 },
  { 9158, 31, 32, 34, 2, -31 },
  { 9282, 30, 44, 34, 1, -43 },
  { 9447, 26, 32, 28, 2, -31 },
  { 9551, 33, 44, 34, 2, -43 },
  { 9733, 28, 32, 32, 2, -31 },
  { 9845, 34, 56, 22, -6, -43 },
  { 10083, 32, 44, 34, 1, -31 },
  { 10259, 31, 43, 34, 1, -43 },
  { 10426, 18, 43, 17, 1, -43 },
  { 10523, 26, 56, 17, -7, -43 },
  { 10705, 35, 43, 33, 1, -43 },
  { 10894, 18, 43, 17, 1, -43 },
  { 10991, 48, 31, 51, 1, -31 },
  { 11177, 31, 31, 34, 1, -31 },
  { 11298, 29, 32, 33, 2, -31 },
  { 11414, 33, 44, 34, -2, -31 },
  { 11596, 31, 44, 34, 2, -31 },
  { 11767, 25, 31, 24, 1, -31 },
  { 11864, 25, 32, 27, 1, -31 },
  { 11964, 23, 38, 24, 2, -37 },
  { 12074, 30, 32, 34, 3, -31 },
  { 12194, 30, 31, 30, 3, -31 },
  { 12311, 45, 31, 45, 3, -31 },
  { 12486, 37, 31, 31, -3, -31 },
  { 12630, 37, 44, 30, -4, -31 },
  { 12834, 29, 31, 27, -1, -31 },
  { 12947, 24, 49, 20, 0, -40 },
  { 13094, 7, 55, 31, 12, -42 },
  { 13143, 23, 49, 20, -3, -40 },
  { 13284, 27, 10, 32, 3, -25 },
};

const GFXfont NotoSans_ExtraBoldItalic56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic56pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_EXTRABOLDITALIC56PT7B_H_
