#ifndef _NOTOSANS_EXTRABOLDITALIC37PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01,
  0xF0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xE0, 0x7E, 0x0F,
  0xE0, 0xFE, 0x07, 0xC0, 0x3E, 0x7E, 0xFC, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7,
  0xC7, 0xCF, 0x8F, 0x1E, 0x3E, 0x3C, 0x7C, 0xF8, 0xF0, 0x00, 0x7C, 0x78,
  0x00, 0xF1, 0xF0, 0x03, 0xE3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x1F, 0x00,
  0x3E, 0x3C, 0x00, 0x7C, 0x78, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x1E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8,
  0xF0, 0x01, 0xE1, 0xE0, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xE0, 0xF8, 0xF0, 0x01, 0xF1, 0xE0, 0x03, 0xC3, 0xC0,
  0x07, 0x8F, 0x80, 0x1F, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0xF8, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x1F, 0xFC, 0x07, 0xFF,
  0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xBC, 0x1F, 0xB8, 0x41, 0xF3,
  0x80, 0x1F, 0xB8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xEF, 0xC0,
  0x0E, 0xFC, 0x80, 0xCF, 0xCF, 0x1D, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x20, 0x3F, 0xC0, 0x0F, 0x01, 0xFF,
  0x00, 0x7C, 0x0F, 0xFE, 0x03, 0xE0, 0x7E, 0xF8, 0x1F, 0x01, 0xF3, 0xE0,
  0x78, 0x07, 0xCF, 0x83, 0xE0, 0x3E, 0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0xF8,
  0x03, 0xE3, 0xE3, 0xC0, 0x0F, 0x8F, 0x9F, 0x00, 0x3E, 0x7C, 0xF9, 0xF8,
  0xFB, 0xF7, 0xCF, 0xFB, 0xFF, 0x9F, 0x7F, 0xE7, 0xFE, 0xFB, 0xFF, 0xCF,
  0xF7, 0xCF, 0x9F, 0x0F, 0x3E, 0x7C, 0x7C, 0x00, 0xF9, 0xF1, 0xF0, 0x07,
  0xC7, 0xC7, 0xC0, 0x3E, 0x1F, 0x1F, 0x00, 0xF0, 0x78, 0xF8, 0x07, 0xC1,
  0xE3, 0xE0, 0x3E, 0x07, 0x8F, 0x81, 0xF0, 0x1F, 0xFC, 0x07, 0x80, 0x7F,
  0xF0, 0x3E, 0x00, 0xFF, 0x81, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC7,
  0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0xFC, 0xFF, 0xF0, 0xFE, 0xFF, 0xFC, 0x7E, 0x7F,
  0x7F, 0x7F, 0x7F, 0x1F, 0xBF, 0x3F, 0x0F, 0xFF, 0x1F, 0x83, 0xFF, 0x8F,
  0xC0, 0xFF, 0x87, 0xF0, 0x7F, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFE, 0x3F, 0x80, 0x3E, 0xFD,
  0xF3, 0xE7, 0xCF, 0x9E, 0x3C, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x81, 0x03, 0xC0, 0x70, 0xF0, 0x1F, 0x3C, 0x0F,
  0xFE, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F,
  0xC0, 0x3F, 0xF8, 0x1F, 0x9E, 0x03, 0xC7, 0xC0, 0x71, 0xF0, 0x08, 0x7E,
  0x00, 0x08, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0xC7, 0xE1, 0xF0,
  0xFC, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x3C, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3F,
  0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xDF, 0xC7, 0xE1,
  0xF9, 0xFC, 0x3F, 0x3F, 0x07, 0xEF, 0xE0, 0xFD, 0xFC, 0x1F, 0xBF, 0x03,
  0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x0F, 0xEF, 0xC1, 0xF9, 0xFC, 0x7F,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0xFE, 0x03, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x7F,
  0xFC, 0xFF, 0xFC, 0x7E, 0xFC, 0x7C, 0xFC, 0x30, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0E, 0x0F, 0xE0,
  0x20, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x78, 0x7F, 0x02, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0xFC, 0x03, 0xFF,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xEC, 0x01, 0xFC, 0xFF,
  0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xF7, 0xE0, 0x3F,
  0x7C, 0x07, 0xEF, 0xC0, 0x7C, 0xFC, 0x0F, 0x8F, 0xC1, 0xF0, 0xFC, 0x3E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x20, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x8C, 0x03, 0xFC,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0,
  0xFF, 0xFC, 0x3F, 0xE0, 0x87, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xFB, 0xF8, 0x7E, 0xFF, 0x8F, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE7, 0xF0, 0xFC, 0xFC, 0x1F, 0xDF, 0x83, 0xF3, 0xF0, 0x7E, 0x7E,
  0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x7F, 0x3F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F,
  0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8,
  0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFC, 0x7F, 0x1F, 0x83,
  0xF1, 0xF8, 0x3E, 0x1F, 0x87, 0xE1, 0xFC, 0x7E, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F,
  0x1F, 0x87, 0xE1, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF,
  0xC1, 0xFC, 0xFE, 0x3F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE,
  0x3F, 0xFF, 0x9F, 0xE7, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFD, 0xFF, 0xBE, 0x3F, 0xDF, 0x83, 0xE7, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F,
  0xF8, 0x0F, 0xF8, 0x00, 0x01, 0x80, 0xF8, 0x3F, 0x87, 0xF0, 0xFC, 0x1F,
  0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x7E, 0x1F, 0xC3, 0xF8, 0x7F, 0x07, 0xC0, 0x00, 0x60, 0x0F,
  0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80,
  0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x03, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x0F,
  0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x00, 0x07, 0xC0, 0x3F, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x7C,
  0x7F, 0x20, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xF8,
  0x1F, 0xE0, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x20,
  0x3E, 0x3E, 0x0F, 0xFC, 0x79, 0xF0, 0x7F, 0xF1, 0xE7, 0xC7, 0xFF, 0xC7,
  0xDE, 0x1F, 0x9F, 0x1F, 0xF8, 0xF8, 0x78, 0x7F, 0xC3, 0xC1, 0xE1, 0xFF,
  0x1F, 0x07, 0x87, 0xBC, 0x7C, 0x3E, 0x1E, 0xF1, 0xE0, 0xF0, 0xFB, 0xC7,
  0x83, 0xC3, 0xCF, 0x1E, 0x1F, 0x1F, 0x3C, 0x7C, 0xFC, 0xF8, 0xF1, 0xFF,
  0xFF, 0xE3, 0xE3, 0xFD, 0xFF, 0x0F, 0x87, 0xE3, 0xF0, 0x1F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x60, 0x01, 0xFF, 0x7F, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0x7C,
  0x00, 0x7E, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x7C, 0x01, 0xF8, 0x7C,
  0x01, 0xF8, 0x7C, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x7F, 0x00, 0x3E,
  0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0x07, 0xF0, 0xFC,
  0x1F, 0xC3, 0xF0, 0x7E, 0x1F, 0xC1, 0xF8, 0x7F, 0x0F, 0xE1, 0xFF, 0xFF,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F,
  0xC1, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x0F, 0xC7, 0xF0, 0x7F, 0x1F, 0x81,
  0xFC, 0x7E, 0x0F, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xE7, 0xE1, 0xFE,
  0x03, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x06, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1,
  0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x87, 0xE0, 0x7F, 0x1F, 0xC0, 0x7E, 0x3F,
  0x80, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xE7, 0xF0,
  0x1F, 0xCF, 0xC0, 0x3F, 0x9F, 0x80, 0x7E, 0x3F, 0x01, 0xFC, 0x7E, 0x03,
  0xF9, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0xC7, 0xE1, 0xFF, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x10, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xDF, 0x87,
  0xF8, 0x02, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE1, 0xFF, 0xDF, 0xC3, 0xFF, 0xBF, 0x87,
  0xFE, 0x7F, 0x0F, 0xFC, 0xFC, 0x3F, 0xF9, 0xF8, 0x03, 0xF3, 0xF8, 0x0F,
  0xE7, 0xF0, 0x1F, 0x8F, 0xE0, 0x3F, 0x0F, 0xE0, 0x7E, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x07, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xE0, 0xFC, 0x07,
  0xF0, 0xFE, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80,
  0xFE, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7E,
  0x01, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0x80, 0xFE, 0x1F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0xC1, 0xF8, 0x0F, 0xE1,
  0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x00, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF8, 0x07,
  0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x01, 0xFC, 0x08, 0x7F, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0xC1, 0xF8, 0x1F,
  0xC0, 0x7E, 0x0F, 0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0xE3, 0xFC, 0x03, 0xF0,
  0xFE, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x1F, 0xDF, 0xC0, 0x07,
  0xE7, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0x3F,
  0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xF1, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x07, 0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0,
  0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x07,
  0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x07,
  0xFC, 0x03, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x0F,
  0xFC, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0x7C, 0x1F,
  0xFC, 0x1F, 0x7C, 0x1F, 0xFC, 0x3E, 0xFC, 0x1F, 0x7C, 0x3E, 0xFC, 0x1F,
  0x3C, 0x7C, 0xF8, 0x3F, 0x3C, 0x7C, 0xF8, 0x3F, 0x3C, 0xF9, 0xF8, 0x3F,
  0x3C, 0xF9, 0xF8, 0x3E, 0x3C, 0xF1, 0xF8, 0x3E, 0x3D, 0xF1, 0xF0, 0x7E,
  0x3D, 0xE1, 0xF0, 0x7E, 0x3F, 0xE3, 0xF0, 0x7E, 0x3F, 0xC3, 0xF0, 0x7C,
  0x3F, 0xC3, 0xF0, 0x7C, 0x3F, 0x83, 0xE0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC,
  0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xE0, 0x07, 0xF8, 0x03, 0xF0, 0x7F,
  0x80, 0x3E, 0x07, 0xF8, 0x07, 0xE0, 0x7F, 0xC0, 0x7E, 0x0F, 0xFC, 0x07,
  0xE0, 0xFF, 0xC0, 0x7E, 0x0F, 0xFE, 0x07, 0xC0, 0xFF, 0xE0, 0xFC, 0x1F,
  0xBE, 0x0F, 0xC1, 0xFB, 0xF0, 0xFC, 0x1F, 0xBF, 0x0F, 0x81, 0xF1, 0xF0,
  0xF8, 0x1F, 0x1F, 0x9F, 0x83, 0xF1, 0xF9, 0xF8, 0x3F, 0x1F, 0x9F, 0x83,
  0xF0, 0xFD, 0xF0, 0x3E, 0x0F, 0xDF, 0x03, 0xE0, 0xFD, 0xF0, 0x7E, 0x07,
  0xFF, 0x07, 0xE0, 0x7F, 0xF0, 0x7E, 0x07, 0xFE, 0x07, 0xC0, 0x3F, 0xE0,
  0x7C, 0x03, 0xFE, 0x0F, 0xC0, 0x3F, 0xE0, 0xFC, 0x03, 0xFE, 0x0F, 0xC0,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFB, 0xFE, 0x1F, 0xE0, 0xFE, 0x3F,
  0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x01, 0xFC, 0xFE, 0x03, 0xFC, 0x7F, 0x07, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0xC3, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC,
  0x7F, 0x07, 0xF1, 0xF8, 0x3F, 0x87, 0xE3, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xE0, 0xFE, 0x3F, 0xC0, 0x7F, 0x3F,
  0x80, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0xFC, 0xFE, 0x01, 0xFC, 0xFE,
  0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0xFE, 0xFF, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x1F,
  0xC1, 0xF8, 0xFE, 0x1F, 0xC7, 0xE1, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0x3F, 0x81, 0xF8,
  0xFC, 0x1F, 0xC7, 0xE0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xF1,
  0xF8, 0x3F, 0x9F, 0xC0, 0xFC, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0xC0, 0x00,
  0x7C, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F,
  0xCF, 0x87, 0xE0, 0x20, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x88, 0x03,
  0xF1, 0xC0, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x7F,
  0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFE,
  0x1F, 0x80, 0xFE, 0x1F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0x01, 0xFC, 0x3F, 0x01, 0xFC, 0x7F, 0x01, 0xF8, 0x7F, 0x01, 0xF8,
  0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0xFE, 0x03, 0xF0,
  0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0xFC, 0xFC,
  0x03, 0xF3, 0xF0, 0x1F, 0x87, 0xC0, 0x7E, 0x1F, 0x03, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01,
  0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x03, 0xF0, 0x1F, 0xFF, 0x01, 0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0x01,
  0xFB, 0xF0, 0x1F, 0xC0, 0xFC, 0xFC, 0x0F, 0xF0, 0x3F, 0x3F, 0x03, 0xFC,
  0x1F, 0xCF, 0xC1, 0xFF, 0x07, 0xE3, 0xF0, 0x7F, 0xC1, 0xF8, 0xFC, 0x3F,
  0xF0, 0xFC, 0x3F, 0x0F, 0xFC, 0x3F, 0x0F, 0xC3, 0xDF, 0x1F, 0x83, 0xF1,
  0xF7, 0xC7, 0xE0, 0xFC, 0x7D, 0xF1, 0xF0, 0x1F, 0x3E, 0x7C, 0xFC, 0x07,
  0xCF, 0x9F, 0x3F, 0x01, 0xF7, 0xC7, 0xDF, 0x80, 0x7D, 0xF1, 0xF7, 0xE0,
  0x1F, 0x7C, 0x7D, 0xF0, 0x07, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xF8, 0x1F,
  0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0x80, 0xFE, 0x01, 0xF8,
  0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xC7, 0xF0,
  0x00, 0xFE, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x7E, 0x3F,
  0x80, 0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03,
  0xF8, 0x0F, 0xC0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x03,
  0xFD, 0xF8, 0x0F, 0xE7, 0xE0, 0x7F, 0x1F, 0x83, 0xF8, 0x7F, 0x0F, 0xC0,
  0xFC, 0x7F, 0x03, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x1F, 0x7F, 0x00, 0x7D,
  0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xF8, 0x7C, 0x3E, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE0, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x3E, 0x78, 0x03, 0xC7, 0x80, 0x7C, 0x78, 0x0F, 0x87, 0xC0,
  0xF0, 0x3C, 0x1F, 0x03, 0xC3, 0xE0, 0x3E, 0x3E, 0x03, 0xE7, 0xC0, 0x1E,
  0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0x0F,
  0xC3, 0xE0, 0xF0, 0x3C, 0x01, 0xC0, 0x00, 0x7F, 0x3F, 0x0F, 0xFB, 0xE1,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFD, 0xFE, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC,
  0xFE, 0x0F, 0xCF, 0xE0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xF8, 0xFC, 0x1F,
  0x8F, 0xC1, 0xF8, 0xFC, 0x3F, 0x8F, 0xC3, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x07, 0xFD, 0xF0, 0x3F, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x60, 0x0F, 0xDF, 0x81, 0xFB, 0xFC, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x1F, 0xEF, 0xE1, 0xF8, 0x7F, 0x3F, 0x87, 0xF3, 0xF0,
  0x7F, 0x3F, 0x07, 0xF3, 0xE0, 0x7E, 0x3E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E,
  0x0F, 0xE7, 0xE0, 0xFC, 0x7F, 0x1F, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF0, 0xFB, 0xFE, 0x0F, 0x9F, 0xC0, 0x00, 0xF0, 0x01, 0xFF, 0xC3,
  0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE3, 0xFC, 0x71, 0xFC, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xFC, 0x18, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x07,
  0xFF, 0x81, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x38,
  0x7E, 0x07, 0xF7, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3,
  0xFD, 0xFE, 0x3F, 0x87, 0xE1, 0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0xFC, 0x0F,
  0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E,
  0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x1F, 0xF7, 0xC0, 0x7F, 0x3C, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xC0, 0xFF,
  0xF8, 0x7F, 0xFF, 0x3F, 0xFF, 0xCF, 0xC3, 0xF7, 0xF0, 0xFD, 0xF8, 0x3F,
  0xFE, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xF0, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x08, 0xFE, 0x1E, 0x3F, 0xFF, 0x87, 0xFF,
  0xE0, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xD8, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x1F, 0xCF, 0xC1, 0xFF, 0x7C, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x0F, 0xF7, 0xF8, 0xFE, 0x1F, 0x87, 0xE0, 0xFC, 0x7F, 0x07, 0xE3,
  0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0x87, 0xE0, 0xFC, 0x3F, 0x07,
  0xE1, 0xF8, 0x7F, 0x0F, 0xC3, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x7F, 0xBF, 0x01, 0xF9, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0xC0, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x70, 0x0F, 0xDF, 0xC1, 0xFB, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x1F, 0xE7, 0xF1, 0xFC, 0x3F, 0x3F, 0x83, 0xF3, 0xF8, 0x7F, 0x3F,
  0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE7, 0xF0, 0x7E, 0x7E, 0x0F, 0xE7,
  0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC1, 0xFC,
  0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F,
  0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F,
  0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0xFF, 0xE0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x01, 0x0F, 0xC1, 0xFC, 0x3F, 0x87,
  0xF0, 0x7E, 0x1F, 0xC0, 0xFC, 0x7F, 0x01, 0xF9, 0xFC, 0x03, 0xF7, 0xF0,
  0x0F, 0xCF, 0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xCF, 0xE0, 0x1F,
  0x8F, 0xC0, 0x7F, 0x1F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xF0,
  0x7F, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7E,
  0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x00,
  0x03, 0x00, 0x70, 0x1F, 0x3F, 0x87, 0xF0, 0x7E, 0xFF, 0x9F, 0xF0, 0xFB,
  0xFF, 0x7F, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFC, 0xFF, 0x9F, 0xC7, 0xF0,
  0xFE, 0x1F, 0x9F, 0xC1, 0xF8, 0x3F, 0x3F, 0x87, 0xF0, 0x7E, 0x7E, 0x0F,
  0xE1, 0xFC, 0xFC, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x07, 0xE7, 0xF0, 0x7E,
  0x0F, 0xCF, 0xC1, 0xFC, 0x1F, 0x9F, 0x83, 0xF0, 0x7F, 0x3F, 0x07, 0xE0,
  0xFC, 0xFE, 0x0F, 0xC1, 0xF9, 0xF8, 0x1F, 0x83, 0xF3, 0xF0, 0x7F, 0x07,
  0xE7, 0xE0, 0xFC, 0x1F, 0xCF, 0xC1, 0xF8, 0x3F, 0x00, 0x00, 0x07, 0x00,
  0xF9, 0xFC, 0x1F, 0xBF, 0xE1, 0xF7, 0xFE, 0x1F, 0xFF, 0xF1, 0xFE, 0x7F,
  0x1F, 0xC3, 0xF3, 0xF8, 0x3F, 0x3F, 0x87, 0xF3, 0xF0, 0x7E, 0x3F, 0x07,
  0xE3, 0xF0, 0x7E, 0x7F, 0x07, 0xE7, 0xE0, 0xFE, 0x7E, 0x0F, 0xC7, 0xE0,
  0xFC, 0xFE, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x1F, 0xCF, 0xC1, 0xF8, 0xFC,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F,
  0xFF, 0xCF, 0xE7, 0xF7, 0xF0, 0xFD, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC1, 0xFB,
  0xF0, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0x80, 0x0F, 0xBF, 0x80, 0x7D, 0xFF, 0x01, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xEF, 0xE0, 0x7E, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xC1, 0xFC, 0x3F, 0x07, 0xF0, 0xF8, 0x1F, 0x83, 0xE0, 0x7E, 0x1F,
  0x81, 0xF8, 0x7E, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xF1, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xDF, 0xE0, 0x3F, 0x3F, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x7F, 0x3F, 0x0F, 0xFB, 0xE1, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE3, 0xFD, 0xFE, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0xFE, 0x0F, 0xCF,
  0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8,
  0xFC, 0x1F, 0x8F, 0xC3, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xFB, 0xF0, 0x3F, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0x0F, 0x9F, 0x1F, 0xBF, 0x1F, 0xFF,
  0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xE2, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xF0,
  0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFC, 0x18, 0x7E,
  0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFD, 0x00, 0xFC, 0xF0, 0xFE, 0x7F, 0xFF,
  0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xC1, 0x1F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F,
  0xFE, 0x9F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F,
  0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x3F, 0x83, 0xF3,
  0xF0, 0x3F, 0x3F, 0x07, 0xF3, 0xF0, 0x7E, 0x3F, 0x07, 0xE7, 0xF0, 0x7E,
  0x7E, 0x07, 0xE7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0xFE, 0x0F,
  0xCF, 0xC1, 0xFC, 0xFC, 0x1F, 0x8F, 0xC3, 0xF8, 0xFC, 0x3F, 0x8F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x7F, 0xDF, 0x03, 0xF1, 0xF0, 0xFC,
  0x07, 0xFF, 0xC0, 0xFE, 0xFC, 0x0F, 0xCF, 0xC1, 0xFC, 0xFC, 0x1F, 0x8F,
  0xC3, 0xF8, 0x7C, 0x3F, 0x07, 0xC7, 0xE0, 0x7C, 0x7E, 0x07, 0xCF, 0xC0,
  0x7C, 0xFC, 0x07, 0xDF, 0x80, 0x7D, 0xF8, 0x07, 0xDF, 0x00, 0x3F, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0xFC, 0x1F, 0xC1, 0xFF, 0xF0, 0x7F, 0x07, 0xEF, 0xC3, 0xFC, 0x3F,
  0x3F, 0x0F, 0xF0, 0xFC, 0xFC, 0x7F, 0xC7, 0xE3, 0xF1, 0xEF, 0x1F, 0x8F,
  0xC7, 0xBC, 0x7C, 0x3F, 0x3E, 0xF3, 0xF0, 0x7C, 0xF7, 0xCF, 0xC1, 0xF7,
  0xDF, 0x7E, 0x07, 0xDF, 0x7D, 0xF8, 0x1F, 0x79, 0xF7, 0xC0, 0x7F, 0xE7,
  0xFF, 0x01, 0xFF, 0x1F, 0xF8, 0x07, 0xFC, 0x7F, 0xE0, 0x1F, 0xF1, 0xFF,
  0x00, 0x7F, 0x87, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x80,
  0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFE, 0x03, 0xF1,
  0xFC, 0x03, 0xF9, 0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xEF,
  0xC0, 0x0F, 0xCF, 0xC0, 0x1F, 0xCF, 0xE0, 0x3F, 0x87, 0xE0, 0x7F, 0x07,
  0xF0, 0xFF, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC1, 0xFC, 0x0F, 0xC1, 0xF8, 0x07, 0xC3, 0xF8, 0x07, 0xC3,
  0xF0, 0x07, 0xE7, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xEF, 0xC0, 0x07, 0xEF,
  0xC0, 0x07, 0xEF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F,
  0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x7F, 0xC0, 0xFF,
  0x80, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F,
  0xC0, 0x3F, 0x80, 0x3F, 0x01, 0xFE, 0x07, 0xFC, 0x1F, 0xC0, 0x3E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x78, 0x00, 0x7F, 0x80,
  0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xC0,
};

const GFXglyph NotoSans_ExtraBoldItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 12, 26, 11, 0, -26 },
  { 40, 15, 9, 17, 3, -26 },
  { 57, 23, 26, 24, 1, -26 },
  { 132, 20, 30, 21, 1, -28 },
  { 207, 30, 27, 33, 2, -27 },
  { 309, 25, 27, 27, 1, -27 },
  { 394, 7, 9, 9, 3, -26 },
  { 402, 15, 33, 13, 1, -27 },
  { 464, 15, 33, 13, -3, -27 },
  { 526, 18, 18, 20, 3, -28 },
  { 567, 18, 18, 21, 2, -22 },
  { 608, 10, 9, 11, -2, -4 },
  { 620, 10, 5, 12, 1, -12 },
  { 627, 7, 6, 11, 0, -6 },
  { 633, 21, 27, 16, -2, -27 },
  { 704, 19, 27, 21, 1, -27 },
  { 769, 16, 26, 21, 3, -26 },
  { 821, 21, 27, 21, -1, -27 },
  { 892, 20, 27, 21, 0, -27 },
  { 960, 20, 26, 21, 0, -26 },
  { 1025, 21, 26, 21, 0, -26 },
  { 1094, 19, 27, 21, 2, -27 },
  { 1159, 22, 26, 21, 1, -26 },
  { 1231, 20, 27, 21, 1, -27 },
  { 1299, 18, 27, 21, 2, -27 },
  { 1360, 11, 21, 11, 0, -21 },
  { 1389, 13, 26, 11, -2, -21 },
  { 1432, 18, 20, 21, 2, -23 },
  { 1477, 18, 12, 21, 2, -19 },
  { 1504, 18, 20, 21, 2, -23 },
  { 1549, 16, 27, 17, 3, -27 },
  { 1603, 30, 30, 32, 2, -27 },
  { 1716, 24, 26, 24, -2, -26 },
  { 1794, 22, 26, 23, 1, -26 },
  { 1866, 22, 27, 23, 2, -27 },
  { 1941, 23, 26, 25, 1, -26 },
  { 2016, 21, 26, 20, 1, -26 },
  { 2085, 21, 26, 20, 1, -26 },
  { 2154, 23, 27, 26, 2, -27 },
  { 2232, 25, 26, 26, 1, -26 },
  { 2314, 18, 26, 15, -1, -26 },
  { 2373, 19, 34, 13, -6, -26 },
  { 2454, 26, 26, 24, 1, -26 },
  { 2539, 16, 26, 19, 1, -26 },
  { 2591, 32, 26, 33, 1, -26 },
  { 2695, 28, 26, 29, 1, -26 },
  { 2786, 24, 27, 27, 2, -27 },
  { 2867, 22, 26, 23, 1, -26 },
  { 2939, 24, 33, 27, 2, -27 },
  { 3038, 21, 26, 23, 1, -26 },
  { 3107, 19, 27, 20, 1, -27 },
  { 3172, 19, 26, 20, 3, -26 },
  { 3234, 24, 26, 26, 2, -26 },
  { 3312, 22, 26, 22, 3, -26 },
  { 3384, 34, 26, 34, 3, -26 },
  { 3495, 28, 26, 23, -2, -26 },
  { 3586, 22, 26, 22, 3, -26 },
  { 3658, 23, 26, 20, -1, -26 },
  { 3733, 16, 33, 13, -1, -27 },
  { 3799, 9, 27, 16, 4, -27 },
  { 3830, 16, 33, 13, -2, -27 },
  { 3896, 20, 17, 20, 0, -26 },
  { 3939, 16, 3, 16, -3, 3 },
  { 3945, 9, 6, 12, 5, -28 },
  { 3952, 20, 21, 22, 2, -21 },
  { 4005, 20, 28, 22, 1, -28 },
  { 4075, 17, 21, 18, 2, -21 },
  { 4120, 21, 28, 22, 2, -28 },
  { 4194, 18, 21, 21, 2, -21 },
  { 4242, 22, 37, 14, -4, -28 },
  { 4344, 21, 30, 22, 1, -21 },
  { 4423, 20, 28, 23, 1, -28 },
  { 4493, 11, 28, 12, 1, -28 },
  { 4532, 18, 37, 12, -5, -28 },
  { 4616, 23, 28, 22, 1, -28 },
  { 4697, 12, 28, 12, 1, -28 },
  { 4739, 31, 21, 34, 1, -21 },
  { 4821, 20, 21, 23, 1, -21 },
  { 4874, 18, 21, 22, 2, -21 },
  { 4922, 22, 30, 22, -1, -21 },
  { 5005, 20, 30, 22, 2, -21 },
  { 5080, 16, 21, 16, 1, -21 },
  { 5122, 17, 21, 18, 0, -21 },
  { 5167, 16, 25, 16, 1, -25 },
  { 5217, 20, 20, 23, 2, -20 },
  { 5267, 20, 20, 20, 2, -20 },
  { 5317, 30, 20, 30, 2, -20 },
  { 5392, 24, 20, 20, -2, -20 },
  { 5452, 24, 29, 20, -2, -20 },
  { 5539, 19, 20, 18, -1, -20 },
  { 5587, 16, 32, 13, 0, -26 },
  { 5651, 5, 36, 21, 8, -28 },
  { 5674, 15, 32, 13, -2, -26 },
  { 5734, 18, 6, 21, 2, -16 },
};

const GFXfont NotoSans_ExtraBoldItalic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic37pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_EXTRABOLDITALIC37PT7B_H_
