#ifndef _NOTOSANS_EXTRABOLDITALIC64PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x3F,
  0xF1, 0xFF, 0x9F, 0xF8, 0xFF, 0xCF, 0xF8, 0x7F, 0xC7, 0xFC, 0x3F, 0xE3,
  0xFE, 0x1F, 0xF1, 0xFE, 0x0F, 0xF9, 0xFF, 0x07, 0xF8, 0xFF, 0x87, 0xFC,
  0x7F, 0x83, 0xFE, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F,
  0x87, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFC, 0x0F,
  0xF0, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xEF, 0x1F,
  0x80, 0x7F, 0xE3, 0xC0, 0xE0, 0x3F, 0xF1, 0xF0, 0x00, 0x0F, 0xFC, 0x7C,
  0x00, 0x03, 0xFF, 0x1F, 0x00, 0x00, 0xFF, 0xC7, 0x80, 0x00, 0x3F, 0xFB,
  0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x0F, 0xBF, 0xF8, 0x00, 0x03, 0xC7, 0xFE, 0x00, 0x01, 0xF1,
  0xFF, 0x80, 0x00, 0x7C, 0x7F, 0xE2, 0x00, 0x1F, 0x1F, 0xF8, 0xE0, 0x07,
  0xC7, 0xFE, 0x3F, 0x01, 0xE3, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0x80,
  0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFE,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x3F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0xFF, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xE1, 0xFE, 0x0F, 0xE0,
  0x7F, 0x87, 0xFC, 0x7F, 0x87, 0xFF, 0x0F, 0xF1, 0xFF, 0x1F, 0xE3, 0xFF,
  0xF9, 0xFF, 0xFF, 0xE7, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0x3F,
  0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xF1,
  0xFF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFE, 0x7F, 0xE7, 0xFC, 0x7F, 0xF8, 0x7F,
  0x8F, 0xF8, 0x7F, 0x87, 0xFE, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x7F, 0xC1, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0x00,
  0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x00,
  0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0xEF, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x80, 0x3F, 0xFF,
  0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x7F, 0xFD, 0xFF, 0xE3, 0xFF,
  0x83, 0xFF, 0x87, 0xFF, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFD, 0xFF, 0xC1,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xF8,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF3, 0xFF, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFC, 0x7F, 0xC7, 0xFC,
  0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x04,
  0x00, 0xFE, 0x00, 0x1E, 0x01, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7F,
  0x8F, 0xE0, 0x01, 0xFF, 0xDF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x17, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC1, 0xF0, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0x7F, 0x00, 0x1F, 0xFC, 0xFF, 0x00, 0x3F, 0xF1, 0xFE,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0x83, 0xFC, 0x00, 0x1E, 0x07, 0xFC,
  0x00, 0x18, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F,
  0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0x3F,
  0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF,
  0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x01, 0x01, 0xFE,
  0x3F, 0xF7, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE,
  0x7F, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xEF, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F,
  0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x0F, 0xFC, 0x7F, 0xF0, 0x07,
  0xFE, 0x7F, 0xF8, 0x03, 0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0x9F, 0xFC, 0x00,
  0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x7F, 0xF7, 0xFF, 0x00,
  0x3F, 0xFB, 0xFF, 0x80, 0x1F, 0xFD, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xBF, 0xF8,
  0x01, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x7F, 0xF7, 0xFF,
  0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x3F, 0xF9, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF,
  0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF8, 0x0F, 0xFF, 0x1F,
  0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xDF, 0xF8, 0xFF, 0xF7, 0xFF,
  0x0F, 0xFC, 0xFF, 0xC0, 0xFE, 0x1F, 0xF8, 0x1F, 0x83, 0xFF, 0x01, 0xC0,
  0xFF, 0xE0, 0x20, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x07, 0xFF, 0x80,
  0x07, 0xE0, 0x1F, 0xFE, 0x00, 0x3C, 0x00, 0x7F, 0xF0, 0x00, 0xC0, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xCF,
  0xFF, 0xE0, 0x07, 0x80, 0x3F, 0xFC, 0x00, 0xC0, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x60, 0x00, 0x07, 0xFF, 0x8F,
  0x00, 0x01, 0xFF, 0xF1, 0xFC, 0x01, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xF8,
  0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xF3,
  0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x0F,
  0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0x87, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xE0,
  0x03, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x0F, 0xF8, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x40, 0x00, 0x0F, 0xFF, 0x0E, 0x00, 0x07, 0xFF, 0xC1, 0xFC, 0x03, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x7F, 0x00, 0x0F, 0xFC, 0xFF, 0xF0, 0x03, 0xFE, 0x7F,
  0xFF, 0x01, 0xFF, 0xBF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFE, 0x7F, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0xE3,
  0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xF8, 0x03, 0xFF,
  0x8F, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F,
  0xFC, 0x3F, 0xF0, 0x07, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x80,
  0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x03,
  0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F,
  0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00,
  0x3F, 0xF8, 0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x8F, 0xFC,
  0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x0F, 0xFC, 0x3F,
  0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x01, 0x70, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x0F, 0xFE, 0x3F, 0xF8,
  0x07, 0xFE, 0x3F, 0xF8, 0x07, 0xFE, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF0,
  0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0x7F, 0xE0,
  0x07, 0xFF, 0x7F, 0xE0, 0x0F, 0xFF, 0x7F, 0xF0, 0x0F, 0xFF, 0x7F, 0xF0,
  0x1F, 0xFF, 0x7F, 0xF0, 0x1F, 0xFE, 0x7F, 0xF8, 0x7F, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF7, 0xFE, 0x1F, 0xFF, 0xEF, 0xFC, 0x0F, 0xFF, 0xEF, 0xFC, 0x07, 0xFF,
  0x8F, 0xFC, 0x01, 0xFF, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0xC0, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F,
  0xE0, 0x1F, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xE1, 0xFF, 0xE3, 0xE0, 0x1F,
  0xFC, 0x70, 0x01, 0xFF, 0x88, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x07, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xFF, 0x81,
  0xFE, 0x1F, 0xF0, 0x0F, 0xFF, 0xFE, 0x1F, 0xE1, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0xFE, 0x3F, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xE3, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F,
  0xF8, 0x3F, 0xC0, 0xFF, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x0F, 0xF7, 0xF0,
  0x3F, 0xE0, 0x3F, 0x80, 0xFF, 0x7F, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xFF,
  0xF0, 0x7F, 0x80, 0x7F, 0x80, 0xFE, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x0F,
  0xEF, 0xF0, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xEF, 0xE0, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0xFE, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xCF, 0xE0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0xFE, 0x0F, 0xF0,
  0x1F, 0xE0, 0x7F, 0x8F, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0xFE, 0x0F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0x03, 0xFF, 0xF3, 0xFF, 0xF8, 0x07, 0xF8, 0x1F, 0xFE, 0x3F, 0xFE,
  0x00, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xDF, 0xF0, 0x00,
  0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x83,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x3F, 0xE0,
  0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xF0,
  0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00,
  0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x8F, 0xFF, 0x00, 0x00, 0x7F,
  0xE3, 0xFF, 0x80, 0x00, 0x1F, 0xF9, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xBF, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x0F,
  0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFE, 0x00, 0xFF,
  0xF8, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F,
  0x80, 0xFF, 0xFC, 0x00, 0x1E, 0x03, 0xFF, 0xE0, 0x00, 0x10, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0x00, 0x7F, 0xFC, 0x00, 0x7C, 0x01, 0xFF, 0xFE, 0x3F,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xFF,
  0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00,
  0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x83, 0xFF,
  0x80, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x0F, 0xFE,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0x00, 0x7F,
  0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01,
  0xF8, 0x07, 0xFF, 0xE0, 0x00, 0x30, 0x0F, 0xFF, 0xC0, 0x00, 0x10, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x04, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0xFF, 0xE0, 0x40, 0x7F, 0xF0,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xDF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x30, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0x81, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE1,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF9, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0x8F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFB,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F,
  0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF8, 0x01,
  0xFF, 0x7F, 0x80, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xDF,
  0xF8, 0x03, 0xFF, 0x7F, 0x80, 0x7F, 0xDF, 0xF8, 0x03, 0xFF, 0x7F, 0x80,
  0x7F, 0x9F, 0xF8, 0x03, 0xFE, 0x7F, 0x80, 0xFF, 0x9F, 0xF0, 0x03, 0xFE,
  0x7F, 0x80, 0xFF, 0x3F, 0xF0, 0x03, 0xFE, 0x7F, 0x80, 0xFF, 0x3F, 0xF0,
  0x07, 0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x7F, 0x81, 0xFE,
  0x3F, 0xF0, 0x07, 0xFE, 0x7F, 0x83, 0xFC, 0x7F, 0xE0, 0x07, 0xFC, 0x7F,
  0x83, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0xE0, 0x0F,
  0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x7F, 0x8F, 0xF0, 0x7F,
  0xC0, 0x0F, 0xFC, 0x7F, 0x8F, 0xF0, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0x9F,
  0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0x9F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8,
  0x7F, 0xBF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xBF, 0xC0, 0xFF, 0x80,
  0x1F, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xFF, 0x81,
  0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x3F,
  0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFB, 0xFF, 0x00,
  0x7F, 0xE0, 0x07, 0xFD, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0xFF, 0xC0,
  0x1F, 0xF8, 0x01, 0xFF, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x9F, 0xF8,
  0x0F, 0xFC, 0x00, 0xFF, 0xCF, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xC3, 0xFE,
  0x03, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF0, 0xFF,
  0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F,
  0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFE, 0x07,
  0xFE, 0x1F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0x80,
  0xFF, 0xCF, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE7, 0xFE, 0x00, 0x7F, 0xE0,
  0x1F, 0xFB, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFD, 0xFF, 0x00, 0x3F, 0xF0,
  0x07, 0xFE, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF0,
  0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x01, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xBF, 0xFC, 0x00,
  0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x01, 0xFF,
  0xDF, 0xFC, 0x00, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0xFF, 0xE7, 0xFF,
  0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x7F, 0xF0, 0x00, 0x3F, 0xFC,
  0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0x3F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x03,
  0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0xFF, 0xE1,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0xFF, 0xF0,
  0x00, 0x0F, 0xFE, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0xBF, 0xFC, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0xFF, 0xEF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xBF,
  0xF8, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x01, 0xFF, 0xEF, 0xFE, 0x00,
  0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x00, 0x7F,
  0xF9, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x7F,
  0xF0, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x03,
  0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC,
  0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xE0,
  0x3F, 0xF9, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x7F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF,
  0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0x03, 0xFF,
  0xC3, 0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0xFF, 0xE0,
  0x03, 0xFF, 0xC7, 0xFF, 0x00, 0x0F, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0x80, 0x3F, 0xF8, 0x00, 0x60, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x08, 0x00, 0x03, 0xFF, 0x83, 0x80, 0x01, 0xFF, 0xE0, 0xFC, 0x00, 0x7F,
  0xF0, 0x3F, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFB, 0xFF,
  0x80, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x03,
  0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x3F,
  0xF0, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x03,
  0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00,
  0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0xFF, 0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x00, 0xFF, 0xC7, 0xFF, 0x00,
  0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x03, 0xFE,
  0x7F, 0xE0, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x0F, 0xFB, 0xFF, 0x00,
  0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF9, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xC3, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xC0, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xC1,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xE0, 0x07, 0xFF, 0xF0,
  0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFE,
  0x03, 0xFE, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFE, 0x01, 0xFF,
  0x01, 0xFE, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xDF, 0xF0, 0x3F,
  0xF0, 0x07, 0xFC, 0x0F, 0xFB, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x81, 0xFE,
  0x7F, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xCF, 0xF8, 0x7F, 0xE0, 0x03,
  0xFE, 0x0F, 0xF9, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xC3, 0xFE, 0x3F, 0xE1,
  0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC7, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x1F,
  0xF0, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x1F, 0xF3, 0xFF, 0x00,
  0x07, 0xFC, 0x7F, 0x83, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0x9F, 0xF0, 0x7F,
  0xCF, 0xF8, 0x00, 0x1F, 0xF3, 0xFE, 0x0F, 0xFB, 0xFF, 0x00, 0x03, 0xFE,
  0xFF, 0x81, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x3F, 0xEF, 0xF8,
  0x00, 0x0F, 0xFB, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFD, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xEF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x87, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x01, 0xFF, 0xE7,
  0xFF, 0x00, 0x0F, 0xFF, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x3F, 0xF0, 0x01,
  0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x0F,
  0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x3F,
  0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x0F,
  0xFC, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0xC7, 0xFF,
  0x00, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x1F,
  0xC0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x81,
  0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0,
  0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0x0F, 0xF0,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x07, 0xF7, 0xF8,
  0x00, 0x03, 0xFC, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x20, 0x07, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0xF1, 0xFF, 0x00, 0xFF, 0xFF,
  0x3F, 0xE0, 0x3F, 0xFF, 0xE7, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF,
  0x83, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x01,
  0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xF0, 0x07, 0xFE, 0x1F, 0xFC,
  0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0x0F,
  0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFC, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xDF, 0xF0, 0x07, 0xFF, 0xF3, 0xFE,
  0x00, 0x7F, 0xFC, 0x7F, 0x80, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0x02,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x87, 0xC0, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xF0,
  0x01, 0xFF, 0xBF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF,
  0x87, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xF8, 0x01,
  0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFE, 0x1F, 0xF8,
  0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x07, 0xFF, 0x0F,
  0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFF,
  0x0F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x3F,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xBF, 0xFF, 0xE0, 0x3F,
  0xE7, 0xFF, 0xF8, 0x07, 0xFC, 0x7F, 0xFC, 0x00, 0xFF, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xF8, 0x0E, 0x0F, 0xFF, 0x80, 0x10, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x08, 0x3F, 0xFC, 0x00, 0xC1, 0xFF, 0xF0, 0x3E, 0x07, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xE0, 0x7F,
  0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFF, 0x1F, 0xF8, 0x00, 0xFF,
  0xFC, 0xFF, 0xC0, 0x1F, 0xFF, 0xF7, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF,
  0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF8,
  0x03, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xC0,
  0xFF, 0xE0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x03,
  0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xEF, 0xF8, 0x00, 0xFF, 0xFE, 0x7F, 0xC0, 0x03, 0xFF, 0xE3,
  0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x07, 0xFF,
  0x1F, 0xFE, 0x07, 0xFF, 0x1F, 0xFC, 0x03, 0xFF, 0x3F, 0xF8, 0x07, 0xFF,
  0x3F, 0xF8, 0x07, 0xFF, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F, 0xF0, 0x1F, 0xFE,
  0x7F, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x40,
  0xFF, 0xF0, 0x01, 0xC0, 0x7F, 0xFC, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x30,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x61, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x7F, 0xC0, 0x07, 0xFF, 0xC7, 0xFC, 0x00, 0xFF, 0xFF, 0x3F, 0xE0, 0x0F,
  0xFF, 0xF9, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE,
  0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x81, 0xFF,
  0xC0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x03, 0xFF,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xE0,
  0x0F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x7F,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xEF, 0xFC,
  0x00, 0x7F, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xE7, 0xFE, 0x00, 0x03, 0xFC,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x80, 0x00, 0x7F,
  0xF0, 0x07, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x83,
  0xF0, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xF8, 0x01, 0xFF,
  0xBF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x87, 0xFF,
  0x80, 0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0x83,
  0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF,
  0xC3, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x01,
  0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0x0F, 0xFE,
  0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x07, 0xFF, 0x07,
  0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF8, 0x03,
  0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x21, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x01,
  0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xE0,
  0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x3F, 0xFC,
  0x00, 0x07, 0xFE, 0x7F, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0xFF, 0xE0, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x00, 0x3F,
  0xF8, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F,
  0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00,
  0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0xF1, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0x8F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x01, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0x0F, 0xFB, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF0, 0x3F, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xC1, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x0F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xF0, 0x0F,
  0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0xFF,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF,
  0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xE1, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0xC0, 0x07, 0xFC,
  0x7F, 0xFC, 0x00, 0xFF, 0x1F, 0xFF, 0xC0, 0x1F, 0xE7, 0xFF, 0xFC, 0x07,
  0xFD, 0xFF, 0xFF, 0x80, 0xFF, 0xBF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE,
  0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0x0F,
  0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF0, 0x07, 0xFF,
  0x0F, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF8, 0x03,
  0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF8,
  0x03, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F,
  0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE,
  0x1F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F,
  0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF0,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFE, 0x0F, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0x3F,
  0xF8, 0x07, 0xFF, 0x3F, 0xF8, 0x07, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0x7F,
  0xF0, 0x03, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF,
  0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF,
  0xE0, 0x3F, 0xFC, 0xFF, 0xF0, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFF, 0x87, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xFC, 0x00, 0x0F, 0xF3,
  0xFF, 0xF8, 0x00, 0x3F, 0xDF, 0xFF, 0xF0, 0x01, 0xFF, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFF, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x0F,
  0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF7, 0xFF, 0xF0,
  0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x0E, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x20, 0x07, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0xF1, 0xFF, 0x00,
  0x7F, 0xFF, 0x3F, 0xE0, 0x3F, 0xFF, 0xF7, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE,
  0x03, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xF0, 0x0F, 0xFE, 0x1F,
  0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xF0, 0x07, 0xFE,
  0x1F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xF0, 0x03,
  0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF8,
  0x03, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xF8, 0x1F,
  0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xBF, 0xF0, 0x03, 0xFF,
  0xEF, 0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xF0, 0x00,
  0x0E, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xF8,
  0x3F, 0xC0, 0x7F, 0xC7, 0xFE, 0x03, 0xFE, 0x7F, 0xE0, 0x1F, 0xF7, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFB, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x38, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE,
  0x07, 0xC0, 0xFF, 0xE0, 0x06, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x20, 0x00, 0x7F, 0xF1, 0xC0, 0x07, 0xFF, 0x8F, 0xF1,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x1F, 0x40, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x06, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x02, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x87,
  0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF,
  0x83, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFC, 0x01,
  0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFE, 0x0F, 0xFC,
  0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x0F,
  0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xFF,
  0x0F, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF8, 0x07,
  0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F, 0xFC, 0x3F, 0xF8,
  0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F,
  0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFB,
  0xFE, 0x01, 0xFF, 0xFE, 0x7F, 0xC0, 0x3F, 0xFF, 0x8F, 0xF0, 0x03, 0xFF,
  0xE1, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFB, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xE0, 0x07, 0xFF, 0x1F, 0xF8, 0x03,
  0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xE0,
  0x1F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF,
  0x81, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF8, 0x03,
  0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0x80,
  0x0F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xCF, 0xFC,
  0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFB, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0x7F, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xCF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xF9, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xC7, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xFC,
  0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x07, 0xF7,
  0xF0, 0x3F, 0xF0, 0x7F, 0xE1, 0xFE, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F,
  0xDF, 0xC1, 0xFF, 0x81, 0xFF, 0x87, 0xF3, 0xF8, 0x7F, 0xE0, 0x3F, 0xF1,
  0xFE, 0x7F, 0x0F, 0xFC, 0x07, 0xFE, 0x3F, 0xCF, 0xE3, 0xFF, 0x00, 0xFF,
  0xCF, 0xF1, 0xFC, 0x7F, 0xE0, 0x1F, 0xF9, 0xFE, 0x3F, 0x8F, 0xFC, 0x01,
  0xFF, 0x3F, 0x87, 0xF3, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0xFE, 0x7F, 0xE0,
  0x07, 0xFD, 0xFE, 0x1F, 0xCF, 0xF8, 0x00, 0xFF, 0xBF, 0x83, 0xFB, 0xFF,
  0x00, 0x1F, 0xEF, 0xF0, 0x7F, 0x7F, 0xC0, 0x03, 0xFD, 0xFC, 0x0F, 0xEF,
  0xF8, 0x00, 0x7F, 0xBF, 0x81, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x7F,
  0xF8, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x87,
  0xFF, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x00, 0x1F, 0xFD, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xEF, 0xFC, 0x00,
  0x00, 0x7F, 0xFB, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0x00, 0x03, 0xFF, 0xC1,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x0F, 0xFE,
  0x00, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x00, 0x3F, 0xF1, 0xFF,
  0x80, 0x00, 0x0F, 0xF9, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xBF, 0xE0, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x43,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0x3F, 0xFF, 0x00, 0x07, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0xC0, 0x00, 0xFF, 0xF8, 0x80, 0x00, 0x1F, 0xE0,
};

const GFXglyph NotoSans_ExtraBoldItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 20, 47, 19, 1, -46 },
  { 119, 25, 17, 29, 6, -46 },
  { 173, 41, 46, 41, 1, -46 },
  { 409, 34, 53, 36, 2, -49 },
  { 635, 51, 47, 57, 4, -46 },
  { 935, 45, 47, 46, 1, -46 },
  { 1200, 12, 17, 16, 6, -46 },
  { 1226, 25, 56, 23, 2, -46 },
  { 1401, 24, 57, 23, -4, -47 },
  { 1572, 31, 31, 35, 5, -49 },
  { 1693, 32, 31, 37, 3, -38 },
  { 1817, 16, 15, 19, -3, -7 },
  { 1847, 19, 9, 21, 1, -22 },
  { 1869, 12, 12, 19, 0, -11 },
  { 1887, 36, 47, 28, -3, -46 },
  { 2099, 33, 47, 36, 2, -46 },
  { 2293, 27, 46, 36, 5, -46 },
  { 2449, 37, 46, 36, -2, -46 },
  { 2662, 35, 47, 36, 0, -46 },
  { 2868, 36, 46, 36, -1, -46 },
  { 3075, 35, 47, 36, 1, -46 },
  { 3281, 34, 47, 36, 3, -46 },
  { 3481, 37, 46, 36, 2, -46 },
  { 3694, 34, 47, 36, 2, -46 },
  { 3894, 32, 47, 36, 3, -46 },
  { 4082, 18, 37, 19, 0, -36 },
  { 4166, 22, 44, 19, -4, -36 },
  { 4287, 31, 34, 37, 3, -40 },
  { 4419, 32, 21, 37, 3, -33 },
  { 4503, 31, 34, 37, 3, -40 },
  { 4635, 27, 47, 30, 5, -46 },
  { 4794, 52, 52, 56, 3, -46 },
  { 5132, 42, 46, 42, -4, -46 },
  { 5374, 38, 46, 40, 1, -46 },
  { 5593, 38, 47, 40, 4, -46 },
  { 5817, 41, 46, 44, 1, -46 },
  { 6053, 36, 46, 35, 1, -46 },
  { 6260, 36, 46, 35, 1, -46 },
  { 6467, 40, 47, 44, 4, -46 },
  { 6702, 45, 46, 45, 1, -46 },
  { 6961, 31, 46, 26, -2, -46 },
  { 7140, 33, 60, 23, -10, -46 },
  { 7388, 45, 46, 41, 1, -46 },
  { 7647, 29, 46, 33, 1, -46 },
  { 7814, 56, 46, 57, 1, -46 },
  { 8136, 49, 46, 49, 1, -46 },
  { 8418, 41, 47, 47, 4, -46 },
  { 8659, 38, 46, 39, 1, -46 },
  { 8878, 41, 57, 47, 4, -46 },
  { 9171, 37, 46, 41, 1, -46 },
  { 9384, 34, 47, 34, 1, -46 },
  { 9584, 34, 46, 35, 5, -46 },
  { 9780, 41, 47, 45, 4, -46 },
  { 10021, 39, 46, 39, 5, -46 },
  { 10246, 59, 46, 58, 5, -46 },
  { 10586, 50, 46, 41, -4, -46 },
  { 10874, 38, 46, 37, 5, -46 },
  { 11093, 40, 46, 34, -2, -46 },
  { 11323, 27, 56, 22, -1, -46 },
  { 11512, 16, 47, 28, 7, -46 },
  { 11606, 27, 56, 22, -4, -46 },
  { 11795, 33, 30, 35, 1, -46 },
  { 11919, 29, 6, 27, -6, 5 },
  { 11941, 15, 10, 22, 9, -49 },
  { 11960, 35, 37, 38, 3, -36 },
  { 12122, 35, 50, 38, 1, -49 },
  { 12341, 29, 37, 32, 3, -36 },
  { 12476, 37, 50, 38, 3, -49 },
  { 12708, 32, 37, 36, 3, -36 },
  { 12856, 39, 64, 25, -7, -49 },
  { 13168, 37, 51, 38, 1, -36 },
  { 13404, 35, 49, 39, 1, -49 },
  { 13619, 21, 49, 20, 1, -49 },
  { 13748, 30, 64, 20, -8, -49 },
  { 13988, 40, 49, 38, 1, -49 },
  { 14233, 21, 49, 20, 1, -49 },
  { 14362, 54, 36, 59, 1, -36 },
  { 14605, 35, 36, 39, 1, -36 },
  { 14763, 32, 37, 38, 3, -36 },
  { 14911, 38, 51, 38, -2, -36 },
  { 15154, 35, 51, 38, 3, -36 },
  { 15378, 29, 36, 27, 1, -36 },
  { 15509, 29, 37, 31, 1, -36 },
  { 15644, 27, 43, 28, 2, -42 },
  { 15790, 35, 36, 39, 3, -35 },
  { 15948, 34, 35, 34, 3, -35 },
  { 16097, 51, 35, 51, 4, -35 },
  { 16321, 42, 35, 35, -3, -35 },
  { 16505, 41, 50, 34, -4, -35 },
  { 16762, 32, 35, 31, -1, -35 },
  { 16902, 27, 56, 23, 0, -46 },
  { 17091, 8, 63, 36, 14, -48 },
  { 17154, 27, 56, 23, -4, -46 },
  { 17343, 32, 11, 37, 3, -28 },
};

const GFXfont NotoSans_ExtraBoldItalic64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic64pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_EXTRABOLDITALIC64PT7B_H_
