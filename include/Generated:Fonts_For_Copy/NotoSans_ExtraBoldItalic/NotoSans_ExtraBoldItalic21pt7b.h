#ifndef _NOTOSANS_EXTRABOLDITALIC21PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x71, 0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0xE0, 0x00, 0x07,
  0x1E, 0x3C, 0x00, 0x77, 0xE7, 0xE6, 0xE6, 0xEE, 0x03, 0x38, 0x1C, 0xC0,
  0x77, 0x01, 0x9C, 0x3F, 0xFD, 0xFF, 0xF0, 0xCE, 0x03, 0x30, 0x1C, 0xC3,
  0xFF, 0xEF, 0xFF, 0x8E, 0x60, 0x39, 0x80, 0xCE, 0x07, 0x30, 0x00, 0x03,
  0x00, 0x60, 0x7F, 0x9F, 0xE7, 0xEC, 0xEC, 0x1F, 0x81, 0xF0, 0x1F, 0x81,
  0xF8, 0x3F, 0x44, 0xEE, 0xFD, 0xFF, 0x3F, 0xC0, 0xC0, 0x10, 0x00, 0x3E,
  0x0E, 0x3F, 0x06, 0x1D, 0xC7, 0x1C, 0xE7, 0x0E, 0x77, 0x07, 0x33, 0x03,
  0xBB, 0xBD, 0xFB, 0xBF, 0x7F, 0xBB, 0x81, 0x9D, 0xC1, 0xCC, 0xE1, 0xC6,
  0x70, 0xC3, 0x70, 0xE1, 0xF8, 0xE0, 0x78, 0x07, 0xE0, 0x1F, 0xE0, 0x7B,
  0xC0, 0xE3, 0x81, 0xEF, 0x03, 0xFC, 0x03, 0xF0, 0x1F, 0x8F, 0x7F, 0x9C,
  0xE7, 0xFB, 0xC7, 0xE7, 0x8F, 0x87, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x00,
  0x7E, 0xEE, 0xE0, 0x0F, 0x1C, 0x1C, 0x38, 0x78, 0x70, 0x70, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0x1E, 0x0E, 0x0E,
  0x0E, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x3C,
  0x38, 0x70, 0xE0, 0x0E, 0x03, 0x8C, 0xE3, 0xF0, 0xFF, 0xC7, 0xF3, 0xE7,
  0xD8, 0x67, 0x09, 0xC0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xFF,
  0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3B, 0x9D, 0xCE, 0x00, 0x7D, 0xFF,
  0xC0, 0xFF, 0xF0, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x78,
  0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00,
  0xF0, 0x00, 0x0F, 0x87, 0xF8, 0xFF, 0x3C, 0xF7, 0x1F, 0xE3, 0xFC, 0x7F,
  0x0E, 0xE1, 0xDC, 0x7B, 0x8F, 0x73, 0xCF, 0xF9, 0xFE, 0x1F, 0x80, 0x07,
  0x8F, 0x8F, 0xDF, 0xEF, 0xF2, 0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x03,
  0x83, 0xC1, 0xE0, 0xF0, 0x07, 0xE1, 0xFF, 0x1F, 0xF0, 0xC7, 0x00, 0x70,
  0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x7F, 0xE7,
  0xFE, 0xFF, 0xE0, 0x0F, 0xC7, 0xFC, 0x7F, 0x88, 0x70, 0x0E, 0x03, 0xC3,
  0xF0, 0xFC, 0x1F, 0xC0, 0x38, 0x07, 0xC0, 0xFF, 0xFD, 0xFF, 0x3F, 0xC0,
  0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1D, 0xC3, 0x9C,
  0x73, 0xCF, 0xFE, 0xFF, 0xEF, 0xFE, 0x03, 0x80, 0x78, 0x07, 0x80, 0x0F,
  0xF1, 0xFE, 0x1F, 0xE1, 0xC0, 0x3C, 0x03, 0xF0, 0x3F, 0xC3, 0xFC, 0x03,
  0xE0, 0x1E, 0x01, 0xE8, 0x3C, 0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0x07, 0xE3,
  0xFC, 0xFF, 0x9C, 0x07, 0x00, 0xEE, 0x3F, 0xE7, 0xFE, 0xF3, 0xDC, 0x3B,
  0x8F, 0x71, 0xEF, 0xF8, 0xFF, 0x0F, 0x80, 0x7F, 0xF7, 0xFE, 0x7F, 0xE0,
  0x1E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0xF0, 0x00, 0x1F, 0x87, 0xF8, 0xF7, 0xBC, 0xF7,
  0x9C, 0x7F, 0x8F, 0xE1, 0xF8, 0x7F, 0x9E, 0x7B, 0x8F, 0x71, 0xEF, 0x79,
  0xFF, 0x1F, 0xC0, 0x1F, 0x8F, 0xF7, 0xFD, 0xC7, 0xF1, 0xFC, 0x7F, 0x3F,
  0xFF, 0x7D, 0xCE, 0xF0, 0x38, 0x1E, 0xFF, 0x3F, 0x8F, 0xC0, 0x18, 0xF3,
  0xCE, 0x00, 0x00, 0x00, 0x03, 0xCF, 0x3C, 0x0C, 0x3C, 0x78, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE3, 0x87, 0x1C, 0x38, 0x00, 0x00, 0x40, 0x70,
  0x7C, 0x7C, 0x7C, 0x3C, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x70, 0x04, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0xC0, 0x3C, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0x70, 0x7C, 0xFC, 0xFC, 0x3C, 0x08, 0x00, 0x7E, 0x7F,
  0xBF, 0xD0, 0xF0, 0x70, 0x78, 0xF8, 0xF8, 0x70, 0x38, 0x00, 0x00, 0x0E,
  0x07, 0x83, 0x80, 0x03, 0xF8, 0x07, 0xFF, 0x07, 0x83, 0xC7, 0x00, 0x67,
  0x1F, 0xBB, 0x1F, 0xDF, 0x9C, 0xCF, 0xDC, 0x67, 0xCE, 0x73, 0xE7, 0x39,
  0xB3, 0xBD, 0xDD, 0xF7, 0xCE, 0x73, 0xC3, 0x80, 0x01, 0xE0, 0xC0, 0x7F,
  0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x77,
  0x03, 0xB8, 0x39, 0xE1, 0xCF, 0x1E, 0x38, 0xFF, 0xCF, 0xFE, 0x7F, 0xF7,
  0x83, 0xB8, 0x1F, 0xC0, 0xE0, 0x0F, 0xE0, 0xFF, 0x87, 0xFE, 0x38, 0xF1,
  0xC7, 0x9E, 0x38, 0xFF, 0x87, 0xF8, 0x3F, 0xE1, 0xC7, 0x9E, 0x3C, 0xF1,
  0xE7, 0xFE, 0x3F, 0xF3, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0xCF, 0xFC, 0x78,
  0x27, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x87, 0xFC, 0x3F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF,
  0x87, 0x1E, 0x1C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x38, 0x38, 0xE1,
  0xE7, 0x87, 0x9E, 0x3C, 0x7F, 0xE1, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xC0, 0x1C, 0x03, 0xC0, 0x3F, 0xE3, 0xFC, 0x3F, 0xC3,
  0x80, 0x78, 0x07, 0x80, 0x7F, 0xC7, 0xF8, 0xFF, 0x80, 0x0F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xC0, 0x1C, 0x03, 0xC0, 0x3F, 0xE3, 0xFC, 0x3F, 0xC3, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0xCF,
  0xFE, 0x78, 0x27, 0x80, 0x3C, 0x03, 0xC7, 0xFE, 0x7E, 0xF3, 0xF7, 0x87,
  0xBC, 0x3D, 0xE1, 0xE7, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0x0E, 0x1E, 0x3C,
  0x3C, 0x78, 0x70, 0xE0, 0xE1, 0xC3, 0xC7, 0x87, 0x8F, 0xFF, 0x1F, 0xFC,
  0x3F, 0xF8, 0x70, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x0E, 0x0E, 0x3C,
  0x3C, 0x00, 0x1F, 0xE3, 0xF8, 0x3E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80,
  0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xE0, 0xFE, 0x3F, 0xC0, 0x01,
  0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80,
  0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0xBE, 0x1F, 0x83,
  0xE0, 0x30, 0x00, 0x0E, 0x1E, 0x3C, 0x78, 0x79, 0xE0, 0xE7, 0x81, 0xDE,
  0x07, 0xBC, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0x77, 0x81, 0xE7, 0x83,
  0xCF, 0x07, 0x9E, 0x0E, 0x1E, 0x3C, 0x3C, 0x00, 0x0E, 0x07, 0x81, 0xE0,
  0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x7F,
  0xDF, 0xEF, 0xF8, 0x0F, 0x03, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x0F, 0x87,
  0xE1, 0xF0, 0xFC, 0x7E, 0x3B, 0x8E, 0xE7, 0xE1, 0xDD, 0xDC, 0x3B, 0xBB,
  0x87, 0x7E, 0x71, 0xEF, 0xDE, 0x39, 0xF3, 0x87, 0x3E, 0x70, 0xE7, 0x8E,
  0x3C, 0xF3, 0xC0, 0x0F, 0x07, 0x1F, 0x07, 0x1F, 0x07, 0x1F, 0x8F, 0x1F,
  0x8E, 0x3B, 0x8E, 0x3B, 0xCE, 0x39, 0xCE, 0x39, 0xDE, 0x39, 0xFC, 0x78,
  0xFC, 0x70, 0xFC, 0x70, 0xFC, 0x70, 0x78, 0xF0, 0x78, 0x07, 0xE0, 0x7F,
  0xC3, 0xFF, 0x8F, 0x0F, 0x78, 0x3D, 0xE0, 0xF7, 0x03, 0xFC, 0x0F, 0xF0,
  0x3B, 0xC1, 0xEF, 0x07, 0xBC, 0x3C, 0x7F, 0xF1, 0xFF, 0x81, 0xF8, 0x00,
  0x0F, 0xE0, 0xFF, 0x87, 0xFE, 0x38, 0xF1, 0xC7, 0x9E, 0x3C, 0xF3, 0xE7,
  0xFE, 0x3F, 0xE1, 0xFC, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0,
  0x00, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x8F, 0x0F, 0x78, 0x3D, 0xE0, 0xF7,
  0x03, 0xFC, 0x0F, 0xF0, 0x3B, 0xC1, 0xEF, 0x07, 0xBC, 0x3C, 0x7F, 0xE1,
  0xFF, 0x81, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x0F,
  0xC0, 0xFF, 0x87, 0xFC, 0x38, 0xF1, 0xC7, 0x9E, 0x38, 0xF3, 0xC7, 0xFC,
  0x3F, 0xC1, 0xDE, 0x1E, 0x70, 0xF3, 0xC7, 0x9E, 0x38, 0x7B, 0xC3, 0xC0,
  0x0F, 0xF1, 0xFE, 0x3F, 0xE3, 0xC2, 0x3C, 0x03, 0xC0, 0x1F, 0x01, 0xF8,
  0x0F, 0x80, 0x3C, 0x03, 0xC8, 0x3C, 0xFF, 0x8F, 0xF8, 0x7E, 0x00, 0xFF,
  0xFF, 0xFB, 0xFF, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x00, 0x3C, 0x3C, 0xF0, 0xE3,
  0xC3, 0x8E, 0x1E, 0x38, 0x79, 0xE1, 0xE7, 0x87, 0x1C, 0x1C, 0x70, 0xF3,
  0xC3, 0xCF, 0x0F, 0x3C, 0x78, 0x7F, 0xE1, 0xFF, 0x03, 0xF8, 0x00, 0xE0,
  0xFE, 0x0F, 0xE0, 0xEE, 0x1E, 0xE1, 0xCE, 0x3C, 0xE3, 0x8F, 0x78, 0xF7,
  0x0F, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x00, 0xE0, 0xE1,
  0xFC, 0x3C, 0x3B, 0x87, 0x87, 0x71, 0xF1, 0xEE, 0x3E, 0x39, 0xCF, 0xCF,
  0x39, 0xF9, 0xC7, 0x37, 0x78, 0xEE, 0xEE, 0x1D, 0xDD, 0xC3, 0xF3, 0xF0,
  0x7E, 0x7E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF0, 0x3C, 0x3E, 0x00, 0x1E, 0x0F,
  0x0E, 0x1E, 0x0F, 0x3C, 0x0F, 0x78, 0x07, 0x78, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x1E, 0xE0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x78, 0x78, 0xF0, 0x78, 0xF0, 0xFF, 0x1E, 0xF1, 0xC7, 0x3C, 0x77, 0x87,
  0xF0, 0x3F, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07,
  0x80, 0x78, 0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xFE,
  0x3F, 0xF3, 0xFF, 0x80, 0x1F, 0x8F, 0x87, 0x03, 0x83, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC0, 0xF8, 0x7C,
  0x00, 0xE1, 0x87, 0x1C, 0x71, 0xC7, 0x1C, 0x38, 0xE3, 0x8E, 0x38, 0xE1,
  0xC0, 0x1F, 0x8F, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x07,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0xF8, 0x7C, 0x00, 0x03, 0x00,
  0x70, 0x1E, 0x07, 0xC0, 0xDC, 0x3B, 0x8E, 0x31, 0x86, 0x70, 0xFC, 0x1C,
  0xFF, 0xFF, 0xC0, 0xF3, 0x8E, 0x0C, 0x67, 0xFD, 0xFF, 0xBC, 0xFF, 0x1D,
  0xE3, 0xBC, 0x77, 0x9E, 0xF3, 0xDF, 0xF3, 0xFE, 0x3D, 0xC0, 0x0E, 0x01,
  0xE0, 0x1E, 0x01, 0xC0, 0x1D, 0xC1, 0xFE, 0x3F, 0xE3, 0xCF, 0x38, 0xF3,
  0x8F, 0x78, 0xF7, 0x8E, 0x79, 0xE7, 0xFC, 0x7F, 0xCE, 0xF8, 0x0F, 0x0F,
  0xF7, 0xF9, 0xE2, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xF0, 0x3F, 0xC7, 0xF0,
  0xFC, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x0C, 0xE3, 0xEE, 0x7F, 0xE7,
  0x9E, 0xF1, 0xCF, 0x1C, 0xF1, 0xCE, 0x3C, 0xF3, 0xCF, 0xF8, 0xFF, 0x87,
  0xB8, 0x07, 0x07, 0xF3, 0xFD, 0xE7, 0xF1, 0xFF, 0xFF, 0xFB, 0xE0, 0xE0,
  0x3C, 0x67, 0xF8, 0xFC, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x38, 0x07, 0xE1,
  0xFE, 0x1F, 0xE0, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01,
  0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0xFC, 0x0F, 0x80, 0xF0, 0x00,
  0x06, 0x31, 0xFF, 0x3F, 0xF3, 0xCF, 0x78, 0xE7, 0x8E, 0x78, 0xE7, 0x9E,
  0x79, 0xE7, 0xFC, 0x7F, 0xC3, 0xDC, 0x03, 0xC8, 0x38, 0xFF, 0x8F, 0xF0,
  0x7E, 0x00, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1D, 0xC1, 0xFE, 0x3F,
  0xF3, 0xCF, 0x3C, 0xF3, 0x8F, 0x78, 0xE7, 0x8E, 0x79, 0xE7, 0x1E, 0x71,
  0xEF, 0x1C, 0x0E, 0x3C, 0x78, 0x01, 0xC3, 0x8F, 0x1E, 0x38, 0x71, 0xE3,
  0xC7, 0x8E, 0x1C, 0x78, 0x01, 0xC0, 0xF0, 0x3C, 0x00, 0x03, 0x80, 0xE0,
  0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78,
  0x1E, 0x07, 0x8F, 0xC3, 0xF0, 0xF8, 0x00, 0x0E, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x01, 0xC7, 0x8E, 0x38, 0xF3, 0xC7, 0xBC, 0x3B, 0xC1, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xBC, 0x39, 0xE1, 0xC7, 0x9E, 0x3C, 0x0E, 0x3C, 0x78,
  0xE1, 0xC3, 0x8F, 0x1E, 0x38, 0x71, 0xE3, 0xC7, 0x8E, 0x1C, 0x78, 0x19,
  0xC3, 0x86, 0xFB, 0xF3, 0xFF, 0xFC, 0xF3, 0xE7, 0x3C, 0xF1, 0xCE, 0x3C,
  0xF7, 0x8E, 0x3D, 0xE3, 0x8F, 0x79, 0xE3, 0x9C, 0x78, 0xE7, 0x1E, 0x7B,
  0xC7, 0x1E, 0x19, 0xC1, 0xBE, 0x3F, 0xF3, 0xCF, 0x3C, 0xF3, 0x8F, 0x78,
  0xE7, 0x8E, 0x79, 0xE7, 0x1E, 0x71, 0xEF, 0x1C, 0x0F, 0x07, 0xF1, 0xFF,
  0x3C, 0xEF, 0x1F, 0xE3, 0xFC, 0x77, 0x0E, 0xF3, 0xDF, 0xF1, 0xFE, 0x1F,
  0x00, 0x0C, 0xE0, 0x6F, 0x87, 0xFC, 0x3C, 0xF1, 0xC7, 0x8E, 0x3C, 0xF1,
  0xE7, 0x8E, 0x3C, 0xF1, 0xFF, 0x0F, 0xF8, 0xF7, 0x87, 0x80, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0xF0, 0x00, 0x0C, 0x67, 0xFD, 0xFF, 0xBC, 0xFF, 0x1D,
  0xE3, 0xBC, 0x77, 0x1E, 0xF3, 0xDF, 0xF3, 0xFE, 0x3D, 0xC0, 0x78, 0x0F,
  0x01, 0xC0, 0x38, 0x0F, 0x00, 0x1D, 0xC6, 0xF3, 0xF8, 0xFE, 0x3C, 0x0E,
  0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0x0F, 0x0F, 0xF3, 0xF9,
  0xE2, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xBB, 0xEF, 0xF3, 0xF8, 0x1C,
  0x1C, 0x3F, 0xFF, 0xFF, 0x78, 0x78, 0x70, 0x70, 0xF0, 0xF0, 0xFC, 0xFC,
  0x7C, 0x38, 0xF7, 0x8E, 0x78, 0xE7, 0x1E, 0x71, 0xE7, 0x1C, 0xF1, 0xCF,
  0x3C, 0xF3, 0xCF, 0xFC, 0xFD, 0x87, 0xB8, 0xE0, 0xFC, 0x3F, 0xC7, 0x79,
  0xEF, 0x38, 0xEF, 0x1D, 0xC3, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3C, 0x00,
  0xE1, 0xC7, 0xF1, 0xE3, 0xF8, 0xF1, 0xDC, 0xF9, 0xEE, 0x6C, 0xE7, 0x36,
  0xF3, 0xBB, 0x70, 0xD9, 0xB8, 0x7C, 0xF8, 0x3E, 0x7C, 0x1E, 0x3C, 0x0F,
  0x1E, 0x00, 0x1C, 0x3C, 0x79, 0xE1, 0xEF, 0x03, 0xB8, 0x0F, 0xC0, 0x1F,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0xC0, 0xF7, 0x07, 0x9E, 0x3C, 0x78, 0x38,
  0x79, 0xE3, 0xCF, 0x1C, 0x79, 0xE1, 0xCE, 0x0E, 0xF0, 0x77, 0x03, 0xF8,
  0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x03, 0xF0, 0x1F,
  0x00, 0xF0, 0x00, 0x3F, 0xCF, 0xF3, 0xFC, 0x1E, 0x0F, 0x03, 0xC1, 0xE0,
  0xF0, 0x78, 0x3F, 0xEF, 0xF3, 0xFC, 0x07, 0x87, 0xC3, 0xC1, 0xC1, 0xC0,
  0xE0, 0x70, 0x78, 0xF8, 0x78, 0x1E, 0x07, 0x03, 0x83, 0x81, 0xC0, 0xE0,
  0x78, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x0F, 0x07,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x87, 0x87, 0xC7, 0x83, 0x81,
  0xC0, 0xE0, 0xF0, 0xF0, 0x70, 0x00, 0xFC, 0x7F, 0xF8, 0xFC,
};

const GFXglyph NotoSans_ExtraBoldItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 15, 6, 0, -15 },
  { 15, 8, 5, 10, 2, -15 },
  { 20, 14, 15, 14, 0, -15 },
  { 47, 11, 17, 12, 1, -16 },
  { 71, 17, 15, 19, 1, -15 },
  { 103, 15, 15, 15, 0, -15 },
  { 132, 4, 5, 5, 2, -15 },
  { 135, 8, 18, 7, 1, -15 },
  { 153, 8, 18, 7, -1, -15 },
  { 171, 10, 10, 11, 2, -16 },
  { 184, 10, 11, 12, 1, -13 },
  { 198, 5, 5, 6, -1, -2 },
  { 202, 6, 3, 7, 0, -7 },
  { 205, 4, 3, 6, 0, -3 },
  { 207, 12, 15, 9, -1, -15 },
  { 230, 11, 15, 12, 1, -15 },
  { 251, 9, 15, 12, 2, -15 },
  { 268, 12, 15, 12, -1, -15 },
  { 291, 11, 15, 12, 0, -15 },
  { 312, 12, 15, 12, 0, -15 },
  { 335, 12, 15, 12, 0, -15 },
  { 358, 11, 15, 12, 1, -15 },
  { 379, 12, 15, 12, 1, -15 },
  { 402, 11, 15, 12, 1, -15 },
  { 423, 10, 15, 12, 1, -15 },
  { 442, 6, 12, 6, 0, -12 },
  { 451, 7, 15, 6, -1, -12 },
  { 465, 10, 11, 12, 1, -13 },
  { 479, 10, 7, 12, 1, -11 },
  { 488, 10, 11, 12, 1, -13 },
  { 502, 9, 15, 10, 2, -15 },
  { 519, 17, 17, 18, 1, -15 },
  { 556, 13, 15, 14, -1, -15 },
  { 581, 13, 15, 13, 0, -15 },
  { 606, 13, 15, 13, 1, -15 },
  { 631, 14, 15, 14, 0, -15 },
  { 658, 12, 15, 12, 0, -15 },
  { 681, 12, 15, 12, 0, -15 },
  { 704, 13, 15, 15, 1, -15 },
  { 729, 15, 15, 15, 0, -15 },
  { 758, 11, 15, 8, -1, -15 },
  { 779, 11, 20, 7, -3, -15 },
  { 807, 15, 15, 13, 0, -15 },
  { 836, 10, 15, 11, 0, -15 },
  { 855, 19, 15, 19, 0, -15 },
  { 891, 16, 15, 16, 0, -15 },
  { 921, 14, 15, 15, 1, -15 },
  { 948, 13, 15, 13, 0, -15 },
  { 973, 14, 19, 15, 1, -15 },
  { 1007, 13, 15, 13, 0, -15 },
  { 1032, 12, 15, 11, 0, -15 },
  { 1055, 11, 15, 11, 2, -15 },
  { 1076, 14, 15, 15, 1, -15 },
  { 1103, 12, 15, 13, 2, -15 },
  { 1126, 19, 15, 19, 2, -15 },
  { 1162, 16, 15, 13, -1, -15 },
  { 1192, 12, 15, 12, 2, -15 },
  { 1215, 13, 15, 11, -1, -15 },
  { 1240, 9, 18, 7, 0, -15 },
  { 1261, 6, 15, 9, 2, -15 },
  { 1273, 9, 18, 7, -1, -15 },
  { 1294, 11, 10, 11, 0, -15 },
  { 1308, 9, 2, 9, -2, 2 },
  { 1311, 5, 3, 7, 3, -16 },
  { 1313, 11, 12, 13, 1, -12 },
  { 1330, 12, 16, 13, 0, -16 },
  { 1354, 10, 12, 10, 1, -12 },
  { 1369, 12, 16, 13, 1, -16 },
  { 1393, 10, 12, 12, 1, -12 },
  { 1408, 12, 21, 8, -2, -16 },
  { 1440, 12, 17, 13, 0, -12 },
  { 1466, 12, 16, 13, 0, -16 },
  { 1490, 7, 16, 7, 0, -16 },
  { 1504, 10, 21, 7, -3, -16 },
  { 1531, 13, 16, 12, 0, -16 },
  { 1557, 7, 16, 7, 0, -16 },
  { 1571, 18, 12, 19, 0, -12 },
  { 1598, 12, 12, 13, 0, -12 },
  { 1616, 11, 12, 13, 1, -12 },
  { 1633, 13, 17, 13, -1, -12 },
  { 1661, 11, 17, 13, 1, -12 },
  { 1685, 10, 12, 9, 0, -12 },
  { 1700, 10, 12, 10, 0, -12 },
  { 1715, 8, 14, 9, 1, -14 },
  { 1729, 12, 12, 13, 1, -12 },
  { 1747, 11, 12, 11, 1, -12 },
  { 1764, 17, 12, 17, 1, -12 },
  { 1790, 14, 12, 12, -1, -12 },
  { 1811, 13, 17, 11, -1, -12 },
  { 1839, 10, 12, 10, 0, -12 },
  { 1854, 9, 18, 8, 0, -15 },
  { 1875, 2, 21, 12, 5, -16 },
  { 1881, 9, 18, 8, -1, -15 },
  { 1902, 10, 3, 12, 1, -9 },
};

const GFXfont NotoSans_ExtraBoldItalic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic21pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_EXTRABOLDITALIC21PT7B_H_
