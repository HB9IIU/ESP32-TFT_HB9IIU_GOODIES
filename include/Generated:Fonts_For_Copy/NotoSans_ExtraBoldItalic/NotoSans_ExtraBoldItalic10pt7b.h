#ifndef _NOTOSANS_EXTRABOLDITALIC10PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xA4, 0xB0, 0xFA, 0x14, 0x59, 0xF9, 0x4F, 0xCA, 0x14, 0x00,
  0x10, 0xF7, 0x9C, 0x38, 0xAF, 0x9C, 0x20, 0xE6, 0xAC, 0xA8, 0xF6, 0x2B,
  0x6A, 0xCE, 0x38, 0x58, 0xE3, 0xBD, 0xD9, 0x9F, 0x80, 0xE0, 0x36, 0x44,
  0xCC, 0xC4, 0x40, 0x31, 0x11, 0x13, 0x26, 0xC0, 0x25, 0x3E, 0xCB, 0x00,
  0x31, 0xBE, 0x63, 0x00, 0xE0, 0xE0, 0x70, 0x18, 0x8C, 0x46, 0x62, 0x00,
  0x39, 0xA4, 0xF2, 0xDB, 0x67, 0x00, 0x3F, 0xB2, 0x66, 0x60, 0x7A, 0x46,
  0x36, 0x63, 0xE0, 0x7A, 0x46, 0x61, 0xCF, 0xC0, 0x1C, 0x63, 0x96, 0xFB,
  0xE3, 0x00, 0x3D, 0x87, 0x1E, 0x1A, 0x6F, 0x00, 0x3D, 0x85, 0x9E, 0xC9,
  0x67, 0x00, 0x7C, 0x21, 0x8C, 0x31, 0x8E, 0x00, 0x39, 0xB7, 0x9C, 0xDB,
  0x67, 0x00, 0x7B, 0x52, 0xF3, 0x8F, 0xC0, 0x2C, 0x05, 0x80, 0x13, 0x00,
  0x06, 0xC0, 0x09, 0xB0, 0x70, 0x80, 0xF8, 0x3E, 0xC1, 0x82, 0xEC, 0x00,
  0xFB, 0x34, 0xC8, 0xC0, 0x1E, 0x30, 0x97, 0xEA, 0xBF, 0x52, 0xF1, 0x88,
  0x78, 0x0C, 0x38, 0x51, 0xB3, 0xEC, 0xF1, 0x80, 0x3D, 0xB6, 0xDE, 0x4D,
  0x7F, 0x80, 0x7F, 0x2C, 0x20, 0x83, 0x4F, 0x00, 0x3D, 0xB6, 0x59, 0x4D,
  0x7F, 0x80, 0x3D, 0x86, 0x1E, 0x41, 0x2F, 0x00, 0x3D, 0x86, 0x1E, 0x41,
  0x0C, 0x00, 0x7F, 0x9C, 0x2E, 0x9B, 0x6F, 0x80, 0x26, 0xCD, 0x9B, 0xE4,
  0xC9, 0xB3, 0x00, 0x79, 0x18, 0xC6, 0x33, 0x80, 0x0C, 0x21, 0x86, 0x18,
  0x43, 0x0C, 0xE0, 0x26, 0xD9, 0xE3, 0xC5, 0x8B, 0x33, 0x00, 0x23, 0x18,
  0xC4, 0x27, 0xC0, 0x33, 0xB9, 0xDD, 0xCA, 0xA5, 0xF2, 0xDB, 0x6C, 0x33,
  0x72, 0x72, 0x5E, 0x4E, 0x4E, 0xCC, 0x7B, 0x3C, 0xE3, 0x8F, 0x6F, 0x00,
  0x3D, 0xB6, 0xDF, 0x71, 0x0C, 0x00, 0x7B, 0x3C, 0xE3, 0x8F, 0x6F, 0x04,
  0x18, 0x3D, 0xB6, 0xDE, 0x59, 0x6C, 0xC0, 0x3B, 0x58, 0x61, 0xCF, 0xC0,
  0xFB, 0x18, 0xC4, 0x23, 0x00, 0x4F, 0x3C, 0xB2, 0x9B, 0x6F, 0x00, 0x8F,
  0x6D, 0xBC, 0xF3, 0x8E, 0x00, 0x99, 0xCC, 0xA6, 0xD5, 0x4A, 0xE7, 0x73,
  0x30, 0x33, 0x16, 0x1C, 0x18, 0x3C, 0x2C, 0xE6, 0xDF, 0x67, 0x18, 0x61,
  0x0C, 0x00, 0x7C, 0x63, 0x0C, 0x63, 0x0F, 0x80, 0x36, 0x44, 0x4C, 0xCC,
  0xC0, 0xD9, 0x24, 0x98, 0x38, 0x84, 0x63, 0x10, 0x8C, 0xE0, 0x11, 0x9A,
  0x98, 0x80, 0xF8, 0xCC, 0x21, 0xF4, 0xB2, 0xD9, 0xE0, 0x20, 0x86, 0x9E,
  0x6D, 0x2D, 0xBC, 0x13, 0xD1, 0x8C, 0xB8, 0x04, 0x32, 0xDF, 0x4B, 0x2D,
  0x9E, 0x13, 0xD3, 0xEC, 0xBC, 0x0C, 0x71, 0x1E, 0x30, 0xC2, 0x08, 0x63,
  0x80, 0x21, 0xF4, 0xB2, 0xD9, 0xE1, 0xBC, 0x20, 0x86, 0x9F, 0x6D, 0x2C,
  0xB6, 0x24, 0x36, 0xB6, 0x11, 0x03, 0x32, 0x66, 0x6C, 0x20, 0x86, 0x5A,
  0x51, 0xCD, 0xB6, 0x25, 0xB6, 0xB6, 0x09, 0x3F, 0xDB, 0x69, 0x2C, 0x96,
  0xD8, 0x09, 0xF6, 0xD2, 0xCB, 0x60, 0x11, 0xE4, 0xF2, 0xD9, 0xC0, 0x19,
  0xE4, 0xD2, 0xDB, 0xCC, 0x20, 0x21, 0xF4, 0xB2, 0xD9, 0xE1, 0x84, 0x0B,
  0x98, 0x8C, 0x60, 0x33, 0xD8, 0xEB, 0x78, 0x22, 0xF6, 0x44, 0x60, 0xDC,
  0xE5, 0x6D, 0x00, 0xCD, 0x65, 0x1C, 0x60, 0xB7, 0xB6, 0xF4, 0xDC, 0xD8,
  0x3E, 0x30, 0x61, 0x4E, 0xC0, 0x66, 0x58, 0xA1, 0xC3, 0x06, 0x38, 0x00,
  0x79, 0x99, 0x8F, 0x00, 0x32, 0x66, 0xC4, 0x46, 0x60, 0xFF, 0xC0, 0x30,
  0x8C, 0x73, 0x11, 0x9C, 0x80, 0xF8,
};

const GFXglyph NotoSans_ExtraBoldItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 7, 3, 0, -7 },
  { 4, 4, 2, 5, 1, -7 },
  { 5, 7, 7, 6, 0, -7 },
  { 12, 6, 9, 6, 0, -8 },
  { 19, 8, 7, 9, 1, -7 },
  { 26, 7, 7, 7, 0, -7 },
  { 33, 2, 2, 2, 1, -7 },
  { 34, 4, 9, 4, 0, -7 },
  { 39, 4, 9, 4, -1, -7 },
  { 44, 5, 5, 5, 1, -8 },
  { 48, 5, 5, 6, 0, -6 },
  { 52, 2, 2, 3, 0, -1 },
  { 53, 3, 1, 3, 0, -3 },
  { 54, 2, 2, 3, 0, -2 },
  { 55, 5, 7, 4, 0, -7 },
  { 60, 6, 7, 6, 0, -7 },
  { 66, 4, 7, 6, 1, -7 },
  { 70, 5, 7, 6, 0, -7 },
  { 75, 5, 7, 6, 0, -7 },
  { 80, 6, 7, 6, 0, -7 },
  { 86, 6, 7, 6, 0, -7 },
  { 92, 6, 7, 6, 0, -7 },
  { 98, 6, 7, 6, 0, -7 },
  { 104, 6, 7, 6, 0, -7 },
  { 110, 5, 7, 6, 0, -7 },
  { 115, 3, 6, 3, 0, -6 },
  { 118, 4, 7, 3, -1, -6 },
  { 122, 5, 5, 6, 0, -6 },
  { 126, 5, 3, 6, 0, -5 },
  { 128, 5, 5, 6, 0, -6 },
  { 132, 4, 7, 5, 1, -7 },
  { 136, 9, 8, 9, 0, -7 },
  { 145, 7, 7, 7, -1, -7 },
  { 152, 6, 7, 6, 0, -7 },
  { 158, 6, 7, 6, 1, -7 },
  { 164, 6, 7, 7, 0, -7 },
  { 170, 6, 7, 6, 0, -7 },
  { 176, 6, 7, 6, 0, -7 },
  { 182, 6, 7, 7, 1, -7 },
  { 188, 7, 7, 7, 0, -7 },
  { 195, 5, 7, 4, 0, -7 },
  { 200, 6, 9, 4, -2, -7 },
  { 207, 7, 7, 6, 0, -7 },
  { 214, 5, 7, 5, 0, -7 },
  { 219, 9, 7, 9, 0, -7 },
  { 227, 8, 7, 8, 0, -7 },
  { 234, 6, 7, 7, 1, -7 },
  { 240, 6, 7, 6, 0, -7 },
  { 246, 6, 9, 7, 1, -7 },
  { 253, 6, 7, 6, 0, -7 },
  { 259, 5, 7, 5, 0, -7 },
  { 264, 5, 7, 5, 1, -7 },
  { 269, 6, 7, 7, 1, -7 },
  { 275, 6, 7, 6, 1, -7 },
  { 281, 9, 7, 9, 1, -7 },
  { 289, 8, 7, 6, -1, -7 },
  { 296, 6, 7, 6, 1, -7 },
  { 302, 6, 7, 5, 0, -7 },
  { 308, 4, 9, 3, 0, -7 },
  { 313, 3, 7, 4, 1, -7 },
  { 316, 5, 9, 3, -1, -7 },
  { 322, 5, 5, 5, 0, -7 },
  { 326, 5, 1, 4, -1, 1 },
  { 327, 3, 2, 3, 1, -8 },
  { 328, 6, 6, 6, 0, -6 },
  { 333, 6, 8, 6, 0, -8 },
  { 339, 5, 6, 5, 0, -6 },
  { 343, 6, 8, 6, 0, -8 },
  { 349, 5, 6, 6, 0, -6 },
  { 353, 6, 10, 4, -1, -8 },
  { 361, 6, 8, 6, 0, -6 },
  { 367, 6, 8, 6, 0, -8 },
  { 373, 3, 8, 3, 0, -8 },
  { 376, 4, 10, 3, -1, -8 },
  { 381, 6, 8, 6, 0, -8 },
  { 387, 3, 8, 3, 0, -8 },
  { 390, 9, 6, 9, 0, -6 },
  { 397, 6, 6, 6, 0, -6 },
  { 402, 6, 6, 6, 0, -6 },
  { 407, 6, 8, 6, 0, -6 },
  { 413, 6, 8, 6, 0, -6 },
  { 419, 5, 6, 4, 0, -6 },
  { 423, 5, 6, 5, 0, -6 },
  { 427, 4, 7, 4, 0, -7 },
  { 431, 5, 5, 6, 1, -5 },
  { 435, 6, 5, 5, 0, -5 },
  { 439, 8, 5, 8, 1, -5 },
  { 444, 7, 5, 5, -1, -5 },
  { 449, 7, 7, 5, -1, -5 },
  { 456, 5, 5, 5, 0, -5 },
  { 460, 4, 9, 4, 0, -7 },
  { 465, 1, 10, 6, 2, -8 },
  { 467, 5, 9, 4, -1, -7 },
  { 473, 5, 1, 6, 0, -4 },
};

const GFXfont NotoSans_ExtraBoldItalic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic10pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_EXTRABOLDITALIC10PT7B_H_
