#ifndef _NOTOSANS_EXTRABOLDITALIC12PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x66, 0x66, 0x0C, 0xC0, 0x5E, 0xF5, 0x20, 0x1A, 0x16, 0x16,
  0x7F, 0x34, 0xFE, 0xFE, 0x68, 0x58, 0x08, 0x7D, 0xB3, 0x83, 0x83, 0xA7,
  0x7E, 0x30, 0x40, 0x61, 0x79, 0xAD, 0x96, 0x8E, 0xBA, 0xF4, 0xDA, 0x4F,
  0x47, 0x00, 0x1C, 0x1F, 0x0D, 0x87, 0x83, 0xBB, 0xDB, 0x39, 0xFC, 0x7F,
  0x00, 0x7E, 0x19, 0x88, 0xC6, 0x23, 0x18, 0x42, 0x18, 0x30, 0x86, 0x31,
  0x8C, 0x66, 0x33, 0x30, 0x13, 0xCF, 0xDD, 0xD0, 0x60, 0x21, 0x3E, 0x42,
  0x10, 0x6F, 0x00, 0xFE, 0xF0, 0x06, 0x0C, 0x30, 0x41, 0x86, 0x0C, 0x30,
  0xE0, 0x18, 0x79, 0x9B, 0x36, 0x79, 0xB3, 0x3E, 0x78, 0x19, 0xFE, 0xE3,
  0x18, 0xC6, 0x60, 0x19, 0xF2, 0xC3, 0x1C, 0xE7, 0x3F, 0xFC, 0x18, 0xF8,
  0x18, 0x63, 0x81, 0x83, 0x7E, 0xF8, 0x06, 0x18, 0x71, 0xE6, 0xD9, 0xBF,
  0x0C, 0x18, 0x3E, 0x7C, 0x83, 0x87, 0xC1, 0x83, 0x7E, 0xF8, 0x0E, 0x7D,
  0xC3, 0x47, 0xCD, 0xB3, 0x3E, 0x78, 0x7E, 0xFC, 0x38, 0x61, 0x83, 0x0C,
  0x38, 0xE0, 0x18, 0x7D, 0x9B, 0xE3, 0x8D, 0xB3, 0x76, 0x78, 0x33, 0xED,
  0xB7, 0xFB, 0xE1, 0xBC, 0xE0, 0x2C, 0x01, 0xB0, 0x13, 0x00, 0x00, 0x64,
  0xC0, 0x08, 0xDD, 0x8E, 0x1C, 0x20, 0xF8, 0x3F, 0xF0, 0x86, 0x1C, 0x33,
  0xF2, 0x00, 0x77, 0xE6, 0x77, 0x22, 0x18, 0xC0, 0x0C, 0x1F, 0x90, 0x7B,
  0xDB, 0x6D, 0x26, 0xB7, 0x6C, 0xC2, 0x3E, 0x00, 0x06, 0x0E, 0x0A, 0x1B,
  0x1B, 0x3F, 0x3F, 0x63, 0xE3, 0x3C, 0x7C, 0xDB, 0x37, 0xCD, 0xD9, 0xBF,
  0xFC, 0x1C, 0xFF, 0x8E, 0x0C, 0x18, 0x30, 0x7C, 0x78, 0x38, 0x3E, 0x37,
  0x63, 0x63, 0x67, 0x66, 0x7E, 0xF8, 0x3E, 0x7C, 0xC3, 0x07, 0xCC, 0x18,
  0x3E, 0xF8, 0x3E, 0x7C, 0xC3, 0x07, 0xCF, 0x98, 0x30, 0xC0, 0x1C, 0xFD,
  0x8E, 0x0D, 0xFB, 0xB3, 0x7E, 0x7C, 0x33, 0x99, 0x8C, 0xCC, 0x67, 0xF3,
  0x31, 0x98, 0xCC, 0xC6, 0x00, 0x7D, 0xE3, 0x0C, 0x31, 0x86, 0x18, 0xF0,
  0x0C, 0x30, 0xC3, 0x18, 0x61, 0x86, 0x18, 0xCF, 0x30, 0x33, 0x9B, 0x8D,
  0x8D, 0x87, 0x83, 0xE1, 0xB0, 0xD8, 0xC6, 0x00, 0x30, 0xC3, 0x18, 0x61,
  0x86, 0x1F, 0xF8, 0x38, 0xE7, 0x1C, 0xE7, 0x3C, 0xE7, 0xBC, 0xF5, 0x9F,
  0xA2, 0xEC, 0xCD, 0x80, 0x31, 0x9C, 0xCE, 0x6D, 0x36, 0xD3, 0x79, 0xBC,
  0x8E, 0xC7, 0x00, 0x1C, 0xFD, 0x9E, 0x3C, 0x78, 0xF1, 0xFE, 0x78, 0x38,
  0x7C, 0xDB, 0x37, 0xEF, 0x98, 0x30, 0xC0, 0x1C, 0xFD, 0x9E, 0x3C, 0x78,
  0xF1, 0xFE, 0x78, 0x30, 0x30, 0x38, 0x7C, 0xDB, 0x37, 0xEF, 0x9B, 0x36,
  0xC6, 0x1E, 0x79, 0x83, 0x83, 0x83, 0x03, 0x7C, 0xF8, 0xFF, 0xF3, 0x0C,
  0x61, 0x86, 0x18, 0xE0, 0x66, 0xCD, 0x9E, 0x3C, 0x79, 0xB3, 0x7E, 0x78,
  0xC7, 0x8F, 0x36, 0x6D, 0x9B, 0x3C, 0x38, 0x60, 0xC4, 0x79, 0x8F, 0x33,
  0x6E, 0x6D, 0x59, 0xEB, 0x3D, 0x47, 0x38, 0xE7, 0x00, 0x31, 0xC6, 0xE1,
  0xB0, 0x78, 0x0C, 0x07, 0x83, 0x61, 0xD8, 0xE3, 0x00, 0xC7, 0x99, 0xB3,
  0xC7, 0x0E, 0x18, 0x30, 0x60, 0x7E, 0xFC, 0x30, 0xC3, 0x86, 0x18, 0x7E,
  0xFC, 0x39, 0xC8, 0xC6, 0x31, 0x18, 0xC6, 0x38, 0xD9, 0x26, 0xDB, 0x20,
  0x39, 0xC6, 0x31, 0x08, 0xC6, 0x31, 0x38, 0x08, 0x63, 0x8B, 0x6F, 0x10,
  0xF8, 0xD0, 0x16, 0xFD, 0x9B, 0x2E, 0xCF, 0x9F, 0x00, 0x30, 0x60, 0xF3,
  0xF6, 0x6C, 0xDB, 0x3E, 0xF8, 0x19, 0xF6, 0x18, 0xE1, 0xE7, 0x80, 0x0E,
  0x18, 0xB7, 0xEC, 0xD9, 0x36, 0x7C, 0xF8, 0x31, 0xEC, 0xFE, 0xC3, 0x2F,
  0x80, 0x0E, 0x34, 0x71, 0xE3, 0x06, 0x0C, 0x18, 0x30, 0xC3, 0x86, 0x00,
  0x16, 0xFD, 0x9B, 0x2E, 0xCF, 0x9F, 0x06, 0xF9, 0xE0, 0x30, 0x60, 0xB3,
  0xF6, 0x6C, 0xDB, 0x26, 0xCC, 0x33, 0x36, 0x66, 0x66, 0xC0, 0x0C, 0x30,
  0xC6, 0x18, 0x61, 0x86, 0x30, 0xCF, 0x38, 0x30, 0x30, 0x37, 0x6E, 0x6C,
  0x78, 0x78, 0x4C, 0xCC, 0x33, 0x36, 0x66, 0x6E, 0xC0, 0x2C, 0xDF, 0xF6,
  0x6D, 0x9B, 0x6C, 0xD3, 0x3C, 0xDC, 0x2C, 0xFD, 0x9B, 0x36, 0xC9, 0xB3,
  0x00, 0x33, 0xEC, 0xF3, 0xDB, 0x6F, 0x00, 0x2C, 0xFD, 0x9B, 0x36, 0xDF,
  0xBE, 0x60, 0xC1, 0x80, 0x2F, 0xFC, 0xF2, 0xDB, 0xEF, 0x86, 0x30, 0xC0,
  0x2D, 0xE7, 0x18, 0x61, 0x8C, 0x00, 0x3D, 0xE6, 0x1E, 0x1A, 0x6F, 0x00,
  0x31, 0xFE, 0xC6, 0x31, 0xCE, 0xCF, 0x3C, 0xF3, 0xDB, 0xEF, 0x80, 0xCF,
  0x6D, 0xBC, 0xF3, 0x8E, 0x00, 0xD9, 0xEC, 0xF6, 0xDF, 0x6E, 0xA7, 0x73,
  0x30, 0x33, 0x36, 0x1E, 0x1C, 0x3C, 0x3C, 0xE6, 0x33, 0x36, 0x36, 0x3C,
  0x3C, 0x38, 0x38, 0x30, 0xF0, 0xE0, 0x7D, 0xF1, 0x8C, 0x63, 0xEF, 0x80,
  0x09, 0xCC, 0x66, 0x61, 0x8C, 0x43, 0x18, 0xFF, 0xF0, 0x21, 0x86, 0x23,
  0x0C, 0xE4, 0x27, 0x30, 0xFD, 0xC0,
};

const GFXglyph NotoSans_ExtraBoldItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 9, 4, 0, -9 },
  { 6, 5, 4, 5, 1, -9 },
  { 9, 8, 9, 8, 0, -9 },
  { 18, 7, 10, 7, 0, -9 },
  { 27, 9, 9, 11, 1, -9 },
  { 38, 9, 9, 9, 0, -9 },
  { 49, 2, 4, 3, 1, -9 },
  { 50, 5, 11, 4, 0, -9 },
  { 57, 5, 11, 4, -1, -9 },
  { 64, 6, 6, 7, 1, -9 },
  { 69, 5, 6, 7, 1, -7 },
  { 73, 3, 3, 4, -1, -1 },
  { 75, 4, 2, 4, 0, -4 },
  { 76, 2, 2, 4, 0, -2 },
  { 77, 7, 9, 5, -1, -9 },
  { 85, 7, 9, 7, 0, -9 },
  { 93, 5, 9, 7, 1, -9 },
  { 99, 6, 9, 7, 0, -9 },
  { 106, 7, 9, 7, 0, -9 },
  { 114, 7, 9, 7, 0, -9 },
  { 122, 7, 9, 7, 0, -9 },
  { 130, 7, 9, 7, 0, -9 },
  { 138, 7, 9, 7, 0, -9 },
  { 146, 7, 9, 7, 0, -9 },
  { 154, 6, 9, 7, 1, -9 },
  { 161, 3, 7, 4, 0, -7 },
  { 164, 4, 9, 4, -1, -7 },
  { 169, 5, 7, 7, 1, -8 },
  { 174, 5, 4, 7, 1, -6 },
  { 177, 5, 7, 7, 1, -8 },
  { 182, 5, 9, 6, 1, -9 },
  { 188, 9, 10, 11, 1, -9 },
  { 200, 8, 9, 8, -1, -9 },
  { 209, 7, 9, 8, 0, -9 },
  { 217, 7, 9, 7, 1, -9 },
  { 225, 8, 9, 8, 0, -9 },
  { 234, 7, 9, 7, 0, -9 },
  { 242, 7, 9, 7, 0, -9 },
  { 250, 7, 9, 8, 1, -9 },
  { 258, 9, 9, 8, 0, -9 },
  { 269, 6, 9, 5, 0, -9 },
  { 276, 6, 12, 4, -2, -9 },
  { 285, 9, 9, 8, 0, -9 },
  { 296, 6, 9, 6, 0, -9 },
  { 303, 11, 9, 11, 0, -9 },
  { 316, 9, 9, 9, 0, -9 },
  { 327, 7, 9, 9, 1, -9 },
  { 335, 7, 9, 7, 0, -9 },
  { 343, 7, 11, 9, 1, -9 },
  { 353, 7, 9, 8, 0, -9 },
  { 361, 7, 9, 6, 0, -9 },
  { 369, 6, 9, 6, 1, -9 },
  { 376, 7, 9, 8, 1, -9 },
  { 384, 7, 9, 7, 1, -9 },
  { 392, 11, 9, 11, 1, -9 },
  { 405, 10, 9, 8, -1, -9 },
  { 417, 7, 9, 7, 1, -9 },
  { 425, 7, 9, 6, 0, -9 },
  { 433, 5, 11, 4, 0, -9 },
  { 440, 3, 9, 5, 1, -9 },
  { 444, 5, 11, 4, -1, -9 },
  { 451, 6, 6, 7, 0, -9 },
  { 456, 5, 1, 5, -1, 1 },
  { 457, 2, 2, 4, 2, -9 },
  { 458, 7, 7, 7, 0, -7 },
  { 465, 7, 9, 7, 0, -9 },
  { 473, 6, 7, 6, 0, -7 },
  { 479, 7, 9, 7, 1, -9 },
  { 487, 6, 7, 7, 1, -7 },
  { 493, 7, 12, 5, -1, -9 },
  { 504, 7, 10, 7, 0, -7 },
  { 513, 7, 9, 7, 0, -9 },
  { 521, 4, 9, 4, 0, -9 },
  { 526, 6, 12, 4, -2, -9 },
  { 535, 8, 9, 7, 0, -9 },
  { 544, 4, 9, 4, 0, -9 },
  { 549, 10, 7, 11, 0, -7 },
  { 558, 7, 7, 7, 0, -7 },
  { 565, 6, 7, 7, 1, -7 },
  { 571, 7, 10, 7, 0, -7 },
  { 580, 6, 10, 7, 1, -7 },
  { 588, 6, 7, 5, 0, -7 },
  { 594, 6, 7, 6, 0, -7 },
  { 600, 5, 8, 5, 0, -8 },
  { 605, 6, 7, 7, 1, -7 },
  { 611, 6, 7, 6, 1, -7 },
  { 617, 9, 7, 10, 1, -7 },
  { 625, 8, 7, 7, -1, -7 },
  { 632, 8, 10, 6, -1, -7 },
  { 642, 6, 7, 6, 0, -7 },
  { 648, 5, 11, 4, 0, -9 },
  { 655, 1, 12, 7, 3, -9 },
  { 657, 5, 11, 4, -1, -9 },
  { 664, 5, 2, 7, 1, -5 },
};

const GFXfont NotoSans_ExtraBoldItalic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic12pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_EXTRABOLDITALIC12PT7B_H_
