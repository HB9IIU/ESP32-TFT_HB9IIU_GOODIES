#ifndef _NOTOSANS_EXTRABOLDITALIC22PT7B_H_
#define _NOTOSANS_EXTRABOLDITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBoldItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBoldItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x78, 0xE3, 0xC7, 0x8F, 0x1C, 0x38, 0x71, 0xE0, 0x02,
  0x1E, 0x3C, 0x78, 0x77, 0xBB, 0x99, 0xDC, 0xEE, 0x67, 0x30, 0x03, 0x98,
  0x0C, 0xE0, 0x73, 0x81, 0xCC, 0x06, 0x70, 0xFF, 0xF7, 0xFF, 0xC3, 0x98,
  0x0C, 0xE3, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x19, 0xC0, 0xE6, 0x03, 0x98,
  0x0C, 0xE0, 0x01, 0x00, 0x60, 0x3F, 0x9F, 0xF7, 0xFE, 0xF4, 0x1F, 0x83,
  0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x06, 0xE8, 0xDD, 0xFF, 0xBF, 0xE7, 0xF8,
  0x18, 0x03, 0x00, 0x1E, 0x07, 0x0F, 0xC1, 0x87, 0x70, 0xE1, 0xDC, 0x70,
  0xE7, 0x38, 0x39, 0xCC, 0x0E, 0x77, 0x73, 0xFB, 0xBE, 0x7F, 0xDF, 0xCE,
  0x67, 0x70, 0x3B, 0x9C, 0x1C, 0xE7, 0x0E, 0x39, 0xC3, 0x8E, 0xE1, 0xC3,
  0xF8, 0xE0, 0x7C, 0x03, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0x70, 0x1E,
  0x70, 0x0E, 0xF0, 0x0F, 0xE0, 0x0F, 0xCF, 0x3F, 0x8E, 0x7F, 0xDE, 0x7B,
  0xFC, 0xF1, 0xFC, 0xF0, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xBC, 0x77,
  0x6E, 0xEE, 0x07, 0x0E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0x70, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x07, 0x03, 0x81,
  0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x70,
  0x78, 0x38, 0x3C, 0x1C, 0x1C, 0x3E, 0x00, 0x05, 0x01, 0x88, 0xE3, 0xB8,
  0xFF, 0xCF, 0xF3, 0xFD, 0xF8, 0xF7, 0x09, 0xC0, 0x60, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x00, 0x39, 0xDE, 0xEF, 0x70, 0x7E, 0xFB, 0xF0, 0x2F, 0xFF, 0x00, 0x70,
  0x0F, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00,
  0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x0F, 0x00, 0x0F, 0x83,
  0xF8, 0xFF, 0xBC, 0xF7, 0x9E, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x3F,
  0x87, 0x71, 0xEF, 0x3D, 0xFF, 0x1F, 0xC1, 0xF0, 0x03, 0x87, 0xC7, 0xEF,
  0xEF, 0xF3, 0x79, 0x3C, 0x1E, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xE0,
  0xF0, 0x78, 0x03, 0xE0, 0x7F, 0x87, 0xFE, 0x1C, 0xF0, 0x87, 0x80, 0x3C,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3F,
  0xF9, 0xFF, 0x9F, 0xFC, 0x0F, 0xC3, 0xFE, 0x1F, 0xF1, 0x8F, 0x00, 0xF0,
  0x0F, 0x03, 0xE0, 0xF8, 0x1F, 0xC0, 0x3E, 0x01, 0xE0, 0x1E, 0x81, 0xEF,
  0xFE, 0xFF, 0xCF, 0xF0, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xE0,
  0xEE, 0x1F, 0xE1, 0xDE, 0x39, 0xC7, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x38, 0x03, 0x80, 0x78, 0x0F, 0xF0, 0xFF, 0x1F, 0xF1, 0xE0, 0x1C, 0x03,
  0xC0, 0x3F, 0x83, 0xFC, 0x3F, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x81, 0xEF,
  0xFC, 0xFF, 0xC7, 0xF0, 0x03, 0xF0, 0xFE, 0x1F, 0xE3, 0xC0, 0x78, 0x07,
  0x00, 0x77, 0x8F, 0xFC, 0xFF, 0xCF, 0x1E, 0xF1, 0xEF, 0x1C, 0xF3, 0xCF,
  0xFC, 0x7F, 0x83, 0xF0, 0x3F, 0xF7, 0xFF, 0x7F, 0xF0, 0x1E, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07,
  0x80, 0x78, 0x0F, 0x00, 0x0F, 0x83, 0xFC, 0xFF, 0x9C, 0x77, 0x8E, 0x73,
  0xCF, 0xF0, 0xFC, 0x3F, 0x8F, 0x7B, 0xCF, 0x70, 0xEE, 0x1D, 0xFF, 0xBF,
  0xE3, 0xF8, 0x0F, 0x07, 0xF9, 0xFF, 0x3C, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x9F, 0x7F, 0xEF, 0xF8, 0x67, 0x01, 0xE0, 0x79, 0xFF, 0x3F, 0xC7, 0xE0,
  0x1C, 0xF3, 0xC6, 0x00, 0x00, 0x00, 0x23, 0xCF, 0x3C, 0x0E, 0x3C, 0x78,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x71, 0xE3, 0x87, 0x1C, 0x38, 0x00, 0x00,
  0x20, 0x1C, 0x0F, 0x87, 0xE3, 0xF1, 0xF0, 0x3C, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x03, 0x80, 0x10, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x80, 0x1C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0xF8,
  0x7E, 0x3F, 0x1F, 0x83, 0x80, 0x40, 0x00, 0x3E, 0x7F, 0xBF, 0xE8, 0xF0,
  0x78, 0x3C, 0x7C, 0x7C, 0x78, 0x38, 0x1C, 0x00, 0x06, 0x07, 0x83, 0xC1,
  0xC0, 0x01, 0xF8, 0x01, 0xFF, 0x81, 0xF9, 0xF0, 0xF0, 0x0E, 0x38, 0x61,
  0x9C, 0x7F, 0x76, 0x3F, 0x9F, 0x9C, 0xE7, 0xE6, 0x39, 0xFB, 0x8C, 0x6E,
  0xE7, 0x3B, 0xBB, 0xDE, 0xE7, 0xFF, 0x38, 0xE7, 0x07, 0x00, 0x00, 0xF0,
  0xE0, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x1F, 0x80,
  0xEE, 0x03, 0xB8, 0x1E, 0xE0, 0x73, 0x83, 0xCE, 0x0E, 0x38, 0x78, 0xE1,
  0xFF, 0x8F, 0xFE, 0x7F, 0xFD, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0x0F, 0xE0,
  0x3F, 0xE1, 0xFF, 0x87, 0x9F, 0x1E, 0x38, 0x71, 0xE3, 0xFF, 0x8F, 0xF8,
  0x3F, 0xE0, 0xF3, 0xC3, 0x87, 0x1E, 0x1C, 0x78, 0xF1, 0xFF, 0xC7, 0xFE,
  0x3F, 0xE0, 0x03, 0xF0, 0x7F, 0xC7, 0xFE, 0x7C, 0x63, 0xC0, 0x3C, 0x01,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x82, 0x3F,
  0xF0, 0xFF, 0x83, 0xF8, 0x0F, 0xC0, 0x3F, 0xC1, 0xFF, 0x87, 0x9F, 0x1E,
  0x3C, 0x70, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0x83, 0xDE,
  0x1E, 0x78, 0xF9, 0xFF, 0xC7, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC7,
  0xFC, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xE1, 0xFF, 0x1F, 0xF8, 0x0F, 0xF8,
  0x7F, 0xC7, 0xFC, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0xFC, 0x3F,
  0xE1, 0xFE, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00,
  0x03, 0xF8, 0x3F, 0xF1, 0xFF, 0x8F, 0x86, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x7E, 0xF1, 0xFB, 0xCF, 0xEF, 0x07, 0xBC, 0x1C, 0x78, 0xF1, 0xFF,
  0xC3, 0xFF, 0x07, 0xF8, 0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1C, 0x1E, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3C, 0x3C,
  0x38, 0x3C, 0x78, 0x38, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF0, 0x70,
  0x0F, 0xE3, 0xFC, 0x7F, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E,
  0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x1F, 0xC7, 0xF8, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x09,
  0xF0, 0xFF, 0x0F, 0xE0, 0x78, 0x00, 0x0F, 0x1F, 0x0E, 0x1E, 0x1E, 0x3C,
  0x1E, 0x78, 0x1E, 0xF0, 0x1D, 0xF0, 0x3D, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x39, 0xE0, 0x79, 0xE0, 0x79, 0xE0, 0x78, 0xF0, 0x70, 0xF0,
  0xF0, 0xF8, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1F, 0xF7, 0xFF, 0xFF, 0x0F, 0x81,
  0xF0, 0xF8, 0x3E, 0x1F, 0x83, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0xFE, 0x3F, 0x8F, 0xC3, 0xF9, 0xDC, 0x3B, 0x9D, 0xC3, 0xBB, 0xBC, 0x3B,
  0xBB, 0xC7, 0xBF, 0x38, 0x7B, 0xF3, 0x87, 0x3E, 0x38, 0x73, 0xE7, 0x8F,
  0x3C, 0x78, 0x0F, 0x03, 0x87, 0x83, 0xC7, 0xE1, 0xE3, 0xF0, 0xE1, 0xF8,
  0x70, 0xFE, 0x38, 0xF7, 0x3C, 0x7B, 0x9E, 0x39, 0xEE, 0x1C, 0x77, 0x0E,
  0x3B, 0x8F, 0x1F, 0xC7, 0x8F, 0xE3, 0x83, 0xE1, 0xC1, 0xF1, 0xE0, 0xF8,
  0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0xCF, 0x8F, 0x3C, 0x3D, 0xE0, 0x77, 0x81,
  0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1E, 0x78, 0xF9, 0xFF,
  0xC3, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x87, 0xFE, 0x3C, 0xF1, 0xE3,
  0x8E, 0x1C, 0xF1, 0xE7, 0xBF, 0x3F, 0xF1, 0xFF, 0x0F, 0xC0, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0xCF,
  0x8F, 0x3C, 0x3D, 0xE0, 0x77, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x1E, 0x78, 0xF9, 0xFF, 0xC3, 0xFE, 0x07, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x1F, 0x00, 0x3C, 0x0F, 0xC0, 0x7F, 0x87, 0xFE, 0x3C, 0xF1,
  0xE7, 0x8E, 0x3C, 0xF1, 0xE7, 0xFE, 0x3F, 0xE1, 0xFE, 0x0E, 0x70, 0xF3,
  0xC7, 0x9E, 0x3C, 0x79, 0xE3, 0xDE, 0x0F, 0x07, 0xE0, 0xFF, 0x1F, 0xE3,
  0xC2, 0x3C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0,
  0x1C, 0xC3, 0xCF, 0xFC, 0xFF, 0x87, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x1C, 0x1C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F,
  0x3C, 0x3C, 0xE0, 0xE7, 0x87, 0x9E, 0x1E, 0x78, 0x79, 0xC1, 0xE7, 0x07,
  0x3C, 0x3C, 0xF0, 0xF1, 0xFF, 0x87, 0xFC, 0x0F, 0xE0, 0xE0, 0x7F, 0x03,
  0xBC, 0x3D, 0xE1, 0xCF, 0x1E, 0x78, 0xE3, 0xCF, 0x1E, 0x70, 0xF7, 0x83,
  0xB8, 0x1D, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xE0,
  0xF0, 0xFE, 0x0F, 0x0F, 0xE1, 0xF1, 0xEE, 0x1F, 0x1E, 0xE3, 0xF1, 0xCE,
  0x3F, 0x3C, 0xE3, 0x73, 0x8E, 0x77, 0x78, 0xE7, 0x77, 0x0E, 0xE7, 0x70,
  0xEE, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xC0, 0xF8, 0x7C,
  0x0F, 0x87, 0x80, 0x1E, 0x0F, 0x87, 0x87, 0x83, 0xC7, 0x81, 0xE7, 0x80,
  0x77, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xFC, 0x03, 0xDE, 0x03, 0xC7, 0x01, 0xE3, 0xC1, 0xE1, 0xE1, 0xE0,
  0xF8, 0xF0, 0xFF, 0x87, 0xBC, 0x78, 0xE3, 0xC7, 0xBC, 0x3F, 0xC0, 0xFC,
  0x07, 0xE0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01,
  0xE0, 0x0F, 0x00, 0x0F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC0, 0x3E, 0x00, 0xF0,
  0x07, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80,
  0x3C, 0x01, 0xFF, 0xCF, 0xFE, 0x3F, 0xF8, 0x0F, 0x8F, 0xC7, 0xE3, 0x81,
  0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x03, 0x81, 0xC1,
  0xC0, 0xE0, 0x7C, 0x3E, 0x1F, 0x00, 0xE1, 0xC7, 0x1C, 0x71, 0xC7, 0x0E,
  0x38, 0xE3, 0x8E, 0x38, 0xF1, 0xC7, 0x0F, 0x8F, 0xC7, 0xE0, 0xE0, 0x70,
  0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x38,
  0x3C, 0x7C, 0x3E, 0x1F, 0x00, 0x01, 0x80, 0x38, 0x07, 0x80, 0x7C, 0x0F,
  0xC1, 0xCC, 0x1C, 0xC3, 0x8E, 0x70, 0xE7, 0x06, 0xE0, 0x70, 0xFF, 0xFF,
  0xE0, 0xF3, 0x8E, 0x30, 0x1F, 0x73, 0xFF, 0x7F, 0xE7, 0x9E, 0xF1, 0xEF,
  0x1E, 0xF1, 0xEF, 0x1C, 0xF3, 0xCF, 0xFC, 0xFF, 0xC7, 0xF8, 0x0F, 0x00,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xDE, 0x1F, 0xF3, 0xFF, 0x3C, 0xF3,
  0x87, 0x38, 0xF7, 0x8F, 0x78, 0xF7, 0x9E, 0x7F, 0xE7, 0xFC, 0xE7, 0x80,
  0x1F, 0xCF, 0xF7, 0xF9, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0xBF,
  0xC7, 0xF0, 0xFC, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x0F,
  0x78, 0xFF, 0xCF, 0xFC, 0x79, 0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0x8F, 0x1C,
  0x79, 0xE3, 0xFF, 0x1F, 0xF8, 0x7F, 0x80, 0x1F, 0xC7, 0xFD, 0xF7, 0xBC,
  0xFF, 0x1F, 0xFF, 0xBF, 0xE7, 0x80, 0xF0, 0x1F, 0x71, 0xFE, 0x1F, 0x80,
  0x00, 0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0x80, 0x38, 0x07, 0xF0, 0x7F, 0x83,
  0xFC, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x00,
  0x0F, 0xB8, 0xFF, 0xCF, 0xFC, 0x79, 0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0xCF,
  0x1C, 0x79, 0xE3, 0xFF, 0x1F, 0xF8, 0x7B, 0x80, 0x1C, 0x01, 0xE3, 0xFF,
  0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xDE, 0x1F, 0xF3, 0xFF, 0x3C, 0x73, 0xC7, 0x38, 0xF7, 0x8F, 0x78, 0xF7,
  0x8E, 0x78, 0xE7, 0x1E, 0xF1, 0xE0, 0x0E, 0x3C, 0x78, 0x20, 0x03, 0xC7,
  0x1E, 0x3C, 0x78, 0xE3, 0xC7, 0x8F, 0x1E, 0x38, 0xF0, 0x01, 0xC0, 0x70,
  0x3C, 0x02, 0x00, 0x00, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C,
  0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xE3, 0xF0, 0xFC, 0x3E,
  0x00, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x71, 0xF1,
  0xC7, 0x8F, 0x3C, 0x3D, 0xE0, 0xEF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0xC1,
  0xEF, 0x07, 0x9E, 0x1C, 0x78, 0xF0, 0xF0, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E,
  0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x78, 0x78, 0x70, 0xF0,
  0x1D, 0xE3, 0xC3, 0xFE, 0xFC, 0xFF, 0xFF, 0x9E, 0x3C, 0xF3, 0xC7, 0x1E,
  0x71, 0xE3, 0xDE, 0x3C, 0x7B, 0xC7, 0x8E, 0x78, 0xE3, 0xCF, 0x1C, 0x79,
  0xC7, 0x8F, 0x78, 0xF1, 0xE0, 0x1D, 0xE1, 0xFF, 0x3F, 0xF3, 0xC7, 0x3C,
  0x73, 0x8F, 0x78, 0xF7, 0x8F, 0x78, 0xE7, 0x8E, 0x71, 0xEF, 0x1E, 0x1F,
  0x87, 0xF9, 0xFF, 0xBC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF3, 0xDF,
  0xF9, 0xFE, 0x1F, 0x80, 0x0E, 0xF0, 0x7F, 0xC7, 0xFE, 0x3C, 0xF1, 0xC3,
  0x8E, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0xF1, 0xFF, 0x8F, 0xF8, 0xF7, 0x87,
  0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x00, 0x1F, 0x73, 0xFF, 0x7F,
  0xE7, 0x9E, 0xF1, 0xEF, 0x1E, 0xF1, 0xCF, 0x1C, 0xF3, 0xCF, 0xFC, 0x7F,
  0xC7, 0xB8, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0x1D, 0xC7,
  0xF3, 0xFC, 0xF8, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x03,
  0xC0, 0x1F, 0xCF, 0xF3, 0xC9, 0xE0, 0x3E, 0x0F, 0xC1, 0xF8, 0x1E, 0x87,
  0xBF, 0xEF, 0xF3, 0xF8, 0x0C, 0x0E, 0x07, 0x0F, 0xFF, 0xF7, 0xF9, 0xE0,
  0xF0, 0x78, 0x38, 0x3C, 0x1E, 0x0F, 0xE7, 0xF1, 0xF8, 0x38, 0xF7, 0x8F,
  0x78, 0xF7, 0x8E, 0x70, 0xE7, 0x1E, 0xF1, 0xEF, 0x1E, 0xF3, 0xCF, 0xFC,
  0xFD, 0xC7, 0xDC, 0xF0, 0xFF, 0x1E, 0xF1, 0xCF, 0x3C, 0x73, 0x87, 0x78,
  0x77, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xF1, 0xE3, 0xFC,
  0xF8, 0xEF, 0x3E, 0x7B, 0xCF, 0x9C, 0xF7, 0xEF, 0x1D, 0xBB, 0x87, 0xEF,
  0xE1, 0xFB, 0xF0, 0x7C, 0xFC, 0x1F, 0x3E, 0x07, 0x8F, 0x81, 0xE3, 0xC0,
  0x1E, 0x3C, 0x79, 0xE0, 0xEF, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0xFC,
  0x03, 0xF0, 0x1F, 0xC0, 0xF7, 0x87, 0x9E, 0x3C, 0x3C, 0x3C, 0x3C, 0xF1,
  0xE3, 0xC7, 0x07, 0x3C, 0x1C, 0xE0, 0x77, 0x81, 0xDC, 0x07, 0x70, 0x1F,
  0x80, 0x7E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x0F, 0xC0, 0x3E,
  0x00, 0xF0, 0x00, 0x3F, 0xE7, 0xF8, 0xFF, 0x03, 0xC0, 0xF0, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1F, 0xF3, 0xFE, 0x7F, 0x80, 0x03, 0x83, 0xC3, 0xE1,
  0xC0, 0xE0, 0xF0, 0x70, 0x38, 0xFC, 0x7C, 0x3C, 0x0F, 0x03, 0x81, 0xC0,
  0xE0, 0xE0, 0x78, 0x3E, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1C, 0x0F, 0x07, 0x81, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x03, 0xC3,
  0xE3, 0xC1, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x78, 0x3C, 0x00, 0x30, 0x3F,
  0xEF, 0xFF, 0xC3, 0xE0,
};

const GFXglyph NotoSans_ExtraBoldItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 16, 6, 0, -16 },
  { 15, 9, 6, 10, 2, -16 },
  { 22, 14, 16, 14, 0, -16 },
  { 50, 11, 18, 12, 1, -17 },
  { 75, 18, 16, 20, 1, -16 },
  { 111, 16, 16, 16, 0, -16 },
  { 143, 4, 6, 5, 2, -16 },
  { 146, 8, 19, 8, 1, -16 },
  { 165, 9, 19, 8, -2, -16 },
  { 187, 10, 11, 12, 2, -17 },
  { 201, 11, 11, 13, 1, -13 },
  { 217, 5, 6, 6, -1, -3 },
  { 221, 7, 3, 7, 0, -7 },
  { 224, 4, 4, 6, 0, -4 },
  { 226, 12, 16, 10, -1, -16 },
  { 250, 11, 16, 12, 1, -16 },
  { 272, 9, 16, 12, 2, -16 },
  { 290, 13, 16, 12, -1, -16 },
  { 316, 12, 16, 12, 0, -16 },
  { 340, 12, 16, 12, 0, -16 },
  { 364, 12, 16, 12, 0, -16 },
  { 388, 12, 16, 12, 1, -16 },
  { 412, 12, 16, 12, 1, -16 },
  { 436, 11, 16, 12, 1, -16 },
  { 458, 11, 16, 12, 1, -16 },
  { 480, 6, 12, 6, 0, -12 },
  { 489, 7, 15, 6, -1, -12 },
  { 503, 11, 12, 13, 1, -14 },
  { 520, 11, 7, 13, 1, -11 },
  { 530, 11, 12, 13, 1, -14 },
  { 547, 9, 16, 10, 2, -16 },
  { 565, 18, 18, 19, 1, -16 },
  { 606, 14, 16, 14, -1, -16 },
  { 634, 14, 16, 14, 0, -16 },
  { 662, 13, 16, 14, 1, -16 },
  { 688, 14, 16, 15, 0, -16 },
  { 716, 13, 16, 12, 0, -16 },
  { 742, 13, 16, 12, 0, -16 },
  { 768, 14, 16, 15, 1, -16 },
  { 796, 16, 16, 16, 0, -16 },
  { 828, 11, 16, 9, -1, -16 },
  { 850, 12, 21, 8, -4, -16 },
  { 882, 16, 16, 14, 0, -16 },
  { 914, 10, 16, 11, 0, -16 },
  { 934, 20, 16, 20, 0, -16 },
  { 974, 17, 16, 17, 0, -16 },
  { 1008, 14, 16, 16, 1, -16 },
  { 1036, 13, 16, 14, 0, -16 },
  { 1062, 14, 20, 16, 1, -16 },
  { 1097, 13, 16, 14, 0, -16 },
  { 1123, 12, 16, 12, 0, -16 },
  { 1147, 11, 16, 12, 2, -16 },
  { 1169, 14, 16, 15, 1, -16 },
  { 1197, 13, 16, 13, 2, -16 },
  { 1223, 20, 16, 20, 2, -16 },
  { 1263, 17, 16, 14, -1, -16 },
  { 1297, 13, 16, 13, 2, -16 },
  { 1323, 14, 16, 12, -1, -16 },
  { 1351, 9, 20, 8, 0, -16 },
  { 1374, 6, 16, 10, 2, -16 },
  { 1386, 9, 20, 8, -1, -16 },
  { 1409, 12, 11, 12, 0, -16 },
  { 1426, 10, 2, 9, -2, 2 },
  { 1429, 5, 4, 7, 3, -17 },
  { 1432, 12, 12, 13, 1, -12 },
  { 1450, 12, 17, 13, 0, -17 },
  { 1476, 10, 12, 11, 1, -12 },
  { 1491, 13, 17, 13, 1, -17 },
  { 1519, 11, 12, 12, 1, -12 },
  { 1536, 13, 22, 9, -2, -17 },
  { 1572, 13, 17, 13, 0, -12 },
  { 1600, 12, 17, 13, 0, -17 },
  { 1626, 7, 17, 7, 0, -17 },
  { 1641, 10, 22, 7, -3, -17 },
  { 1669, 14, 17, 13, 0, -17 },
  { 1699, 8, 17, 7, 0, -17 },
  { 1716, 19, 12, 20, 0, -12 },
  { 1745, 12, 12, 13, 0, -12 },
  { 1763, 11, 12, 13, 1, -12 },
  { 1780, 13, 17, 13, -1, -12 },
  { 1808, 12, 17, 13, 1, -12 },
  { 1834, 10, 12, 9, 0, -12 },
  { 1849, 10, 12, 11, 0, -12 },
  { 1864, 9, 15, 10, 1, -15 },
  { 1881, 12, 12, 13, 1, -12 },
  { 1899, 12, 12, 12, 1, -12 },
  { 1917, 18, 12, 18, 1, -12 },
  { 1944, 14, 12, 12, -1, -12 },
  { 1965, 14, 17, 12, -1, -12 },
  { 1995, 11, 12, 11, 0, -12 },
  { 2012, 9, 19, 8, 0, -16 },
  { 2034, 2, 22, 12, 5, -17 },
  { 2040, 9, 19, 8, -1, -16 },
  { 2062, 11, 4, 13, 1, -10 },
};

const GFXfont NotoSans_ExtraBoldItalic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBoldItalic22pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBoldItalic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_EXTRABOLDITALIC22PT7B_H_
