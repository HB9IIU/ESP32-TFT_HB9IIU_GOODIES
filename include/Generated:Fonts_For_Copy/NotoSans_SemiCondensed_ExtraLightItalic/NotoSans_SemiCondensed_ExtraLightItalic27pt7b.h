#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC27PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x44, 0x21, 0x08, 0xC4, 0x21, 0x08, 0x84, 0x20, 0x00, 0x04,
  0x20, 0x45, 0x34, 0xA2, 0x8A, 0x29, 0x00, 0x02, 0x10, 0x08, 0x40, 0x21,
  0x01, 0x08, 0x04, 0x20, 0x10, 0x87, 0xBD, 0xC2, 0x10, 0x08, 0x40, 0x21,
  0x01, 0x08, 0x04, 0x20, 0xFF, 0xF0, 0x84, 0x02, 0x10, 0x08, 0x40, 0x21,
  0x01, 0x08, 0x04, 0x20, 0x00, 0x00, 0x80, 0x10, 0x01, 0x00, 0xFE, 0x19,
  0x13, 0x10, 0x22, 0x02, 0x20, 0x22, 0x01, 0x20, 0x0C, 0x00, 0x60, 0x05,
  0x80, 0x48, 0x04, 0x40, 0x84, 0x08, 0x80, 0x88, 0x8B, 0x07, 0xC0, 0x10,
  0x01, 0x00, 0x10, 0x00, 0x08, 0x00, 0x6C, 0x08, 0x88, 0x22, 0x10, 0x44,
  0x21, 0x10, 0x44, 0x20, 0x88, 0x41, 0x20, 0x84, 0x8D, 0x09, 0x66, 0x24,
  0x8E, 0xD2, 0x12, 0x24, 0x20, 0x88, 0x42, 0x20, 0x84, 0x41, 0x10, 0x84,
  0x41, 0x08, 0x82, 0x22, 0x03, 0xC0, 0x01, 0x80, 0x36, 0x02, 0x08, 0x10,
  0x40, 0x82, 0x04, 0x30, 0x21, 0x01, 0x10, 0x0B, 0x00, 0x20, 0x07, 0x80,
  0x44, 0x14, 0x10, 0xC0, 0x8A, 0x02, 0x50, 0x14, 0x80, 0x44, 0x06, 0x30,
  0x48, 0xFC, 0x60, 0x56, 0xA8, 0x03, 0x04, 0x08, 0x18, 0x10, 0x20, 0x20,
  0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x40, 0x40, 0x04, 0x02, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10,
  0x30, 0x20, 0xC0, 0x04, 0x01, 0x0C, 0x40, 0xD0, 0x0F, 0xC3, 0x03, 0x41,
  0x88, 0x42, 0x00, 0xC0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x3F, 0xF8, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x32, 0x24,
  0x48, 0xFC, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x00, 0x01, 0x80, 0x6C, 0x08,
  0x21, 0x02, 0x10, 0x22, 0x03, 0x20, 0x34, 0x02, 0x40, 0x24, 0x02, 0x40,
  0x24, 0x02, 0x80, 0x68, 0x04, 0x80, 0x48, 0x0C, 0x80, 0x84, 0x10, 0x43,
  0x03, 0xE0, 0x0C, 0xD6, 0xA2, 0x08, 0x20, 0x84, 0x10, 0x41, 0x0C, 0x20,
  0x82, 0x08, 0x41, 0x04, 0x00, 0x01, 0x80, 0x66, 0x08, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x18, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0F, 0xFC, 0x00,
  0x80, 0x7B, 0x06, 0x04, 0x00, 0x20, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x60, 0x1C, 0x03, 0xE0, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x20, 0x21, 0xFE, 0x00, 0x00, 0x30, 0x07, 0x00,
  0x50, 0x0A, 0x01, 0x20, 0x22, 0x02, 0x20, 0x42, 0x08, 0x41, 0x04, 0x30,
  0x42, 0x04, 0x40, 0x4F, 0xFF, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01,
  0x00, 0x07, 0xF8, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x02, 0xC0, 0x19, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x44, 0x0C, 0x1F, 0xC0, 0x00, 0x60, 0x39, 0x04,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x47, 0x05, 0x8C, 0x60,
  0x44, 0x04, 0x40, 0x2C, 0x06, 0x80, 0x48, 0x04, 0xC0, 0x44, 0x08, 0x41,
  0x03, 0xE0, 0x7F, 0xE0, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40,
  0x18, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00,
  0x20, 0x08, 0x03, 0x00, 0x00, 0x01, 0x00, 0xEE, 0x18, 0x21, 0x01, 0x10,
  0x11, 0x03, 0x10, 0x21, 0x06, 0x08, 0x80, 0x70, 0x0F, 0x03, 0x18, 0x40,
  0x88, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0xC1, 0x83, 0xF0, 0x03,
  0x01, 0x98, 0x41, 0x98, 0x12, 0x02, 0x40, 0x50, 0x0A, 0x01, 0x40, 0x28,
  0x0C, 0x83, 0x98, 0x90, 0xE4, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x60,
  0x18, 0x7C, 0x00, 0x32, 0x00, 0x00, 0x00, 0x00, 0x00, 0x88, 0x0C, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x20, 0x84, 0x10, 0x80, 0x00,
  0x20, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0x20, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x00, 0x08, 0x76, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x40, 0x40, 0x00, 0x00,
  0x00, 0x80, 0x80, 0x00, 0xFE, 0x00, 0xC0, 0xC0, 0xC0, 0x08, 0x20, 0x02,
  0x10, 0x00, 0x48, 0x1E, 0x12, 0x18, 0x85, 0x0C, 0x21, 0x42, 0x08, 0x51,
  0x04, 0x18, 0x41, 0x0A, 0x10, 0x42, 0x84, 0x30, 0xA1, 0x0C, 0x48, 0x45,
  0x32, 0x0E, 0x78, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x30, 0x02, 0x80, 0x14, 0x01, 0x20, 0x09, 0x00,
  0x88, 0x04, 0x40, 0x42, 0x02, 0x10, 0x20, 0x81, 0x06, 0x1F, 0xF0, 0x80,
  0x88, 0x04, 0x40, 0x24, 0x01, 0x20, 0x0A, 0x00, 0x70, 0x02, 0x0F, 0xE0,
  0x40, 0x84, 0x02, 0x20, 0x11, 0x00, 0x88, 0x0C, 0xC0, 0x44, 0x04, 0x3F,
  0xC1, 0x0E, 0x08, 0x08, 0x80, 0x44, 0x02, 0x20, 0x11, 0x00, 0x88, 0x04,
  0x80, 0x44, 0x0C, 0x3F, 0x80, 0x00, 0xC0, 0x39, 0xC3, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x20, 0x41, 0x00, 0x84, 0x02, 0x10, 0x04, 0x40,
  0x13, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x32, 0x00, 0x90, 0x02, 0x40,
  0x09, 0x00, 0x44, 0x03, 0x10, 0x08, 0x80, 0xC2, 0x06, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00,
  0x3F, 0xC2, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x80, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x03, 0xFC, 0x20, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x1C, 0xF0, 0xC0, 0x44, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x1F, 0xA0, 0x06, 0x80, 0x12, 0x00, 0x48, 0x01,
  0x20, 0x04, 0x80, 0x21, 0x00, 0x86, 0x02, 0x07, 0xF0, 0x08, 0x02, 0x10,
  0x04, 0x40, 0x08, 0x80, 0x21, 0x00, 0x42, 0x00, 0x8C, 0x01, 0x10, 0x06,
  0x3F, 0xF8, 0x40, 0x10, 0x80, 0x22, 0x00, 0x44, 0x01, 0x08, 0x02, 0x10,
  0x04, 0x20, 0x08, 0x80, 0x11, 0x00, 0x42, 0x00, 0x80, 0x0F, 0x81, 0x00,
  0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x3E, 0x00, 0x00, 0x40, 0x10, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x01, 0x83,
  0x80, 0x08, 0x0C, 0x20, 0x41, 0x02, 0x04, 0x10, 0x10, 0x80, 0x44, 0x03,
  0x30, 0x09, 0x80, 0x2C, 0x00, 0xD8, 0x02, 0x20, 0x10, 0x80, 0x41, 0x01,
  0x04, 0x04, 0x18, 0x10, 0x20, 0x80, 0x82, 0x01, 0x08, 0x04, 0x00, 0x08,
  0x08, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40,
  0x40, 0x40, 0x40, 0x80, 0x80, 0xFF, 0x0C, 0x00, 0x61, 0x80, 0x14, 0x50,
  0x03, 0x0A, 0x00, 0xA1, 0x40, 0x14, 0x28, 0x04, 0x8D, 0x00, 0xA1, 0x20,
  0x24, 0x22, 0x04, 0x84, 0x41, 0x10, 0x88, 0x62, 0x21, 0x08, 0x84, 0x22,
  0x10, 0x84, 0x42, 0x10, 0x90, 0x42, 0x12, 0x08, 0x82, 0x82, 0x10, 0x30,
  0x42, 0x04, 0x08, 0x00, 0x08, 0x02, 0x18, 0x04, 0x50, 0x08, 0xA0, 0x11,
  0x60, 0x42, 0x40, 0x8C, 0x81, 0x11, 0x82, 0x21, 0x0C, 0x42, 0x10, 0x86,
  0x22, 0x04, 0x44, 0x08, 0x88, 0x1B, 0x10, 0x14, 0x20, 0x28, 0x80, 0x71,
  0x00, 0x62, 0x00, 0x80, 0x01, 0x80, 0x19, 0xC0, 0x81, 0x84, 0x02, 0x20,
  0x05, 0x80, 0x14, 0x00, 0x50, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0,
  0x02, 0x80, 0x0A, 0x00, 0x28, 0x01, 0x20, 0x04, 0x80, 0x23, 0x01, 0x86,
  0x0C, 0x0F, 0xC0, 0x0F, 0xE0, 0x83, 0x10, 0x11, 0x01, 0x10, 0x11, 0x01,
  0x30, 0x12, 0x03, 0x20, 0x22, 0x0C, 0x3F, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x01, 0x80, 0x19, 0xC0,
  0x81, 0x84, 0x02, 0x20, 0x05, 0x80, 0x14, 0x00, 0x50, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x01, 0x20, 0x04,
  0x80, 0x21, 0x01, 0x86, 0x0C, 0x0F, 0xC0, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x0F, 0xE0, 0x83, 0x10, 0x11, 0x01, 0x10, 0x11,
  0x01, 0x30, 0x12, 0x02, 0x20, 0x62, 0x3C, 0x3E, 0x06, 0x10, 0x41, 0x04,
  0x10, 0x40, 0x84, 0x08, 0x80, 0x88, 0x0C, 0x80, 0x40, 0x00, 0x80, 0x77,
  0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C,
  0x81, 0x8F, 0xF0, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x00, 0x10, 0x04, 0x80, 0x12,
  0x00, 0x48, 0x03, 0x20, 0x08, 0x80, 0x24, 0x00, 0x90, 0x02, 0x40, 0x11,
  0x00, 0x4C, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x88, 0x02, 0x20, 0x18,
  0x80, 0x41, 0x02, 0x03, 0xF0, 0x00, 0x80, 0x38, 0x02, 0x80, 0x48, 0x04,
  0x80, 0x88, 0x08, 0x81, 0x08, 0x10, 0x82, 0x08, 0x20, 0x84, 0x08, 0x40,
  0x48, 0x04, 0x80, 0x50, 0x05, 0x00, 0x60, 0x06, 0x00, 0x40, 0x00, 0x80,
  0x40, 0x30, 0x18, 0x0A, 0x03, 0x01, 0x40, 0xA0, 0x68, 0x14, 0x09, 0x04,
  0x81, 0x20, 0x90, 0x44, 0x12, 0x08, 0x84, 0x42, 0x10, 0x88, 0x42, 0x21,
  0x10, 0x44, 0x22, 0x09, 0x04, 0x41, 0x20, 0x90, 0x2C, 0x0A, 0x05, 0x01,
  0x80, 0xA0, 0x30, 0x18, 0x04, 0x03, 0x00, 0x80, 0x00, 0x04, 0x03, 0x02,
  0x04, 0x02, 0x0C, 0x02, 0x08, 0x01, 0x10, 0x01, 0x30, 0x01, 0x20, 0x01,
  0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x40, 0x04, 0x40, 0x0C,
  0x40, 0x08, 0x20, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0xC0, 0x10, 0xC0,
  0x34, 0x06, 0x40, 0x44, 0x08, 0x20, 0x82, 0x10, 0x22, 0x02, 0x20, 0x24,
  0x01, 0xC0, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x00, 0x07, 0xFC, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x20, 0x0F, 0x80, 0x88, 0x88, 0x84, 0x44, 0x44,
  0x42, 0x22, 0x22, 0x21, 0x10, 0x07, 0xC0, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x0F, 0x80, 0x03, 0x00,
  0x30, 0x04, 0x80, 0xC8, 0x08, 0x81, 0x04, 0x10, 0x42, 0x04, 0x40, 0x24,
  0x02, 0x80, 0x30, 0xFF, 0x80, 0x99, 0x12, 0x02, 0x00, 0xD9, 0x10, 0x62,
  0x06, 0x60, 0x64, 0x06, 0x40, 0x4C, 0x04, 0x80, 0x48, 0x04, 0x80, 0xC8,
  0x08, 0x81, 0x84, 0x28, 0x7C, 0x80, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x41, 0x36, 0x28, 0x26, 0x04, 0x80, 0x90, 0x16, 0x02,
  0x80, 0x50, 0x0A, 0x01, 0x40, 0x58, 0x0B, 0x02, 0x50, 0xCB, 0xE0, 0x03,
  0x03, 0x31, 0x00, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x40, 0x10, 0x03, 0xF0, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x0C, 0x41, 0xB2, 0x10, 0x51, 0x01, 0x18, 0x08,
  0x80, 0x44, 0x02, 0x60, 0x22, 0x01, 0x10, 0x08, 0x80, 0xC4, 0x06, 0x20,
  0x60, 0x85, 0x07, 0xC8, 0x00, 0x02, 0x03, 0x21, 0x04, 0x81, 0x20, 0x50,
  0x24, 0x19, 0xF8, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x23, 0xF0,
  0x00, 0x38, 0x02, 0x40, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x81,
  0xF8, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x38, 0x00, 0x01, 0x80, 0x36, 0x42,
  0x0A, 0x20, 0x23, 0x01, 0x10, 0x08, 0x80, 0x4C, 0x04, 0x40, 0x22, 0x01,
  0x10, 0x18, 0x80, 0xC4, 0x0C, 0x10, 0xA0, 0xF9, 0x00, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x02, 0x0F, 0xE0, 0x00, 0x08, 0x01, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x41, 0x36, 0x28, 0x26, 0x04, 0x80, 0x90, 0x14,
  0x04, 0x80, 0x90, 0x12, 0x02, 0x40, 0x50, 0x12, 0x02, 0x40, 0x48, 0x08,
  0x18, 0x80, 0x00, 0x18, 0x84, 0x21, 0x10, 0x84, 0x21, 0x10, 0x84, 0x20,
  0x00, 0xC0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x60, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x08, 0x02, 0x00, 0x80, 0x60, 0xF0, 0x00, 0x08, 0x01, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x09, 0x02, 0x20, 0x84, 0x20, 0x88, 0x12,
  0x04, 0x80, 0xB0, 0x19, 0x02, 0x20, 0x46, 0x10, 0x42, 0x08, 0x40, 0x88,
  0x10, 0x08, 0x46, 0x21, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x08, 0x44,
  0x21, 0x08, 0x00, 0x01, 0x02, 0x09, 0xB3, 0x62, 0x85, 0x0C, 0xC1, 0x81,
  0x20, 0x60, 0x48, 0x10, 0x24, 0x04, 0x09, 0x01, 0x02, 0x40, 0x80, 0x90,
  0x20, 0x24, 0x08, 0x12, 0x02, 0x04, 0x80, 0x81, 0x20, 0x40, 0x48, 0x10,
  0x30, 0x01, 0x04, 0xD8, 0xA0, 0x98, 0x12, 0x02, 0x40, 0x58, 0x12, 0x02,
  0x40, 0x48, 0x09, 0x01, 0x40, 0x48, 0x09, 0x01, 0x20, 0x20, 0x02, 0x01,
  0x98, 0x41, 0x90, 0x16, 0x02, 0x80, 0x50, 0x0E, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0x40, 0x2C, 0x08, 0x82, 0x0F, 0x80, 0x00, 0x40, 0x4D, 0x82, 0x82,
  0x18, 0x10, 0x80, 0x84, 0x04, 0x60, 0x22, 0x01, 0x10, 0x08, 0x80, 0x44,
  0x04, 0x60, 0x23, 0x02, 0x14, 0x30, 0xBE, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0x00, 0x03, 0x00, 0xD9, 0x10, 0x52, 0x02,
  0x60, 0x24, 0x02, 0x40, 0x2C, 0x04, 0x80, 0x48, 0x04, 0x80, 0xC8, 0x0C,
  0x81, 0x84, 0x28, 0x7C, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x01, 0x13, 0x4A, 0x06, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x00, 0x06, 0x06, 0x72, 0x00, 0x80,
  0x20, 0x08, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x20,
  0xCF, 0xE0, 0x10, 0x20, 0x40, 0x87, 0xE4, 0x08, 0x10, 0x60, 0x81, 0x02,
  0x04, 0x10, 0x20, 0x40, 0x80, 0xE0, 0x20, 0x32, 0x02, 0x20, 0x22, 0x02,
  0x40, 0x44, 0x04, 0x40, 0x44, 0x04, 0x40, 0x48, 0x08, 0x80, 0x88, 0x18,
  0xC2, 0x87, 0xC8, 0x80, 0x50, 0x24, 0x09, 0x04, 0x41, 0x10, 0x84, 0x21,
  0x10, 0x44, 0x12, 0x04, 0x80, 0xC0, 0x30, 0x08, 0x00, 0x83, 0x03, 0x06,
  0x0A, 0x0C, 0x14, 0x28, 0x48, 0x50, 0x91, 0x23, 0x22, 0x44, 0x48, 0x88,
  0x91, 0x21, 0x42, 0x42, 0x85, 0x06, 0x0A, 0x0C, 0x08, 0x10, 0x10, 0x00,
  0x18, 0x10, 0x82, 0x08, 0x40, 0x48, 0x04, 0x80, 0x50, 0x02, 0x00, 0x60,
  0x09, 0x01, 0x90, 0x11, 0x02, 0x08, 0x40, 0x8C, 0x0C, 0x04, 0x06, 0x08,
  0x08, 0x10, 0x20, 0x20, 0x40, 0x41, 0x00, 0x86, 0x01, 0x08, 0x02, 0x30,
  0x02, 0x40, 0x05, 0x80, 0x0A, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x05, 0x80, 0x04, 0x00,
  0x00, 0x0F, 0xE0, 0x08, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x01, 0xFF, 0x00, 0x03, 0x82, 0x01,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x08, 0x18, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x30, 0x60, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02,
  0x02, 0x01, 0x01, 0x83, 0x80, 0x70, 0x31, 0xCE, 0x06, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 19, 6, 1, -19 },
  { 13, 6, 7, 8, 3, -19 },
  { 19, 14, 19, 14, 1, -19 },
  { 53, 12, 23, 13, 1, -21 },
  { 88, 15, 20, 19, 2, -20 },
  { 126, 13, 20, 15, 1, -20 },
  { 159, 2, 7, 5, 3, -19 },
  { 161, 8, 23, 7, 1, -19 },
  { 184, 8, 23, 7, -2, -19 },
  { 207, 10, 10, 12, 3, -20 },
  { 220, 11, 13, 14, 2, -16 },
  { 238, 4, 6, 5, -1, -3 },
  { 241, 6, 1, 8, 1, -8 },
  { 242, 1, 2, 5, 1, -2 },
  { 243, 12, 19, 8, -1, -19 },
  { 272, 12, 20, 13, 1, -20 },
  { 302, 6, 19, 13, 4, -19 },
  { 317, 12, 20, 13, 0, -20 },
  { 347, 13, 20, 13, 0, -20 },
  { 380, 12, 19, 13, 0, -19 },
  { 409, 13, 19, 13, 0, -19 },
  { 440, 12, 20, 13, 1, -20 },
  { 470, 11, 19, 13, 2, -19 },
  { 497, 12, 20, 13, 1, -20 },
  { 527, 11, 20, 13, 1, -20 },
  { 555, 4, 14, 5, 1, -14 },
  { 562, 6, 17, 5, -1, -14 },
  { 575, 11, 12, 14, 2, -16 },
  { 592, 11, 7, 14, 2, -13 },
  { 602, 11, 12, 14, 2, -16 },
  { 619, 8, 20, 9, 2, -20 },
  { 639, 18, 21, 20, 1, -19 },
  { 687, 13, 19, 13, -2, -19 },
  { 718, 13, 19, 14, 1, -19 },
  { 749, 13, 20, 14, 2, -20 },
  { 782, 14, 19, 16, 1, -19 },
  { 816, 12, 19, 12, 1, -19 },
  { 845, 12, 19, 11, 1, -19 },
  { 874, 14, 20, 16, 2, -20 },
  { 909, 15, 19, 16, 1, -19 },
  { 945, 9, 19, 7, -1, -19 },
  { 967, 10, 24, 6, -4, -19 },
  { 997, 14, 19, 13, 1, -19 },
  { 1031, 8, 19, 11, 1, -19 },
  { 1050, 19, 19, 20, 1, -19 },
  { 1096, 15, 19, 16, 1, -19 },
  { 1132, 14, 20, 17, 2, -20 },
  { 1167, 12, 19, 13, 1, -19 },
  { 1196, 14, 25, 17, 2, -20 },
  { 1240, 12, 19, 13, 1, -19 },
  { 1269, 12, 20, 12, 0, -20 },
  { 1299, 12, 19, 11, 2, -19 },
  { 1328, 14, 19, 16, 2, -19 },
  { 1362, 12, 19, 13, 3, -19 },
  { 1391, 19, 19, 20, 3, -19 },
  { 1437, 16, 19, 12, -2, -19 },
  { 1475, 12, 19, 11, 2, -19 },
  { 1504, 14, 19, 12, -1, -19 },
  { 1538, 10, 23, 8, 0, -19 },
  { 1567, 4, 19, 9, 3, -19 },
  { 1577, 10, 23, 8, -2, -19 },
  { 1606, 12, 11, 13, 1, -19 },
  { 1623, 9, 1, 9, -2, 3 },
  { 1625, 3, 5, 6, 4, -21 },
  { 1627, 12, 15, 13, 1, -15 },
  { 1650, 11, 21, 14, 1, -21 },
  { 1679, 10, 15, 11, 1, -15 },
  { 1698, 13, 21, 14, 1, -21 },
  { 1733, 10, 15, 12, 1, -15 },
  { 1752, 13, 27, 7, -3, -21 },
  { 1796, 13, 21, 14, 0, -15 },
  { 1831, 11, 21, 13, 1, -21 },
  { 1860, 5, 19, 5, 1, -19 },
  { 1872, 10, 25, 5, -4, -19 },
  { 1904, 11, 21, 11, 1, -21 },
  { 1933, 5, 21, 5, 1, -21 },
  { 1947, 18, 15, 20, 1, -15 },
  { 1981, 11, 15, 13, 1, -15 },
  { 2002, 11, 15, 13, 1, -15 },
  { 2023, 13, 21, 14, -1, -15 },
  { 2058, 12, 21, 14, 1, -15 },
  { 2090, 9, 15, 9, 1, -15 },
  { 2107, 10, 15, 10, 0, -15 },
  { 2126, 7, 18, 7, 1, -18 },
  { 2142, 12, 14, 13, 1, -14 },
  { 2163, 10, 14, 10, 1, -14 },
  { 2181, 15, 14, 16, 2, -14 },
  { 2208, 12, 14, 11, -1, -14 },
  { 2229, 15, 21, 10, -3, -14 },
  { 2269, 11, 14, 10, -1, -14 },
  { 2289, 9, 23, 9, 1, -19 },
  { 2315, 1, 28, 13, 6, -21 },
  { 2319, 9, 23, 9, -1, -19 },
  { 2345, 11, 3, 14, 2, -11 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic27pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC27PT7B_H_
