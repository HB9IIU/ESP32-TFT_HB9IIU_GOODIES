#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC8PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0xA0, 0xE0, 0x35, 0x76, 0xFA, 0x34, 0x42, 0x6C, 0xDE, 0xAF,
  0xBB, 0x25, 0x27, 0x9F, 0xC0, 0x2A, 0x49, 0x20, 0x24, 0x92, 0xB0, 0x5F,
  0x00, 0x22, 0xF2, 0xC0, 0xC0, 0x80, 0x25, 0x29, 0x00, 0x25, 0x99, 0x9E,
  0x75, 0xA0, 0x61, 0x12, 0x4E, 0x61, 0x16, 0x1E, 0x12, 0x5A, 0xF2, 0x74,
  0x61, 0x1E, 0x34, 0xE9, 0x9E, 0xE5, 0x29, 0x00, 0x75, 0x66, 0x9E, 0x69,
  0x96, 0x2E, 0x10, 0x18, 0x16, 0xC3, 0xFF, 0x86, 0x3C, 0x64, 0xA9, 0x00,
  0x39, 0x1B, 0xF5, 0xDA, 0x87, 0x00, 0x25, 0xFB, 0x40, 0x75, 0x5B, 0x9E,
  0x72, 0x49, 0x80, 0x75, 0x59, 0x9E, 0x74, 0x4A, 0x8E, 0x74, 0x4A, 0x88,
  0x78, 0x8B, 0xAE, 0x4A, 0x53, 0x69, 0x48, 0x55, 0xA0, 0x24, 0xA4, 0xB0,
  0x55, 0x64, 0xAA, 0x49, 0x49, 0xC0, 0x45, 0x14, 0xAD, 0xAA, 0xA0, 0x4A,
  0x53, 0x5B, 0x48, 0x69, 0x99, 0x9E, 0x65, 0x56, 0x88, 0x69, 0x99, 0x9A,
  0x40, 0x65, 0x5A, 0xAA, 0x78, 0x42, 0x2E, 0xEA, 0x49, 0x00, 0x99, 0x9A,
  0xAE, 0xB6, 0xE9, 0x00, 0xA6, 0xAE, 0xAA, 0x92, 0x80, 0x55, 0x64, 0xAA,
  0xB7, 0x49, 0x00, 0x71, 0x24, 0x8E, 0x69, 0x49, 0x20, 0xFC, 0x24, 0x92,
  0x70, 0x26, 0x59, 0xE0, 0x80, 0x79, 0xAE, 0x46, 0x59, 0x9E, 0x72, 0x70,
  0x13, 0x59, 0x9E, 0x7E, 0x70, 0x36, 0x24, 0x44, 0x48, 0x79, 0x9E, 0x2E,
  0x46, 0x59, 0x9A, 0x46, 0xA0, 0x20, 0xA4, 0x94, 0x49, 0xAD, 0x40, 0x56,
  0xA0, 0x7E, 0x5A, 0x6A, 0x79, 0x9A, 0x79, 0x9E, 0x79, 0x9E, 0x88, 0x79,
  0x9E, 0x22, 0x72, 0x40, 0xE8, 0xF0, 0xDA, 0xC0, 0x59, 0xAE, 0xB7, 0x40,
  0xAF, 0x5D, 0x40, 0x69, 0x50, 0x55, 0x62, 0x4C, 0x6A, 0x60, 0x29, 0x65,
  0x30, 0xFF, 0x55, 0x58, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 2, 1, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 4, 6, 4, 0, -6 },
  { 10, 4, 6, 5, 1, -6 },
  { 13, 4, 6, 4, 0, -6 },
  { 16, 1, 2, 1, 1, -6 },
  { 17, 3, 7, 2, 0, -6 },
  { 20, 3, 7, 2, -1, -6 },
  { 23, 3, 3, 4, 1, -6 },
  { 25, 4, 4, 4, 0, -5 },
  { 27, 1, 2, 1, 0, -1 },
  { 28, 2, 1, 2, 0, -3 },
  { 29, 1, 1, 2, 0, -1 },
  { 30, 3, 6, 2, 0, -6 },
  { 33, 4, 6, 4, 0, -6 },
  { 36, 2, 6, 4, 1, -6 },
  { 38, 4, 6, 4, 0, -6 },
  { 41, 4, 6, 4, 0, -6 },
  { 44, 4, 6, 4, 0, -6 },
  { 47, 4, 6, 4, 0, -6 },
  { 50, 4, 6, 4, 0, -6 },
  { 53, 3, 6, 4, 1, -6 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 4, 6, 4, 0, -6 },
  { 62, 1, 4, 2, 0, -4 },
  { 63, 1, 5, 2, 0, -4 },
  { 64, 4, 4, 4, 0, -5 },
  { 66, 4, 2, 4, 0, -4 },
  { 67, 4, 4, 4, 0, -5 },
  { 69, 3, 6, 3, 0, -6 },
  { 72, 6, 7, 6, 0, -6 },
  { 78, 3, 6, 4, 0, -6 },
  { 81, 4, 6, 4, 0, -6 },
  { 84, 3, 6, 4, 1, -6 },
  { 87, 4, 6, 5, 0, -6 },
  { 90, 4, 6, 4, 0, -6 },
  { 93, 4, 6, 3, 0, -6 },
  { 96, 4, 6, 5, 1, -6 },
  { 99, 5, 6, 5, 0, -6 },
  { 103, 2, 6, 2, 0, -6 },
  { 105, 3, 7, 2, -1, -6 },
  { 108, 4, 6, 4, 0, -6 },
  { 111, 3, 6, 3, 0, -6 },
  { 114, 6, 6, 6, 0, -6 },
  { 119, 5, 6, 5, 0, -6 },
  { 123, 4, 6, 5, 1, -6 },
  { 126, 4, 6, 4, 0, -6 },
  { 129, 4, 7, 5, 1, -6 },
  { 133, 4, 6, 4, 0, -6 },
  { 136, 4, 6, 4, 0, -6 },
  { 139, 3, 6, 3, 1, -6 },
  { 142, 4, 6, 5, 1, -6 },
  { 145, 3, 6, 4, 1, -6 },
  { 148, 6, 6, 6, 1, -6 },
  { 153, 4, 6, 3, 0, -6 },
  { 156, 3, 6, 3, 1, -6 },
  { 159, 4, 6, 4, 0, -6 },
  { 162, 3, 7, 2, 0, -6 },
  { 165, 1, 6, 3, 1, -6 },
  { 166, 3, 7, 2, -1, -6 },
  { 169, 4, 4, 4, 0, -6 },
  { 171, 3, 1, 3, -1, 0 },
  { 172, 1, 1, 2, 1, -6 },
  { 173, 4, 4, 4, 0, -4 },
  { 175, 4, 6, 4, 0, -6 },
  { 178, 3, 4, 3, 0, -4 },
  { 180, 4, 6, 4, 0, -6 },
  { 183, 3, 4, 3, 0, -4 },
  { 185, 4, 8, 2, -1, -6 },
  { 189, 4, 6, 4, 0, -4 },
  { 192, 4, 6, 4, 0, -6 },
  { 195, 2, 6, 2, 0, -6 },
  { 197, 3, 8, 2, -1, -6 },
  { 200, 3, 6, 3, 0, -6 },
  { 203, 2, 6, 2, 0, -6 },
  { 205, 6, 4, 6, 0, -4 },
  { 208, 4, 4, 4, 0, -4 },
  { 210, 4, 4, 4, 0, -4 },
  { 212, 4, 6, 4, 0, -4 },
  { 215, 4, 6, 4, 0, -4 },
  { 218, 3, 4, 3, 0, -4 },
  { 220, 3, 4, 3, 0, -4 },
  { 222, 2, 5, 2, 0, -5 },
  { 224, 4, 4, 4, 0, -4 },
  { 226, 3, 4, 3, 0, -4 },
  { 228, 5, 4, 5, 0, -4 },
  { 231, 3, 4, 3, 0, -4 },
  { 233, 4, 6, 3, -1, -4 },
  { 236, 3, 4, 3, 0, -4 },
  { 238, 3, 7, 3, 0, -6 },
  { 241, 1, 8, 4, 2, -6 },
  { 242, 2, 7, 3, 0, -6 },
  { 244, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic8pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC8PT7B_H_
