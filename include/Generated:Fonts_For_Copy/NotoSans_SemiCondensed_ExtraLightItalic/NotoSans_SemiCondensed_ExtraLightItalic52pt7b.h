#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC52PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x60, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x01,
  0xC0, 0x70, 0x0E, 0x00, 0x18, 0x31, 0x83, 0x30, 0x33, 0x06, 0x30, 0x63,
  0x06, 0x30, 0x62, 0x04, 0x60, 0xC6, 0x0C, 0x60, 0xC4, 0x08, 0xC0, 0x80,
  0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x20, 0x00, 0x10, 0x0C, 0x00, 0x06,
  0x01, 0x80, 0x00, 0xC0, 0x20, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x01, 0x80,
  0x00, 0xC0, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x02, 0x01, 0x80, 0x00, 0xC0,
  0x30, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x00, 0xC0, 0x30, 0x00,
  0x18, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x40, 0x30, 0x00, 0x18, 0x06,
  0x00, 0x03, 0x00, 0x80, 0x00, 0x40, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x60, 0x30, 0x00, 0x18, 0x06, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x60, 0x10, 0x00, 0x08, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60,
  0x10, 0x00, 0x08, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00,
  0x0C, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x06,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x38,
  0xC3, 0x80, 0xC1, 0x80, 0x03, 0x02, 0x00, 0x0E, 0x04, 0x00, 0x18, 0x18,
  0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x80, 0x01, 0x81, 0x00,
  0x03, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x98, 0x00, 0x03, 0xA0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x04, 0xE0, 0x00,
  0x08, 0xE0, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0x80, 0x01,
  0x01, 0x80, 0x02, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x70, 0x00, 0x40, 0xC1, 0x00, 0x87, 0x03, 0xE3, 0x3C, 0x03, 0xFF, 0xE0,
  0x00, 0x3C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x10, 0x3F, 0x80,
  0x03, 0x03, 0x8E, 0x00, 0x10, 0x38, 0x30, 0x01, 0x81, 0x81, 0x80, 0x18,
  0x18, 0x0C, 0x00, 0xC0, 0xC0, 0x20, 0x0C, 0x0C, 0x03, 0x00, 0xC0, 0x60,
  0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x06, 0x06, 0x01, 0x80, 0x30,
  0x30, 0x0C, 0x01, 0x83, 0x00, 0x60, 0x08, 0x30, 0x03, 0x00, 0xC1, 0x80,
  0x18, 0x06, 0x18, 0x30, 0xC0, 0x31, 0x87, 0xF6, 0x03, 0x0C, 0x61, 0xB0,
  0x18, 0xC6, 0x07, 0x81, 0x8C, 0x30, 0x3C, 0x1C, 0x63, 0x01, 0xB1, 0xC6,
  0x10, 0x0D, 0xFC, 0x61, 0x80, 0x61, 0x03, 0x0C, 0x03, 0x00, 0x30, 0x40,
  0x18, 0x01, 0x86, 0x00, 0xC0, 0x18, 0x30, 0x06, 0x01, 0x81, 0x80, 0x20,
  0x0C, 0x0C, 0x03, 0x00, 0xC0, 0x40, 0x18, 0x0C, 0x06, 0x00, 0xC0, 0x60,
  0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x60, 0x0C, 0x03, 0x03, 0x00, 0x30,
  0x30, 0x30, 0x01, 0x83, 0x03, 0x00, 0x0E, 0x30, 0x38, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x38, 0x03, 0x00,
  0x0C, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x06,
  0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0xE0, 0x00, 0xC0, 0x70, 0x00, 0x30,
  0x38, 0x00, 0x06, 0x1C, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x70, 0x00, 0x03, 0x8C, 0x00,
  0x01, 0x83, 0x80, 0x30, 0xC0, 0x60, 0x0C, 0x60, 0x0C, 0x06, 0x30, 0x03,
  0x01, 0x9C, 0x00, 0x60, 0xC6, 0x00, 0x18, 0x31, 0x80, 0x03, 0x18, 0xC0,
  0x00, 0xC6, 0x30, 0x00, 0x1B, 0x0C, 0x00, 0x07, 0x83, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x78, 0x18, 0x00, 0x3E, 0x06, 0x00, 0x18, 0xC0, 0xC0, 0x1C,
  0x30, 0x3E, 0x1E, 0x06, 0x03, 0xFE, 0x01, 0xC0, 0x08, 0x00, 0x00, 0x18,
  0xCC, 0x63, 0x18, 0xC4, 0x63, 0x18, 0x8C, 0x00, 0x00, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x04, 0x06, 0x01, 0xE0, 0xC0,
  0x0E, 0x18, 0x00, 0x72, 0x00, 0x03, 0xCF, 0xE0, 0x1F, 0xF8, 0x07, 0x00,
  0x01, 0xB0, 0x00, 0x62, 0x00, 0x18, 0x60, 0x06, 0x04, 0x03, 0x80, 0xC0,
  0x20, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x06, 0x0C, 0x38, 0x61, 0xC3, 0x06, 0x18, 0x30, 0xC1, 0x86,
  0x08, 0x00, 0xFF, 0xFF, 0xFE, 0x67, 0xEE, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x80, 0x07, 0x87, 0x00, 0x38, 0x0E,
  0x01, 0xC0, 0x18, 0x0E, 0x00, 0x70, 0x30, 0x00, 0xC1, 0x80, 0x03, 0x06,
  0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC7, 0x00, 0x03, 0x18, 0x00,
  0x0C, 0x60, 0x00, 0x33, 0x80, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C,
  0xC0, 0x00, 0x77, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80,
  0x00, 0x66, 0x00, 0x03, 0x98, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00,
  0xC6, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xE1, 0x80, 0x03, 0x06,
  0x00, 0x0C, 0x18, 0x00, 0x60, 0x60, 0x03, 0x81, 0x80, 0x0C, 0x03, 0x00,
  0x60, 0x0E, 0x03, 0x00, 0x1E, 0x78, 0x00, 0x3F, 0xC0, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x0F, 0x01, 0xF0, 0x73, 0x0E, 0x63, 0xC6, 0xF0, 0x66,
  0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x0C, 0x00, 0x80, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0xF8, 0x3C,
  0x01, 0xE0, 0x0E, 0x01, 0x80, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0xC0, 0x03, 0x80, 0xFC, 0x1F, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x64, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x8C,
  0x00, 0x03, 0x0C, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x30, 0x18, 0x00, 0x70, 0x18, 0x00, 0x60, 0x30,
  0x00, 0xC0, 0x30, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x60, 0x38, 0x00, 0x60,
  0x30, 0x00, 0xC0, 0x60, 0x00, 0xC1, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x04, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xC0, 0x07, 0x00,
  0xF8, 0x3E, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0xF0, 0x01, 0xE0, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x1F, 0x00, 0x61, 0xFF, 0x01, 0x9C, 0x0E, 0x06, 0xC0,
  0x0C, 0x1E, 0x00, 0x38, 0xF0, 0x00, 0x63, 0x80, 0x01, 0x8E, 0x00, 0x06,
  0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30,
  0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00,
  0x70, 0xC0, 0x01, 0x81, 0x80, 0x0C, 0x06, 0x00, 0x70, 0x0C, 0x03, 0x80,
  0x3C, 0x7C, 0x00, 0x3F, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xE0, 0x01, 0xE0, 0xE0,
  0x07, 0x00, 0x60, 0x1C, 0x00, 0x60, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x81,
  0x80, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18,
  0x00, 0x30, 0x30, 0x00, 0xC0, 0x30, 0x03, 0x80, 0x60, 0x0E, 0x00, 0x60,
  0x38, 0x00, 0x61, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x3C, 0x38, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x30, 0x0C, 0x00, 0x30,
  0x30, 0x00, 0x70, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x8C,
  0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x60, 0xC0, 0x00, 0xC1, 0xC0, 0x03, 0x01, 0xC0, 0x1C, 0x01, 0xF0,
  0xF0, 0x00, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x7F, 0xC0, 0x01, 0xC1, 0xC0, 0x06, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x60,
  0x01, 0x81, 0xC0, 0x03, 0x03, 0x00, 0x03, 0x0E, 0x00, 0x06, 0x18, 0x00,
  0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00,
  0xC6, 0x00, 0x03, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x38,
  0x30, 0x00, 0xF0, 0x60, 0x03, 0x60, 0x60, 0x0C, 0x80, 0xF0, 0x73, 0x00,
  0xFF, 0xC6, 0x00, 0x3C, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x0F, 0x1F, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x07, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0xE0, 0xE0, 0xE0, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x70, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x03,
  0x00, 0x40, 0x18, 0x02, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x07, 0xFE, 0x0F, 0x87, 0x82, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x1C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x80, 0x0C, 0x30, 0x03,
  0xFF, 0x03, 0x18, 0x01, 0xC1, 0x80, 0xC6, 0x00, 0xC0, 0x60, 0x11, 0x00,
  0x60, 0x18, 0x0C, 0xC0, 0x30, 0x06, 0x03, 0x30, 0x18, 0x01, 0x00, 0xD8,
  0x06, 0x00, 0xC0, 0x36, 0x03, 0x00, 0x30, 0x0D, 0x80, 0xC0, 0x0C, 0x03,
  0x60, 0x30, 0x02, 0x00, 0xD8, 0x18, 0x01, 0x80, 0x64, 0x06, 0x00, 0x60,
  0x1B, 0x01, 0x80, 0x18, 0x06, 0xC0, 0x60, 0x0C, 0x03, 0x30, 0x18, 0x03,
  0x00, 0xCC, 0x06, 0x01, 0xC0, 0x63, 0x01, 0x80, 0xD0, 0x38, 0xC0, 0x70,
  0x66, 0x1C, 0x30, 0x0E, 0x71, 0xDE, 0x06, 0x01, 0xF8, 0x3E, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x20, 0x00, 0x0F, 0x00, 0x70,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x03, 0x18, 0x00,
  0x01, 0x8C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC0, 0x80,
  0x00, 0x60, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x30, 0x0C,
  0x00, 0x18, 0x06, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0x00,
  0x06, 0x03, 0x80, 0x03, 0x01, 0x80, 0x01, 0x81, 0xC0, 0x00, 0xC0, 0xC0,
  0x00, 0x60, 0xE0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x70, 0x00, 0x0C, 0x30,
  0x00, 0x06, 0x38, 0x00, 0x03, 0x18, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x60, 0x03, 0x80, 0x30, 0x00, 0xE0, 0x38, 0x00, 0x30, 0x18, 0x00,
  0x18, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x03, 0x00, 0x03, 0x83, 0x00,
  0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x60, 0x30,
  0x00, 0x70, 0x30, 0x00, 0x70, 0x18, 0x00, 0x70, 0x0C, 0x07, 0xE0, 0x07,
  0xFF, 0x80, 0x03, 0x01, 0xF8, 0x03, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x80,
  0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x70, 0x00, 0x18, 0x30, 0x00, 0x0C,
  0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x86, 0x00, 0x01,
  0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x60, 0x60, 0x00,
  0x60, 0x60, 0x00, 0xF0, 0x30, 0x01, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xF0, 0x3C,
  0x00, 0xE0, 0x02, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x80, 0x07,
  0x83, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x06, 0x00, 0x78, 0x00, 0xC0, 0x03, 0x80, 0x38,
  0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x06,
  0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x86,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x38, 0x18, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x80, 0x60, 0x00, 0xE0,
  0x18, 0x00, 0x78, 0x03, 0x00, 0x7C, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0x03, 0xF0, 0x03, 0x80, 0x07, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x1F, 0xF8, 0x60, 0x01, 0xFF, 0x86, 0x00, 0x00,
  0x18, 0xE0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x07, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x06, 0x03, 0x80, 0x00, 0xC0, 0x1C, 0x00, 0x0C, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0xE3, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C,
  0x07, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x30, 0x00,
  0x38, 0x06, 0x00, 0x0E, 0x00, 0xC0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x06,
  0x00, 0x38, 0x00, 0xC0, 0x0E, 0x00, 0x18, 0x03, 0x80, 0x03, 0x00, 0xE0,
  0x00, 0xC0, 0x38, 0x00, 0x18, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x00, 0x60,
  0xE0, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x0C, 0xF0, 0x00, 0x01, 0xBE, 0x00, 0x00, 0x3E, 0xE0, 0x00, 0x0D, 0x8C,
  0x00, 0x01, 0xE1, 0x80, 0x00, 0x30, 0x18, 0x00, 0x06, 0x03, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x1C,
  0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x0E, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x18,
  0x03, 0x00, 0x03, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1B, 0x03, 0x60, 0x00, 0x01, 0xE0,
  0x36, 0x00, 0x00, 0x36, 0x03, 0x60, 0x00, 0x03, 0x60, 0x36, 0x00, 0x00,
  0x66, 0x03, 0x20, 0x00, 0x06, 0x60, 0x63, 0x00, 0x00, 0xCC, 0x06, 0x30,
  0x00, 0x1C, 0xC0, 0x63, 0x00, 0x01, 0x8C, 0x06, 0x30, 0x00, 0x30, 0xC0,
  0x63, 0x00, 0x03, 0x0C, 0x0C, 0x30, 0x00, 0x61, 0x80, 0xC3, 0x00, 0x06,
  0x18, 0x0C, 0x10, 0x00, 0xC1, 0x80, 0xC1, 0x80, 0x0C, 0x18, 0x0C, 0x18,
  0x01, 0x83, 0x01, 0x81, 0x80, 0x18, 0x30, 0x18, 0x18, 0x03, 0x03, 0x01,
  0x81, 0x80, 0x70, 0x30, 0x18, 0x18, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x08, 0x0C, 0x06, 0x03, 0x00, 0x81, 0x80, 0x60, 0x30, 0x0C,
  0x18, 0x06, 0x03, 0x00, 0xC3, 0x00, 0x60, 0x60, 0x0C, 0x30, 0x0C, 0x06,
  0x00, 0xC6, 0x00, 0xC0, 0x60, 0x0C, 0x60, 0x0C, 0x06, 0x00, 0xCC, 0x00,
  0xC0, 0x60, 0x05, 0x80, 0x1C, 0x0C, 0x00, 0x58, 0x01, 0x80, 0xC0, 0x07,
  0x00, 0x18, 0x0C, 0x00, 0x70, 0x01, 0x80, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x01, 0x80,
  0x78, 0x00, 0x06, 0x03, 0x60, 0x00, 0x18, 0x0D, 0x80, 0x00, 0xC0, 0x33,
  0x00, 0x03, 0x00, 0xCC, 0x00, 0x0C, 0x03, 0x30, 0x00, 0x30, 0x18, 0x60,
  0x00, 0xC0, 0x61, 0x80, 0x06, 0x01, 0x86, 0x00, 0x18, 0x06, 0x0C, 0x00,
  0x60, 0x18, 0x30, 0x01, 0x80, 0xC0, 0xC0, 0x06, 0x03, 0x01, 0x80, 0x30,
  0x0C, 0x06, 0x00, 0xC0, 0x30, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06,
  0x00, 0xC0, 0x60, 0x18, 0x03, 0x01, 0x80, 0x60, 0x06, 0x06, 0x01, 0x80,
  0x18, 0x18, 0x0C, 0x00, 0x60, 0x60, 0x30, 0x00, 0xC3, 0x00, 0xC0, 0x03,
  0x0C, 0x03, 0x00, 0x0C, 0x30, 0x0C, 0x00, 0x18, 0xC0, 0x60, 0x00, 0x63,
  0x01, 0x80, 0x01, 0x98, 0x06, 0x00, 0x03, 0x60, 0x18, 0x00, 0x0D, 0x80,
  0x60, 0x00, 0x36, 0x03, 0x00, 0x00, 0x78, 0x0C, 0x00, 0x01, 0xC0, 0x30,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x01,
  0xC0, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x71, 0x80, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x76, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x30, 0x01, 0xE0, 0x0E,
  0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0x80, 0x3C, 0x01, 0x80, 0x0C,
  0x03, 0x80, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x07,
  0x03, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x07, 0x06, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C,
  0x0C, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0xE0, 0x18, 0x1F, 0xC0,
  0x1F, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3C,
  0x1F, 0x00, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x01, 0xC0, 0x18, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x0C, 0x03, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x30, 0x01, 0xE0, 0x0E, 0x00, 0x0F, 0xC7, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0x80, 0x3C, 0x01, 0x80, 0x0C,
  0x03, 0x80, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x07, 0x03, 0x00, 0x03,
  0x03, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x1C,
  0x0C, 0x00, 0x38, 0x0C, 0x00, 0x70, 0x0C, 0x03, 0xE0, 0x1F, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x18, 0x06, 0x00, 0x18, 0x06, 0x00, 0x38, 0x06, 0x00,
  0x30, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x60, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x01, 0xC0,
  0x60, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x7C, 0x3F,
  0x00, 0xE0, 0x02, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0xC0, 0x07, 0x80, 0xFC, 0x7F, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x1C, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x18, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x18, 0x06, 0x00, 0x03, 0x80, 0x60, 0x00, 0x70, 0x03, 0x00, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30,
  0x60, 0x00, 0x30, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0xC0,
  0x60, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x03, 0x00,
  0x60, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0x20, 0x0C, 0x00, 0x20, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x30, 0x00,
  0x30, 0x30, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x31, 0x80, 0x00, 0x33, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x16, 0x00, 0x00, 0x16, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3E, 0x00,
  0x03, 0x00, 0x01, 0xB0, 0x00, 0x38, 0x00, 0x1D, 0x80, 0x01, 0x40, 0x00,
  0xCC, 0x00, 0x1A, 0x00, 0x06, 0x60, 0x00, 0xD0, 0x00, 0x63, 0x00, 0x0C,
  0x80, 0x03, 0x18, 0x00, 0x64, 0x00, 0x30, 0xC0, 0x06, 0x20, 0x01, 0x86,
  0x00, 0x31, 0x00, 0x1C, 0x30, 0x03, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x60,
  0x06, 0x0C, 0x00, 0xC3, 0x00, 0x60, 0x60, 0x0C, 0x18, 0x03, 0x03, 0x00,
  0x60, 0xC0, 0x30, 0x18, 0x06, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x30, 0x18,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x81, 0x80,
  0x60, 0x60, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0x60, 0x60, 0x18, 0x30, 0x03,
  0x06, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x30,
  0xC0, 0x06, 0x18, 0x01, 0x86, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x01, 0x8C,
  0x00, 0x63, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0x66, 0x00, 0x19, 0x80,
  0x03, 0x30, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00,
  0x34, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x0E, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x08, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x38,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x58, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x03, 0x80, 0x18, 0x00, 0x18,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0xC0, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xEC, 0x00, 0x03, 0x18, 0x00, 0x18,
  0x60, 0x00, 0xE1, 0x80, 0x03, 0x06, 0x00, 0x18, 0x18, 0x00, 0xE0, 0x30,
  0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x10, 0x18,
  0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x06, 0x1C, 0x00, 0x18, 0x60, 0x00,
  0x33, 0x00, 0x00, 0xDC, 0x00, 0x03, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xC0, 0x40, 0x40, 0x60, 0x60, 0x60, 0x60,
  0x60, 0x20, 0x30, 0x30, 0x30, 0x30, 0x30, 0x10, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x08, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x04, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x02, 0x03, 0x03, 0x03, 0x03, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x31,
  0x00, 0x00, 0xC6, 0x00, 0x06, 0x18, 0x00, 0x30, 0x20, 0x00, 0xC0, 0xC0,
  0x06, 0x03, 0x00, 0x38, 0x04, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x60, 0x18,
  0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x18, 0xC0, 0x00,
  0x67, 0x00, 0x01, 0x98, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC3, 0x06, 0x18, 0x30, 0xC1, 0x83, 0x00, 0x3F, 0x04, 0x03,
  0xFE, 0x30, 0x1C, 0x0C, 0xC0, 0xC0, 0x1B, 0x06, 0x00, 0x6C, 0x30, 0x00,
  0xE1, 0xC0, 0x03, 0x86, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xC0, 0x00, 0xC3,
  0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00,
  0x06, 0x38, 0x00, 0x18, 0xE0, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x0E,
  0x30, 0x00, 0x30, 0xC0, 0x01, 0xC3, 0x00, 0x07, 0x0E, 0x00, 0x3C, 0x18,
  0x01, 0xA0, 0x60, 0x0C, 0x80, 0xC0, 0x66, 0x03, 0xC7, 0x18, 0x07, 0xF8,
  0x60, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x7E, 0x00, 0x63, 0xFE, 0x01, 0x8C, 0x0E, 0x03,
  0x30, 0x0E, 0x06, 0xC0, 0x0C, 0x0F, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x78,
  0x00, 0x30, 0xE0, 0x00, 0x61, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00,
  0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00,
  0x61, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x30, 0xE0, 0x00, 0x61, 0xC0, 0x01, 0x83, 0xC0, 0x07, 0x06,
  0x80, 0x1C, 0x09, 0x80, 0x70, 0x31, 0xE3, 0xC0, 0x61, 0xFE, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xFC, 0x07, 0x00, 0x81, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x40, 0x78, 0x70, 0x07, 0xFE, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x03, 0xF0, 0x60, 0x07, 0xFE, 0x30, 0x07, 0x03, 0x30, 0x06, 0x00,
  0xD8, 0x06, 0x00, 0x2C, 0x06, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x03, 0x00,
  0x03, 0x03, 0x80, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0x70, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x1C,
  0x00, 0x0E, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x03, 0x81,
  0x80, 0x01, 0xC0, 0xC0, 0x01, 0xE0, 0x60, 0x00, 0xE0, 0x38, 0x00, 0xF0,
  0x0C, 0x00, 0xD8, 0x06, 0x00, 0xEC, 0x01, 0x80, 0xE6, 0x00, 0xF1, 0xC2,
  0x00, 0x3F, 0xC3, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F,
  0xF8, 0x07, 0x03, 0x01, 0xC0, 0x30, 0x60, 0x06, 0x1C, 0x00, 0xC3, 0x00,
  0x18, 0xC0, 0x03, 0x18, 0x00, 0x66, 0x00, 0x18, 0xC0, 0x07, 0x30, 0x03,
  0xC6, 0x01, 0xE0, 0xFF, 0xF0, 0x1F, 0xE0, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x40, 0x78, 0x78,
  0x03, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xE1, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x02, 0x38, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC1, 0x80, 0x1F, 0xF8, 0xC0, 0x1C, 0x0C, 0x40, 0x18,
  0x03, 0x60, 0x18, 0x00, 0xB0, 0x18, 0x00, 0x78, 0x1C, 0x00, 0x1C, 0x0C,
  0x00, 0x0C, 0x0E, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x83,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30,
  0x70, 0x00, 0x38, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0E,
  0x06, 0x00, 0x07, 0x03, 0x00, 0x07, 0x81, 0x80, 0x03, 0x80, 0xE0, 0x03,
  0xC0, 0x30, 0x03, 0x60, 0x18, 0x03, 0xB0, 0x0E, 0x03, 0x98, 0x03, 0xC7,
  0x18, 0x00, 0xFF, 0x0C, 0x00, 0x04, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x06, 0x00, 0x70, 0x03,
  0xE0, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x07, 0xE0, 0x0C, 0x7F, 0xC0, 0x23, 0x03, 0x81,
  0x98, 0x07, 0x06, 0xC0, 0x0C, 0x1E, 0x00, 0x30, 0x70, 0x00, 0xC3, 0x80,
  0x03, 0x0E, 0x00, 0x0C, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x06,
  0x18, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18,
  0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x18, 0x30, 0x00,
  0x60, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0xC1,
  0x80, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x01, 0xC0, 0x70, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x70, 0x02, 0x38, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x1C, 0x0C, 0x00,
  0xE0, 0x60, 0x07, 0x01, 0x80, 0x38, 0x06, 0x01, 0xC0, 0x18, 0x06, 0x00,
  0x60, 0x30, 0x03, 0x01, 0x80, 0x0C, 0x0C, 0x00, 0x30, 0x60, 0x00, 0xC3,
  0x00, 0x03, 0x18, 0x00, 0x18, 0xE0, 0x00, 0x67, 0x80, 0x01, 0xB3, 0x00,
  0x07, 0x8C, 0x00, 0x1C, 0x30, 0x00, 0xE0, 0x60, 0x03, 0x01, 0x80, 0x0C,
  0x07, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x18, 0x01,
  0x80, 0x60, 0x06, 0x01, 0x80, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C,
  0x03, 0x00, 0x03, 0x0F, 0xC0, 0x3F, 0x00, 0x47, 0xFC, 0x0F, 0xF8, 0x09,
  0xC1, 0xC7, 0x07, 0x03, 0x60, 0x19, 0x80, 0x70, 0x68, 0x01, 0x20, 0x06,
  0x0E, 0x00, 0x3C, 0x00, 0xC1, 0xC0, 0x07, 0x00, 0x18, 0x70, 0x00, 0xC0,
  0x03, 0x0E, 0x00, 0x18, 0x00, 0x61, 0x80, 0x07, 0x00, 0x0C, 0x30, 0x00,
  0xC0, 0x03, 0x06, 0x00, 0x18, 0x00, 0x61, 0x80, 0x03, 0x00, 0x0C, 0x30,
  0x00, 0x60, 0x01, 0x86, 0x00, 0x18, 0x00, 0x30, 0xC0, 0x03, 0x00, 0x0C,
  0x18, 0x00, 0x60, 0x01, 0x86, 0x00, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x00,
  0x06, 0x18, 0x00, 0x60, 0x00, 0xC3, 0x00, 0x0C, 0x00, 0x30, 0xC0, 0x01,
  0x80, 0x06, 0x18, 0x00, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x00, 0x18, 0x60,
  0x01, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x00, 0xC3, 0x00, 0x06, 0x00, 0x18,
  0x60, 0x01, 0xC0, 0x03, 0x00, 0x03, 0x07, 0xE0, 0x08, 0x7F, 0xC0, 0x63,
  0x03, 0x81, 0x98, 0x07, 0x06, 0xC0, 0x0C, 0x1E, 0x00, 0x30, 0x70, 0x00,
  0xC3, 0x80, 0x03, 0x0E, 0x00, 0x0C, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83,
  0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x03, 0x06, 0x00,
  0x0C, 0x18, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x18,
  0x30, 0x00, 0x61, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x38, 0x60,
  0x00, 0xC1, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x00, 0x3F,
  0x00, 0x07, 0xFE, 0x00, 0x70, 0x38, 0x06, 0x00, 0xE0, 0x60, 0x03, 0x06,
  0x00, 0x0C, 0x70, 0x00, 0x63, 0x00, 0x03, 0x38, 0x00, 0x19, 0x80, 0x00,
  0xCC, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D,
  0x80, 0x00, 0xCC, 0x00, 0x06, 0x70, 0x00, 0x71, 0x80, 0x03, 0x0C, 0x00,
  0x30, 0x70, 0x03, 0x81, 0xC0, 0x38, 0x07, 0x8F, 0x80, 0x1F, 0xF0, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xC1, 0xF8, 0x00, 0x43, 0xFE, 0x00, 0x23, 0x03,
  0x80, 0x33, 0x00, 0xE0, 0x1B, 0x00, 0x30, 0x0F, 0x00, 0x18, 0x07, 0x00,
  0x06, 0x07, 0x80, 0x03, 0x03, 0x80, 0x01, 0x81, 0xC0, 0x00, 0xC0, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0x30, 0x70, 0x00, 0x18, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x03,
  0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60,
  0x70, 0x00, 0x60, 0x3C, 0x00, 0x70, 0x1A, 0x00, 0x70, 0x0D, 0x80, 0x70,
  0x0C, 0x70, 0xF0, 0x06, 0x1F, 0xE0, 0x03, 0x01, 0x80, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x06, 0x01,
  0xFF, 0x8C, 0x07, 0x03, 0x10, 0x18, 0x03, 0x60, 0x60, 0x02, 0xC1, 0x80,
  0x07, 0x87, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x60, 0x00,
  0x30, 0xC0, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x0C, 0x00, 0x06,
  0x18, 0x00, 0x0C, 0x70, 0x00, 0x18, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3,
  0x00, 0x03, 0x86, 0x00, 0x07, 0x0C, 0x00, 0x1E, 0x18, 0x00, 0x38, 0x38,
  0x00, 0xF0, 0x30, 0x03, 0x60, 0x60, 0x0E, 0xC0, 0xE0, 0x39, 0x80, 0xF1,
  0xC6, 0x00, 0xFF, 0x0C, 0x00, 0x10, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x03, 0x07, 0xC0, 0x87, 0xE0, 0x27, 0x00, 0x19, 0x80,
  0x06, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFC, 0x1C,
  0x03, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x10, 0x01, 0x83, 0xE1, 0xE0, 0x3F, 0xF8,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x3F, 0xEF, 0xFF, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x61, 0x03, 0xF8, 0x02, 0x00,
  0x06, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x06, 0x0C,
  0x00, 0x18, 0x30, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00,
  0x30, 0x60, 0x00, 0xC3, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30,
  0xC0, 0x01, 0x83, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80,
  0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0xC0, 0x01, 0xC3, 0x00, 0x0F,
  0x0C, 0x00, 0x28, 0x30, 0x01, 0xE0, 0xE0, 0x0D, 0x81, 0x80, 0x66, 0x07,
  0x8F, 0x18, 0x0F, 0xF0, 0x40, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x78, 0x00,
  0x1B, 0x00, 0x03, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x06, 0x30, 0x00,
  0xC6, 0x00, 0x30, 0xC0, 0x06, 0x0C, 0x01, 0x81, 0x80, 0x70, 0x30, 0x0C,
  0x06, 0x03, 0x80, 0xC0, 0x60, 0x18, 0x1C, 0x03, 0x03, 0x00, 0x60, 0xC0,
  0x0C, 0x18, 0x01, 0x86, 0x00, 0x10, 0xC0, 0x03, 0x30, 0x00, 0x66, 0x00,
  0x0D, 0x80, 0x01, 0xB0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x6C, 0x00,
  0x70, 0x01, 0xB0, 0x01, 0x40, 0x06, 0xC0, 0x0D, 0x00, 0x33, 0x00, 0x34,
  0x00, 0xCC, 0x01, 0x90, 0x06, 0x30, 0x06, 0x40, 0x18, 0xC0, 0x31, 0x00,
  0xC3, 0x00, 0xC4, 0x03, 0x0C, 0x06, 0x18, 0x18, 0x30, 0x18, 0x60, 0x60,
  0xC0, 0xC1, 0x81, 0x83, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x10,
  0x60, 0x61, 0x80, 0x41, 0x01, 0x86, 0x01, 0x0C, 0x06, 0x30, 0x04, 0x20,
  0x18, 0xC0, 0x11, 0x80, 0x63, 0x00, 0x46, 0x01, 0x98, 0x01, 0xB0, 0x06,
  0x60, 0x06, 0xC0, 0x1B, 0x00, 0x1E, 0x00, 0x6C, 0x00, 0x58, 0x01, 0xA0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x03, 0x01, 0x80, 0x06, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x1C,
  0x00, 0xC0, 0x18, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x60, 0x00, 0x60, 0xE0,
  0x00, 0x61, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x33, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0xC6, 0x00, 0x01, 0xC6, 0x00, 0x01, 0x83, 0x00,
  0x03, 0x03, 0x00, 0x06, 0x03, 0x00, 0x0E, 0x01, 0x80, 0x0C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x70, 0x00, 0xC0, 0xE0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60, 0x06,
  0x00, 0x06, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x03, 0x00, 0x18, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x30, 0x06, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x01,
  0xC0, 0x00, 0x18, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0xB0, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x87, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x05, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x40, 0x00, 0x70, 0x00, 0x3E,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x7F, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80, 0x1E, 0x07, 0x81, 0xE0, 0x07,
  0xFE, 0x80, 0x07, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 11, 37, 11, 1, -37 },
  { 52, 12, 13, 16, 5, -37 },
  { 72, 27, 37, 28, 1, -37 },
  { 197, 23, 42, 25, 1, -39 },
  { 318, 29, 39, 36, 4, -38 },
  { 460, 26, 39, 29, 1, -38 },
  { 587, 5, 13, 9, 5, -37 },
  { 596, 14, 45, 13, 2, -37 },
  { 675, 14, 45, 13, -3, -37 },
  { 754, 19, 19, 24, 6, -39 },
  { 800, 22, 24, 27, 3, -30 },
  { 866, 7, 13, 10, -2, -6 },
  { 878, 12, 2, 15, 2, -15 },
  { 881, 4, 4, 10, 1, -4 },
  { 883, 22, 37, 16, -2, -37 },
  { 985, 22, 39, 25, 2, -38 },
  { 1093, 12, 37, 25, 7, -37 },
  { 1149, 24, 38, 25, 0, -38 },
  { 1263, 24, 39, 25, 0, -38 },
  { 1380, 24, 37, 25, 0, -37 },
  { 1491, 24, 38, 25, 1, -37 },
  { 1605, 22, 39, 25, 3, -38 },
  { 1713, 22, 37, 25, 4, -37 },
  { 1815, 23, 39, 25, 1, -38 },
  { 1928, 23, 39, 25, 1, -38 },
  { 2041, 8, 28, 10, 1, -28 },
  { 2069, 11, 35, 10, -2, -28 },
  { 2118, 22, 23, 27, 3, -30 },
  { 2182, 22, 13, 27, 3, -25 },
  { 2218, 22, 23, 27, 3, -30 },
  { 2282, 17, 38, 18, 3, -38 },
  { 2363, 34, 42, 38, 2, -37 },
  { 2542, 25, 37, 25, -3, -37 },
  { 2658, 25, 37, 27, 2, -37 },
  { 2774, 26, 39, 26, 3, -38 },
  { 2901, 27, 37, 30, 2, -37 },
  { 3026, 24, 37, 24, 2, -37 },
  { 3137, 24, 37, 22, 2, -37 },
  { 3248, 28, 39, 31, 3, -38 },
  { 3385, 29, 37, 31, 2, -37 },
  { 3520, 17, 37, 13, -1, -37 },
  { 3599, 20, 46, 11, -8, -37 },
  { 3714, 27, 37, 25, 2, -37 },
  { 3839, 16, 37, 22, 2, -37 },
  { 3913, 36, 37, 38, 2, -37 },
  { 4080, 30, 37, 31, 2, -37 },
  { 4219, 28, 39, 32, 3, -38 },
  { 4356, 24, 37, 25, 2, -37 },
  { 4467, 28, 47, 32, 3, -38 },
  { 4632, 24, 37, 26, 2, -37 },
  { 4743, 24, 39, 23, 0, -38 },
  { 4860, 21, 37, 22, 5, -37 },
  { 4958, 28, 38, 31, 3, -37 },
  { 5091, 24, 37, 25, 5, -37 },
  { 5202, 37, 37, 39, 6, -37 },
  { 5374, 29, 37, 22, -3, -37 },
  { 5509, 22, 37, 22, 5, -37 },
  { 5611, 27, 37, 24, -1, -37 },
  { 5736, 20, 45, 15, -1, -37 },
  { 5849, 8, 37, 17, 5, -37 },
  { 5886, 20, 45, 15, -4, -37 },
  { 5999, 22, 21, 26, 2, -37 },
  { 6057, 17, 2, 18, -4, 5 },
  { 6062, 6, 8, 12, 8, -40 },
  { 6068, 22, 29, 26, 2, -28 },
  { 6148, 23, 41, 26, 1, -40 },
  { 6266, 19, 29, 20, 2, -28 },
  { 6335, 25, 41, 26, 2, -40 },
  { 6464, 19, 29, 23, 2, -28 },
  { 6533, 27, 52, 13, -7, -40 },
  { 6709, 25, 40, 26, 0, -28 },
  { 6834, 22, 40, 25, 1, -40 },
  { 6944, 10, 37, 10, 1, -37 },
  { 6991, 18, 49, 10, -7, -37 },
  { 7102, 22, 40, 21, 1, -40 },
  { 7212, 10, 40, 10, 1, -40 },
  { 7262, 35, 28, 39, 1, -28 },
  { 7385, 22, 28, 25, 1, -28 },
  { 7462, 21, 29, 26, 2, -28 },
  { 7539, 25, 40, 26, -1, -28 },
  { 7664, 23, 40, 26, 2, -28 },
  { 7779, 18, 28, 17, 1, -28 },
  { 7842, 19, 29, 19, 0, -28 },
  { 7911, 13, 35, 14, 2, -34 },
  { 7968, 22, 29, 25, 2, -28 },
  { 8048, 19, 28, 19, 3, -28 },
  { 8115, 30, 28, 31, 3, -28 },
  { 8220, 24, 28, 21, -2, -28 },
  { 8304, 28, 41, 20, -6, -28 },
  { 8448, 21, 28, 19, -1, -28 },
  { 8522, 19, 45, 17, 1, -37 },
  { 8629, 2, 53, 24, 12, -40 },
  { 8643, 19, 45, 17, -3, -37 },
  { 8750, 22, 5, 27, 3, -21 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic52pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC52PT7B_H_
