#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC68PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x00, 0x1C, 0x07, 0x1C,
  0x0E, 0x1C, 0x0E, 0x18, 0x0E, 0x18, 0x0E, 0x38, 0x0C, 0x38, 0x0C, 0x38,
  0x1C, 0x30, 0x1C, 0x30, 0x18, 0x30, 0x18, 0x70, 0x18, 0x60, 0x38, 0x60,
  0x30, 0x60, 0x30, 0x60, 0x30, 0xC0, 0x30, 0xC0, 0x60, 0x00, 0x00, 0x30,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00,
  0x18, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x60, 0x07, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xF7, 0xF8, 0x03,
  0xC1, 0x81, 0xC0, 0x3C, 0x0C, 0x02, 0x03, 0xC0, 0x60, 0x00, 0x1C, 0x06,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x70, 0x0C, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x79, 0x80, 0x00, 0x01, 0xEC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0C, 0xF0, 0x00, 0x00, 0xC3, 0xC0, 0x00, 0x06,
  0x0F, 0x00, 0x00, 0x30, 0x38, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0xC0, 0x38, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x30, 0x0E, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0x30, 0x1C, 0x08, 0x01, 0x83, 0xC0, 0x70, 0x18, 0x3C,
  0x03, 0xFE, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x30, 0x07, 0xFC, 0x00, 0x01, 0xC0, 0x38,
  0x78, 0x00, 0x0E, 0x01, 0xC0, 0xE0, 0x00, 0x30, 0x0E, 0x01, 0x80, 0x01,
  0xC0, 0x30, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x1C, 0x00, 0x30, 0x06, 0x00,
  0x70, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xC0, 0x07, 0x00, 0x30,
  0x03, 0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x60, 0x0E, 0x00, 0x70, 0x01,
  0x80, 0x30, 0x01, 0x80, 0x06, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x06, 0x00,
  0x38, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0x80, 0x0C,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x30, 0x01, 0xC1, 0xC0, 0x60,
  0xC0, 0x07, 0x06, 0x0F, 0xF3, 0x00, 0x18, 0x38, 0x7F, 0xEC, 0x00, 0xE1,
  0xC3, 0x81, 0xF0, 0x03, 0x06, 0x1C, 0x07, 0xC0, 0x1C, 0x38, 0x60, 0x0F,
  0x80, 0x61, 0xC3, 0x80, 0x36, 0x03, 0x06, 0x0C, 0x00, 0xDC, 0x3C, 0x38,
  0x70, 0x03, 0x3F, 0xE1, 0xC1, 0x80, 0x0C, 0x7E, 0x06, 0x0E, 0x00, 0x30,
  0x00, 0x38, 0x38, 0x00, 0xC0, 0x01, 0xC0, 0xC0, 0x03, 0x00, 0x06, 0x03,
  0x00, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x70, 0x01, 0xC0,
  0x06, 0x01, 0x80, 0x06, 0x00, 0x38, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x18,
  0x00, 0xE0, 0x06, 0x00, 0x60, 0x03, 0x80, 0x38, 0x03, 0x80, 0x0C, 0x00,
  0xC0, 0x0E, 0x00, 0x30, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x38, 0x00, 0xE0,
  0x06, 0x00, 0xC0, 0x01, 0x80, 0x38, 0x07, 0x00, 0x06, 0x00, 0xC0, 0x38,
  0x00, 0x1C, 0x06, 0x00, 0xC0, 0x00, 0x70, 0x38, 0x07, 0x00, 0x00, 0xF7,
  0xC0, 0x38, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x3C, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x01, 0x80, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0x71, 0xE0, 0x00,
  0x00, 0x0E, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0x3C, 0xE0,
  0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x1E, 0x03, 0x00, 0x07, 0x0F, 0x00,
  0xE0, 0x01, 0x87, 0x00, 0x1C, 0x00, 0xE3, 0xC0, 0x07, 0x00, 0x30, 0xE0,
  0x00, 0xE0, 0x1C, 0x70, 0x00, 0x38, 0x06, 0x1C, 0x00, 0x07, 0x03, 0x8E,
  0x00, 0x01, 0xC0, 0xC3, 0x80, 0x00, 0x38, 0x70, 0xC0, 0x00, 0x06, 0x38,
  0x30, 0x00, 0x01, 0xDC, 0x0C, 0x00, 0x00, 0x3F, 0x03, 0x00, 0x00, 0x0F,
  0x80, 0xC0, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00,
  0x7E, 0x03, 0x80, 0x00, 0x3B, 0x80, 0x70, 0x00, 0x1C, 0x70, 0x1E, 0x00,
  0x1E, 0x0C, 0x03, 0xC0, 0x1F, 0x03, 0x80, 0x7F, 0xFF, 0x00, 0x70, 0x0F,
  0xFF, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x71, 0xC6, 0x18,
  0xE3, 0x8E, 0x30, 0xC3, 0x1C, 0x61, 0x86, 0x18, 0xC3, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x01, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x00,
  0xF8, 0x0C, 0x00, 0x1F, 0x06, 0x00, 0x03, 0xC2, 0x00, 0x00, 0x7B, 0x01,
  0xF0, 0x0F, 0xBF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x01, 0xD8,
  0x00, 0x01, 0xCC, 0x00, 0x01, 0xC3, 0x00, 0x01, 0xC1, 0x80, 0x01, 0xC0,
  0x60, 0x01, 0xC0, 0x30, 0x03, 0xC0, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x06, 0x03,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x6F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xC1,
  0xF0, 0x00, 0x78, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x30,
  0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x30, 0x1C,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x06,
  0x1C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x70,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x63, 0x80, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x0E, 0x30,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x1C,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x78, 0x0F, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x00, 0xF8, 0x07, 0xF0,
  0x1E, 0xC0, 0x79, 0x83, 0xC7, 0x0F, 0x0E, 0x78, 0x1D, 0xE0, 0x33, 0x80,
  0xE2, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0x07, 0xC0,
  0x01, 0xF0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x04, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xE0, 0x07, 0x80, 0x01, 0xC0, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x18, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x1F, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x07, 0x18, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x03, 0x83, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x60, 0x38, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x03, 0x80,
  0x18, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x60, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x70, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x00, 0xE0,
  0x0E, 0x00, 0x01, 0x80, 0x38, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x0E, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x3B, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x80, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xE0, 0x18, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x80,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07,
  0x01, 0xF8, 0x00, 0x18, 0x3F, 0xFC, 0x00, 0x63, 0xF9, 0xF8, 0x03, 0x9E,
  0x00, 0xF0, 0x0E, 0xE0, 0x01, 0xC0, 0x37, 0x00, 0x03, 0x80, 0xD8, 0x00,
  0x06, 0x07, 0xC0, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0x83, 0x80, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0x38, 0x18, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x38, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0xE0, 0x1E, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x0E,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0C,
  0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF1,
  0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x01, 0x81, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x1C, 0x30, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x0E,
  0x00, 0xF0, 0x00, 0x70, 0x01, 0xE0, 0x0F, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x70, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x06, 0x03, 0x80, 0x00, 0x38, 0x18, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0x87, 0x00, 0x00, 0x0C, 0x38,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x07,
  0x86, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x3E, 0x0E,
  0x00, 0x03, 0xF0, 0x38, 0x00, 0x3B, 0x81, 0xE0, 0x03, 0x98, 0x07, 0xC0,
  0x78, 0xC0, 0x1F, 0xFF, 0x0E, 0x00, 0x3F, 0xE0, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x02, 0x00, 0x7C, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF,
  0x01, 0xF8, 0x3E, 0x03, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x03, 0x03,
  0x80, 0x00, 0x7C, 0x00, 0x18, 0x18, 0x00, 0x1F, 0xFE, 0x00, 0xC1, 0xC0,
  0x03, 0xF3, 0xF0, 0x07, 0x0C, 0x00, 0x3C, 0x03, 0x80, 0x38, 0xE0, 0x03,
  0x80, 0x1C, 0x01, 0xC6, 0x00, 0x38, 0x00, 0xC0, 0x0E, 0x30, 0x03, 0x80,
  0x06, 0x00, 0x73, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x18, 0x01, 0xC0, 0x03,
  0x00, 0x18, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0xCE, 0x00, 0xE0, 0x00, 0xC0,
  0x06, 0x70, 0x06, 0x00, 0x0E, 0x00, 0x73, 0x00, 0x70, 0x00, 0x60, 0x03,
  0x98, 0x03, 0x80, 0x03, 0x00, 0x19, 0xC0, 0x18, 0x00, 0x38, 0x00, 0xCE,
  0x00, 0xC0, 0x01, 0xC0, 0x0E, 0x70, 0x0E, 0x00, 0x0C, 0x00, 0x73, 0x80,
  0x70, 0x00, 0xE0, 0x03, 0x1C, 0x03, 0x80, 0x07, 0x00, 0x38, 0xC0, 0x1C,
  0x00, 0x78, 0x01, 0x86, 0x00, 0xE0, 0x03, 0xC0, 0x1C, 0x30, 0x07, 0x00,
  0x36, 0x00, 0xC1, 0x80, 0x18, 0x01, 0xB0, 0x0E, 0x0E, 0x00, 0xE0, 0x19,
  0x80, 0xE0, 0x70, 0x07, 0x03, 0x8E, 0x0E, 0x03, 0x80, 0x1F, 0xF8, 0x3F,
  0xE0, 0x1C, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x06, 0x00, 0x00, 0x01, 0xF8, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x1C, 0x18, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01,
  0x80, 0x1C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x03, 0x80, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x03, 0x70, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x06, 0x00, 0x0F, 0x80, 0x03,
  0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38,
  0x06, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x1F,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x03, 0x80, 0x03, 0xE0, 0x01, 0xC0, 0x00, 0x78, 0x00, 0xC0, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0xE0, 0x18, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x70, 0x0C,
  0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x78, 0x03,
  0x00, 0x00, 0xF8, 0x01, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x00, 0x06, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x70,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x7E, 0x00, 0x03, 0x00, 0x03, 0xE0,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x03,
  0x83, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x1C, 0x0C, 0x00,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00,
  0xF0, 0x06, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x38, 0x00,
  0x07, 0xC0, 0x07, 0x00, 0x01, 0xF0, 0x00, 0xC0, 0x01, 0xF8, 0x00, 0x18,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x40, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x01, 0xFE, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x01, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xFC, 0x18, 0x00, 0x03,
  0xFF, 0xE0, 0xC0, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x00, 0x30, 0x70,
  0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x30, 0x38, 0x00,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x3C, 0x00, 0x00, 0x30, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x38, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x0F,
  0x3F, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x30, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x01, 0x81, 0xE0, 0x00, 0x00,
  0x38, 0x3C, 0x00, 0x00, 0x03, 0x87, 0x80, 0x00, 0x00, 0x38, 0xF0, 0x00,
  0x00, 0x03, 0x1F, 0x00, 0x00, 0x00, 0x73, 0xB8, 0x00, 0x00, 0x07, 0x73,
  0x80, 0x00, 0x00, 0x7E, 0x38, 0x00, 0x00, 0x06, 0xC1, 0xC0, 0x00, 0x00,
  0x78, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x03, 0x80, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x70, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x76, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x66, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x66, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0xE6, 0x00, 0x00, 0x01, 0xCC, 0x00, 0xE6, 0x00, 0x00, 0x01, 0x9C,
  0x00, 0xE6, 0x00, 0x00, 0x03, 0x9C, 0x00, 0xC7, 0x00, 0x00, 0x03, 0x1C,
  0x00, 0xC7, 0x00, 0x00, 0x07, 0x18, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x18,
  0x01, 0xC3, 0x00, 0x00, 0x0E, 0x38, 0x01, 0xC3, 0x00, 0x00, 0x1C, 0x38,
  0x01, 0x83, 0x00, 0x00, 0x1C, 0x38, 0x01, 0x83, 0x00, 0x00, 0x38, 0x30,
  0x03, 0x83, 0x00, 0x00, 0x30, 0x30, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70,
  0x03, 0x83, 0x80, 0x00, 0x60, 0x70, 0x03, 0x03, 0x80, 0x00, 0xE0, 0x70,
  0x07, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x07, 0x01, 0x80, 0x01, 0xC0, 0x60,
  0x07, 0x01, 0x80, 0x03, 0x80, 0xE0, 0x06, 0x01, 0x80, 0x03, 0x80, 0xE0,
  0x06, 0x01, 0x80, 0x07, 0x00, 0xC0, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0xC0,
  0x0E, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x0C, 0x01, 0xC0,
  0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x1C, 0x00, 0xC0, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x30, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x70, 0x03, 0x80, 0x18, 0x00, 0xE0, 0xE0, 0x03, 0x80,
  0x18, 0x00, 0xE0, 0xE0, 0x03, 0x00, 0x38, 0x00, 0xE1, 0xC0, 0x03, 0x00,
  0x38, 0x00, 0x61, 0x80, 0x07, 0x00, 0x30, 0x00, 0x63, 0x80, 0x07, 0x00,
  0x30, 0x00, 0x63, 0x00, 0x07, 0x00, 0x70, 0x00, 0x67, 0x00, 0x06, 0x00,
  0x70, 0x00, 0x66, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x00,
  0xC0, 0x0F, 0xC0, 0x00, 0x01, 0x80, 0x1F, 0x80, 0x00, 0x07, 0x00, 0x33,
  0x00, 0x00, 0x0E, 0x00, 0x67, 0x00, 0x00, 0x1C, 0x01, 0xCE, 0x00, 0x00,
  0x30, 0x03, 0x8C, 0x00, 0x00, 0x60, 0x07, 0x1C, 0x00, 0x01, 0xC0, 0x0C,
  0x38, 0x00, 0x03, 0x80, 0x18, 0x30, 0x00, 0x07, 0x00, 0x70, 0x70, 0x00,
  0x0C, 0x00, 0xE0, 0xE0, 0x00, 0x18, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x03,
  0x01, 0xC0, 0x00, 0xE0, 0x06, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x03, 0x00,
  0x03, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x00,
  0xC0, 0x0C, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x07, 0x00, 0x38,
  0x00, 0xC0, 0x0E, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0x70, 0x07, 0x00,
  0x30, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0xC0, 0x18, 0x01, 0xC0, 0x01,
  0xC0, 0x30, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x06, 0x00, 0x03, 0x01, 0xC0,
  0x0C, 0x00, 0x07, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x06, 0x00, 0x70, 0x00,
  0x0C, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x38, 0x01, 0x80, 0x00, 0x38, 0x70,
  0x03, 0x00, 0x00, 0x30, 0xE0, 0x0E, 0x00, 0x00, 0x71, 0x80, 0x1C, 0x00,
  0x00, 0xE3, 0x00, 0x38, 0x00, 0x00, 0xCE, 0x00, 0x60, 0x00, 0x01, 0xDC,
  0x01, 0xC0, 0x00, 0x03, 0xB0, 0x03, 0x80, 0x00, 0x03, 0x60, 0x07, 0x00,
  0x00, 0x07, 0xC0, 0x0C, 0x00, 0x00, 0x0F, 0x80, 0x18, 0x00, 0x00, 0x0F,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x73, 0x00, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x30, 0x01, 0xF0,
  0x00, 0x30, 0x00, 0x78, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38,
  0x03, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x03, 0xC0,
  0x07, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x30, 0x01, 0xF8, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x0E, 0x01,
  0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x78, 0x03, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x03, 0xE0, 0x07,
  0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0x70, 0x03, 0x80, 0x00, 0x20, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x18, 0x00, 0x07,
  0x80, 0x3E, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x1C, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x1C, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x18,
  0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x70, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x70, 0x06, 0x00, 0x01, 0x80,
  0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x30, 0x01, 0xC0, 0x01, 0xC0, 0x07,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0xC0,
  0x07, 0x00, 0x03, 0x00, 0x18, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x30, 0x03,
  0x00, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0x80, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x1D, 0x80, 0x00, 0x38, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x18,
  0x30, 0x00, 0x0E, 0x60, 0x00, 0x1C, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C,
  0x0C, 0x00, 0x07, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x8C, 0x00, 0x07,
  0x03, 0x00, 0x01, 0x86, 0x00, 0x07, 0x01, 0x80, 0x01, 0xC3, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x80, 0x60, 0x00, 0xE0, 0xC0, 0x01,
  0xC0, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x70, 0x30, 0x00,
  0xE0, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x70, 0x06, 0x00, 0x38, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x1C, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x03, 0x80,
  0x18, 0x00, 0xC0, 0x0E, 0x01, 0xC0, 0x1C, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0C, 0x00, 0x30, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x18, 0x03, 0x00, 0x38,
  0x07, 0x00, 0x0C, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x06, 0x01, 0x80, 0x0E,
  0x03, 0x80, 0x03, 0x81, 0xC0, 0x07, 0x01, 0x80, 0x01, 0xC0, 0xE0, 0x03,
  0x81, 0xC0, 0x00, 0xE0, 0x60, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x70, 0x00,
  0xE0, 0xE0, 0x00, 0x38, 0x30, 0x00, 0x70, 0x60, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0x70, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x38, 0x00, 0x07, 0x1C, 0x00,
  0x06, 0x18, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x1C, 0x00, 0x01, 0xCE, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x37, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x1B, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x00, 0x01, 0x87, 0x00, 0x00, 0x00, 0x07, 0x18, 0x00,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x00, 0x0E, 0x18, 0x00, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x38, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x0E,
  0x00, 0x07, 0x00, 0x30, 0x00, 0x38, 0x01, 0x80, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xC0, 0x01, 0x80, 0x1C, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x06, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x03, 0x07, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x03, 0x38, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0xE0,
  0x38, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x70,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x00, 0x60, 0x00, 0x30, 0x03, 0x80,
  0x03, 0x80, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x03, 0x80, 0x1C,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x60, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x1C, 0x06, 0x00, 0x00, 0x60, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0C,
  0x38, 0x00, 0x00, 0x63, 0x80, 0x00, 0x03, 0x98, 0x00, 0x00, 0x0D, 0xC0,
  0x00, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0xE0, 0x70,
  0x70, 0x38, 0x18, 0x1C, 0x0C, 0x06, 0x06, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0xC0, 0x0F, 0xFF, 0x0E, 0x01, 0xF0, 0x1C, 0x60, 0x1E,
  0x00, 0x73, 0x01, 0xE0, 0x01, 0x98, 0x0E, 0x00, 0x05, 0xC0, 0xE0, 0x00,
  0x3C, 0x0E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x78,
  0x38, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x78, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x3C, 0x0E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1F, 0x03, 0x80, 0x01, 0xF8,
  0x0C, 0x00, 0x0D, 0x80, 0x70, 0x00, 0xCC, 0x03, 0xC0, 0x1C, 0x60, 0x0F,
  0x01, 0xC3, 0x00, 0x3F, 0xFC, 0x38, 0x00, 0xFF, 0x81, 0x80, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x03, 0x00, 0x00, 0xE0, 0xFF, 0x80, 0x03, 0x0F, 0xFF, 0x80, 0x0C, 0x78,
  0x0F, 0x00, 0x73, 0x80, 0x1C, 0x01, 0xDC, 0x00, 0x38, 0x06, 0xE0, 0x00,
  0xE0, 0x1B, 0x00, 0x01, 0xC0, 0xF8, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x70, 0x3C,
  0x00, 0x01, 0xC0, 0xD0, 0x00, 0x0E, 0x03, 0x60, 0x00, 0x70, 0x1D, 0x80,
  0x03, 0xC0, 0x63, 0x00, 0x1E, 0x01, 0x8F, 0x01, 0xF0, 0x06, 0x1F, 0xFF,
  0x00, 0x38, 0x3F, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x78, 0x03, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1F, 0xF8,
  0x18, 0x00, 0x1F, 0xFF, 0x0C, 0x00, 0x3E, 0x03, 0xCE, 0x00, 0x3C, 0x00,
  0x67, 0x00, 0x3C, 0x00, 0x1B, 0x80, 0x1C, 0x00, 0x0D, 0x80, 0x1C, 0x00,
  0x02, 0xC0, 0x1C, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0xF0, 0x0E, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x80, 0x38, 0x00, 0x07, 0xC0,
  0x1C, 0x00, 0x03, 0xE0, 0x0E, 0x00, 0x03, 0xE0, 0x07, 0x00, 0x03, 0xB0,
  0x01, 0x80, 0x01, 0x98, 0x00, 0xE0, 0x01, 0xCC, 0x00, 0x78, 0x03, 0xCE,
  0x00, 0x1E, 0x03, 0xC6, 0x00, 0x07, 0xFF, 0x83, 0x00, 0x01, 0xFF, 0x81,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x0E, 0x00,
  0x1C, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x87, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0xC3, 0x80, 0x00, 0xE1, 0x80, 0x00, 0x71, 0xC0,
  0x00, 0x70, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0x70, 0x03, 0xF0, 0x38,
  0x7F, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x08, 0x07, 0xC0, 0x1C, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xC3, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x10, 0x78, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFE, 0x07, 0x00,
  0x0F, 0xFF, 0x86, 0x00, 0x3E, 0x03, 0xC6, 0x00, 0x78, 0x00, 0xC6, 0x00,
  0xF0, 0x00, 0x6E, 0x00, 0xE0, 0x00, 0x6C, 0x01, 0xC0, 0x00, 0x2C, 0x03,
  0x80, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x3C, 0x07,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x0C,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x30, 0x1C,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x01, 0xE0, 0x38, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x03, 0xC0, 0x38, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x07, 0xC0, 0x38,
  0x00, 0x0F, 0x80, 0x38, 0x00, 0x1D, 0x80, 0x18, 0x00, 0x19, 0x80, 0x1C,
  0x00, 0x3B, 0x80, 0x1E, 0x00, 0xF3, 0x80, 0x0F, 0x01, 0xE3, 0x00, 0x07,
  0xFF, 0x83, 0x00, 0x03, 0xFF, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0xFF,
  0xC0, 0x06, 0x1F, 0xFF, 0x00, 0x31, 0xE0, 0x3C, 0x03, 0x9C, 0x00, 0xE0,
  0x1D, 0xC0, 0x03, 0x80, 0xDC, 0x00, 0x1C, 0x06, 0xC0, 0x00, 0xE0, 0x3C,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x60, 0x70, 0x00, 0x03, 0x03, 0x80, 0x00, 0x38,
  0x1C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x03, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x0E, 0x06, 0x00, 0x00, 0x60, 0x70, 0x00, 0x03, 0x03, 0x80, 0x00, 0x38,
  0x1C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x18, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x0C, 0x0E, 0x00, 0x00, 0x60, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38,
  0x18, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x87, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x78, 0x06, 0x00, 0x07, 0x00, 0x30, 0x00, 0x70, 0x03, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x07, 0x00, 0x06, 0x00, 0x70,
  0x00, 0x70, 0x07, 0x80, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0xC0, 0x38, 0x00, 0x06, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xC3, 0xC0, 0x00, 0x06, 0x3E, 0x00,
  0x00, 0x73, 0xB0, 0x00, 0x03, 0xB9, 0xC0, 0x00, 0x1B, 0x8E, 0x00, 0x00,
  0xF8, 0x30, 0x00, 0x0F, 0x81, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x18, 0x01, 0xC0, 0x00, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x38, 0x00,
  0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x06, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80,
  0x01, 0xC0, 0x18, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x06, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x03,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0C, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x31,
  0xC0, 0x70, 0x78, 0x1E, 0x01, 0xCC, 0x00, 0xE3, 0x80, 0x3C, 0x06, 0x60,
  0x03, 0x9C, 0x00, 0x70, 0x1B, 0x00, 0x06, 0xE0, 0x01, 0xC0, 0x78, 0x00,
  0x1B, 0x00, 0x03, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0C, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x30, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x06, 0x07, 0xFE, 0x00, 0x30, 0xFF,
  0xF8, 0x01, 0x8F, 0x01, 0xE0, 0x1C, 0xE0, 0x07, 0x00, 0xCE, 0x00, 0x1C,
  0x06, 0xE0, 0x00, 0xE0, 0x36, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x38, 0x1E,
  0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x03, 0x03, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0x70, 0x30, 0x00, 0x03, 0x03, 0x80, 0x00, 0x18, 0x1C,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x03, 0x03, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x03, 0x80, 0x00, 0x38, 0x1C,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x03, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0x80, 0xF8, 0x01, 0xE0, 0x03, 0x80, 0x3C,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x06, 0x38,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x30, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x06, 0x70, 0x00, 0x00, 0x67, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0C, 0xE0, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x38,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x0F, 0xFC, 0x00, 0x06, 0x1F, 0xFF, 0x00, 0x03, 0x1E, 0x03, 0xC0, 0x03,
  0x9C, 0x00, 0xE0, 0x01, 0x9C, 0x00, 0x38, 0x00, 0xCC, 0x00, 0x1C, 0x00,
  0x6C, 0x00, 0x07, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x3E, 0x00, 0x01, 0xC0,
  0x1E, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x38,
  0x07, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x60, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00,
  0x38, 0x06, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x78, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x01, 0xC0, 0x1A, 0x00,
  0x01, 0xC0, 0x0D, 0x80, 0x01, 0xC0, 0x0E, 0xC0, 0x01, 0xE0, 0x07, 0x30,
  0x01, 0xE0, 0x03, 0x9C, 0x03, 0xE0, 0x01, 0x87, 0xFF, 0xC0, 0x00, 0xC1,
  0xFF, 0xC0, 0x00, 0xE0, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x70, 0x03, 0xFF, 0xE1, 0x80, 0x3E, 0x03, 0xC6,
  0x01, 0xE0, 0x03, 0x18, 0x0F, 0x00, 0x06, 0xE0, 0x38, 0x00, 0x1B, 0x01,
  0xC0, 0x00, 0x2C, 0x0E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x03, 0x83, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x01, 0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1F, 0x03, 0x80, 0x00,
  0xF8, 0x0E, 0x00, 0x07, 0x60, 0x18, 0x00, 0x19, 0x80, 0x70, 0x00, 0xEE,
  0x01, 0xE0, 0x0F, 0x38, 0x03, 0xC0, 0x78, 0xC0, 0x07, 0xFF, 0x83, 0x00,
  0x0F, 0xFC, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x01, 0x81, 0xFC, 0x03, 0x0F,
  0xF8, 0x06, 0x3C, 0x00, 0x1C, 0xE0, 0x00, 0x33, 0x80, 0x00, 0x6E, 0x00,
  0x00, 0xD8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x3C, 0x00, 0xE0, 0x3C, 0x00, 0x10, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x40, 0x00,
  0xF0, 0x3C, 0x00, 0xF0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0xDF,
  0xFF, 0xE0, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0x78, 0x00, 0x03, 0x00, 0x00, 0x30, 0x70, 0x00, 0x03, 0x07,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x06, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x01, 0x83, 0x80, 0x00, 0x18,
  0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x30, 0x00, 0x03, 0x83, 0x00,
  0x00, 0x30, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07,
  0x06, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x06,
  0xC0, 0xE0, 0x00, 0xEC, 0x0E, 0x00, 0x1C, 0xC0, 0x70, 0x03, 0x9C, 0x07,
  0x80, 0xF1, 0x80, 0x3F, 0xFE, 0x18, 0x01, 0xFF, 0x81, 0x80, 0x03, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xB0, 0x00, 0x01, 0x98,
  0x00, 0x01, 0xCE, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xE1,
  0xC0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x18, 0x00, 0x38,
  0x0C, 0x00, 0x1C, 0x06, 0x00, 0x1C, 0x03, 0x00, 0x0E, 0x01, 0x80, 0x0E,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x00, 0x1C, 0x03,
  0x80, 0x0E, 0x01, 0x80, 0x03, 0x01, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0,
  0xE0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x0E,
  0x38, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0F,
  0x80, 0x00, 0x70, 0x00, 0x1B, 0x00, 0x01, 0xE0, 0x00, 0x76, 0x00, 0x03,
  0xC0, 0x00, 0xEE, 0x00, 0x0D, 0x80, 0x03, 0x9C, 0x00, 0x1B, 0x00, 0x07,
  0x38, 0x00, 0x76, 0x00, 0x0C, 0x70, 0x00, 0xCC, 0x00, 0x38, 0xE0, 0x03,
  0x98, 0x00, 0x61, 0xC0, 0x06, 0x30, 0x01, 0xC3, 0x80, 0x1C, 0x60, 0x03,
  0x07, 0x00, 0x30, 0xC0, 0x0E, 0x0E, 0x00, 0xE1, 0x80, 0x1C, 0x1C, 0x01,
  0x83, 0x80, 0x70, 0x38, 0x07, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x0E, 0x01,
  0x80, 0xE0, 0x18, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0C, 0x01, 0x80,
  0xC0, 0x70, 0x38, 0x03, 0x03, 0x80, 0x60, 0x60, 0x06, 0x06, 0x00, 0xC1,
  0xC0, 0x0C, 0x1C, 0x01, 0x83, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x30,
  0xE0, 0x06, 0x1C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x00, 0xC7, 0x00, 0x18,
  0xE0, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x03, 0x38, 0x00, 0x67, 0x00, 0x06,
  0x60, 0x00, 0xCC, 0x00, 0x0D, 0xC0, 0x01, 0x98, 0x00, 0x1B, 0x00, 0x03,
  0x70, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x38, 0x30, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x07, 0x00, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0x60, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x70, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x03, 0x98,
  0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x08, 0x3C, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x70, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x09, 0xFF, 0xE0, 0x00, 0xDE, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC1, 0xE8, 0x00, 0x1F, 0xFE, 0x40, 0x00, 0x3F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 13, 49, 15, 2, -49 },
  { 81, 16, 18, 21, 7, -49 },
  { 117, 36, 49, 36, 1, -49 },
  { 338, 29, 56, 32, 2, -52 },
  { 541, 38, 50, 47, 5, -49 },
  { 779, 34, 50, 38, 2, -49 },
  { 992, 6, 18, 12, 7, -49 },
  { 1006, 19, 59, 17, 2, -48 },
  { 1147, 20, 59, 17, -5, -48 },
  { 1295, 25, 26, 31, 8, -52 },
  { 1377, 29, 32, 35, 4, -40 },
  { 1493, 10, 16, 13, -3, -7 },
  { 1513, 16, 3, 20, 2, -20 },
  { 1519, 4, 5, 14, 2, -5 },
  { 1522, 30, 49, 21, -3, -49 },
  { 1706, 29, 50, 33, 3, -49 },
  { 1888, 15, 49, 33, 10, -49 },
  { 1980, 31, 49, 33, 0, -49 },
  { 2170, 31, 50, 33, 0, -49 },
  { 2364, 31, 49, 33, 0, -49 },
  { 2554, 31, 50, 33, 1, -49 },
  { 2748, 30, 50, 33, 3, -49 },
  { 2936, 28, 49, 33, 6, -49 },
  { 3108, 30, 50, 33, 2, -49 },
  { 3296, 29, 50, 33, 2, -49 },
  { 3478, 11, 36, 14, 1, -36 },
  { 3528, 15, 45, 14, -3, -36 },
  { 3613, 28, 30, 35, 4, -39 },
  { 3718, 28, 16, 35, 4, -32 },
  { 3774, 29, 30, 35, 4, -39 },
  { 3883, 22, 49, 24, 4, -49 },
  { 4018, 45, 54, 49, 3, -48 },
  { 4322, 32, 49, 32, -4, -49 },
  { 4518, 33, 49, 35, 2, -49 },
  { 4721, 34, 50, 34, 4, -49 },
  { 4934, 35, 49, 40, 2, -49 },
  { 5149, 32, 49, 31, 2, -49 },
  { 5345, 32, 49, 29, 2, -49 },
  { 5541, 37, 50, 41, 4, -49 },
  { 5773, 39, 49, 41, 2, -49 },
  { 6012, 22, 49, 17, -1, -49 },
  { 6147, 26, 61, 14, -11, -49 },
  { 6346, 36, 49, 33, 2, -49 },
  { 6567, 22, 49, 29, 2, -49 },
  { 6702, 48, 49, 50, 2, -49 },
  { 6996, 39, 49, 41, 2, -49 },
  { 7235, 36, 50, 42, 4, -49 },
  { 7460, 32, 49, 33, 2, -49 },
  { 7656, 36, 61, 42, 4, -49 },
  { 7931, 32, 49, 34, 2, -49 },
  { 8127, 31, 50, 30, 0, -49 },
  { 8321, 28, 49, 29, 6, -49 },
  { 8493, 37, 50, 40, 4, -49 },
  { 8725, 30, 49, 32, 7, -49 },
  { 8909, 49, 49, 51, 7, -49 },
  { 9210, 38, 49, 29, -4, -49 },
  { 9443, 29, 49, 29, 6, -49 },
  { 9621, 35, 49, 31, -1, -49 },
  { 9836, 25, 60, 20, -1, -49 },
  { 10024, 10, 49, 22, 7, -49 },
  { 10086, 26, 60, 20, -5, -49 },
  { 10281, 29, 28, 34, 3, -49 },
  { 10383, 24, 2, 23, -6, 7 },
  { 10389, 8, 11, 16, 10, -52 },
  { 10400, 29, 38, 33, 3, -37 },
  { 10538, 30, 53, 34, 1, -52 },
  { 10737, 24, 38, 26, 3, -37 },
  { 10851, 33, 53, 34, 3, -52 },
  { 11070, 25, 38, 30, 3, -37 },
  { 11189, 35, 68, 17, -9, -52 },
  { 11487, 32, 53, 34, 1, -37 },
  { 11699, 29, 52, 33, 1, -52 },
  { 11888, 14, 49, 13, 1, -49 },
  { 11974, 24, 65, 14, -9, -49 },
  { 12169, 29, 52, 27, 1, -52 },
  { 12358, 14, 52, 13, 1, -52 },
  { 12449, 46, 37, 50, 1, -37 },
  { 12662, 29, 37, 33, 1, -37 },
  { 12797, 28, 38, 34, 3, -37 },
  { 12930, 33, 53, 34, -2, -37 },
  { 13149, 30, 53, 34, 3, -37 },
  { 13348, 23, 37, 22, 1, -37 },
  { 13455, 25, 38, 25, 0, -37 },
  { 13574, 17, 46, 18, 3, -45 },
  { 13672, 28, 37, 33, 3, -36 },
  { 13802, 25, 36, 25, 4, -36 },
  { 13915, 39, 36, 41, 4, -36 },
  { 14091, 32, 36, 27, -3, -36 },
  { 14235, 36, 52, 26, -7, -36 },
  { 14469, 27, 36, 25, -1, -36 },
  { 14591, 24, 60, 22, 2, -49 },
  { 14771, 2, 68, 32, 16, -52 },
  { 14788, 24, 59, 22, -4, -48 },
  { 14965, 29, 6, 35, 4, -27 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic68pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC68PT7B_H_
