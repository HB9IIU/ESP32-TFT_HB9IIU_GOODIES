#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC72PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x10, 0x00, 0x1C, 0x07, 0x1C, 0x0E,
  0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0C, 0x30, 0x0C, 0x30, 0x1C,
  0x70, 0x1C, 0x70, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x38, 0xE0, 0x30,
  0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x07, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x70, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x60, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x07, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x07, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x70, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x18, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x7E, 0x30, 0x7C, 0x01, 0xE0, 0x60, 0x18, 0x07,
  0x80, 0xC0, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70,
  0x0C, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x03, 0x80, 0x30, 0x00, 0x07, 0x00,
  0x60, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x38, 0x06,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x00, 0xF0, 0xC0, 0x00, 0x00, 0xF1, 0x80, 0x00, 0x00, 0xFB, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xDF, 0x00, 0x00, 0x03, 0x9F, 0x00,
  0x00, 0x06, 0x0F, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x18, 0x0E, 0x00,
  0x00, 0x30, 0x1C, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x30, 0x07, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x01,
  0x80, 0x70, 0x00, 0x07, 0x03, 0xC0, 0x60, 0x0C, 0x0F, 0x00, 0xF8, 0x18,
  0x7C, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x02, 0x00, 0x7F,
  0xC0, 0x00, 0x0E, 0x00, 0x78, 0xF0, 0x00, 0x06, 0x00, 0x70, 0x38, 0x00,
  0x07, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x07, 0x00, 0x03, 0x00,
  0x38, 0x03, 0x80, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x0E, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x01,
  0x80, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x00, 0xE0, 0x38,
  0x00, 0x38, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x00, 0x30, 0x18, 0x00, 0x0E,
  0x00, 0x18, 0x1C, 0x00, 0x07, 0x00, 0x1C, 0x1C, 0x0F, 0xE3, 0x80, 0x0C,
  0x0C, 0x1F, 0xF9, 0xC0, 0x0E, 0x0E, 0x1E, 0x1E, 0xE0, 0x07, 0x0E, 0x1E,
  0x07, 0x70, 0x03, 0x06, 0x0E, 0x01, 0xF8, 0x03, 0x87, 0x0E, 0x00, 0xEC,
  0x03, 0x87, 0x06, 0x00, 0x77, 0x03, 0x83, 0x87, 0x00, 0x3B, 0xE7, 0x83,
  0x83, 0x00, 0x1C, 0xFF, 0x83, 0x83, 0x80, 0x0E, 0x1F, 0x81, 0xC1, 0xC0,
  0x07, 0x00, 0x01, 0xC0, 0xC0, 0x03, 0x80, 0x00, 0xC0, 0xE0, 0x01, 0xC0,
  0x00, 0xE0, 0x70, 0x00, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x18, 0x00, 0x30, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x0E, 0x00,
  0x1C, 0x00, 0x30, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x03, 0x80, 0x06, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x80, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x1C, 0x00, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x07,
  0x00, 0x03, 0x80, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x07, 0x00, 0x00,
  0x7F, 0xF0, 0x07, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x00, 0x38, 0x00, 0x70, 0x00, 0x03, 0x80, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00,
  0x00, 0xE7, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x79,
  0xC0, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00,
  0x78, 0x07, 0x00, 0x07, 0x0F, 0x00, 0x70, 0x00, 0xE1, 0xE0, 0x03, 0x80,
  0x0E, 0x1C, 0x00, 0x38, 0x00, 0xC3, 0x80, 0x01, 0xC0, 0x1C, 0x70, 0x00,
  0x0E, 0x01, 0x87, 0x00, 0x00, 0xE0, 0x38, 0x60, 0x00, 0x07, 0x07, 0x0E,
  0x00, 0x00, 0x70, 0x70, 0xE0, 0x00, 0x03, 0x8E, 0x0E, 0x00, 0x00, 0x39,
  0xC0, 0xE0, 0x00, 0x01, 0xDC, 0x0C, 0x00, 0x00, 0x1F, 0x80, 0xC0, 0x00,
  0x00, 0xF0, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x0E,
  0x00, 0x00, 0x3B, 0x80, 0xF0, 0x00, 0x07, 0x38, 0x07, 0x00, 0x01, 0xE1,
  0xC0, 0x78, 0x00, 0x3C, 0x1C, 0x03, 0xE0, 0x0F, 0x80, 0xE0, 0x1F, 0xFF,
  0xE0, 0x0E, 0x00, 0x7F, 0xF8, 0x00, 0x70, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1C, 0x73, 0x8E, 0x38, 0xE3, 0x0C, 0x71, 0xC6, 0x18, 0x63, 0x8C, 0x30,
  0xC3, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x01, 0x80, 0x18, 0x00, 0xF0, 0x0C, 0x00, 0x3E, 0x06, 0x00, 0x07,
  0x83, 0x00, 0x00, 0xF1, 0x00, 0x10, 0x1E, 0x83, 0xF8, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0xEC, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x30, 0x01, 0xE0, 0x1C,
  0x01, 0xE0, 0x06, 0x00, 0x60, 0x03, 0x80, 0x20, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x70,
  0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x60,
  0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF4, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x03, 0x80, 0x00, 0x0C,
  0x1C, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x71, 0x80, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x0E, 0x18, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x81, 0x80, 0x00, 0x1C,
  0x06, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0xC0, 0x0F, 0xE0, 0x1E, 0x70, 0x1E, 0x30, 0x3E, 0x18, 0x3C, 0x1C, 0x7C,
  0x0E, 0x78, 0x07, 0x18, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x3F,
  0x00, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0xF0, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x01, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x38, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x18, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x03, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x02,
  0x00, 0x00, 0x3C, 0x01, 0x80, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xF0,
  0x70, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x3E, 0x00, 0x07, 0x03,
  0xFF, 0x80, 0x0E, 0x1F, 0xFF, 0x80, 0x1C, 0xF8, 0x07, 0x80, 0x33, 0x80,
  0x07, 0x80, 0xEE, 0x00, 0x07, 0x01, 0xF8, 0x00, 0x07, 0x03, 0xE0, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x0C, 0x1E, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C,
  0x03, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xE1, 0xF8, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x38, 0x01, 0xE0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x78, 0x00, 0x00, 0xFC, 0x3C, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x07,
  0xC0, 0x07, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x07, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0xF0, 0x07, 0x80, 0x03, 0x80, 0x07, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x07, 0x00, 0xF0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0C, 0x07, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x7C,
  0x0E, 0x00, 0x01, 0xF8, 0x1C, 0x00, 0x07, 0x60, 0x3C, 0x00, 0x1C, 0xC0,
  0x3C, 0x00, 0x73, 0x80, 0x3E, 0x07, 0xC7, 0x00, 0x3F, 0xFE, 0x0C, 0x00,
  0x1F, 0xF0, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x01, 0x80, 0x1F, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x07, 0x00, 0x20, 0x00,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0x8F, 0xC0, 0x70,
  0x03, 0xC0, 0x80, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x1F, 0x80, 0x03, 0x83, 0x80, 0x00, 0xFF, 0xF0, 0x03, 0x07, 0x00, 0x07,
  0xFF, 0xE0, 0x06, 0x1C, 0x00, 0x1E, 0x01, 0xC0, 0x0C, 0x38, 0x00, 0x70,
  0x03, 0x80, 0x18, 0xE0, 0x01, 0xC0, 0x06, 0x00, 0x31, 0xC0, 0x07, 0x00,
  0x0C, 0x00, 0x63, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xCE, 0x00, 0x70, 0x00,
  0x70, 0x01, 0x9C, 0x00, 0xE0, 0x00, 0xC0, 0x07, 0x30, 0x03, 0x80, 0x01,
  0x80, 0x0E, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x1D, 0xC0, 0x0C, 0x00, 0x0E,
  0x00, 0x3B, 0x80, 0x38, 0x00, 0x18, 0x00, 0x66, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xCC, 0x00, 0xC0, 0x00, 0xE0, 0x03, 0x98, 0x03, 0x80, 0x01, 0xC0,
  0x07, 0x70, 0x07, 0x00, 0x07, 0x00, 0x0C, 0xE0, 0x0E, 0x00, 0x0E, 0x00,
  0x39, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0x63, 0x80, 0x38, 0x00, 0x78, 0x01,
  0xC7, 0x00, 0x70, 0x00, 0xF0, 0x03, 0x0E, 0x00, 0xE0, 0x03, 0xE0, 0x0E,
  0x1C, 0x01, 0xC0, 0x0F, 0xC0, 0x38, 0x38, 0x01, 0x80, 0x39, 0x80, 0xF0,
  0x70, 0x03, 0x80, 0xE3, 0x03, 0xC0, 0xE0, 0x03, 0xC7, 0x87, 0x9F, 0x00,
  0xC0, 0x07, 0xFE, 0x07, 0xFC, 0x01, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x00, 0xE0, 0x06, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0xC0, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x07,
  0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x01, 0x87, 0x00, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x01, 0xE0, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x01, 0xFC, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x0E, 0x00,
  0x00, 0x38, 0x01, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x38,
  0x06, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x3C, 0x03, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x1C, 0x00, 0x01, 0xF0, 0x03, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x7F,
  0x80, 0x01, 0xF0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x04, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x80, 0x00, 0xFC, 0x00,
  0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x03, 0x80, 0x0F, 0xE0, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x01, 0xE0,
  0x01, 0xC0, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xF8, 0x00, 0x1C, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xE1, 0xFF, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x18, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0xFF, 0xFC, 0x38, 0x00, 0x03, 0xFF, 0xF0, 0xE0, 0x00, 0x0F,
  0xFF, 0xC3, 0x80, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x00,
  0x0E, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x08, 0x0F, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x00, 0x18, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x07, 0x80,
  0x00, 0x00, 0xC0, 0x3C, 0x00, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x01, 0x83, 0xC0, 0x00,
  0x00, 0x0E, 0x1E, 0x00, 0x00, 0x00, 0x38, 0xF8, 0x00, 0x00, 0x00, 0xE7,
  0xE0, 0x00, 0x00, 0x03, 0xBD, 0xC0, 0x00, 0x00, 0x0C, 0xE7, 0x00, 0x00,
  0x00, 0x77, 0x0E, 0x00, 0x00, 0x01, 0xF8, 0x38, 0x00, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x01, 0x80, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x6E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x0D, 0xC0, 0x00, 0x00, 0x07, 0x70,
  0x03, 0xB8, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x73, 0x00, 0x00, 0x00, 0x39,
  0x80, 0x0E, 0x60, 0x00, 0x00, 0x0E, 0x70, 0x01, 0xCC, 0x00, 0x00, 0x01,
  0xCE, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x00, 0x00,
  0x0E, 0x30, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x71, 0xC0, 0x06, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0xC1, 0x80,
  0x00, 0x03, 0x07, 0x00, 0x38, 0x30, 0x00, 0x00, 0xE0, 0xC0, 0x07, 0x06,
  0x00, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x18,
  0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00,
  0xE0, 0x70, 0x00, 0x0E, 0x03, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xE0,
  0x03, 0x80, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x60, 0x18, 0x00, 0x0E, 0x03,
  0x80, 0x1C, 0x03, 0x00, 0x03, 0x80, 0x60, 0x03, 0x80, 0x70, 0x00, 0x60,
  0x1C, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x07,
  0x00, 0x70, 0x01, 0x80, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x01, 0x80, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x0C,
  0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x38, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x00, 0xE0, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x0C, 0x00, 0x38, 0x00,
  0xC0, 0x03, 0x83, 0x80, 0x07, 0x00, 0x38, 0x00, 0x30, 0xE0, 0x00, 0xE0,
  0x07, 0x00, 0x06, 0x1C, 0x00, 0x18, 0x00, 0xE0, 0x00, 0xC7, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x18, 0xE0, 0x00, 0xE0, 0x03, 0x00, 0x03, 0xB8, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x77, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x0F, 0xC0,
  0x00, 0xE0, 0x03, 0x80, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x07,
  0x80, 0x00, 0x00, 0x60, 0x03, 0xE0, 0x00, 0x00, 0x38, 0x00, 0xF8, 0x00,
  0x00, 0x0E, 0x00, 0x3F, 0x00, 0x00, 0x03, 0x80, 0x0D, 0xC0, 0x00, 0x00,
  0xE0, 0x03, 0x70, 0x00, 0x00, 0x30, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0x00,
  0x73, 0x80, 0x00, 0x07, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xC0, 0x06, 0x1C,
  0x00, 0x00, 0x60, 0x01, 0x87, 0x00, 0x00, 0x38, 0x00, 0xE1, 0xC0, 0x00,
  0x0E, 0x00, 0x38, 0x38, 0x00, 0x03, 0x80, 0x0E, 0x0E, 0x00, 0x00, 0xE0,
  0x03, 0x83, 0x80, 0x00, 0x30, 0x00, 0xC0, 0x70, 0x00, 0x1C, 0x00, 0x70,
  0x1C, 0x00, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x00, 0xE0,
  0x00, 0x70, 0x01, 0x80, 0x38, 0x00, 0x18, 0x00, 0xE0, 0x0E, 0x00, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x06, 0x00,
  0x70, 0x01, 0xC0, 0x01, 0xC0, 0x18, 0x00, 0x60, 0x00, 0x70, 0x0E, 0x00,
  0x38, 0x00, 0x0C, 0x03, 0x80, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x03, 0x80,
  0x00, 0xE0, 0x38, 0x00, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x00, 0x07,
  0x07, 0x00, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x07, 0x00, 0x00, 0x30, 0x70,
  0x01, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x60, 0x00, 0x03, 0x86, 0x00, 0x38,
  0x00, 0x00, 0x63, 0x80, 0x0E, 0x00, 0x00, 0x1C, 0xE0, 0x03, 0x80, 0x00,
  0x07, 0x38, 0x00, 0xE0, 0x00, 0x00, 0xCE, 0x00, 0x30, 0x00, 0x00, 0x3B,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x01,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x03, 0x1C,
  0x00, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00,
  0x06, 0x70, 0x00, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x07, 0x30, 0x00,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x78, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0x80, 0x1F, 0xC0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x38,
  0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00,
  0x78, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x70, 0x01, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x00, 0x18, 0xE0,
  0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0x80, 0x1F,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x03, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x03, 0xC0, 0x0E, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x01, 0xF0, 0x00, 0xC0,
  0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0x7F, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x10, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x18, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x38, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x80,
  0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0x06, 0x03, 0x80, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x70, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x36, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xD8, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x60, 0x00, 0x0E, 0x1C, 0x00,
  0x01, 0x8C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x71, 0x80, 0x00, 0x70, 0x70,
  0x00, 0x0E, 0x30, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x86, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x70, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0C, 0x18, 0x00, 0x0E,
  0x07, 0x00, 0x03, 0x83, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x60, 0x60, 0x00,
  0x70, 0x1C, 0x00, 0x1C, 0x0C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x01, 0x80,
  0x03, 0x80, 0x70, 0x00, 0xE0, 0x30, 0x00, 0x60, 0x0E, 0x00, 0x1C, 0x06,
  0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0xE0,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x18, 0x00, 0x70, 0x06, 0x00, 0x38, 0x07, 0x00, 0x0E,
  0x01, 0xC0, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x38, 0x00,
  0x18, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x01, 0xC0, 0x03, 0x81, 0xC0,
  0x00, 0x60, 0x70, 0x00, 0x70, 0x38, 0x00, 0x0C, 0x0E, 0x00, 0x0E, 0x06,
  0x00, 0x01, 0x81, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x38,
  0x30, 0x00, 0x06, 0x0C, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0xE1, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x1C, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x63, 0x80, 0x00, 0x71, 0x80, 0x00, 0x0C, 0xE0,
  0x00, 0x06, 0x70, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x1B, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x03, 0x70, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x07, 0x80, 0x00, 0x00,
  0xC0, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x38, 0x60, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x0E,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x38, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x30, 0x07,
  0x00, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x1C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x38, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x1C,
  0x01, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x60, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x0C, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x01, 0x9C, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0xE0,
  0xE0, 0xE0, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x1C, 0x00, 0xFF, 0xFC, 0x30, 0x03, 0xE0,
  0x3C, 0x60, 0x0F, 0x00, 0x18, 0xC0, 0x3C, 0x00, 0x3B, 0x80, 0xF0, 0x00,
  0x37, 0x01, 0xC0, 0x00, 0x6C, 0x07, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0xF0, 0x38, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38,
  0x30, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0x78, 0x1C, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x0D, 0x80, 0x70, 0x00, 0x3B, 0x00, 0xE0, 0x00, 0xEE, 0x01, 0xE0, 0x03,
  0x9C, 0x01, 0xC0, 0x0E, 0x30, 0x03, 0xE0, 0x78, 0x60, 0x03, 0xFF, 0xE0,
  0xC0, 0x01, 0xFF, 0x03, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xC0, 0x1F, 0x00, 0x03, 0x81, 0xFF, 0x80, 0x07, 0x0F, 0xFF, 0x80, 0x0E,
  0x3C, 0x07, 0x80, 0x18, 0xE0, 0x03, 0x80, 0x33, 0x80, 0x07, 0x80, 0xEE,
  0x00, 0x07, 0x01, 0xF8, 0x00, 0x0E, 0x03, 0xE0, 0x00, 0x0E, 0x07, 0xC0,
  0x00, 0x1C, 0x0F, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x70, 0x78, 0x00,
  0x00, 0xE0, 0xF0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x87, 0x80, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x78, 0x3E,
  0x00, 0x00, 0xE0, 0x6C, 0x00, 0x03, 0x80, 0xD8, 0x00, 0x0F, 0x03, 0x98,
  0x00, 0x3C, 0x07, 0x38, 0x00, 0xF0, 0x0C, 0x38, 0x07, 0xC0, 0x18, 0x3F,
  0xFE, 0x00, 0x30, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xF0, 0x02, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x40, 0x0F, 0x00, 0x70, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF8, 0x06, 0x00, 0x01,
  0xFF, 0xC0, 0xC0, 0x00, 0xFF, 0xFC, 0x38, 0x00, 0x3E, 0x01, 0xC7, 0x00,
  0x0F, 0x00, 0x1C, 0xE0, 0x03, 0xC0, 0x01, 0x98, 0x00, 0xF0, 0x00, 0x1B,
  0x00, 0x1C, 0x00, 0x03, 0xE0, 0x07, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x7C,
  0x01, 0xC0, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x03, 0xE0, 0x07, 0x00, 0x00,
  0xFC, 0x00, 0x70, 0x00, 0x3B, 0x80, 0x0E, 0x00, 0x0E, 0x70, 0x01, 0xE0,
  0x03, 0xCC, 0x00, 0x1C, 0x00, 0xF1, 0x80, 0x01, 0xE0, 0x7C, 0x30, 0x00,
  0x3F, 0xFE, 0x0E, 0x00, 0x01, 0xFF, 0x81, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0xF0, 0x1E, 0x00, 0xF0, 0x01, 0xC0, 0x78, 0x00, 0x70, 0x1C, 0x00, 0x0C,
  0x0E, 0x00, 0x03, 0x07, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x30, 0xE0, 0x00,
  0x1C, 0x30, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x86, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x70, 0xE0, 0x00, 0x78, 0x30, 0x00, 0x3C, 0x1C, 0x00, 0x7E, 0x07,
  0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x20, 0x0F, 0x00,
  0x78, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFC,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x08, 0x7C, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0xC0, 0x03, 0xFF, 0xF0, 0x60,
  0x03, 0xE0, 0x1C, 0x30, 0x03, 0xC0, 0x07, 0x38, 0x03, 0xC0, 0x01, 0x98,
  0x03, 0xC0, 0x00, 0x6C, 0x01, 0xC0, 0x00, 0x36, 0x01, 0xC0, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x3C, 0x07, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1F, 0x01, 0xC0,
  0x00, 0x1F, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x70, 0x00, 0x0F, 0xC0, 0x1C,
  0x00, 0x0E, 0xE0, 0x0E, 0x00, 0x0E, 0x70, 0x07, 0x00, 0x0F, 0x30, 0x01,
  0xC0, 0x0F, 0x38, 0x00, 0xF8, 0x1F, 0x1C, 0x00, 0x3F, 0xFE, 0x0E, 0x00,
  0x07, 0xFE, 0x06, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x10, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xC0, 0x1F, 0x00, 0x03, 0x03, 0xFF, 0x80, 0x1C, 0x3F,
  0xFF, 0x00, 0x71, 0xE0, 0x3C, 0x01, 0x8E, 0x00, 0x38, 0x06, 0x70, 0x00,
  0xE0, 0x3B, 0x80, 0x01, 0xC0, 0xFC, 0x00, 0x07, 0x03, 0x60, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x06, 0x07,
  0x80, 0x00, 0x18, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x03, 0x81, 0x80, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x08, 0x7C,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00,
  0x1C, 0x00, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x80, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x18, 0x1C,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x71, 0xF0, 0x00,
  0x03, 0x1F, 0x80, 0x00, 0x19, 0xDC, 0x00, 0x01, 0xCC, 0x70, 0x00, 0x0E,
  0xC3, 0x80, 0x00, 0x7C, 0x1C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1C, 0x03,
  0x80, 0x01, 0xC0, 0x0C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x03, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xC3, 0xFF, 0xC0, 0x7F, 0xFC,
  0x01, 0x8F, 0x01, 0xE0, 0xF0, 0x1E, 0x01, 0x9C, 0x00, 0xE1, 0xC0, 0x0E,
  0x01, 0x98, 0x00, 0x73, 0x80, 0x07, 0x03, 0xB0, 0x00, 0x77, 0x00, 0x07,
  0x03, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x03, 0x60, 0x00, 0x7C, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x07, 0x03, 0xFF, 0x80, 0x1C, 0x3F, 0xFF, 0x00,
  0x61, 0xE0, 0x3E, 0x01, 0x8E, 0x00, 0x38, 0x06, 0x70, 0x00, 0xE0, 0x3B,
  0x80, 0x01, 0xC0, 0xFC, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x1C, 0x0F, 0x00,
  0x00, 0x70, 0x3C, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x06, 0x07, 0x80, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x30, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x03,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x78, 0x0F, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38,
  0x78, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x03, 0x9E, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xF0, 0x0F, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0x81, 0xFF,
  0x80, 0x00, 0x70, 0xFF, 0xFC, 0x00, 0x0C, 0x3C, 0x07, 0x80, 0x01, 0x8E,
  0x00, 0x38, 0x00, 0x33, 0x80, 0x07, 0x80, 0x0E, 0xE0, 0x00, 0x70, 0x01,
  0xD8, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x07, 0xC0, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x3E, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0xE0,
  0x07, 0xC0, 0x00, 0x38, 0x00, 0xD8, 0x00, 0x0F, 0x00, 0x19, 0x80, 0x03,
  0xC0, 0x07, 0x38, 0x00, 0xF0, 0x00, 0xE3, 0x80, 0x7C, 0x00, 0x1C, 0x3F,
  0xFE, 0x00, 0x03, 0x03, 0xFF, 0x80, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x0C, 0x00, 0xFF, 0xFC, 0x18, 0x03, 0xE0, 0x1C,
  0x30, 0x0F, 0x00, 0x1C, 0xE0, 0x3C, 0x00, 0x19, 0x80, 0xF0, 0x00, 0x1B,
  0x01, 0xC0, 0x00, 0x36, 0x07, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x78,
  0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x7C, 0x1C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x0F,
  0xC0, 0x70, 0x00, 0x3B, 0x80, 0xE0, 0x00, 0x67, 0x01, 0xC0, 0x03, 0xCC,
  0x01, 0xC0, 0x0F, 0x38, 0x03, 0xE0, 0x3C, 0x70, 0x03, 0xFF, 0xE0, 0xE0,
  0x01, 0xFF, 0x81, 0x80, 0x00, 0x70, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0xC1, 0xFF, 0x01, 0xC3, 0xFE, 0x01, 0x87, 0x80, 0x01, 0x8E,
  0x00, 0x01, 0x9C, 0x00, 0x03, 0xB8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0x60,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x03, 0xC0, 0x0F, 0x01, 0xC0, 0x00, 0x80,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x03, 0x00, 0x03, 0xC0, 0xF8, 0x03, 0xE0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x1F, 0xFF, 0xF7, 0xFF, 0xFC, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x20, 0x1F, 0xF8,
  0x03, 0xFE, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x70, 0x30, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x18,
  0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0x80, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0x00,
  0x00, 0x1C, 0x0C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x78, 0x38, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x01,
  0xF0, 0x38, 0x00, 0x0D, 0xC0, 0xE0, 0x00, 0x76, 0x01, 0xC0, 0x03, 0x98,
  0x07, 0x00, 0x1C, 0x60, 0x1F, 0x01, 0xE3, 0x80, 0x3F, 0xFF, 0x0E, 0x00,
  0x3F, 0xF0, 0x30, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07,
  0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x70, 0x60, 0x00,
  0x1C, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0x70,
  0x00, 0x70, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0x00,
  0x70, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x38, 0x00, 0xC0, 0x1C,
  0x00, 0x30, 0x06, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x00, 0xE0,
  0x70, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x06, 0x38, 0x00, 0x01, 0x9C, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xEE, 0x00,
  0x03, 0xC0, 0x00, 0x33, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0x38, 0x00, 0x1B, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0xE0, 0x00,
  0xE3, 0x80, 0x03, 0xB8, 0x00, 0x70, 0xE0, 0x00, 0xCE, 0x00, 0x1C, 0x38,
  0x00, 0x73, 0x80, 0x06, 0x06, 0x00, 0x18, 0xE0, 0x03, 0x81, 0x80, 0x0E,
  0x38, 0x00, 0xC0, 0x60, 0x03, 0x0E, 0x00, 0x70, 0x18, 0x01, 0xC1, 0x80,
  0x1C, 0x06, 0x00, 0x60, 0x60, 0x0E, 0x01, 0x80, 0x38, 0x18, 0x03, 0x80,
  0x60, 0x0C, 0x06, 0x01, 0xC0, 0x18, 0x07, 0x01, 0x80, 0x70, 0x06, 0x01,
  0xC0, 0x60, 0x18, 0x01, 0x80, 0xE0, 0x18, 0x0E, 0x00, 0x60, 0x38, 0x06,
  0x03, 0x00, 0x18, 0x1C, 0x01, 0x81, 0xC0, 0x06, 0x07, 0x00, 0x60, 0x70,
  0x01, 0x83, 0x80, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x1C,
  0x30, 0x01, 0xC3, 0x00, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x01, 0xC6, 0x00,
  0x1C, 0x60, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x1C, 0xC0, 0x01, 0xCC,
  0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x01, 0xD8, 0x00, 0x1D, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0x60, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x18, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x03, 0x80, 0x07, 0x00, 0x03,
  0xC0, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x30,
  0xF0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x03,
  0x70, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70,
  0x07, 0x80, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00,
  0x18, 0x07, 0x00, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x38,
  0x00, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00,
  0x00, 0x33, 0x80, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x00, 0xDC,
  0x00, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x08, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x17, 0xFF, 0xF0, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xE0, 0x01, 0xFF, 0xFA, 0x00, 0x01, 0xFF, 0xC8, 0x00, 0x01, 0xFC,
  0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 14, 52, 16, 2, -51 },
  { 92, 16, 18, 22, 8, -51 },
  { 128, 37, 51, 38, 2, -51 },
  { 364, 31, 59, 34, 2, -55 },
  { 593, 41, 53, 49, 5, -52 },
  { 865, 36, 53, 40, 2, -52 },
  { 1104, 6, 18, 12, 8, -51 },
  { 1118, 21, 62, 18, 2, -51 },
  { 1281, 21, 62, 18, -5, -51 },
  { 1444, 25, 27, 33, 9, -55 },
  { 1529, 30, 33, 37, 4, -42 },
  { 1653, 10, 17, 13, -3, -8 },
  { 1675, 17, 3, 21, 2, -21 },
  { 1682, 4, 6, 14, 2, -5 },
  { 1685, 31, 51, 22, -3, -51 },
  { 1883, 30, 53, 34, 3, -52 },
  { 2082, 17, 51, 34, 10, -51 },
  { 2191, 34, 52, 34, -1, -52 },
  { 2412, 33, 53, 34, 0, -52 },
  { 2631, 33, 52, 34, 0, -52 },
  { 2846, 33, 52, 34, 1, -51 },
  { 3061, 31, 53, 34, 4, -52 },
  { 3267, 30, 51, 34, 6, -51 },
  { 3459, 32, 53, 34, 2, -52 },
  { 3671, 31, 53, 34, 2, -52 },
  { 3877, 12, 39, 14, 1, -38 },
  { 3936, 16, 47, 14, -3, -38 },
  { 4030, 30, 32, 37, 4, -42 },
  { 4150, 30, 17, 37, 4, -34 },
  { 4214, 30, 32, 37, 4, -42 },
  { 4334, 23, 53, 25, 4, -52 },
  { 4487, 47, 57, 52, 3, -51 },
  { 4822, 34, 52, 34, -4, -52 },
  { 5043, 35, 51, 37, 2, -51 },
  { 5267, 35, 53, 36, 5, -52 },
  { 5499, 38, 51, 42, 2, -51 },
  { 5742, 34, 51, 33, 2, -51 },
  { 5959, 34, 51, 31, 2, -51 },
  { 6176, 38, 53, 43, 5, -52 },
  { 6428, 41, 51, 43, 2, -51 },
  { 6690, 23, 51, 18, -1, -51 },
  { 6837, 27, 64, 15, -11, -51 },
  { 7053, 38, 51, 34, 2, -51 },
  { 7296, 23, 51, 30, 2, -51 },
  { 7443, 51, 51, 53, 2, -51 },
  { 7769, 42, 51, 43, 2, -51 },
  { 8037, 37, 53, 45, 5, -52 },
  { 8283, 34, 51, 35, 2, -51 },
  { 8500, 37, 64, 45, 5, -52 },
  { 8796, 34, 51, 36, 2, -51 },
  { 9013, 33, 53, 32, 0, -52 },
  { 9232, 30, 51, 30, 6, -51 },
  { 9424, 39, 52, 43, 5, -51 },
  { 9678, 33, 51, 34, 7, -51 },
  { 9889, 51, 51, 54, 8, -51 },
  { 10215, 40, 51, 31, -4, -51 },
  { 10470, 30, 51, 30, 7, -51 },
  { 10662, 38, 51, 33, -2, -51 },
  { 10905, 27, 62, 21, -1, -51 },
  { 11115, 11, 51, 23, 7, -51 },
  { 11186, 27, 62, 21, -5, -51 },
  { 11396, 30, 30, 36, 3, -52 },
  { 11509, 25, 3, 24, -6, 7 },
  { 11519, 8, 11, 16, 11, -55 },
  { 11530, 31, 40, 35, 3, -39 },
  { 11685, 31, 56, 36, 2, -55 },
  { 11902, 26, 40, 28, 3, -39 },
  { 12032, 35, 56, 36, 3, -55 },
  { 12277, 26, 40, 31, 3, -39 },
  { 12407, 36, 72, 18, -9, -55 },
  { 12731, 33, 56, 36, 1, -39 },
  { 12962, 30, 55, 35, 2, -55 },
  { 13169, 14, 52, 14, 2, -52 },
  { 13260, 26, 69, 14, -10, -52 },
  { 13485, 29, 55, 29, 2, -55 },
  { 13685, 14, 55, 14, 2, -55 },
  { 13782, 48, 39, 53, 2, -39 },
  { 14016, 30, 39, 35, 2, -39 },
  { 14163, 29, 40, 36, 3, -39 },
  { 14308, 35, 56, 36, -2, -39 },
  { 14553, 31, 56, 36, 3, -39 },
  { 14770, 24, 39, 24, 2, -39 },
  { 14887, 26, 40, 27, 0, -39 },
  { 15017, 18, 48, 19, 3, -47 },
  { 15125, 30, 39, 35, 3, -38 },
  { 15272, 26, 38, 27, 4, -38 },
  { 15396, 42, 38, 43, 4, -38 },
  { 15596, 33, 38, 29, -3, -38 },
  { 15753, 39, 55, 27, -8, -38 },
  { 16022, 29, 38, 26, -2, -38 },
  { 16160, 26, 62, 23, 2, -51 },
  { 16362, 2, 72, 34, 17, -55 },
  { 16380, 26, 62, 23, -4, -51 },
  { 16582, 30, 7, 37, 4, -29 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic72pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC72PT7B_H_
