#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC61PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x00, 0xE0,
  0x00, 0x1C, 0x0C, 0x70, 0x71, 0x81, 0xC6, 0x06, 0x18, 0x18, 0xE0, 0x63,
  0x03, 0x8C, 0x0C, 0x30, 0x30, 0xC0, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x61,
  0x81, 0x84, 0x06, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x0C, 0x01,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x03,
  0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x70, 0x06,
  0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x38, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0xC0,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x03, 0xE3, 0x0F, 0x01, 0xE0, 0xC0, 0x80, 0x60, 0x20, 0x00, 0x38, 0x18,
  0x00, 0x1C, 0x06, 0x00, 0x07, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60,
  0x10, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x30, 0x30, 0x00, 0x0E, 0x18, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x3D, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xDE, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x08, 0x38, 0x00,
  0x06, 0x07, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C,
  0x00, 0x04, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x70, 0x00, 0x30,
  0x18, 0x00, 0x0C, 0x0E, 0x00, 0x06, 0x07, 0x02, 0x01, 0x83, 0x80, 0xF0,
  0x63, 0xC0, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0x80, 0x7F, 0xC0, 0x00, 0x60, 0x1C, 0x1C, 0x00, 0x1C, 0x03, 0x01, 0x80,
  0x03, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x38, 0x06, 0x00, 0x38, 0x06, 0x00,
  0xC0, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x38, 0x01, 0x80, 0xE0,
  0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x06, 0x07, 0x00, 0x18, 0x01, 0x80,
  0xC0, 0x03, 0x00, 0x30, 0x30, 0x00, 0xE0, 0x06, 0x0E, 0x00, 0x1C, 0x00,
  0xC1, 0x80, 0xC3, 0x80, 0x30, 0x60, 0xFE, 0x60, 0x06, 0x1C, 0x3D, 0xEC,
  0x01, 0xC3, 0x0C, 0x0D, 0xC0, 0x30, 0xC3, 0x01, 0xD8, 0x0E, 0x38, 0xE0,
  0x1B, 0x03, 0x86, 0x18, 0x03, 0x70, 0xE1, 0x87, 0x00, 0x67, 0xF8, 0x70,
  0xC0, 0x0C, 0x7E, 0x0C, 0x18, 0x01, 0x80, 0x03, 0x06, 0x00, 0x30, 0x00,
  0xE0, 0xC0, 0x0E, 0x00, 0x18, 0x18, 0x01, 0x80, 0x06, 0x07, 0x00, 0x30,
  0x01, 0xC0, 0xE0, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x0C, 0x03, 0x00,
  0x38, 0x01, 0x80, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x1C, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x38,
  0x00, 0xC0, 0x30, 0x06, 0x00, 0x18, 0x0E, 0x01, 0x80, 0x03, 0x83, 0x80,
  0x70, 0x00, 0x3C, 0xE0, 0x1C, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x70, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x06, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x07, 0x00, 0x30, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0x18, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x31, 0xE0, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x81,
  0x80, 0x06, 0x0E, 0x03, 0x80, 0x1C, 0x38, 0x03, 0x00, 0x30, 0xE0, 0x07,
  0x00, 0xE3, 0x80, 0x06, 0x01, 0x86, 0x00, 0x0E, 0x07, 0x1C, 0x00, 0x0E,
  0x0C, 0x30, 0x00, 0x0C, 0x38, 0x60, 0x00, 0x1C, 0x60, 0xC0, 0x00, 0x19,
  0x83, 0x80, 0x00, 0x3F, 0x07, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x70,
  0x0C, 0x00, 0x01, 0xE0, 0x18, 0x00, 0x07, 0xE0, 0x38, 0x00, 0x1C, 0xE0,
  0x38, 0x00, 0x71, 0xC0, 0x78, 0x03, 0xC1, 0xC0, 0x7F, 0xFE, 0x01, 0x80,
  0x3F, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x71, 0x86, 0x18,
  0xE3, 0x0C, 0x30, 0xC6, 0x18, 0x61, 0x84, 0x30, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x01,
  0x00, 0x60, 0x0F, 0x01, 0x80, 0x1F, 0x04, 0x00, 0x1E, 0x10, 0x00, 0x1E,
  0xC0, 0x70, 0x1F, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x70, 0x00, 0x07, 0x60,
  0x00, 0x39, 0x80, 0x01, 0xC3, 0x00, 0x0E, 0x0C, 0x00, 0x70, 0x18, 0x07,
  0x80, 0x60, 0x0C, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x81, 0xC0,
  0xC0, 0xE0, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x03, 0x03,
  0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x77, 0xF7, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0x07,
  0x80, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x18, 0x0E, 0x00,
  0x0E, 0x06, 0x00, 0x03, 0x07, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x0C, 0x60,
  0x00, 0x06, 0x70, 0x00, 0x03, 0x38, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x07, 0x70, 0x00, 0x03,
  0xB8, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x18, 0x60, 0x00,
  0x1C, 0x30, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x07, 0x00,
  0x07, 0x01, 0x80, 0x03, 0x00, 0xE0, 0x03, 0x80, 0x30, 0x03, 0x80, 0x1E,
  0x07, 0x80, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x76, 0x03, 0x98, 0x3C, 0xE1, 0xC3,
  0x1E, 0x0C, 0xF0, 0x33, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x3E, 0x07, 0x80, 0x07, 0x80, 0x1C, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3E,
  0x03, 0xC0, 0x0F, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x60, 0x08, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x47, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x80,
  0x00, 0x78, 0x0F, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x0C, 0x18, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x38, 0x18, 0x00, 0x03, 0x03, 0x80, 0x00, 0x60,
  0x38, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x38, 0x03, 0x00,
  0x03, 0x00, 0x70, 0x00, 0x60, 0x06, 0x00, 0x0E, 0x00, 0x60, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0E, 0x00, 0x60, 0x00, 0xC0,
  0x0E, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x1C, 0x03, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x18, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x7F, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x80,
  0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x78, 0x04, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x07, 0xE0, 0x03, 0x87, 0xFE, 0x00, 0xC7, 0x83, 0xC0, 0x33, 0x80,
  0x38, 0x1D, 0x80, 0x07, 0x07, 0xC0, 0x00, 0xC1, 0xE0, 0x00, 0x38, 0x70,
  0x00, 0x06, 0x1C, 0x00, 0x01, 0x86, 0x00, 0x00, 0x63, 0x80, 0x00, 0x18,
  0xE0, 0x00, 0x06, 0x38, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x60, 0xE0, 0x00, 0x38, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x07, 0x01,
  0xC0, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xF0, 0x3C,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x01, 0x80, 0x60,
  0x00, 0x38, 0x0C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x1C,
  0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x07, 0x00,
  0x03, 0x80, 0x60, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x0E, 0x00,
  0x1C, 0x03, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x07,
  0x80, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x00, 0x60, 0x1C, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x86, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x38, 0x00,
  0x07, 0x03, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0x81, 0xE0, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x03, 0x00, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x06,
  0x06, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x0C, 0x30, 0x00,
  0x03, 0x1C, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x1C, 0x60,
  0x00, 0x07, 0x18, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x71, 0x80, 0x00, 0x38,
  0x60, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x83, 0x00, 0x03, 0x60, 0xE0, 0x01,
  0xF8, 0x3C, 0x00, 0xEC, 0x07, 0x80, 0xF3, 0x00, 0xFF, 0xF0, 0xC0, 0x0F,
  0xF0, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x20,
  0x0F, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x70, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF,
  0xF8, 0x1F, 0x03, 0xC0, 0x80, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x06, 0x0E, 0x00,
  0x0F, 0xF0, 0x06, 0x0C, 0x00, 0x3F, 0xFC, 0x07, 0x1C, 0x00, 0xF0, 0x18,
  0x07, 0x18, 0x01, 0xC0, 0x18, 0x07, 0x38, 0x03, 0x80, 0x38, 0x07, 0x30,
  0x03, 0x00, 0x30, 0x07, 0x30, 0x06, 0x00, 0x30, 0x07, 0x70, 0x0E, 0x00,
  0x30, 0x06, 0x60, 0x0C, 0x00, 0x70, 0x06, 0x60, 0x1C, 0x00, 0x60, 0x06,
  0x60, 0x18, 0x00, 0x60, 0x06, 0xE0, 0x18, 0x00, 0x60, 0x06, 0xC0, 0x38,
  0x00, 0xE0, 0x0C, 0xC0, 0x30, 0x00, 0xC0, 0x0C, 0xC0, 0x30, 0x00, 0xC0,
  0x0C, 0xC0, 0x30, 0x01, 0xC0, 0x18, 0xC0, 0x30, 0x01, 0xC0, 0x18, 0xC0,
  0x30, 0x03, 0x80, 0x38, 0xC0, 0x30, 0x03, 0x80, 0x30, 0xC0, 0x30, 0x06,
  0x80, 0x60, 0xC0, 0x38, 0x0C, 0xC0, 0xE0, 0xC0, 0x18, 0x1C, 0xC1, 0xC0,
  0xC0, 0x1F, 0xF8, 0xFF, 0x80, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x07, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x70, 0x18, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x38, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x1C, 0x01, 0x80, 0x00,
  0xC0, 0x0C, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x60, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x00, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x30, 0x0E,
  0x00, 0x01, 0x80, 0x70, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x70,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x01, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x60, 0x00, 0x1C,
  0x03, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x18, 0x0E,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x18, 0x0E, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x0C,
  0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x38, 0x01,
  0xF0, 0x01, 0xC0, 0x01, 0xE0, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x1C,
  0x03, 0x00, 0x00, 0x60, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03, 0x81, 0x80, 0x00, 0x38, 0x0C,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x78, 0x07, 0x00, 0x1F, 0x80, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFC, 0x03, 0xC0, 0x07, 0x80, 0x02, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x20, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xE0, 0x03, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x0E, 0x01,
  0x80, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x06, 0x03, 0x80, 0x00, 0x07, 0x03, 0x00, 0x00, 0x07, 0x03,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x0F, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x60,
  0x01, 0xF0, 0x00, 0xE0, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0xF8, 0xE0, 0x00, 0x7F, 0xF8, 0xE0,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0xC0, 0x1C,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0C, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x30,
  0x07, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00,
  0x38, 0x03, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x1C, 0x00,
  0x00, 0x18, 0x03, 0x80, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x77, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x60, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0xC0,
  0x03, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0x80,
  0x1C, 0x00, 0x01, 0x80, 0x38, 0x00, 0x01, 0x80, 0x70, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x03, 0x07,
  0x80, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x06, 0x3C,
  0x00, 0x00, 0x06, 0x7C, 0x00, 0x00, 0x06, 0x6E, 0x00, 0x00, 0x0E, 0xC6,
  0x00, 0x00, 0x0F, 0x87, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x60, 0x00, 0x18, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x0D, 0x80, 0x00,
  0x00, 0x7C, 0x01, 0xB0, 0x00, 0x00, 0x0D, 0x80, 0x36, 0x00, 0x00, 0x03,
  0xF0, 0x06, 0xC0, 0x00, 0x00, 0xEE, 0x01, 0xD8, 0x00, 0x00, 0x19, 0x80,
  0x33, 0x80, 0x00, 0x07, 0x30, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00, 0xC6,
  0x00, 0x00, 0x39, 0xC0, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x07, 0x18, 0x00,
  0x01, 0xC6, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x18, 0x60, 0x00, 0x0E,
  0x18, 0x03, 0x0C, 0x00, 0x01, 0x87, 0x00, 0xE1, 0xC0, 0x00, 0x60, 0xC0,
  0x1C, 0x18, 0x00, 0x1C, 0x18, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x60,
  0x60, 0x00, 0xE0, 0xE0, 0x0C, 0x0C, 0x00, 0x18, 0x1C, 0x03, 0x81, 0x80,
  0x07, 0x03, 0x00, 0x70, 0x30, 0x00, 0xC0, 0x60, 0x0C, 0x06, 0x00, 0x38,
  0x0C, 0x01, 0x80, 0xE0, 0x06, 0x03, 0x80, 0x30, 0x0C, 0x01, 0xC0, 0x70,
  0x0E, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x60, 0x0E, 0x00, 0xC0, 0x18,
  0x1C, 0x01, 0x80, 0x38, 0x03, 0x03, 0x00, 0x30, 0x06, 0x00, 0x70, 0xE0,
  0x06, 0x00, 0xC0, 0x06, 0x18, 0x01, 0xC0, 0x18, 0x00, 0xC7, 0x00, 0x38,
  0x07, 0x00, 0x18, 0xC0, 0x06, 0x00, 0xE0, 0x03, 0x38, 0x00, 0xC0, 0x18,
  0x00, 0x66, 0x00, 0x18, 0x03, 0x00, 0x0D, 0x80, 0x07, 0x00, 0x60, 0x01,
  0xF0, 0x00, 0xE0, 0x1C, 0x00, 0x3C, 0x00, 0x18, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x0E, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x78, 0x00,
  0x00, 0x60, 0x0F, 0x80, 0x00, 0x0C, 0x01, 0xB0, 0x00, 0x01, 0x80, 0x36,
  0x00, 0x00, 0x70, 0x06, 0xE0, 0x00, 0x0E, 0x01, 0xCC, 0x00, 0x01, 0x80,
  0x31, 0x80, 0x00, 0x30, 0x06, 0x38, 0x00, 0x06, 0x00, 0xC3, 0x00, 0x01,
  0xC0, 0x18, 0x60, 0x00, 0x38, 0x07, 0x0E, 0x00, 0x06, 0x00, 0xC0, 0xC0,
  0x00, 0xC0, 0x18, 0x18, 0x00, 0x18, 0x03, 0x03, 0x80, 0x07, 0x00, 0xE0,
  0x30, 0x00, 0xC0, 0x1C, 0x06, 0x00, 0x18, 0x03, 0x00, 0xE0, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x1C, 0x03, 0x80, 0x38, 0x03,
  0x00, 0x70, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x0E,
  0x03, 0x80, 0x30, 0x00, 0xC0, 0x70, 0x0E, 0x00, 0x18, 0x0C, 0x01, 0xC0,
  0x03, 0x81, 0x80, 0x30, 0x00, 0x30, 0x30, 0x06, 0x00, 0x06, 0x0E, 0x00,
  0xC0, 0x00, 0xE1, 0xC0, 0x38, 0x00, 0x0C, 0x30, 0x06, 0x00, 0x01, 0x86,
  0x00, 0xC0, 0x00, 0x38, 0xC0, 0x18, 0x00, 0x03, 0x38, 0x07, 0x00, 0x00,
  0x66, 0x00, 0xE0, 0x00, 0x0E, 0xC0, 0x18, 0x00, 0x00, 0xD8, 0x03, 0x00,
  0x00, 0x1B, 0x00, 0x60, 0x00, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0xE0, 0x01, 0xC0, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30,
  0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x38, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x70, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x70, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x70, 0x0E, 0x00, 0x1E, 0x00, 0xE0, 0x7F, 0x80, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x01, 0x80, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xE0, 0x01,
  0xE0, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70,
  0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x38, 0x06, 0x00, 0x07, 0x00, 0x60, 0x01, 0xE0,
  0x0E, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xC0,
  0x18, 0x00, 0x0C, 0x01, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x1C, 0x00, 0xC0,
  0x01, 0x80, 0x0E, 0x00, 0x18, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0x60, 0x03, 0x80, 0x07, 0x00, 0x30, 0x00, 0x30, 0x03, 0x00, 0x03,
  0x00, 0x70, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x60, 0x00, 0x18, 0x06,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x02, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x30, 0x07, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x1C, 0x06, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x38, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x70, 0x06,
  0x00, 0x06, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0x30, 0x03, 0x80, 0x03, 0x00, 0x30, 0x00,
  0x30, 0x07, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x30, 0x1C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x38, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x86, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x60, 0x00, 0x0F, 0x00, 0x00, 0xEC, 0x00, 0x03, 0xE0, 0x00,
  0x19, 0x80, 0x00, 0x6C, 0x00, 0x07, 0x30, 0x00, 0x0D, 0x80, 0x00, 0xC6,
  0x00, 0x03, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x66, 0x00, 0x07, 0x18, 0x00,
  0x1C, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x18, 0x00, 0x38, 0x60, 0x00, 0xE3,
  0x00, 0x06, 0x0C, 0x00, 0x18, 0x60, 0x01, 0xC1, 0x80, 0x07, 0x0C, 0x00,
  0x30, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x06, 0x00, 0x18, 0x30, 0x01, 0xC0,
  0xC0, 0x06, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0xC0, 0x0E, 0x03, 0x00,
  0x38, 0x18, 0x01, 0x80, 0x60, 0x06, 0x03, 0x00, 0x70, 0x0C, 0x01, 0xC0,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80,
  0x60, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x00, 0xC0, 0x70, 0x06, 0x03, 0x80,
  0x18, 0x0C, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x18, 0x1C, 0x00, 0x60,
  0x60, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x01, 0xC3, 0x80,
  0x0C, 0x18, 0x00, 0x38, 0x60, 0x01, 0x83, 0x00, 0x07, 0x1C, 0x00, 0x30,
  0xE0, 0x00, 0xE3, 0x00, 0x06, 0x18, 0x00, 0x1C, 0xE0, 0x00, 0xC7, 0x00,
  0x03, 0x98, 0x00, 0x18, 0xC0, 0x00, 0x73, 0x00, 0x03, 0x18, 0x00, 0x0E,
  0xC0, 0x00, 0x66, 0x00, 0x01, 0xD8, 0x00, 0x0C, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xB8, 0x00, 0x03, 0xC0, 0x00, 0x36, 0x00, 0x00, 0x78, 0x00, 0x02,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x30, 0x00, 0x06, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x03, 0x80, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x19,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x70, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x38, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xCE, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x70,
  0x18, 0x00, 0x30, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x38, 0x03, 0x80, 0x18,
  0x01, 0xC0, 0x1C, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x0E,
  0x00, 0x0E, 0x06, 0x00, 0x03, 0x07, 0x00, 0x01, 0x87, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x07, 0x60, 0x00, 0x03, 0x98, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x07, 0x01, 0x80,
  0x01, 0x80, 0x70, 0x00, 0xE0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00,
  0xE0, 0x0E, 0x00, 0x18, 0x03, 0x00, 0x06, 0x01, 0xC0, 0x01, 0xC0, 0xE0,
  0x00, 0x30, 0x30, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x86, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x19, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xC1, 0xC1, 0x83, 0x83, 0x07, 0x06, 0x06, 0x0C,
  0x0C, 0x00, 0x0F, 0x80, 0x40, 0x1F, 0xF8, 0x60, 0x0F, 0x8F, 0x18, 0x07,
  0x00, 0xE6, 0x03, 0x80, 0x19, 0x81, 0xC0, 0x03, 0xE0, 0xE0, 0x00, 0xF0,
  0x30, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x06, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x70, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x06, 0x18, 0x00, 0x03, 0x86, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0E,
  0x0C, 0x00, 0x03, 0x83, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x78, 0x30, 0x00,
  0x3C, 0x0C, 0x00, 0x0F, 0x03, 0x80, 0x06, 0xC0, 0xE0, 0x03, 0x30, 0x1C,
  0x01, 0x98, 0x07, 0x80, 0xC6, 0x00, 0xFF, 0xE1, 0x80, 0x1F, 0xF0, 0x60,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x01, 0xF0, 0x00, 0x60, 0xFF, 0x80, 0x0C, 0x78, 0x78, 0x01, 0x9C,
  0x03, 0x80, 0x77, 0x00, 0x38, 0x0D, 0xC0, 0x03, 0x01, 0xB0, 0x00, 0x60,
  0x3C, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x18, 0x38, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x0E, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x0E, 0x18, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x06, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x30, 0x70, 0x00, 0x0E,
  0x0E, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x70, 0x7C, 0x00, 0x1C, 0x0D, 0x80,
  0x07, 0x01, 0x98, 0x01, 0xE0, 0x33, 0x80, 0x78, 0x06, 0x3E, 0xFC, 0x01,
  0x83, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0xF0, 0x0F, 0x83, 0x80, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x10, 0x07, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xC0, 0x60, 0x01, 0xFF, 0x83, 0x00,
  0x1F, 0x0F, 0x38, 0x01, 0xC0, 0x19, 0xC0, 0x1C, 0x00, 0x6C, 0x01, 0xC0,
  0x03, 0x60, 0x1C, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x38, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x0E, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x07, 0x03, 0x00, 0x00, 0x38, 0x18, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x78, 0x0C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x3C, 0x03, 0x00,
  0x01, 0xE0, 0x18, 0x00, 0x1B, 0x00, 0xE0, 0x01, 0xB0, 0x07, 0x00, 0x1D,
  0x80, 0x1C, 0x01, 0xCC, 0x00, 0xF0, 0x1C, 0x60, 0x03, 0xFF, 0xC3, 0x00,
  0x0F, 0xF8, 0x30, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0xC0, 0x0F, 0x87, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x1C, 0x1C, 0x00,
  0x70, 0xE0, 0x00, 0xC3, 0x00, 0x03, 0x1C, 0x00, 0x1C, 0x60, 0x00, 0x73,
  0x80, 0x01, 0x8C, 0x00, 0x0E, 0x70, 0x00, 0x71, 0x80, 0x07, 0x86, 0x00,
  0x7C, 0x18, 0x7F, 0xC0, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x18, 0x07, 0xF7, 0xE0,
  0x07, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFF, 0x83, 0x00, 0x3E, 0x1E, 0x30, 0x07, 0x00, 0x63, 0x00, 0xE0, 0x03,
  0x60, 0x1C, 0x00, 0x36, 0x03, 0x80, 0x01, 0xE0, 0x30, 0x00, 0x1E, 0x07,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x1C, 0x1C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x83,
  0x80, 0x00, 0x18, 0x38, 0x00, 0x03, 0x83, 0x00, 0x00, 0x38, 0x30, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x70, 0x30, 0x00, 0x07, 0x03, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x0F, 0x03, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x1E, 0x03, 0x00,
  0x03, 0xE0, 0x30, 0x00, 0x36, 0x03, 0x80, 0x07, 0xC0, 0x38, 0x00, 0xEC,
  0x01, 0xC0, 0x1C, 0xC0, 0x1E, 0x03, 0x8C, 0x00, 0xFF, 0xF1, 0xC0, 0x07,
  0xFC, 0x18, 0x00, 0x04, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x08, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x3F, 0x00, 0x18, 0x3F, 0xF0, 0x06, 0x3E, 0x3E, 0x01,
  0x9C, 0x03, 0x80, 0xEC, 0x00, 0x60, 0x36, 0x00, 0x1C, 0x0D, 0x00, 0x07,
  0x03, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x1C, 0x1C, 0x00,
  0x06, 0x07, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x18, 0x38,
  0x00, 0x0E, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30,
  0x70, 0x00, 0x0C, 0x1C, 0x00, 0x07, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x60, 0x60, 0x00, 0x18, 0x38, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x83, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x0C, 0x1C, 0x00, 0x07, 0x06,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x38, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x10, 0x18, 0x00, 0x38, 0x06, 0x00, 0x1C, 0x01, 0x80,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x0C, 0x01, 0xC0, 0x03,
  0x00, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x18, 0x00, 0x18, 0x0C, 0x00,
  0x06, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x30, 0xE0,
  0x00, 0x0C, 0x78, 0x00, 0x03, 0x37, 0x00, 0x00, 0xD8, 0xC0, 0x00, 0x7C,
  0x30, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00,
  0xE0, 0x1C, 0x00, 0x38, 0x03, 0x00, 0x0C, 0x00, 0xE0, 0x03, 0x00, 0x38,
  0x00, 0xC0, 0x06, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x30, 0x06, 0x00,
  0x0C, 0x01, 0x80, 0x03, 0x80, 0x60, 0x00, 0x60, 0x38, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xC3, 0xFE, 0x01, 0xFF, 0x00, 0x63, 0xC7, 0x83, 0xC3,
  0xC0, 0x33, 0x00, 0xE3, 0x80, 0x70, 0x33, 0x00, 0x33, 0x80, 0x38, 0x1B,
  0x00, 0x1B, 0x80, 0x0C, 0x0F, 0x00, 0x0D, 0x80, 0x06, 0x07, 0x80, 0x07,
  0x80, 0x03, 0x03, 0x80, 0x03, 0xC0, 0x01, 0x83, 0x80, 0x01, 0xC0, 0x00,
  0xC1, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x60,
  0x00, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x00, 0x18, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x00, 0x07,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x07, 0x00, 0x03, 0x80, 0x01, 0x83, 0x80,
  0x01, 0x80, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x60, 0x00, 0x70, 0x00, 0x30, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x0C, 0x00,
  0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x07, 0x00, 0x03, 0x00,
  0x01, 0x83, 0x00, 0x01, 0x80, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0x00, 0xE0,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x60, 0xFF, 0xC0, 0x18, 0xF8, 0xF8, 0x06, 0x70, 0x0E,
  0x03, 0x30, 0x01, 0xC0, 0xD8, 0x00, 0x70, 0x36, 0x00, 0x1C, 0x0F, 0x00,
  0x07, 0x07, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C,
  0x00, 0x06, 0x06, 0x00, 0x01, 0x83, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x38,
  0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC1, 0xC0, 0x00,
  0x70, 0x70, 0x00, 0x1C, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x83, 0x80,
  0x00, 0x60, 0xE0, 0x00, 0x38, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x03,
  0x00, 0x00, 0xC1, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x1C, 0x18, 0x00, 0x07,
  0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xF8, 0x78, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x0E, 0x07, 0x00, 0x06, 0x0E, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x1C,
  0x00, 0x03, 0x38, 0x00, 0x03, 0x38, 0x00, 0x03, 0x30, 0x00, 0x03, 0x70,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0,
  0x00, 0x1C, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x70, 0x60,
  0x00, 0xE0, 0x70, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x1F, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xC1, 0xFF,
  0x00, 0x03, 0x1E, 0x1E, 0x00, 0x0C, 0xE0, 0x1C, 0x00, 0x67, 0x00, 0x38,
  0x01, 0xB8, 0x00, 0x60, 0x06, 0xC0, 0x01, 0x80, 0x1E, 0x00, 0x07, 0x00,
  0x78, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x00, 0xC0, 0x38,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x07, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x60, 0x38, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x18, 0x07,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xE0,
  0x00, 0xE0, 0x0F, 0x80, 0x07, 0x00, 0x33, 0x00, 0x3C, 0x00, 0xCE, 0x01,
  0xE0, 0x03, 0x1F, 0x7E, 0x00, 0x1C, 0x3F, 0xF0, 0x00, 0x70, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xF8, 0x30, 0x0F, 0x87, 0x8C,
  0x07, 0x00, 0x63, 0x03, 0x80, 0x0D, 0x81, 0xC0, 0x03, 0x60, 0xE0, 0x00,
  0x78, 0x30, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x86, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x70, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x18, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x63, 0x80, 0x00, 0x18, 0xE0, 0x00, 0x0E, 0x30, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x1C, 0x30, 0x00,
  0x07, 0x0C, 0x00, 0x03, 0xC3, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x78, 0x30,
  0x00, 0x1E, 0x0C, 0x00, 0x0D, 0x83, 0x80, 0x07, 0xC0, 0xE0, 0x03, 0xB0,
  0x1C, 0x01, 0xCC, 0x07, 0x80, 0xE3, 0x00, 0xFF, 0xF1, 0xC0, 0x1F, 0xF0,
  0x60, 0x00, 0x40, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xF8, 0x0C, 0x3F, 0xC0, 0x63, 0xE4, 0x03, 0x38, 0x00, 0x33, 0x80,
  0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0x07, 0xC0, 0xE0,
  0x02, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC2, 0x00, 0x0E,
  0x0E, 0x00, 0x70, 0x3F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x3F, 0xFF, 0x7F, 0xFE, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x06, 0x00, 0x06, 0x00,
  0x01, 0x87, 0x00, 0x00, 0xC3, 0x80, 0x00, 0xE1, 0x80, 0x00, 0x60, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x18, 0x70, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x18,
  0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x87, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x18,
  0x70, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03,
  0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0xE0, 0xC0, 0x00, 0xF0, 0x60, 0x00, 0x58, 0x30, 0x00, 0x7C, 0x18, 0x00,
  0x6C, 0x0E, 0x00, 0x66, 0x03, 0x80, 0xE3, 0x01, 0xFF, 0xE1, 0x80, 0x7F,
  0xC0, 0xC0, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3B,
  0x80, 0x00, 0x63, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x0C, 0x00, 0x0E, 0x18,
  0x00, 0x18, 0x30, 0x00, 0x70, 0x60, 0x00, 0xC0, 0xC0, 0x03, 0x81, 0xC0,
  0x06, 0x03, 0x80, 0x18, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x0C, 0x03,
  0x80, 0x18, 0x06, 0x00, 0x30, 0x1C, 0x00, 0x60, 0x30, 0x00, 0xC0, 0xE0,
  0x01, 0x81, 0x80, 0x03, 0x07, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x38, 0x00,
  0x1C, 0x60, 0x00, 0x19, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0xD8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x3B, 0x00,
  0x07, 0x00, 0x06, 0x60, 0x01, 0xA0, 0x00, 0xCC, 0x00, 0x36, 0x00, 0x39,
  0x80, 0x0C, 0xC0, 0x06, 0x30, 0x01, 0x98, 0x01, 0xC6, 0x00, 0x73, 0x00,
  0x30, 0xC0, 0x0C, 0x60, 0x0E, 0x18, 0x03, 0x8C, 0x01, 0x83, 0x00, 0x61,
  0x80, 0x70, 0x60, 0x1C, 0x30, 0x0C, 0x0C, 0x03, 0x06, 0x01, 0x81, 0x80,
  0x60, 0xC0, 0x70, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x03, 0x80,
  0xC0, 0xC0, 0x60, 0x60, 0x18, 0x18, 0x0C, 0x1C, 0x03, 0x06, 0x01, 0x83,
  0x00, 0x60, 0xC0, 0x30, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x01, 0x86, 0x00,
  0xC3, 0x00, 0x31, 0xC0, 0x18, 0xE0, 0x06, 0x30, 0x03, 0x98, 0x00, 0xCE,
  0x00, 0x77, 0x00, 0x19, 0x80, 0x06, 0xC0, 0x03, 0x70, 0x00, 0xD8, 0x00,
  0x6C, 0x00, 0x1E, 0x00, 0x0D, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0x60, 0x07, 0x00, 0x07, 0x00, 0x60, 0x00, 0x30, 0x0E, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x0E, 0x1C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x60, 0x06, 0x00, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x38, 0x00, 0x30, 0x03, 0x00, 0x03, 0x80, 0x70, 0x00, 0x18, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x06,
  0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x06, 0x00, 0x18, 0x00, 0x03, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC1, 0xC0,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0C, 0x78, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xC0, 0x01, 0xFE,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xA0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0x70, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xBF, 0xFC, 0x00, 0x78, 0x0F,
  0x80, 0xF0, 0x01, 0xFF, 0xE8, 0x00, 0x3F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 13, 44, 13, 1, -44 },
  { 73, 14, 16, 19, 6, -44 },
  { 101, 32, 44, 32, 1, -44 },
  { 277, 26, 50, 29, 2, -46 },
  { 440, 35, 45, 42, 4, -44 },
  { 637, 31, 45, 34, 1, -44 },
  { 812, 6, 16, 10, 6, -44 },
  { 824, 17, 54, 15, 2, -44 },
  { 939, 17, 54, 15, -4, -44 },
  { 1054, 22, 23, 28, 7, -46 },
  { 1118, 25, 29, 31, 4, -36 },
  { 1209, 9, 15, 11, -3, -7 },
  { 1226, 14, 3, 18, 2, -18 },
  { 1232, 4, 4, 12, 1, -4 },
  { 1234, 27, 44, 19, -3, -44 },
  { 1383, 25, 45, 29, 3, -44 },
  { 1524, 14, 44, 29, 9, -44 },
  { 1601, 28, 44, 29, 0, -44 },
  { 1755, 28, 45, 29, 0, -44 },
  { 1913, 28, 44, 29, 0, -44 },
  { 2067, 28, 45, 29, 1, -44 },
  { 2225, 26, 45, 29, 3, -44 },
  { 2372, 25, 44, 29, 5, -44 },
  { 2510, 27, 45, 29, 2, -44 },
  { 2662, 26, 45, 29, 2, -44 },
  { 2809, 10, 33, 12, 1, -33 },
  { 2851, 14, 41, 12, -3, -33 },
  { 2923, 25, 27, 31, 4, -35 },
  { 3008, 25, 15, 31, 4, -29 },
  { 3055, 25, 27, 31, 4, -35 },
  { 3140, 20, 44, 21, 3, -44 },
  { 3250, 40, 48, 44, 3, -43 },
  { 3490, 29, 44, 29, -3, -44 },
  { 3650, 29, 44, 32, 2, -44 },
  { 3810, 30, 45, 31, 4, -44 },
  { 3979, 32, 44, 36, 2, -44 },
  { 4155, 28, 44, 28, 2, -44 },
  { 4309, 28, 44, 26, 2, -44 },
  { 4463, 32, 45, 37, 4, -44 },
  { 4643, 35, 44, 36, 2, -44 },
  { 4836, 19, 44, 15, -1, -44 },
  { 4941, 24, 55, 13, -10, -44 },
  { 5106, 32, 44, 29, 2, -44 },
  { 5282, 19, 44, 26, 2, -44 },
  { 5387, 43, 44, 45, 2, -44 },
  { 5624, 35, 44, 37, 2, -44 },
  { 5817, 32, 45, 38, 4, -44 },
  { 5997, 28, 44, 30, 2, -44 },
  { 6151, 32, 54, 38, 4, -44 },
  { 6367, 28, 44, 30, 2, -44 },
  { 6521, 28, 45, 27, 0, -44 },
  { 6679, 26, 44, 26, 5, -44 },
  { 6822, 33, 45, 36, 4, -44 },
  { 7008, 28, 44, 29, 6, -44 },
  { 7162, 43, 44, 46, 7, -44 },
  { 7399, 35, 44, 26, -4, -44 },
  { 7592, 25, 44, 26, 6, -44 },
  { 7730, 31, 44, 28, -1, -44 },
  { 7901, 23, 54, 18, -1, -44 },
  { 8057, 9, 44, 19, 6, -44 },
  { 8107, 22, 54, 18, -4, -44 },
  { 8256, 26, 25, 30, 2, -44 },
  { 8338, 21, 2, 21, -5, 6 },
  { 8344, 7, 10, 14, 9, -47 },
  { 8353, 26, 34, 30, 3, -33 },
  { 8464, 27, 47, 31, 1, -46 },
  { 8623, 22, 34, 24, 3, -33 },
  { 8717, 29, 47, 31, 3, -46 },
  { 8888, 22, 34, 27, 3, -33 },
  { 8982, 31, 62, 15, -8, -47 },
  { 9223, 28, 48, 31, 1, -33 },
  { 9391, 26, 46, 30, 1, -46 },
  { 9541, 12, 44, 12, 1, -44 },
  { 9607, 21, 59, 12, -8, -44 },
  { 9762, 26, 46, 24, 1, -46 },
  { 9912, 12, 46, 12, 1, -46 },
  { 9981, 41, 33, 45, 1, -33 },
  { 10151, 26, 33, 30, 1, -33 },
  { 10259, 24, 34, 30, 3, -33 },
  { 10361, 30, 47, 31, -2, -33 },
  { 10538, 26, 47, 31, 3, -33 },
  { 10691, 21, 33, 20, 1, -33 },
  { 10778, 22, 34, 23, 0, -33 },
  { 10872, 16, 41, 16, 2, -40 },
  { 10954, 25, 33, 30, 3, -32 },
  { 11058, 23, 32, 23, 3, -32 },
  { 11150, 35, 32, 36, 4, -32 },
  { 11290, 28, 32, 24, -2, -32 },
  { 11402, 33, 47, 23, -7, -32 },
  { 11596, 24, 32, 22, -1, -32 },
  { 11692, 21, 54, 20, 2, -44 },
  { 11834, 2, 61, 29, 14, -46 },
  { 11850, 21, 54, 20, -3, -44 },
  { 11992, 25, 5, 31, 4, -24 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic61pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC61PT7B_H_
