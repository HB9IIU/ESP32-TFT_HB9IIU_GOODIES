#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC32PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0xC2, 0x08, 0x21, 0x86, 0x10, 0x41, 0x0C, 0x20, 0x82,
  0x08, 0x60, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x23, 0x22, 0x62, 0x42, 0x46,
  0x44, 0x44, 0x84, 0x00, 0x82, 0x01, 0x86, 0x01, 0x04, 0x01, 0x04, 0x01,
  0x04, 0x02, 0x08, 0x02, 0x08, 0x3F, 0xFF, 0x06, 0x10, 0x04, 0x10, 0x04,
  0x10, 0x04, 0x30, 0x08, 0x20, 0x08, 0x20, 0x08, 0x20, 0xFF, 0xFC, 0x10,
  0x40, 0x10, 0x40, 0x30, 0xC0, 0x20, 0x80, 0x20, 0x80, 0x21, 0x80, 0x41,
  0x00, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x01, 0xDF, 0x08, 0x84, 0x42, 0x01,
  0x08, 0x04, 0x20, 0x11, 0x00, 0x44, 0x00, 0x90, 0x01, 0xC0, 0x03, 0x00,
  0x0B, 0x00, 0x26, 0x00, 0x88, 0x02, 0x30, 0x08, 0xC0, 0x42, 0x01, 0x08,
  0x84, 0x43, 0xFE, 0x01, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x0F,
  0x00, 0x84, 0x40, 0x62, 0x18, 0x10, 0x82, 0x08, 0x40, 0x86, 0x10, 0x61,
  0x04, 0x10, 0x83, 0x04, 0x60, 0x81, 0x10, 0x20, 0x48, 0xE8, 0x26, 0x47,
  0x09, 0x21, 0x44, 0x98, 0x5E, 0x24, 0x10, 0x11, 0x04, 0x08, 0xC1, 0x02,
  0x20, 0x41, 0x08, 0x10, 0x82, 0x08, 0x20, 0x82, 0x10, 0x21, 0x8C, 0x0C,
  0x46, 0x01, 0xE0, 0x01, 0xF0, 0x02, 0x18, 0x04, 0x08, 0x04, 0x08, 0x0C,
  0x08, 0x0C, 0x18, 0x0C, 0x10, 0x04, 0x30, 0x04, 0x60, 0x07, 0x80, 0x03,
  0x00, 0x0F, 0x00, 0x19, 0x00, 0x20, 0x83, 0x40, 0xC2, 0xC0, 0x46, 0x80,
  0x64, 0x80, 0x28, 0x80, 0x38, 0x80, 0x30, 0x80, 0x78, 0x40, 0xC8, 0x3F,
  0x04, 0x25, 0xA4, 0x94, 0x01, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x40,
  0x20, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0x40, 0x20, 0x10, 0x04, 0x00,
  0x02, 0x01, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x40,
  0x20, 0x20, 0x30, 0x10, 0x10, 0x18, 0x18, 0x00, 0x02, 0x00, 0x42, 0x08,
  0x62, 0x03, 0x40, 0x1F, 0xC3, 0x00, 0x90, 0x22, 0x18, 0x61, 0x04, 0x00,
  0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x1F, 0xFF, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x32, 0x26, 0x4C, 0x80, 0xFE, 0xF0, 0x00, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x00, 0x03, 0xE0,
  0x61, 0x82, 0x04, 0x20, 0x33, 0x00, 0x90, 0x05, 0x80, 0x28, 0x01, 0x40,
  0x1E, 0x00, 0xF0, 0x05, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0xD0, 0x04,
  0x80, 0x24, 0x03, 0x20, 0x11, 0x01, 0x88, 0x18, 0x21, 0x80, 0xF8, 0x00,
  0x06, 0x1C, 0xD3, 0x28, 0x41, 0x83, 0x04, 0x08, 0x10, 0x60, 0x81, 0x02,
  0x04, 0x18, 0x20, 0x40, 0x81, 0x06, 0x08, 0x10, 0x00, 0x01, 0xF0, 0x0C,
  0x18, 0x10, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF8, 0x0C, 0x18, 0x20, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30,
  0x07, 0x80, 0x3E, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x10, 0x1C, 0x1F, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x50, 0x01, 0xA0, 0x06, 0xC0, 0x09,
  0x00, 0x22, 0x00, 0x84, 0x03, 0x08, 0x04, 0x30, 0x10, 0x40, 0x40, 0x81,
  0x81, 0x06, 0x06, 0x08, 0x0C, 0x20, 0x10, 0xFF, 0xFC, 0x00, 0x40, 0x01,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x03, 0xFE, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x37, 0x00, 0x73, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02,
  0x18, 0x18, 0x1F, 0xE0, 0x00, 0x00, 0xF8, 0x18, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x7C, 0x16, 0x19, 0x40,
  0x4C, 0x03, 0x40, 0x1A, 0x00, 0xD0, 0x06, 0x80, 0x24, 0x01, 0x20, 0x09,
  0x00, 0x8C, 0x0C, 0x20, 0xC0, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x00, 0x03, 0xF0, 0x18,
  0x60, 0x80, 0xC2, 0x01, 0x18, 0x04, 0x40, 0x11, 0x80, 0xC2, 0x02, 0x08,
  0x10, 0x11, 0x80, 0x3C, 0x01, 0xE0, 0x18, 0xC0, 0x80, 0x84, 0x03, 0x30,
  0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20, 0x0C, 0xC0, 0x21, 0x83, 0x03,
  0xF8, 0x00, 0x03, 0xE0, 0x10, 0x40, 0x80, 0x84, 0x02, 0x10, 0x0C, 0x80,
  0x32, 0x00, 0xC8, 0x03, 0x20, 0x0C, 0x80, 0x22, 0x01, 0x88, 0x0E, 0x10,
  0x68, 0x3E, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x0F, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x80, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x10, 0x20, 0x81, 0x04, 0x08,
  0x00, 0x00, 0x08, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x20, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x02, 0x00, 0x00, 0x3F, 0x18, 0x60, 0x0C, 0x01, 0x00, 0x40, 0x10,
  0x0C, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x0C, 0x02, 0x01, 0x80,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x1F, 0x00,
  0x07, 0x06, 0x00, 0x60, 0x08, 0x0C, 0x00, 0x20, 0x40, 0x01, 0x84, 0x00,
  0x04, 0x40, 0x00, 0x22, 0x07, 0xE1, 0x20, 0x41, 0x09, 0x04, 0x10, 0x58,
  0x40, 0x82, 0x82, 0x04, 0x14, 0x20, 0x20, 0xA1, 0x02, 0x07, 0x08, 0x10,
  0x58, 0x40, 0x82, 0xC2, 0x0C, 0x26, 0x10, 0xA3, 0x10, 0xF9, 0xF0, 0x81,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x0C, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x08, 0x00, 0x30, 0x00, 0x70,
  0x01, 0x60, 0x02, 0x40, 0x08, 0x80, 0x11, 0x00, 0x42, 0x00, 0x84, 0x02,
  0x08, 0x04, 0x10, 0x10, 0x20, 0x20, 0x40, 0xFF, 0xC1, 0xFF, 0x84, 0x03,
  0x08, 0x02, 0x20, 0x04, 0xC0, 0x09, 0x00, 0x16, 0x00, 0x28, 0x00, 0x70,
  0x00, 0x80, 0x07, 0xF0, 0x08, 0x38, 0x30, 0x18, 0x40, 0x10, 0x80, 0x21,
  0x00, 0x46, 0x00, 0x8C, 0x03, 0x10, 0x04, 0x20, 0x10, 0x7F, 0xC1, 0xFF,
  0x02, 0x01, 0x84, 0x01, 0x08, 0x03, 0x10, 0x06, 0x60, 0x0C, 0x80, 0x11,
  0x00, 0x22, 0x00, 0xC4, 0x03, 0x18, 0x1C, 0x3F, 0xE0, 0x00, 0x00, 0xFE,
  0x03, 0x83, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x10, 0x1F, 0xE0, 0x07, 0xE0, 0x02, 0x1E,
  0x03, 0x01, 0x81, 0x00, 0x60, 0x80, 0x10, 0x40, 0x08, 0x60, 0x04, 0x30,
  0x03, 0x10, 0x01, 0x88, 0x00, 0xC4, 0x00, 0x66, 0x00, 0x22, 0x00, 0x11,
  0x00, 0x08, 0x80, 0x0C, 0x40, 0x04, 0x60, 0x06, 0x20, 0x02, 0x10, 0x03,
  0x08, 0x03, 0x04, 0x07, 0x06, 0x0E, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x08,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x7F, 0xC1, 0xFF, 0x82, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x03, 0xFF, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x00, 0x00, 0xFF, 0x01, 0xC0, 0xC1, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x28, 0x07, 0xE4, 0x00, 0x12, 0x00, 0x09, 0x00, 0x0C, 0x80,
  0x04, 0x60, 0x02, 0x10, 0x01, 0x08, 0x00, 0x86, 0x00, 0xC1, 0x80, 0x40,
  0x3F, 0xC0, 0x04, 0x00, 0x41, 0x00, 0x10, 0xC0, 0x0C, 0x20, 0x02, 0x08,
  0x00, 0x82, 0x00, 0x21, 0x80, 0x08, 0x60, 0x06, 0x10, 0x01, 0x04, 0x00,
  0x41, 0xFF, 0xF0, 0xFF, 0xFC, 0x20, 0x03, 0x08, 0x00, 0x82, 0x00, 0x20,
  0x80, 0x08, 0x60, 0x06, 0x10, 0x01, 0x84, 0x00, 0x41, 0x00, 0x10, 0x40,
  0x04, 0x30, 0x03, 0x08, 0x00, 0x80, 0x07, 0xE0, 0x20, 0x04, 0x00, 0x80,
  0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20,
  0x3F, 0x00, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x0F, 0x80, 0x70, 0x00, 0x04, 0x01,
  0x82, 0x01, 0x83, 0x01, 0x81, 0x01, 0x80, 0x81, 0x80, 0x41, 0x80, 0x61,
  0x80, 0x31, 0x80, 0x11, 0x80, 0x09, 0x80, 0x05, 0xC0, 0x07, 0xA0, 0x03,
  0x90, 0x01, 0x8C, 0x00, 0x82, 0x00, 0x41, 0x00, 0x60, 0x40, 0x20, 0x20,
  0x10, 0x18, 0x08, 0x04, 0x04, 0x02, 0x06, 0x01, 0x82, 0x00, 0x40, 0x04,
  0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01,
  0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x30, 0x0F, 0xFC, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x18, 0x28, 0x00,
  0x70, 0x50, 0x00, 0xA0, 0xA0, 0x03, 0xC1, 0x40, 0x05, 0x06, 0x80, 0x1A,
  0x09, 0x00, 0x24, 0x13, 0x00, 0x88, 0x22, 0x01, 0x30, 0x44, 0x04, 0x41,
  0x88, 0x18, 0x82, 0x10, 0x21, 0x04, 0x20, 0xC2, 0x08, 0x41, 0x0C, 0x10,
  0x86, 0x10, 0x61, 0x88, 0x20, 0x81, 0x20, 0x41, 0x02, 0x40, 0x82, 0x05,
  0x03, 0x04, 0x0A, 0x04, 0x18, 0x18, 0x08, 0x20, 0x30, 0x10, 0x00, 0x04,
  0x00, 0x41, 0x80, 0x10, 0xA0, 0x04, 0x28, 0x01, 0x0B, 0x00, 0xC2, 0x40,
  0x21, 0x90, 0x08, 0x46, 0x02, 0x10, 0x81, 0x84, 0x20, 0x41, 0x08, 0x10,
  0xC1, 0x04, 0x20, 0x41, 0x08, 0x10, 0xC2, 0x02, 0x20, 0x80, 0x88, 0x60,
  0x22, 0x10, 0x04, 0x84, 0x01, 0x61, 0x00, 0x50, 0x40, 0x0C, 0x30, 0x03,
  0x08, 0x00, 0xC0, 0x01, 0xF8, 0x03, 0x83, 0x03, 0x00, 0xC1, 0x00, 0x21,
  0x00, 0x19, 0x80, 0x0C, 0x80, 0x02, 0xC0, 0x01, 0x40, 0x00, 0xA0, 0x00,
  0xD0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x0D, 0x00,
  0x06, 0x80, 0x02, 0x60, 0x03, 0x30, 0x01, 0x08, 0x01, 0x86, 0x01, 0x81,
  0x81, 0x80, 0x7F, 0x00, 0x07, 0xE0, 0x08, 0x30, 0x30, 0x30, 0x40, 0x30,
  0x80, 0x61, 0x00, 0xC6, 0x01, 0x8C, 0x03, 0x10, 0x04, 0x20, 0x08, 0x40,
  0x21, 0x81, 0x83, 0xFE, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x00,
  0x01, 0xF8, 0x03, 0x83, 0x03, 0x00, 0xC1, 0x00, 0x21, 0x00, 0x19, 0x80,
  0x0C, 0x80, 0x02, 0xC0, 0x01, 0x40, 0x00, 0xA0, 0x00, 0xD0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x0D, 0x00, 0x06, 0x80, 0x02,
  0x60, 0x03, 0x30, 0x01, 0x08, 0x01, 0x86, 0x01, 0x81, 0x81, 0x80, 0x7F,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x07, 0xE0, 0x08, 0x30, 0x30, 0x10, 0x40, 0x30, 0x80, 0x61, 0x00, 0xC6,
  0x01, 0x8C, 0x03, 0x10, 0x04, 0x20, 0x18, 0x40, 0x61, 0x83, 0x83, 0xFC,
  0x04, 0x10, 0x08, 0x30, 0x10, 0x20, 0x60, 0x40, 0x80, 0x81, 0x01, 0x82,
  0x01, 0x04, 0x02, 0x18, 0x06, 0x20, 0x04, 0x00, 0x01, 0xFC, 0x0C, 0x0C,
  0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x10,
  0x18, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x00, 0x08, 0x00, 0x8C, 0x00, 0x44, 0x00,
  0x22, 0x00, 0x31, 0x00, 0x11, 0x80, 0x08, 0xC0, 0x04, 0x40, 0x02, 0x20,
  0x03, 0x10, 0x01, 0x18, 0x00, 0x88, 0x00, 0x44, 0x00, 0x62, 0x00, 0x21,
  0x00, 0x11, 0x80, 0x08, 0x80, 0x04, 0x40, 0x04, 0x20, 0x02, 0x18, 0x03,
  0x04, 0x03, 0x03, 0x03, 0x00, 0x7F, 0x00, 0x80, 0x07, 0x00, 0x0A, 0x00,
  0x26, 0x00, 0x4C, 0x01, 0x08, 0x02, 0x10, 0x08, 0x20, 0x10, 0x40, 0x40,
  0x80, 0x81, 0x02, 0x02, 0x04, 0x04, 0x10, 0x08, 0x20, 0x10, 0x80, 0x21,
  0x00, 0x64, 0x00, 0xC8, 0x00, 0xA0, 0x01, 0x40, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x0D, 0x00, 0xE0, 0x12,
  0x01, 0x40, 0x24, 0x06, 0x80, 0x88, 0x09, 0x01, 0x10, 0x32, 0x06, 0x20,
  0x44, 0x08, 0x40, 0x88, 0x30, 0x82, 0x10, 0x41, 0x04, 0x21, 0x82, 0x10,
  0x42, 0x04, 0x20, 0x84, 0x08, 0xC1, 0x10, 0x11, 0x02, 0x20, 0x26, 0x04,
  0xC0, 0x48, 0x09, 0x00, 0x90, 0x16, 0x01, 0x40, 0x28, 0x02, 0x80, 0x50,
  0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x40, 0x80, 0x20, 0x30, 0x10, 0x04, 0x0C, 0x01, 0x02, 0x00, 0x41, 0x00,
  0x08, 0xC0, 0x02, 0x20, 0x00, 0x90, 0x00, 0x38, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x48, 0x00, 0x32, 0x00, 0x08, 0xC0, 0x04, 0x10,
  0x03, 0x04, 0x01, 0x81, 0x00, 0x40, 0x60, 0x20, 0x08, 0x18, 0x02, 0x0C,
  0x00, 0xC0, 0x80, 0x0C, 0x00, 0xF0, 0x0C, 0x80, 0x44, 0x06, 0x20, 0x21,
  0x82, 0x04, 0x30, 0x21, 0x01, 0x10, 0x09, 0x80, 0x68, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x03, 0xFF, 0x82, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20,
  0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x7E, 0x00, 0x86, 0x10, 0x84, 0x21,
  0x0C, 0x21, 0x08, 0x42, 0x18, 0x42, 0x10, 0x84, 0x30, 0x84, 0x20, 0x03,
  0xF0, 0x42, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x04, 0x0F, 0xC0, 0x00, 0x80, 0x07, 0x00, 0x14, 0x00, 0x90,
  0x02, 0x20, 0x10, 0x80, 0xC3, 0x02, 0x04, 0x10, 0x10, 0xC0, 0x62, 0x00,
  0x98, 0x02, 0xC0, 0x0C, 0xFF, 0xE0, 0x89, 0x12, 0x07, 0xE4, 0x30, 0x91,
  0x81, 0x84, 0x06, 0x20, 0x18, 0x80, 0x64, 0x01, 0x90, 0x04, 0x40, 0x13,
  0x00, 0x4C, 0x03, 0x30, 0x0C, 0xC0, 0x23, 0x01, 0x84, 0x0A, 0x18, 0x48,
  0x3E, 0x60, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x04, 0x7C, 0x16, 0x18, 0x70, 0x21, 0x80, 0x8C, 0x03, 0x30,
  0x0C, 0x80, 0x32, 0x00, 0x98, 0x02, 0x40, 0x09, 0x00, 0x24, 0x01, 0x10,
  0x04, 0xC0, 0x32, 0x81, 0x8B, 0x0C, 0x27, 0xE0, 0x03, 0xF0, 0xC0, 0x18,
  0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x02, 0x04, 0x1F, 0x80, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x07, 0xE4, 0x0C, 0x34, 0x18, 0x14, 0x30, 0x0C, 0x20, 0x08, 0x20, 0x08,
  0x40, 0x08, 0x40, 0x18, 0x40, 0x18, 0xC0, 0x10, 0xC0, 0x10, 0xC0, 0x30,
  0xC0, 0x30, 0xC0, 0x60, 0x40, 0xA0, 0x61, 0xA0, 0x3E, 0x20, 0x03, 0xE0,
  0xC3, 0x18, 0x11, 0x01, 0x20, 0x12, 0x03, 0x40, 0x64, 0x1C, 0x7E, 0x04,
  0x00, 0x40, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x04, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x03, 0xF8, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00,
  0xB0, 0x00, 0xE0, 0x00, 0x03, 0xF2, 0x0C, 0x34, 0x30, 0x28, 0xC0, 0x31,
  0x00, 0x42, 0x00, 0x88, 0x01, 0x10, 0x06, 0x20, 0x0C, 0xC0, 0x11, 0x80,
  0x23, 0x00, 0xC6, 0x01, 0x8C, 0x06, 0x08, 0x14, 0x18, 0x68, 0x1F, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x20, 0x30, 0x7B,
  0xC0, 0x3C, 0x00, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x60, 0x02, 0x3E, 0x16, 0x18, 0xE0, 0x46, 0x02, 0x60, 0x13, 0x00,
  0x90, 0x0C, 0x80, 0x4C, 0x02, 0x60, 0x12, 0x00, 0x90, 0x0C, 0x80, 0x4C,
  0x02, 0x40, 0x12, 0x00, 0x90, 0x0C, 0x0C, 0x30, 0x00, 0x00, 0x01, 0x84,
  0x10, 0x43, 0x08, 0x20, 0x86, 0x18, 0x41, 0x04, 0x30, 0x82, 0x08, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x04, 0x00,
  0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x81, 0xE0, 0x38, 0x00, 0x04, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x03, 0x10, 0x30, 0x83, 0x04,
  0x30, 0x63, 0x02, 0x30, 0x13, 0x00, 0xB0, 0x0F, 0xC0, 0x52, 0x03, 0x10,
  0x10, 0x40, 0x82, 0x0C, 0x18, 0x40, 0x42, 0x02, 0x10, 0x18, 0x04, 0x30,
  0x82, 0x08, 0x21, 0x84, 0x10, 0x41, 0x0C, 0x20, 0x82, 0x18, 0x41, 0x04,
  0x10, 0xC2, 0x08, 0x20, 0x13, 0xE1, 0xF0, 0xB1, 0x90, 0xC6, 0x05, 0x02,
  0x30, 0x30, 0x13, 0x01, 0x80, 0x98, 0x08, 0x04, 0x80, 0x40, 0x24, 0x02,
  0x03, 0x60, 0x30, 0x13, 0x01, 0x00, 0x90, 0x08, 0x04, 0x80, 0x40, 0x64,
  0x06, 0x02, 0x60, 0x20, 0x12, 0x01, 0x00, 0x90, 0x08, 0x04, 0x80, 0xC0,
  0x60, 0x11, 0xF0, 0xB0, 0xC7, 0x02, 0x30, 0x13, 0x00, 0x98, 0x04, 0x80,
  0x64, 0x02, 0x60, 0x13, 0x00, 0x90, 0x04, 0x80, 0x64, 0x02, 0x60, 0x12,
  0x00, 0x90, 0x0C, 0x80, 0x60, 0x07, 0xE0, 0x61, 0x86, 0x06, 0x60, 0x12,
  0x00, 0xB0, 0x05, 0x00, 0x28, 0x01, 0x40, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x2C, 0x01, 0x20, 0x11, 0x01, 0x8C, 0x18, 0x3F, 0x80, 0x04, 0x7C, 0x05,
  0x86, 0x05, 0x02, 0x06, 0x02, 0x0C, 0x03, 0x0C, 0x03, 0x08, 0x03, 0x08,
  0x02, 0x18, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x04, 0x10, 0x04, 0x30,
  0x0C, 0x28, 0x18, 0x28, 0x30, 0x27, 0xE0, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x07, 0xE4, 0x30,
  0xD1, 0x81, 0x44, 0x03, 0x20, 0x08, 0x80, 0x26, 0x00, 0x90, 0x02, 0x40,
  0x1B, 0x00, 0x4C, 0x01, 0x30, 0x0C, 0xC0, 0x33, 0x01, 0x84, 0x0A, 0x18,
  0x68, 0x3E, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x20, 0x13, 0xC5, 0x81, 0xC0, 0x60, 0x30, 0x0C, 0x02, 0x00,
  0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80,
  0x00, 0x0F, 0xF1, 0x82, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x88,
  0x18, 0xFF, 0x00, 0x08, 0x08, 0x08, 0x18, 0x7F, 0x10, 0x10, 0x30, 0x20,
  0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0x78,
  0x10, 0x0C, 0x40, 0x31, 0x00, 0x8C, 0x02, 0x20, 0x08, 0x80, 0x62, 0x01,
  0x18, 0x04, 0x60, 0x11, 0x00, 0x44, 0x03, 0x10, 0x08, 0xC0, 0x63, 0x01,
  0x8C, 0x0A, 0x10, 0x58, 0x3E, 0x40, 0x80, 0x30, 0x0E, 0x01, 0x40, 0x68,
  0x09, 0x03, 0x20, 0x46, 0x18, 0xC2, 0x08, 0xC1, 0x10, 0x24, 0x04, 0x80,
  0xA0, 0x14, 0x03, 0x00, 0x60, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x14,
  0x0A, 0x05, 0x02, 0x83, 0x41, 0x20, 0x90, 0x48, 0x64, 0x22, 0x11, 0x08,
  0x84, 0x46, 0x22, 0x11, 0x08, 0x84, 0xC2, 0x41, 0x20, 0x90, 0x48, 0x28,
  0x14, 0x0A, 0x05, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x00, 0x08, 0x06, 0x10,
  0x10, 0x10, 0x60, 0x21, 0x80, 0x62, 0x00, 0x48, 0x00, 0xB0, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x12, 0x00, 0x44, 0x01, 0x8C, 0x02, 0x08, 0x08,
  0x10, 0x20, 0x30, 0xC0, 0x20, 0x02, 0x00, 0xC0, 0x80, 0x20, 0x20, 0x10,
  0x08, 0x04, 0x03, 0x02, 0x00, 0x40, 0x80, 0x10, 0x40, 0x04, 0x10, 0x01,
  0x08, 0x00, 0x42, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x20, 0x00, 0x68,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x02, 0x60, 0x00, 0x60,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60,
  0x06, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x18,
  0x00, 0x80, 0x08, 0x00, 0xFF, 0xC0, 0x00, 0x60, 0x30, 0x0C, 0x01, 0x00,
  0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x01, 0x81,
  0xE0, 0x38, 0x01, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x40, 0x08, 0x00, 0x80, 0x0E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x1C, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x0F, 0x00, 0xE0, 0x18, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x18, 0x0F, 0x00, 0x38,
  0x0E, 0x38, 0x60, 0x7C,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 23, 7, 1, -23 },
  { 19, 8, 8, 10, 3, -23 },
  { 27, 16, 23, 17, 1, -23 },
  { 73, 14, 26, 15, 1, -24 },
  { 119, 18, 23, 22, 2, -23 },
  { 171, 16, 23, 18, 1, -23 },
  { 217, 3, 8, 5, 3, -23 },
  { 220, 9, 28, 8, 1, -23 },
  { 252, 9, 28, 8, -2, -23 },
  { 284, 11, 12, 15, 4, -24 },
  { 301, 13, 15, 16, 2, -19 },
  { 326, 4, 7, 6, -1, -3 },
  { 330, 7, 1, 9, 1, -9 },
  { 331, 2, 2, 6, 1, -2 },
  { 332, 13, 23, 10, -1, -23 },
  { 370, 13, 23, 15, 2, -23 },
  { 408, 7, 23, 15, 5, -23 },
  { 429, 15, 23, 15, 0, -23 },
  { 473, 15, 23, 15, 0, -23 },
  { 517, 15, 23, 15, 0, -23 },
  { 561, 15, 23, 15, 0, -23 },
  { 605, 13, 23, 15, 2, -23 },
  { 643, 13, 23, 15, 3, -23 },
  { 681, 14, 23, 15, 1, -23 },
  { 722, 14, 23, 15, 1, -23 },
  { 763, 5, 17, 6, 1, -17 },
  { 774, 7, 21, 6, -1, -17 },
  { 793, 13, 15, 16, 2, -19 },
  { 818, 13, 8, 16, 2, -15 },
  { 831, 13, 15, 16, 2, -19 },
  { 856, 10, 23, 11, 2, -23 },
  { 885, 21, 26, 23, 1, -23 },
  { 954, 15, 23, 15, -2, -23 },
  { 998, 15, 23, 17, 1, -23 },
  { 1042, 16, 23, 16, 2, -23 },
  { 1088, 17, 23, 19, 1, -23 },
  { 1137, 15, 23, 15, 1, -23 },
  { 1181, 15, 23, 14, 1, -23 },
  { 1225, 17, 23, 19, 2, -23 },
  { 1274, 18, 23, 19, 1, -23 },
  { 1326, 11, 23, 8, -1, -23 },
  { 1358, 12, 29, 7, -5, -23 },
  { 1402, 17, 23, 15, 1, -23 },
  { 1451, 10, 23, 14, 1, -23 },
  { 1480, 23, 23, 24, 1, -23 },
  { 1547, 18, 23, 19, 1, -23 },
  { 1599, 17, 23, 20, 2, -23 },
  { 1648, 15, 23, 16, 1, -23 },
  { 1692, 17, 28, 20, 2, -23 },
  { 1752, 15, 23, 16, 1, -23 },
  { 1796, 15, 23, 14, 0, -23 },
  { 1840, 13, 23, 13, 3, -23 },
  { 1878, 17, 23, 19, 2, -23 },
  { 1927, 15, 23, 15, 3, -23 },
  { 1971, 23, 23, 24, 3, -23 },
  { 2038, 18, 23, 14, -2, -23 },
  { 2090, 13, 23, 13, 3, -23 },
  { 2128, 17, 23, 15, -1, -23 },
  { 2177, 11, 28, 9, 0, -23 },
  { 2216, 5, 23, 10, 3, -23 },
  { 2231, 12, 28, 9, -2, -23 },
  { 2273, 14, 13, 16, 1, -23 },
  { 2296, 11, 1, 11, -3, 3 },
  { 2298, 3, 5, 7, 5, -24 },
  { 2300, 14, 17, 16, 1, -17 },
  { 2330, 14, 24, 16, 1, -24 },
  { 2372, 12, 17, 12, 1, -17 },
  { 2398, 16, 24, 16, 1, -24 },
  { 2446, 12, 17, 14, 1, -17 },
  { 2472, 16, 32, 8, -4, -24 },
  { 2536, 15, 25, 16, 0, -17 },
  { 2583, 13, 24, 16, 1, -24 },
  { 2622, 6, 23, 6, 1, -23 },
  { 2640, 11, 31, 6, -4, -23 },
  { 2683, 13, 24, 13, 1, -24 },
  { 2722, 6, 24, 6, 1, -24 },
  { 2740, 21, 17, 24, 1, -17 },
  { 2785, 13, 17, 16, 1, -17 },
  { 2813, 13, 17, 16, 1, -17 },
  { 2841, 16, 24, 16, -1, -17 },
  { 2889, 14, 24, 16, 1, -17 },
  { 2931, 10, 17, 10, 1, -17 },
  { 2953, 12, 17, 12, 0, -17 },
  { 2979, 8, 21, 9, 1, -21 },
  { 3000, 14, 17, 16, 1, -17 },
  { 3030, 11, 17, 12, 2, -17 },
  { 3054, 18, 17, 19, 2, -17 },
  { 3093, 15, 17, 13, -1, -17 },
  { 3125, 18, 25, 12, -4, -17 },
  { 3182, 13, 17, 12, -1, -17 },
  { 3210, 11, 28, 10, 1, -23 },
  { 3249, 2, 32, 15, 7, -24 },
  { 3257, 12, 28, 10, -2, -23 },
  { 3299, 13, 3, 16, 2, -13 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic32pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC32PT7B_H_
