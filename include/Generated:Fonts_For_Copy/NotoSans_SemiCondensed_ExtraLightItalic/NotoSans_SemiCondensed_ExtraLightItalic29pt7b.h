#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC29PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x20, 0x82, 0x18, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0x84,
  0x10, 0x00, 0x00, 0x30, 0x80, 0x66, 0x89, 0x12, 0x24, 0x51, 0x22, 0x44,
  0x01, 0x08, 0x02, 0x10, 0x08, 0x20, 0x10, 0x80, 0x21, 0x00, 0x42, 0x01,
  0x04, 0x1F, 0xFF, 0x04, 0x20, 0x10, 0x40, 0x21, 0x00, 0x42, 0x01, 0x04,
  0x1F, 0xFF, 0x04, 0x20, 0x08, 0x40, 0x20, 0x80, 0x42, 0x00, 0x84, 0x02,
  0x08, 0x04, 0x20, 0x00, 0x00, 0x80, 0x08, 0x01, 0x80, 0xEF, 0x19, 0x01,
  0x10, 0x31, 0x02, 0x10, 0x32, 0x01, 0x20, 0x0E, 0x00, 0x60, 0x03, 0x80,
  0x4C, 0x04, 0x40, 0x44, 0x04, 0x40, 0x44, 0x08, 0xCE, 0xB0, 0x1C, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x1E, 0x03, 0x19, 0x01, 0x08, 0x41, 0x08, 0x21,
  0x84, 0x10, 0x82, 0x18, 0x82, 0x08, 0xC1, 0x04, 0x40, 0x82, 0x46, 0x43,
  0x6C, 0xA1, 0x24, 0x59, 0x24, 0x37, 0x12, 0x10, 0x13, 0x08, 0x11, 0x04,
  0x08, 0x82, 0x08, 0x41, 0x08, 0x21, 0x04, 0x10, 0x84, 0x08, 0x84, 0x03,
  0xC0, 0x03, 0xC0, 0x18, 0x80, 0xC1, 0x02, 0x04, 0x08, 0x10, 0x20, 0x80,
  0x86, 0x02, 0x30, 0x05, 0x80, 0x18, 0x00, 0xE0, 0x0C, 0xC0, 0x61, 0x05,
  0x06, 0x28, 0x08, 0xA0, 0x14, 0x80, 0x72, 0x00, 0x88, 0x06, 0x30, 0x64,
  0x7E, 0x18, 0x69, 0x25, 0x24, 0x01, 0x02, 0x04, 0x0C, 0x08, 0x10, 0x30,
  0x20, 0x20, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x06, 0x02, 0x02, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x02, 0x02,
  0x06, 0x04, 0x0C, 0x08, 0x10, 0x10, 0x20, 0x40, 0x80, 0x02, 0x00, 0x42,
  0x08, 0x32, 0x01, 0x42, 0x1F, 0xC3, 0x00, 0x90, 0x22, 0x08, 0x20, 0x04,
  0x00, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFF, 0xF0,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x32, 0x24, 0x48,
  0x80, 0xFE, 0xE0, 0x00, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x00, 0x03,
  0xC0, 0x42, 0x08, 0x11, 0x81, 0x10, 0x13, 0x01, 0x20, 0x12, 0x01, 0x40,
  0x14, 0x01, 0x40, 0x14, 0x01, 0x40, 0x3C, 0x02, 0xC0, 0x2C, 0x06, 0xC0,
  0x44, 0x0C, 0x40, 0x86, 0x10, 0x3E, 0x00, 0x06, 0x1C, 0x53, 0x28, 0x40,
  0x82, 0x04, 0x08, 0x10, 0x60, 0x81, 0x02, 0x04, 0x18, 0x20, 0x40, 0x81,
  0x04, 0x00, 0x03, 0xE0, 0x70, 0x82, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0F, 0xFE,
  0x00, 0x03, 0xE0, 0x60, 0xC2, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x03, 0x00, 0x30, 0x06, 0x03, 0xE0, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x19, 0x01, 0x87, 0xF0, 0x00,
  0x00, 0x08, 0x00, 0xC0, 0x0A, 0x00, 0xA0, 0x0D, 0x00, 0x48, 0x04, 0x40,
  0x42, 0x04, 0x20, 0x61, 0x02, 0x08, 0x20, 0x42, 0x06, 0x30, 0x21, 0x01,
  0x1F, 0xFF, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x07,
  0xFC, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x7F, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x20, 0x30, 0x7F, 0x00,
  0x00, 0xF8, 0x18, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x27, 0x82, 0x46, 0x14, 0x08, 0xC0, 0x44, 0x02, 0x20, 0x13, 0x00,
  0x98, 0x04, 0x40, 0x22, 0x02, 0x10, 0x30, 0xC3, 0x03, 0xF0, 0x00, 0x7F,
  0xF0, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x08, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x61, 0x82, 0x04,
  0x20, 0x31, 0x01, 0x88, 0x08, 0x40, 0x43, 0x04, 0x08, 0x40, 0x3C, 0x03,
  0xC0, 0x31, 0x06, 0x04, 0x20, 0x32, 0x00, 0x90, 0x04, 0x80, 0x24, 0x03,
  0x20, 0x10, 0x81, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0xC6, 0x18, 0x31, 0x01,
  0x20, 0x12, 0x01, 0x60, 0x16, 0x01, 0x40, 0x16, 0x03, 0x20, 0x73, 0x0E,
  0x1F, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20,
  0xFC, 0x00, 0x31, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x80, 0x0C, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x82, 0x10, 0x42, 0x08,
  0x00, 0x00, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x00, 0x80, 0x00, 0x3E, 0x20, 0x80, 0x60, 0x10, 0x08, 0x04, 0x04,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x01, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x10, 0x08, 0x00, 0x00, 0x18, 0x00, 0x3C, 0x60, 0x0C, 0x03, 0x02,
  0x00, 0x20, 0x80, 0x02, 0x20, 0x00, 0x4C, 0x0F, 0x09, 0x06, 0x21, 0x61,
  0x04, 0x28, 0x60, 0x85, 0x08, 0x30, 0xA1, 0x04, 0x1C, 0x40, 0x83, 0x08,
  0x10, 0xA1, 0x06, 0x14, 0x21, 0x44, 0x82, 0x69, 0x98, 0x70, 0xC1, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x03, 0x8E, 0x00, 0x1E,
  0x00, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x12, 0x00, 0x48, 0x02, 0x20,
  0x08, 0x80, 0x42, 0x01, 0x08, 0x08, 0x20, 0x20, 0x81, 0x02, 0x07, 0xF8,
  0x20, 0x20, 0x80, 0xC4, 0x01, 0x10, 0x04, 0x80, 0x12, 0x00, 0x50, 0x01,
  0xC0, 0x04, 0x0F, 0xE0, 0x20, 0xE0, 0x80, 0x82, 0x01, 0x18, 0x04, 0x40,
  0x11, 0x00, 0x84, 0x02, 0x10, 0x10, 0x83, 0x83, 0xFC, 0x08, 0x08, 0x20,
  0x11, 0x80, 0x44, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0xCC, 0x06, 0x20,
  0x30, 0xFF, 0x00, 0x01, 0xF8, 0x1C, 0x10, 0xC0, 0x06, 0x00, 0x10, 0x00,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x10, 0xE0, 0x20, 0x20, 0x40, 0x21,
  0x80, 0x62, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x02, 0x40, 0x04, 0x80,
  0x09, 0x00, 0x32, 0x00, 0x4C, 0x00, 0x90, 0x03, 0x20, 0x04, 0x40, 0x10,
  0x80, 0x63, 0x01, 0x84, 0x0C, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x40, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x0F, 0xF8, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x7F, 0xC2, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFC, 0x0E, 0x0C, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x04, 0x07, 0xE8, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x04,
  0x80, 0x19, 0x80, 0x21, 0x00, 0x41, 0x80, 0x81, 0xFE, 0x00, 0x08, 0x01,
  0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x18, 0x02, 0x10, 0x02, 0x10, 0x02,
  0x10, 0x02, 0x10, 0x02, 0x20, 0x04, 0x3F, 0xFC, 0x20, 0x04, 0x20, 0x04,
  0x60, 0x0C, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0xC0, 0x18,
  0x80, 0x10, 0x80, 0x10, 0x07, 0xC0, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x01, 0x00, 0x40, 0xFC, 0x00, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x20, 0x0C, 0x1F, 0x00, 0x08, 0x02, 0x10, 0x08, 0x20,
  0x20, 0x40, 0x81, 0x82, 0x02, 0x08, 0x04, 0x20, 0x08, 0x80, 0x12, 0x00,
  0x4C, 0x00, 0xA8, 0x01, 0x90, 0x02, 0x10, 0x0C, 0x20, 0x10, 0x60, 0x20,
  0x40, 0x40, 0x80, 0x80, 0x83, 0x01, 0x04, 0x03, 0x08, 0x02, 0x00, 0x08,
  0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04,
  0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10, 0x0F, 0xF8, 0x0C,
  0x00, 0x10, 0xC0, 0x03, 0x0C, 0x00, 0x70, 0xC0, 0x05, 0x14, 0x00, 0xF1,
  0x60, 0x0A, 0x12, 0x01, 0x21, 0x20, 0x12, 0x12, 0x02, 0x22, 0x20, 0x24,
  0x22, 0x04, 0x42, 0x20, 0x44, 0x22, 0x08, 0x46, 0x31, 0x8C, 0x41, 0x10,
  0x84, 0x13, 0x08, 0x41, 0x20, 0x84, 0x14, 0x08, 0xC1, 0x41, 0x88, 0x18,
  0x10, 0x81, 0x81, 0x00, 0x08, 0x01, 0x86, 0x00, 0x83, 0x00, 0x41, 0x80,
  0x21, 0x20, 0x10, 0x90, 0x18, 0x48, 0x08, 0x22, 0x04, 0x11, 0x02, 0x10,
  0x81, 0x08, 0x21, 0x04, 0x10, 0x82, 0x08, 0x43, 0x02, 0x21, 0x01, 0x30,
  0x80, 0x90, 0x40, 0x28, 0x20, 0x14, 0x30, 0x0A, 0x10, 0x03, 0x08, 0x01,
  0x00, 0x03, 0xF0, 0x0C, 0x30, 0x20, 0x10, 0x80, 0x33, 0x00, 0x24, 0x00,
  0x58, 0x00, 0xA0, 0x01, 0x40, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x04, 0x80, 0x09, 0x80, 0x21, 0x00,
  0xC3, 0x03, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x43, 0x82, 0x06, 0x10, 0x11,
  0x80, 0x88, 0x04, 0x40, 0x22, 0x01, 0x10, 0x19, 0x00, 0x88, 0x18, 0x7F,
  0x82, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0x00, 0x03, 0xF0, 0x0C, 0x30, 0x20, 0x10, 0x80, 0x33,
  0x00, 0x24, 0x00, 0x58, 0x00, 0xA0, 0x01, 0x40, 0x03, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x04, 0x80, 0x09,
  0x80, 0x21, 0x00, 0xC3, 0x03, 0x01, 0xF8, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0x0F, 0xC0, 0x43, 0x82, 0x06, 0x10, 0x11,
  0x80, 0x88, 0x04, 0x40, 0x22, 0x01, 0x10, 0x11, 0x01, 0x88, 0x38, 0x7F,
  0x02, 0x10, 0x30, 0xC1, 0x02, 0x08, 0x10, 0x40, 0x82, 0x02, 0x30, 0x11,
  0x00, 0x88, 0x06, 0x00, 0x03, 0xF0, 0x30, 0x42, 0x00, 0x30, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x11, 0x01,
  0x0F, 0xF0, 0x00, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x00, 0x10,
  0x03, 0x10, 0x02, 0x10, 0x02, 0x30, 0x02, 0x20, 0x06, 0x20, 0x04, 0x20,
  0x04, 0x20, 0x04, 0x60, 0x04, 0x40, 0x0C, 0x40, 0x08, 0x40, 0x08, 0x40,
  0x08, 0x80, 0x08, 0x80, 0x10, 0x80, 0x10, 0x80, 0x10, 0x80, 0x20, 0xC0,
  0x60, 0x60, 0xC0, 0x3F, 0x80, 0x80, 0x0C, 0x00, 0xA0, 0x05, 0x00, 0x48,
  0x02, 0x40, 0x22, 0x01, 0x10, 0x10, 0xC0, 0x86, 0x08, 0x10, 0x40, 0x84,
  0x04, 0x20, 0x22, 0x01, 0x10, 0x09, 0x00, 0x48, 0x02, 0x80, 0x14, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xA0, 0x18, 0x05,
  0x00, 0xC0, 0x48, 0x0A, 0x02, 0x40, 0x50, 0x32, 0x04, 0x81, 0x10, 0x24,
  0x08, 0x82, 0x20, 0x84, 0x11, 0x04, 0x21, 0x88, 0x41, 0x08, 0x42, 0x08,
  0xC2, 0x30, 0x44, 0x11, 0x03, 0x20, 0x88, 0x1A, 0x04, 0x80, 0x50, 0x24,
  0x03, 0x01, 0x40, 0x18, 0x0A, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x00,
  0x06, 0x01, 0x81, 0x00, 0x80, 0x80, 0x80, 0x40, 0x80, 0x10, 0xC0, 0x08,
  0x40, 0x04, 0x40, 0x03, 0x60, 0x00, 0xA0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x28, 0x00, 0x34, 0x00, 0x12, 0x00, 0x10, 0x80, 0x18, 0x40, 0x08, 0x20,
  0x08, 0x18, 0x08, 0x04, 0x0C, 0x02, 0x0C, 0x01, 0x80, 0x80, 0x38, 0x02,
  0x80, 0x48, 0x0C, 0x40, 0x84, 0x10, 0x41, 0x04, 0x20, 0x66, 0x02, 0x40,
  0x28, 0x03, 0x80, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x00, 0x07, 0xFE, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xC1, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30,
  0x08, 0x02, 0x00, 0x80, 0x3E, 0x00, 0x88, 0x88, 0x44, 0x44, 0x44, 0x22,
  0x22, 0x22, 0x11, 0x11, 0x10, 0x07, 0xE0, 0x0C, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x1F, 0x00, 0x01, 0x00, 0x18, 0x02, 0x80, 0x68, 0x04,
  0x40, 0x84, 0x08, 0x61, 0x02, 0x20, 0x22, 0x01, 0x40, 0x1C, 0x01, 0xFF,
  0x80, 0xC4, 0x23, 0x03, 0x08, 0x76, 0x86, 0x0C, 0x60, 0x62, 0x03, 0x30,
  0x19, 0x00, 0x88, 0x04, 0xC0, 0x24, 0x01, 0x20, 0x19, 0x00, 0x88, 0x0C,
  0x60, 0xA1, 0x0D, 0x07, 0x90, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x11, 0x81, 0x76, 0x38, 0x32, 0x81, 0x30, 0x12, 0x01, 0x20,
  0x16, 0x01, 0x40, 0x14, 0x01, 0x40, 0x24, 0x02, 0xC0, 0x6C, 0x04, 0xA1,
  0x89, 0xF0, 0x03, 0x81, 0xCC, 0x60, 0x18, 0x02, 0x00, 0x80, 0x10, 0x02,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0xF8,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x38,
  0x83, 0xB2, 0x18, 0x30, 0xC0, 0xC2, 0x01, 0x18, 0x04, 0x40, 0x31, 0x00,
  0x8C, 0x02, 0x20, 0x08, 0x80, 0x62, 0x01, 0x88, 0x0C, 0x30, 0x70, 0x43,
  0x40, 0xF9, 0x00, 0x03, 0x01, 0xD8, 0x60, 0x98, 0x12, 0x02, 0xC0, 0x90,
  0x32, 0x38, 0x78, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x21,
  0xFC, 0x00, 0x1E, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x01, 0xF8, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x80, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x1D, 0x90,
  0xC1, 0x86, 0x06, 0x10, 0x08, 0xC0, 0x22, 0x01, 0x88, 0x04, 0x60, 0x11,
  0x00, 0x44, 0x03, 0x10, 0x0C, 0x40, 0x61, 0x83, 0x82, 0x1A, 0x07, 0xC8,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x83, 0x0C, 0x07, 0xE0,
  0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x11, 0xC1,
  0x66, 0x38, 0x33, 0x01, 0x30, 0x12, 0x03, 0x20, 0x26, 0x02, 0x40, 0x24,
  0x02, 0x40, 0x64, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x08, 0x40,
  0x00, 0x00, 0x46, 0x21, 0x08, 0x46, 0x21, 0x08, 0x44, 0x21, 0x08, 0x00,
  0x00, 0x40, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x03, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x11, 0x02, 0x30,
  0x42, 0x08, 0x21, 0x02, 0x20, 0x24, 0x04, 0xC0, 0x54, 0x06, 0x40, 0x42,
  0x04, 0x20, 0x83, 0x08, 0x10, 0x81, 0x08, 0x18, 0x08, 0x42, 0x11, 0x08,
  0x42, 0x31, 0x08, 0x42, 0x31, 0x08, 0x42, 0x21, 0x08, 0x40, 0x01, 0x81,
  0x82, 0xD8, 0xD8, 0xA0, 0xA0, 0x98, 0x18, 0x13, 0x03, 0x02, 0x40, 0x40,
  0x48, 0x08, 0x0B, 0x03, 0x02, 0x40, 0x40, 0x48, 0x08, 0x09, 0x01, 0x01,
  0x20, 0x20, 0x28, 0x08, 0x09, 0x01, 0x01, 0x20, 0x20, 0x24, 0x04, 0x04,
  0x01, 0xC1, 0x66, 0x28, 0x33, 0x01, 0x30, 0x12, 0x03, 0x20, 0x26, 0x02,
  0x40, 0x24, 0x02, 0x40, 0x64, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x08,
  0x03, 0x80, 0xEE, 0x18, 0x23, 0x01, 0x20, 0x16, 0x01, 0x40, 0x14, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x28, 0x02, 0xC0, 0x44, 0x0C, 0x61, 0x83, 0xF0,
  0x00, 0x60, 0x17, 0x60, 0xB0, 0xC2, 0x81, 0x0C, 0x04, 0x20, 0x10, 0x80,
  0x46, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x84, 0x02, 0x30, 0x18, 0xC0,
  0x42, 0x86, 0x09, 0xF0, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x00, 0x00, 0x03, 0x80, 0x76, 0x46, 0x0C, 0x60, 0x62,
  0x01, 0x30, 0x09, 0x00, 0xC8, 0x04, 0xC0, 0x24, 0x01, 0x20, 0x19, 0x00,
  0xC8, 0x0C, 0x60, 0xE1, 0x0D, 0x07, 0xC8, 0x00, 0xC0, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x01, 0x8B, 0x4A, 0x06, 0x03,
  0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x07, 0x03, 0x9C, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x08, 0x02, 0x20, 0x47, 0xF0, 0x08,
  0x20, 0x40, 0x87, 0xE4, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x30,
  0x40, 0x81, 0x01, 0xE0, 0x10, 0x12, 0x01, 0x20, 0x12, 0x03, 0x20, 0x26,
  0x02, 0x40, 0x24, 0x02, 0x40, 0x64, 0x04, 0xC0, 0x48, 0x0C, 0x81, 0x44,
  0x34, 0x7C, 0x80, 0x80, 0x60, 0x28, 0x0A, 0x04, 0x83, 0x20, 0x88, 0x62,
  0x10, 0x8C, 0x32, 0x05, 0x81, 0x40, 0x60, 0x18, 0x04, 0x00, 0x81, 0x81,
  0x81, 0x83, 0x82, 0x82, 0x82, 0x82, 0x84, 0x84, 0x84, 0x84, 0x88, 0x88,
  0x88, 0x88, 0x90, 0x90, 0x90, 0x90, 0xA0, 0xB0, 0xA0, 0xA0, 0xC0, 0xA0,
  0xC0, 0xC0, 0xC0, 0xC0, 0x18, 0x18, 0x40, 0x83, 0x08, 0x08, 0x80, 0x48,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x05, 0x00, 0x48, 0x06, 0x20, 0x21, 0x02,
  0x08, 0x20, 0x23, 0x01, 0x00, 0x04, 0x02, 0x08, 0x08, 0x10, 0x10, 0x20,
  0x40, 0x40, 0x80, 0x82, 0x01, 0x84, 0x01, 0x10, 0x02, 0x20, 0x04, 0x80,
  0x09, 0x00, 0x14, 0x00, 0x28, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0xF0, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x04,
  0x00, 0x80, 0x18, 0x03, 0x00, 0x20, 0x04, 0x00, 0xFF, 0x80, 0x00, 0x40,
  0xC0, 0x60, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00,
  0x40, 0xE0, 0x38, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x70, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x02,
  0x00, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x0E, 0x03, 0x80, 0xC0, 0x10, 0x02, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x70, 0x10, 0x00, 0x30,
  0x0C, 0xE1, 0x83, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 21, 6, 1, -21 },
  { 17, 7, 8, 9, 3, -21 },
  { 24, 15, 21, 15, 1, -21 },
  { 64, 12, 24, 14, 1, -22 },
  { 100, 17, 21, 20, 2, -21 },
  { 145, 14, 21, 16, 1, -21 },
  { 182, 3, 8, 5, 3, -21 },
  { 185, 8, 26, 7, 1, -21 },
  { 211, 8, 26, 7, -2, -21 },
  { 237, 11, 11, 13, 3, -22 },
  { 253, 12, 13, 15, 2, -17 },
  { 273, 4, 7, 5, -1, -3 },
  { 277, 7, 1, 9, 1, -8 },
  { 278, 2, 2, 6, 1, -2 },
  { 279, 12, 21, 9, -1, -21 },
  { 311, 12, 21, 14, 1, -21 },
  { 343, 7, 21, 14, 4, -21 },
  { 362, 13, 21, 14, 0, -21 },
  { 397, 13, 21, 14, 0, -21 },
  { 432, 13, 21, 14, 0, -21 },
  { 467, 14, 21, 14, 0, -21 },
  { 504, 13, 21, 14, 1, -21 },
  { 539, 12, 21, 14, 2, -21 },
  { 571, 13, 21, 14, 1, -21 },
  { 606, 12, 21, 14, 1, -21 },
  { 638, 4, 15, 6, 1, -15 },
  { 646, 6, 19, 6, -1, -15 },
  { 661, 12, 13, 15, 2, -17 },
  { 681, 12, 7, 15, 2, -14 },
  { 692, 12, 13, 15, 2, -17 },
  { 712, 9, 21, 10, 2, -21 },
  { 736, 19, 24, 21, 1, -21 },
  { 793, 14, 21, 14, -2, -21 },
  { 830, 14, 21, 15, 1, -21 },
  { 867, 14, 21, 15, 2, -21 },
  { 904, 15, 21, 17, 1, -21 },
  { 944, 13, 21, 13, 1, -21 },
  { 979, 13, 21, 12, 1, -21 },
  { 1014, 15, 21, 18, 2, -21 },
  { 1054, 16, 21, 17, 1, -21 },
  { 1096, 10, 21, 7, -1, -21 },
  { 1123, 11, 26, 6, -5, -21 },
  { 1159, 15, 21, 14, 1, -21 },
  { 1199, 9, 21, 12, 1, -21 },
  { 1223, 20, 21, 21, 1, -21 },
  { 1276, 17, 21, 18, 1, -21 },
  { 1321, 15, 21, 18, 2, -21 },
  { 1361, 13, 21, 14, 1, -21 },
  { 1396, 15, 26, 18, 2, -21 },
  { 1445, 13, 21, 14, 1, -21 },
  { 1480, 13, 21, 13, 0, -21 },
  { 1515, 12, 21, 12, 3, -21 },
  { 1547, 16, 21, 17, 2, -21 },
  { 1589, 13, 21, 14, 3, -21 },
  { 1624, 21, 21, 22, 3, -21 },
  { 1680, 17, 21, 13, -2, -21 },
  { 1725, 12, 21, 12, 3, -21 },
  { 1757, 15, 21, 13, -1, -21 },
  { 1797, 10, 26, 8, 0, -21 },
  { 1830, 4, 21, 9, 3, -21 },
  { 1841, 11, 26, 8, -2, -21 },
  { 1877, 12, 12, 14, 1, -21 },
  { 1895, 9, 1, 10, -2, 3 },
  { 1897, 4, 4, 7, 4, -22 },
  { 1899, 13, 16, 14, 1, -16 },
  { 1925, 12, 22, 15, 1, -22 },
  { 1958, 11, 16, 11, 1, -16 },
  { 1980, 14, 22, 15, 1, -22 },
  { 2019, 11, 16, 13, 1, -16 },
  { 2041, 15, 29, 7, -4, -22 },
  { 2096, 14, 23, 15, 0, -16 },
  { 2137, 12, 22, 14, 1, -22 },
  { 2170, 5, 21, 6, 1, -21 },
  { 2184, 10, 28, 6, -4, -21 },
  { 2219, 12, 22, 12, 1, -22 },
  { 2252, 5, 22, 6, 1, -22 },
  { 2266, 19, 16, 22, 1, -16 },
  { 2304, 12, 16, 14, 1, -16 },
  { 2328, 12, 16, 14, 1, -16 },
  { 2352, 14, 23, 15, -1, -16 },
  { 2393, 13, 23, 15, 1, -16 },
  { 2431, 9, 16, 9, 1, -16 },
  { 2449, 11, 16, 11, 0, -16 },
  { 2471, 7, 19, 8, 1, -19 },
  { 2488, 12, 15, 14, 1, -15 },
  { 2511, 10, 15, 11, 2, -15 },
  { 2530, 16, 15, 17, 2, -15 },
  { 2560, 13, 15, 12, -1, -15 },
  { 2585, 15, 22, 11, -3, -15 },
  { 2627, 12, 15, 11, -1, -15 },
  { 2650, 10, 26, 9, 1, -21 },
  { 2683, 1, 29, 14, 7, -22 },
  { 2687, 11, 26, 9, -2, -21 },
  { 2723, 12, 3, 15, 2, -12 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic29pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC29PT7B_H_
