#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC54PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x07, 0x01, 0xE0, 0x38, 0x00, 0x30, 0x33, 0x07, 0x30, 0x63,
  0x06, 0x70, 0x66, 0x06, 0x60, 0xC6, 0x0C, 0x60, 0xC4, 0x0C, 0xC0, 0x8C,
  0x08, 0xC1, 0x88, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x40,
  0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x08, 0x02, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x0C, 0x00, 0x02, 0x01, 0x80,
  0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x80, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x04, 0x01, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x18, 0x06,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x7D, 0xBF, 0x00, 0xE1, 0x82, 0x01, 0x81, 0x00,
  0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x02, 0x00,
  0x06, 0x02, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x03, 0x06, 0x00,
  0x03, 0x84, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1B, 0xC0, 0x00, 0x18, 0xE0,
  0x00, 0x18, 0x60, 0x00, 0x10, 0x30, 0x00, 0x10, 0x30, 0x00, 0x30, 0x30,
  0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x20, 0x30, 0x00, 0x20, 0x30,
  0x00, 0x60, 0x60, 0x00, 0x60, 0xE0, 0xC0, 0x63, 0xC0, 0xFC, 0x5F, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x18, 0x1F, 0xE0, 0x00, 0xC0, 0xE1, 0x80, 0x06, 0x07, 0x03, 0x00, 0x18,
  0x18, 0x0C, 0x00, 0xC0, 0xC0, 0x30, 0x06, 0x03, 0x00, 0xC0, 0x18, 0x0C,
  0x03, 0x00, 0xC0, 0x60, 0x0C, 0x06, 0x01, 0x80, 0x30, 0x18, 0x06, 0x00,
  0xC0, 0xC0, 0x30, 0x03, 0x03, 0x00, 0xC0, 0x18, 0x18, 0x03, 0x00, 0x60,
  0xC0, 0x0C, 0x01, 0x83, 0x00, 0x30, 0x06, 0x18, 0x10, 0xC0, 0x30, 0xC3,
  0xFB, 0x00, 0xC3, 0x1C, 0x7C, 0x06, 0x18, 0xE0, 0xF0, 0x18, 0xC3, 0x03,
  0xC0, 0xC3, 0x18, 0x0D, 0x87, 0x18, 0x60, 0x37, 0xF8, 0xC3, 0x00, 0xCF,
  0x83, 0x0C, 0x03, 0x00, 0x18, 0x60, 0x0C, 0x00, 0xC1, 0x80, 0x30, 0x03,
  0x06, 0x00, 0xC0, 0x18, 0x18, 0x03, 0x00, 0xE0, 0x40, 0x0C, 0x03, 0x03,
  0x00, 0x60, 0x18, 0x0C, 0x01, 0x80, 0xE0, 0x30, 0x06, 0x03, 0x00, 0xC0,
  0x30, 0x18, 0x03, 0x00, 0xC0, 0x60, 0x0C, 0x03, 0x03, 0x00, 0x30, 0x18,
  0x18, 0x00, 0x60, 0xC0, 0x60, 0x01, 0xC7, 0x03, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x18, 0x06, 0x00, 0x06, 0x00, 0xE0, 0x00, 0xC0, 0x0C, 0x00,
  0x38, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x0E, 0x00, 0x18, 0x01,
  0x80, 0x03, 0x00, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0xC0, 0xE0, 0x00, 0x18, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x3C,
  0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x81, 0xC0, 0x18, 0xE0, 0x18, 0x03,
  0x38, 0x03, 0x80, 0xC6, 0x00, 0x30, 0x19, 0x80, 0x07, 0x06, 0x30, 0x00,
  0x61, 0xC6, 0x00, 0x06, 0x31, 0x80, 0x00, 0xCC, 0x30, 0x00, 0x0F, 0x86,
  0x00, 0x01, 0xE0, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x07, 0x81, 0x80, 0x03,
  0xB0, 0x38, 0x00, 0xE7, 0x03, 0x80, 0x38, 0x60, 0x3C, 0x3C, 0x06, 0x03,
  0xFF, 0x00, 0xE0, 0x04, 0x00, 0x00, 0x33, 0x33, 0x76, 0x66, 0x64, 0xCC,
  0xC8, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x06, 0x03, 0x00, 0xF0, 0x20,
  0x01, 0xC2, 0x00, 0x07, 0x60, 0x10, 0x1E, 0xFF, 0x00, 0x7F, 0x80, 0x0E,
  0x00, 0x03, 0xB0, 0x00, 0x73, 0x00, 0x0E, 0x18, 0x01, 0xC1, 0x80, 0x78,
  0x0C, 0x03, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x06, 0x0C, 0x38,
  0x61, 0xC3, 0x06, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x00, 0xFF, 0xFF, 0xFF,
  0x67, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF,
  0x80, 0x0E, 0x07, 0x00, 0x70, 0x0E, 0x03, 0x80, 0x18, 0x0C, 0x00, 0x60,
  0x60, 0x00, 0xC3, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x70, 0x00, 0x31, 0x80,
  0x00, 0xC6, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00,
  0xDC, 0x00, 0x03, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x76, 0x00, 0x01, 0xB8,
  0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x03, 0xB0, 0x00,
  0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x06, 0x30, 0x00, 0x18,
  0xC0, 0x00, 0xE3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x60, 0xC0,
  0x01, 0x83, 0x00, 0x0C, 0x0E, 0x00, 0x70, 0x18, 0x03, 0x80, 0x70, 0x1C,
  0x00, 0xF3, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x07,
  0x01, 0xF0, 0x3E, 0x0F, 0x61, 0xC6, 0x78, 0x6E, 0x0E, 0xC0, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x3E, 0x07, 0x80, 0x1C, 0x00, 0xC0, 0x08, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3E, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x08,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x10,
  0x00, 0x1C, 0x0C, 0x00, 0x3C, 0x07, 0xE0, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x01, 0x90, 0x00, 0x01,
  0x98, 0x00, 0x01, 0x8C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x60, 0x60, 0x00,
  0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x18, 0x00, 0x70, 0x0C, 0x00,
  0x30, 0x06, 0x00, 0x30, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x38, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x18, 0x00, 0x60, 0x18, 0x00, 0x30,
  0x1C, 0x00, 0x18, 0x0F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x04,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x80, 0x01, 0xC0, 0xC0, 0x07, 0x80, 0xFC, 0x3E, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x1F, 0x00, 0x31, 0xFF, 0x80, 0xC7, 0x07, 0x81, 0xB8, 0x03, 0x83,
  0x40, 0x03, 0x07, 0x00, 0x07, 0x1E, 0x00, 0x06, 0x38, 0x00, 0x0C, 0x70,
  0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00,
  0x01, 0x8C, 0x00, 0x07, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00,
  0x70, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x81, 0x80, 0x06, 0x03, 0x00, 0x18,
  0x03, 0x00, 0xE0, 0x03, 0xCF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x40, 0x00,
  0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x70, 0x1E, 0x00, 0xE0, 0x06, 0x01, 0xC0, 0x03, 0x01, 0x80, 0x03, 0x01,
  0x80, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03,
  0x00, 0x03, 0x03, 0x00, 0x07, 0x01, 0x80, 0x06, 0x01, 0x80, 0x0C, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x30, 0x00, 0x70, 0xE0, 0x00, 0x3B, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xE3, 0x80, 0x07, 0x81, 0xC0, 0x0E,
  0x00, 0xE0, 0x1C, 0x00, 0x70, 0x38, 0x00, 0x30, 0x30, 0x00, 0x38, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0xE0, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x38, 0x60, 0x00, 0x30, 0x60,
  0x00, 0x70, 0x30, 0x00, 0xE0, 0x3C, 0x01, 0xC0, 0x1F, 0x9F, 0x80, 0x07,
  0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xC0, 0x03,
  0x81, 0xC0, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0xC0, 0xE0, 0x01, 0x81, 0x80,
  0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x38, 0x00, 0x0C, 0x60, 0x00,
  0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x67, 0x00, 0x01, 0xCE, 0x00, 0x03,
  0x18, 0x00, 0x06, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x38, 0x60, 0x00, 0xF0,
  0xC0, 0x03, 0x60, 0xC0, 0x0F, 0x81, 0xC0, 0x3B, 0x01, 0xFF, 0xC6, 0x00,
  0xFE, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x1C, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x01, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x38, 0x1C, 0x0E, 0x00, 0x00, 0x60, 0x07,
  0x00, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0E, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0xF8, 0x0F, 0xFF, 0x07, 0x01, 0xC2, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0xC0, 0x07, 0xFE, 0x03, 0x0C, 0x01, 0xE0, 0xE0, 0x31, 0x80, 0x38, 0x0C,
  0x03, 0x18, 0x07, 0x00, 0xC0, 0x33, 0x00, 0x60, 0x0C, 0x03, 0x30, 0x0C,
  0x00, 0xC0, 0x33, 0x01, 0x80, 0x18, 0x03, 0x60, 0x18, 0x01, 0x80, 0x66,
  0x03, 0x00, 0x18, 0x06, 0x60, 0x30, 0x01, 0x00, 0x66, 0x03, 0x00, 0x30,
  0x06, 0x60, 0x30, 0x03, 0x00, 0xC4, 0x06, 0x00, 0x30, 0x0C, 0xC0, 0x60,
  0x06, 0x00, 0xCC, 0x06, 0x00, 0x60, 0x18, 0xC0, 0x60, 0x0E, 0x01, 0x8C,
  0x06, 0x00, 0xA0, 0x30, 0xC0, 0x30, 0x1A, 0x07, 0x0C, 0x03, 0x03, 0x30,
  0xE0, 0x60, 0x1F, 0xE3, 0xFC, 0x06, 0x00, 0xF8, 0x1F, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x10, 0x00, 0x03, 0xE0,
  0x0E, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x60, 0x00,
  0x03, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60,
  0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60,
  0x60, 0x00, 0x30, 0x18, 0x00, 0x1C, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x03,
  0x80, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x30, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x60, 0x00,
  0xC0, 0x38, 0x00, 0x30, 0x0C, 0x00, 0x0E, 0x07, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x60, 0xE0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x1C, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x63, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x1C, 0x07, 0xE0, 0x06, 0x00, 0x1C, 0x01, 0x80, 0x03, 0x80,
  0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x18, 0x1C, 0x00, 0x06, 0x06, 0x00,
  0x01, 0x81, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x70, 0x18, 0x00, 0x38, 0x0E,
  0x00, 0x1C, 0x03, 0x00, 0x3E, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x0C, 0x00, 0x70, 0x07, 0x00, 0x06, 0x01, 0x80, 0x01, 0xC0, 0x60, 0x00,
  0x30, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x18, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x30, 0x60, 0x00, 0x18, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x07,
  0x03, 0x80, 0x03, 0x80, 0xC0, 0x07, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xC0, 0x1C,
  0x01, 0xC0, 0x01, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x20, 0x03, 0xE1, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xC0, 0xFE, 0x00, 0x18,
  0x00, 0xF0, 0x01, 0x80, 0x03, 0x80, 0x18, 0x00, 0x1C, 0x01, 0x80, 0x00,
  0xC0, 0x30, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x60, 0x70, 0x00, 0x07, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x38, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x1C, 0x06, 0x00, 0x07, 0x80, 0x60,
  0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x80, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x00, 0x03, 0x01,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0xC0, 0x01, 0xFF, 0x8C, 0x00,
  0x1F, 0xF8, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x06, 0x07, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0xC0, 0x1E, 0x00, 0x1C, 0x00, 0xFE, 0x7F, 0xC0, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x30, 0x1C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01,
  0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x07, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x07, 0x01, 0x80, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x60, 0x38, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x01, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x01, 0x9F, 0x00, 0x1F, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00,
  0x30, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x60, 0x70, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0C, 0xF8, 0x00, 0x00, 0xD9,
  0x80, 0x00, 0x0F, 0x18, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x1C, 0x0C, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30,
  0x07, 0x00, 0x03, 0x00, 0x30, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x00, 0xC0, 0x06,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0xE0, 0x0E, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x70, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x06, 0x80, 0x00, 0x03,
  0x60, 0x1B, 0x00, 0x00, 0x19, 0x80, 0xCC, 0x00, 0x00, 0x6C, 0x03, 0x30,
  0x00, 0x03, 0x30, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x33, 0x00, 0x00, 0x63,
  0x01, 0xCC, 0x00, 0x01, 0x9C, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x18, 0xC0,
  0x00, 0x71, 0x80, 0x61, 0x80, 0x01, 0x86, 0x01, 0x86, 0x00, 0x0E, 0x18,
  0x0C, 0x18, 0x00, 0x30, 0xC0, 0x30, 0x60, 0x01, 0x83, 0x00, 0xC1, 0x80,
  0x06, 0x0C, 0x03, 0x06, 0x00, 0x30, 0x30, 0x0C, 0x18, 0x00, 0xC0, 0xC0,
  0x60, 0x60, 0x06, 0x06, 0x01, 0x80, 0xC0, 0x18, 0x18, 0x06, 0x03, 0x00,
  0xC0, 0x60, 0x18, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x30, 0x18, 0x0E, 0x03,
  0x00, 0xC0, 0xE0, 0x30, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x18,
  0x03, 0x00, 0xC0, 0x30, 0x60, 0x0C, 0x07, 0x00, 0x63, 0x00, 0x70, 0x18,
  0x01, 0x8C, 0x01, 0x80, 0x60, 0x06, 0x60, 0x06, 0x01, 0x80, 0x19, 0x80,
  0x18, 0x06, 0x00, 0x6C, 0x00, 0x60, 0x30, 0x01, 0xF0, 0x03, 0x00, 0xC0,
  0x07, 0x80, 0x0C, 0x03, 0x00, 0x1C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x07, 0x80,
  0x00, 0x30, 0x0F, 0x00, 0x00, 0x60, 0x1E, 0x00, 0x00, 0xC0, 0x36, 0x00,
  0x01, 0x80, 0x6C, 0x00, 0x07, 0x01, 0x98, 0x00, 0x0C, 0x03, 0x18, 0x00,
  0x18, 0x06, 0x30, 0x00, 0x30, 0x0C, 0x60, 0x00, 0x60, 0x38, 0xE0, 0x01,
  0xC0, 0x60, 0xC0, 0x03, 0x00, 0xC1, 0x80, 0x06, 0x01, 0x83, 0x80, 0x0C,
  0x03, 0x03, 0x00, 0x18, 0x0E, 0x06, 0x00, 0x60, 0x18, 0x0E, 0x00, 0xC0,
  0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x38, 0x0E, 0x03,
  0x00, 0x30, 0x18, 0x06, 0x00, 0x60, 0x30, 0x0C, 0x00, 0xE0, 0x60, 0x18,
  0x00, 0xC0, 0xC0, 0x30, 0x01, 0x83, 0x80, 0xC0, 0x03, 0x86, 0x01, 0x80,
  0x03, 0x0C, 0x03, 0x00, 0x06, 0x18, 0x06, 0x00, 0x0E, 0x30, 0x1C, 0x00,
  0x0C, 0xC0, 0x30, 0x00, 0x19, 0x80, 0x60, 0x00, 0x3B, 0x00, 0xC0, 0x00,
  0x36, 0x01, 0x80, 0x00, 0x6C, 0x06, 0x00, 0x00, 0xF0, 0x0C, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xE0, 0x03,
  0x80, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x70, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x06, 0x38, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0x0C, 0xE0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0x60, 0x70, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x70, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x70, 0x3F, 0x00, 0x30, 0x01, 0xC0,
  0x18, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x06,
  0x03, 0x00, 0x03, 0x81, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0xE0, 0xE0, 0x00,
  0x70, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00,
  0x0C, 0x0E, 0x00, 0x06, 0x06, 0x00, 0x06, 0x03, 0x00, 0x07, 0x01, 0x80,
  0x0F, 0x00, 0xC0, 0x1E, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x30, 0x0E,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x03, 0x38,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x1C, 0x30, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x60, 0x70, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x07, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x70, 0x3F, 0x00, 0x30, 0x01, 0xC0, 0x18, 0x00, 0x70, 0x0C,
  0x00, 0x18, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x07, 0x03, 0x00, 0x03, 0x81,
  0x80, 0x01, 0xC0, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x60, 0x60, 0x00, 0x30,
  0x30, 0x00, 0x18, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x0C, 0x0E, 0x00, 0x0E,
  0x06, 0x00, 0x0E, 0x03, 0x00, 0x0E, 0x01, 0x80, 0x1E, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x03,
  0x00, 0x0C, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x0C, 0x01, 0xC0, 0x07, 0x00, 0xC0, 0x01, 0x80, 0x60,
  0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x38, 0x1C, 0x00, 0x0C, 0x0C,
  0x00, 0x06, 0x06, 0x00, 0x03, 0x83, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x1E, 0x01, 0xE0, 0x1C, 0x00, 0x20, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x0C, 0x00, 0x38, 0x07, 0xF3, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x07, 0x00, 0x00, 0x38,
  0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x38, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x18, 0x06, 0x00, 0x01, 0x80, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x1C, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xB0, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0xCE, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x70, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x38, 0x30, 0x00, 0x18, 0x18, 0x00,
  0x1C, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x06, 0x01, 0x80,
  0x07, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x03, 0x80, 0x18, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x60, 0x00,
  0xC0, 0x30, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x0C, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0D, 0x80,
  0x00, 0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xB0, 0x00, 0x1C, 0x00, 0x06,
  0xC0, 0x00, 0xF0, 0x00, 0x3B, 0x00, 0x03, 0xC0, 0x00, 0xCC, 0x00, 0x1B,
  0x00, 0x03, 0x30, 0x00, 0x64, 0x00, 0x18, 0xC0, 0x01, 0x90, 0x00, 0x63,
  0x00, 0x0C, 0x40, 0x03, 0x0C, 0x00, 0x31, 0x00, 0x0C, 0x30, 0x01, 0x84,
  0x00, 0x70, 0xC0, 0x06, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x0E, 0x0C,
  0x00, 0xC1, 0x80, 0x30, 0x30, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x18,
  0x06, 0x03, 0x00, 0xE0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x30,
  0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x1C, 0x03, 0x01, 0x80, 0x60,
  0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x06, 0x0C, 0x00, 0xC1,
  0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x61, 0x80, 0x0C, 0x38, 0x01, 0x86,
  0x00, 0x30, 0xC0, 0x06, 0x38, 0x00, 0xC3, 0x00, 0x18, 0xC0, 0x01, 0x18,
  0x00, 0x63, 0x00, 0x04, 0x60, 0x01, 0x98, 0x00, 0x13, 0x00, 0x06, 0x60,
  0x00, 0x4C, 0x00, 0x1B, 0x00, 0x01, 0x60, 0x00, 0x6C, 0x00, 0x05, 0x80,
  0x01, 0xB0, 0x00, 0x16, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x70, 0x03, 0x00, 0x03, 0x80, 0x0C,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x03, 0x80, 0x01, 0x80,
  0x0C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x30, 0x1C,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x1C, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x38, 0x18, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x0E, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x63, 0x00,
  0x01, 0xC6, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x38, 0x38, 0x00,
  0x60, 0x30, 0x01, 0x80, 0x60, 0x07, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30,
  0x01, 0x80, 0x60, 0x03, 0x01, 0x80, 0x06, 0x07, 0x00, 0x0C, 0x0C, 0x00,
  0x18, 0x30, 0x00, 0x18, 0xE0, 0x00, 0x31, 0x80, 0x00, 0x66, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0x80, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0xC0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x00, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x00, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x04,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x06, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x68, 0x00, 0x01, 0x98, 0x00, 0x07,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x01, 0x80,
  0xC0, 0x07, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06,
  0x01, 0x80, 0x0C, 0x07, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x30,
  0xE0, 0x00, 0x31, 0x80, 0x00, 0x66, 0x00, 0x00, 0xDC, 0x00, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC1, 0x86, 0x0C, 0x30, 0x60, 0x83, 0x00,
  0x3F, 0x02, 0x01, 0xFF, 0x8C, 0x07, 0x03, 0x98, 0x1C, 0x03, 0x30, 0x70,
  0x03, 0x41, 0xC0, 0x03, 0x83, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x18, 0x00,
  0x1C, 0x70, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC6, 0x00, 0x01,
  0x8C, 0x00, 0x07, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0xE0, 0x00, 0x31,
  0xC0, 0x00, 0xE3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x0E, 0x18,
  0x00, 0x1C, 0x38, 0x00, 0x78, 0x30, 0x01, 0xA0, 0x60, 0x02, 0xC0, 0xE0,
  0x0D, 0x80, 0xC0, 0x73, 0x01, 0xF3, 0xC6, 0x00, 0xFE, 0x08, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x07, 0xE0, 0x03, 0x1F, 0xF8, 0x03, 0x38, 0x1C, 0x03,
  0x60, 0x0E, 0x06, 0xC0, 0x06, 0x06, 0x80, 0x06, 0x07, 0x80, 0x07, 0x07,
  0x00, 0x03, 0x0F, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0C,
  0x00, 0x07, 0x0C, 0x00, 0x07, 0x1C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18,
  0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x30,
  0x00, 0x0C, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x38, 0x00, 0x30, 0x78,
  0x00, 0x70, 0x68, 0x00, 0x60, 0x6C, 0x00, 0xC0, 0x4E, 0x03, 0xC0, 0xC7,
  0x8F, 0x00, 0xC3, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xE0, 0x0F,
  0xFF, 0x01, 0xE0, 0x20, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x02, 0x01, 0xF1, 0xE0, 0x07, 0xFC, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x3F, 0x83, 0x00, 0x3F, 0xF0, 0xC0, 0x1C, 0x06, 0x60,
  0x0E, 0x00, 0xD8, 0x07, 0x00, 0x16, 0x03, 0x80, 0x07, 0x80, 0xC0, 0x01,
  0xE0, 0x70, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x03, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06,
  0x00, 0x01, 0x81, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x0C,
  0x0C, 0x00, 0x07, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0xF0, 0x30, 0x00,
  0x38, 0x0E, 0x00, 0x1E, 0x01, 0x80, 0x0F, 0x80, 0x60, 0x03, 0x60, 0x1C,
  0x01, 0x98, 0x03, 0x01, 0xCC, 0x00, 0xF9, 0xE3, 0x00, 0x0F, 0xE0, 0xC0,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x0F, 0x07, 0x03,
  0x80, 0x70, 0xE0, 0x06, 0x18, 0x00, 0xC6, 0x00, 0x19, 0xC0, 0x03, 0x30,
  0x00, 0xEE, 0x00, 0x19, 0x80, 0x07, 0x30, 0x01, 0xCE, 0x01, 0xE1, 0x87,
  0xF8, 0x3F, 0xF8, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x08, 0x1F, 0x0F, 0x00, 0xFF,
  0xC0, 0x01, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0xC0, 0x0F,
  0xFC, 0x30, 0x07, 0x81, 0x88, 0x03, 0x80, 0x36, 0x01, 0xC0, 0x05, 0x80,
  0xE0, 0x01, 0xE0, 0x30, 0x00, 0x78, 0x1C, 0x00, 0x0C, 0x06, 0x00, 0x03,
  0x03, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x18, 0x18, 0x00,
  0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x38, 0x38,
  0x00, 0x0C, 0x0E, 0x00, 0x03, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x70,
  0x30, 0x00, 0x3C, 0x0C, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x80, 0x60, 0x03,
  0xE0, 0x18, 0x00, 0xD8, 0x07, 0x00, 0x64, 0x00, 0xC0, 0x73, 0x00, 0x3E,
  0x78, 0xC0, 0x03, 0xF8, 0x30, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x08, 0x00,
  0x70, 0x03, 0xC0, 0x78, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x7F, 0x00, 0x63, 0xFF, 0x00, 0xCE, 0x07, 0x01, 0xB0, 0x06, 0x06, 0xC0,
  0x0E, 0x0F, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x38, 0x00, 0x30, 0x60, 0x00,
  0x61, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C,
  0x38, 0x00, 0x38, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83,
  0x00, 0x03, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60,
  0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00,
  0x0C, 0x18, 0x00, 0x18, 0x70, 0x00, 0x30, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x1C, 0x07, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x01, 0xC0, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x30,
  0x03, 0x80, 0xC0, 0x1C, 0x06, 0x00, 0xE0, 0x18, 0x07, 0x00, 0x60, 0x38,
  0x01, 0x81, 0xC0, 0x0E, 0x0E, 0x00, 0x30, 0x70, 0x00, 0xC1, 0x80, 0x03,
  0x0C, 0x00, 0x0C, 0x60, 0x00, 0x63, 0xC0, 0x01, 0x9B, 0x00, 0x06, 0xCC,
  0x00, 0x1E, 0x18, 0x00, 0x70, 0x60, 0x03, 0x81, 0x80, 0x0C, 0x03, 0x00,
  0x30, 0x0C, 0x00, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60,
  0x07, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x38, 0x00, 0x60, 0xC0, 0x01,
  0x80, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x00, 0x03, 0x07,
  0xE0, 0x1F, 0x80, 0x31, 0xFF, 0x07, 0xFE, 0x03, 0x30, 0x38, 0xE0, 0x70,
  0x26, 0x01, 0x98, 0x03, 0x06, 0xC0, 0x19, 0x00, 0x30, 0x78, 0x01, 0xB0,
  0x03, 0x07, 0x00, 0x1E, 0x00, 0x30, 0x70, 0x01, 0xC0, 0x03, 0x06, 0x00,
  0x1C, 0x00, 0x30, 0xE0, 0x01, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0xC0, 0x01, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x00, 0x61, 0xC0, 0x03, 0x00,
  0x06, 0x18, 0x00, 0x30, 0x00, 0x61, 0x80, 0x03, 0x00, 0x06, 0x18, 0x00,
  0x30, 0x00, 0x61, 0x80, 0x07, 0x00, 0x0C, 0x30, 0x00, 0x60, 0x00, 0xC3,
  0x00, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x00,
  0x1C, 0x30, 0x00, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x00, 0x18, 0x60, 0x00,
  0xC0, 0x01, 0x86, 0x00, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC0, 0x03, 0x0E,
  0x00, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x07, 0xF0,
  0x06, 0x3F, 0xF0, 0x0C, 0xE0, 0x70, 0x13, 0x00, 0x60, 0x6C, 0x00, 0xE0,
  0xF0, 0x00, 0xC1, 0xE0, 0x01, 0x83, 0x80, 0x03, 0x0E, 0x00, 0x0E, 0x1C,
  0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x80,
  0x03, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00,
  0x30, 0xC0, 0x00, 0xE1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06,
  0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1,
  0x80, 0x01, 0x87, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0x80, 0x1E, 0x07, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x18, 0x38,
  0x00, 0x70, 0xC0, 0x00, 0xC7, 0x00, 0x03, 0x18, 0x00, 0x0C, 0xE0, 0x00,
  0x33, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x36,
  0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x80, 0x00, 0x6E, 0x00,
  0x01, 0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x33, 0x80, 0x01, 0xC6, 0x00, 0x06,
  0x18, 0x00, 0x38, 0x60, 0x01, 0xC0, 0xC0, 0x0E, 0x03, 0x80, 0x70, 0x07,
  0x8F, 0x80, 0x0F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC1, 0xFC, 0x00,
  0x31, 0xFF, 0x80, 0x0C, 0xE0, 0x70, 0x02, 0x70, 0x0E, 0x01, 0xB0, 0x01,
  0x80, 0x6C, 0x00, 0x60, 0x1E, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0xC0, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x0C, 0x0C, 0x00, 0x07, 0x03,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06,
  0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0x30, 0x00,
  0x0C, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xE0, 0x00, 0xC0, 0x78,
  0x00, 0x70, 0x1A, 0x00, 0x18, 0x06, 0xC0, 0x0C, 0x01, 0xB8, 0x0E, 0x00,
  0xE7, 0x8F, 0x00, 0x30, 0xFF, 0x80, 0x0C, 0x02, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x83, 0x00, 0xFF, 0xC3, 0x01, 0xE0, 0x62, 0x03, 0x80,
  0x36, 0x07, 0x00, 0x16, 0x0E, 0x00, 0x1E, 0x0C, 0x00, 0x1E, 0x1C, 0x00,
  0x0C, 0x18, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x30, 0x00,
  0x18, 0x70, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00,
  0x38, 0x60, 0x00, 0x30, 0xE0, 0x00, 0x30, 0xC0, 0x00, 0x70, 0xC0, 0x00,
  0x70, 0xC0, 0x00, 0xF0, 0xC0, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0x60, 0x01,
  0xE0, 0x60, 0x03, 0x60, 0x70, 0x06, 0x60, 0x30, 0x1C, 0xC0, 0x3E, 0x78,
  0xC0, 0x0F, 0xE0, 0xC0, 0x01, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x03, 0x07, 0xC0, 0xC7, 0xF0,
  0x33, 0x80, 0x09, 0x80, 0x06, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x03, 0x80, 0x60, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0xC0, 0x0E, 0x0F, 0x87, 0xC0, 0x7F,
  0xF0, 0x00, 0x70, 0x00, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x03, 0xFF, 0x7F, 0xFC, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0x10, 0x1F, 0xC0, 0x08, 0x00, 0x06, 0x00, 0x06,
  0x0C, 0x00, 0x0C, 0x38, 0x00, 0x38, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1,
  0x80, 0x01, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x06, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x70, 0x00, 0x70, 0xC0, 0x00,
  0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x1C,
  0x30, 0x00, 0x70, 0x60, 0x01, 0xE0, 0xE0, 0x06, 0xC0, 0xC0, 0x1D, 0x81,
  0xC0, 0x72, 0x01, 0xE7, 0x84, 0x01, 0xFE, 0x18, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x7C, 0x00, 0x06, 0xC0, 0x00, 0xEC, 0x00, 0x0C, 0xC0, 0x01,
  0xCC, 0x00, 0x18, 0xC0, 0x03, 0x8E, 0x00, 0x30, 0x60, 0x06, 0x06, 0x00,
  0x60, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x30, 0x06, 0x03, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x30, 0xC0, 0x03,
  0x0C, 0x00, 0x31, 0x80, 0x03, 0x38, 0x00, 0x33, 0x00, 0x03, 0x70, 0x00,
  0x36, 0x00, 0x03, 0x60, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x01, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x36, 0x00, 0x3C, 0x00, 0x6C, 0x00, 0x78, 0x01, 0x98, 0x01, 0xB0, 0x03,
  0x30, 0x03, 0x60, 0x0E, 0x60, 0x0C, 0xC0, 0x18, 0xC0, 0x19, 0x80, 0x31,
  0x80, 0x63, 0x00, 0xC3, 0x00, 0xC6, 0x01, 0x86, 0x01, 0x0C, 0x06, 0x04,
  0x06, 0x08, 0x0C, 0x08, 0x0C, 0x10, 0x30, 0x18, 0x30, 0x20, 0x60, 0x30,
  0x60, 0x61, 0xC0, 0x61, 0x80, 0xC3, 0x00, 0xC3, 0x01, 0x86, 0x01, 0x8C,
  0x03, 0x18, 0x03, 0x18, 0x06, 0x30, 0x06, 0x60, 0x0C, 0xC0, 0x0C, 0xC0,
  0x19, 0x80, 0x1B, 0x00, 0x36, 0x00, 0x36, 0x00, 0x6C, 0x00, 0x78, 0x00,
  0xD0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x03, 0x80, 0xC0, 0x01,
  0x80, 0x60, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x01, 0xC0, 0x06, 0x00,
  0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x18,
  0xE0, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x60, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x31, 0x80, 0x00, 0x38, 0x60, 0x00, 0x18, 0x30, 0x00,
  0x18, 0x1C, 0x00, 0x18, 0x06, 0x00, 0x1C, 0x03, 0x00, 0x1C, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x0C, 0x0E, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x03, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0xE0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80,
  0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x40,
  0x00, 0x07, 0xC0, 0x01, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x3F,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xC0, 0x05, 0xC3, 0xE0,
  0x1E, 0x00, 0xF9, 0xE8, 0x00, 0x7F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 11, 39, 12, 1, -39 },
  { 55, 12, 14, 17, 6, -39 },
  { 76, 28, 39, 29, 1, -39 },
  { 213, 24, 44, 26, 1, -41 },
  { 345, 30, 40, 37, 4, -39 },
  { 495, 27, 40, 30, 1, -39 },
  { 630, 4, 14, 9, 6, -39 },
  { 637, 15, 48, 13, 2, -39 },
  { 727, 16, 48, 13, -4, -39 },
  { 823, 20, 20, 25, 6, -41 },
  { 873, 23, 25, 28, 3, -32 },
  { 945, 7, 13, 10, -2, -6 },
  { 957, 12, 2, 16, 2, -16 },
  { 960, 4, 4, 11, 1, -4 },
  { 962, 23, 39, 17, -2, -39 },
  { 1075, 22, 40, 26, 3, -39 },
  { 1185, 12, 39, 26, 8, -39 },
  { 1244, 25, 39, 26, 0, -39 },
  { 1366, 25, 40, 26, 0, -39 },
  { 1491, 25, 39, 26, 0, -39 },
  { 1613, 24, 40, 26, 1, -39 },
  { 1733, 23, 40, 26, 3, -39 },
  { 1848, 23, 39, 26, 4, -39 },
  { 1961, 24, 40, 26, 1, -39 },
  { 2081, 23, 40, 26, 2, -39 },
  { 2196, 9, 29, 11, 1, -29 },
  { 2229, 12, 36, 11, -2, -29 },
  { 2283, 23, 24, 28, 3, -31 },
  { 2352, 23, 13, 28, 3, -26 },
  { 2390, 23, 24, 28, 3, -31 },
  { 2459, 17, 39, 19, 3, -39 },
  { 2542, 36, 43, 39, 2, -38 },
  { 2736, 26, 39, 26, -3, -39 },
  { 2863, 26, 39, 28, 2, -39 },
  { 2990, 26, 40, 27, 4, -39 },
  { 3120, 28, 39, 31, 2, -39 },
  { 3257, 25, 39, 25, 2, -39 },
  { 3379, 25, 39, 23, 2, -39 },
  { 3501, 28, 40, 33, 4, -39 },
  { 3641, 30, 39, 32, 2, -39 },
  { 3788, 17, 39, 14, -1, -39 },
  { 3871, 21, 49, 11, -9, -39 },
  { 4000, 28, 39, 26, 2, -39 },
  { 4137, 17, 39, 23, 2, -39 },
  { 4220, 38, 39, 40, 2, -39 },
  { 4406, 31, 39, 33, 2, -39 },
  { 4558, 29, 40, 34, 3, -39 },
  { 4703, 25, 39, 26, 2, -39 },
  { 4825, 29, 48, 34, 3, -39 },
  { 4999, 25, 39, 27, 2, -39 },
  { 5121, 25, 40, 24, 0, -39 },
  { 5246, 22, 39, 23, 5, -39 },
  { 5354, 29, 40, 32, 4, -39 },
  { 5499, 25, 39, 25, 5, -39 },
  { 5621, 38, 39, 41, 6, -39 },
  { 5807, 30, 39, 23, -3, -39 },
  { 5954, 23, 39, 23, 5, -39 },
  { 6067, 28, 39, 25, -1, -39 },
  { 6204, 20, 48, 16, -1, -39 },
  { 6324, 9, 39, 17, 5, -39 },
  { 6368, 20, 48, 16, -4, -39 },
  { 6488, 23, 22, 27, 2, -39 },
  { 6552, 18, 2, 18, -4, 5 },
  { 6557, 6, 8, 12, 8, -41 },
  { 6563, 23, 30, 27, 2, -29 },
  { 6650, 24, 42, 27, 1, -41 },
  { 6776, 20, 30, 21, 2, -29 },
  { 6851, 26, 42, 27, 2, -41 },
  { 6988, 19, 30, 24, 3, -29 },
  { 7060, 27, 54, 13, -7, -41 },
  { 7243, 26, 42, 27, 0, -29 },
  { 7380, 23, 41, 26, 1, -41 },
  { 7498, 11, 39, 11, 1, -39 },
  { 7552, 19, 52, 11, -7, -39 },
  { 7676, 22, 41, 22, 1, -41 },
  { 7789, 11, 41, 11, 1, -41 },
  { 7846, 36, 29, 40, 1, -29 },
  { 7977, 23, 29, 26, 1, -29 },
  { 8061, 22, 30, 27, 2, -29 },
  { 8144, 26, 42, 27, -1, -29 },
  { 8281, 24, 42, 27, 2, -29 },
  { 8407, 18, 29, 18, 1, -29 },
  { 8473, 20, 30, 20, 0, -29 },
  { 8548, 14, 37, 15, 2, -36 },
  { 8613, 23, 30, 26, 2, -29 },
  { 8700, 20, 29, 20, 3, -29 },
  { 8773, 31, 29, 32, 3, -29 },
  { 8886, 25, 29, 22, -2, -29 },
  { 8977, 29, 42, 20, -6, -29 },
  { 9130, 21, 29, 20, -1, -29 },
  { 9207, 20, 48, 18, 1, -39 },
  { 9327, 1, 54, 25, 13, -41 },
  { 9334, 19, 48, 18, -3, -39 },
  { 9448, 23, 5, 28, 3, -22 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic54pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC54PT7B_H_
