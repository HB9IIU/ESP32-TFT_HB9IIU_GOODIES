#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC22PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x22, 0x22, 0x24, 0x44, 0x44, 0x00, 0x88, 0x4A, 0x52, 0x99,
  0x48, 0x02, 0x20, 0x22, 0x04, 0x40, 0x44, 0x04, 0x43, 0xFF, 0x08, 0x80,
  0x88, 0x08, 0x81, 0x10, 0xFF, 0xE1, 0x10, 0x22, 0x02, 0x20, 0x22, 0x04,
  0x20, 0x02, 0x01, 0x03, 0xC6, 0x92, 0x42, 0x21, 0x10, 0x50, 0x18, 0x06,
  0x02, 0x81, 0x21, 0x10, 0x88, 0x49, 0xF8, 0x20, 0x10, 0x00, 0x38, 0x24,
  0x82, 0x88, 0x48, 0x88, 0x88, 0x88, 0x90, 0x8A, 0x69, 0x29, 0x95, 0x1E,
  0x91, 0x09, 0x11, 0x21, 0x22, 0x12, 0x22, 0x42, 0x2C, 0x1C, 0x0F, 0x02,
  0x20, 0x42, 0x08, 0x41, 0x10, 0x26, 0x05, 0x00, 0xC0, 0x28, 0x28, 0x8A,
  0x11, 0x41, 0x48, 0x19, 0x02, 0x20, 0xA3, 0xE4, 0x55, 0xA0, 0x04, 0x21,
  0x08, 0x21, 0x04, 0x10, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x04,
  0x00, 0x08, 0x20, 0x81, 0x04, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x41,
  0x08, 0x21, 0x08, 0x00, 0x08, 0x08, 0x90, 0x50, 0x3F, 0x30, 0x48, 0x88,
  0x0C, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x3F, 0xF0, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x25, 0x28, 0xF8, 0xC0, 0x00, 0x40, 0x20, 0x10, 0x04, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x02, 0x00, 0x0F, 0x08, 0x48, 0x24, 0x14, 0x0A, 0x05, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x50, 0x28, 0x14, 0x11, 0x10, 0xF0, 0x08, 0xDB, 0x11, 0x08,
  0x42, 0x21, 0x08, 0x42, 0x21, 0x08, 0x0F, 0x84, 0x30, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x03, 0xFC, 0x0F, 0x84, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x7C,
  0x03, 0x00, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x13, 0xF8, 0x00, 0x40,
  0x30, 0x14, 0x0A, 0x02, 0x81, 0x20, 0x88, 0x42, 0x21, 0x08, 0x44, 0x13,
  0xFF, 0x02, 0x00, 0x80, 0x20, 0x08, 0x0F, 0xC2, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x02, 0xC0, 0xCC, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40,
  0x33, 0xF0, 0x07, 0xC2, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0xC1, 0xCC,
  0xC1, 0x20, 0x48, 0x12, 0x04, 0x81, 0x20, 0x44, 0x21, 0xF0, 0x7F, 0xC0,
  0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02,
  0x02, 0x01, 0x01, 0x00, 0x0F, 0x08, 0x48, 0x24, 0x12, 0x09, 0x04, 0x4C,
  0x18, 0x34, 0x21, 0x20, 0x50, 0x28, 0x14, 0x0A, 0x08, 0xF8, 0x0E, 0x08,
  0x88, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x83, 0x42, 0x9E, 0x80, 0x40, 0x20,
  0x20, 0x20, 0x31, 0xE0, 0x11, 0x00, 0x00, 0x00, 0x00, 0x4C, 0x08, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x84, 0x22, 0x00, 0x00, 0x40, 0x60, 0x60,
  0x60, 0x60, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x70,
  0x60, 0x60, 0x60, 0x20, 0x00, 0x3C, 0x84, 0x08, 0x10, 0x20, 0x41, 0x04,
  0x10, 0x41, 0x02, 0x00, 0x00, 0x10, 0x60, 0x01, 0xE0, 0x18, 0x60, 0x80,
  0x84, 0x01, 0x20, 0x05, 0x0F, 0x94, 0x44, 0x62, 0x11, 0x88, 0x46, 0x21,
  0x18, 0x88, 0x62, 0x22, 0x89, 0x52, 0x18, 0x88, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x7E, 0x00, 0x00, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x81, 0x20, 0x48,
  0x21, 0x08, 0x47, 0xF1, 0x04, 0x81, 0x20, 0x50, 0x18, 0x06, 0x01, 0x1F,
  0x04, 0x32, 0x04, 0x81, 0x20, 0x48, 0x12, 0x09, 0xFC, 0x41, 0x10, 0x24,
  0x09, 0x02, 0x80, 0xA0, 0x48, 0x33, 0xF0, 0x03, 0xE1, 0x84, 0x40, 0x10,
  0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x18, 0x01, 0xF8, 0x1F, 0x02, 0x18, 0x81, 0x10, 0x12, 0x02,
  0x40, 0x48, 0x0A, 0x01, 0x40, 0x28, 0x05, 0x01, 0x20, 0x28, 0x09, 0x02,
  0x20, 0x87, 0xE0, 0x1F, 0xC4, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01,
  0xFC, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x03, 0xF8, 0x1F,
  0xC4, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x7F, 0x10, 0x04,
  0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x03, 0xE0, 0xC1, 0x10, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x81, 0xE8, 0x02, 0x80, 0x28,
  0x04, 0x40, 0x44, 0x04, 0x20, 0x41, 0xF8, 0x10, 0x11, 0x01, 0x20, 0x12,
  0x01, 0x20, 0x22, 0x02, 0x20, 0x27, 0xFE, 0x40, 0x24, 0x04, 0x40, 0x44,
  0x04, 0x80, 0x48, 0x08, 0x80, 0x88, 0x08, 0x1E, 0x10, 0x20, 0x41, 0x02,
  0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0x70, 0x01, 0x01, 0x01,
  0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x10, 0x10, 0xE0, 0x10, 0x22, 0x08, 0x82, 0x10, 0x82, 0x20,
  0x48, 0x0A, 0x02, 0xC0, 0x68, 0x08, 0x81, 0x10, 0x22, 0x08, 0x21, 0x04,
  0x20, 0x44, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81,
  0x02, 0x08, 0x10, 0x20, 0x7F, 0x10, 0x02, 0x20, 0x0C, 0xA0, 0x19, 0x40,
  0x52, 0x80, 0xC5, 0x02, 0x8A, 0x09, 0x24, 0x12, 0x48, 0x44, 0x90, 0x91,
  0x12, 0x22, 0x24, 0x48, 0x50, 0x90, 0xA1, 0x21, 0x84, 0x42, 0x08, 0x10,
  0x11, 0x01, 0x28, 0x12, 0x81, 0x28, 0x12, 0x42, 0x24, 0x24, 0x42, 0x42,
  0x24, 0x24, 0x42, 0x44, 0x14, 0x81, 0x48, 0x14, 0x80, 0x88, 0x08, 0x07,
  0xC0, 0x82, 0x10, 0x22, 0x01, 0x20, 0x14, 0x01, 0x40, 0x14, 0x01, 0x80,
  0x18, 0x02, 0x80, 0x28, 0x02, 0x40, 0x44, 0x04, 0x60, 0x83, 0xF0, 0x1F,
  0x04, 0x22, 0x04, 0x81, 0x20, 0x48, 0x12, 0x09, 0x02, 0x47, 0x1E, 0x04,
  0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x07, 0xC0, 0x82, 0x10, 0x22,
  0x01, 0x20, 0x14, 0x01, 0x40, 0x14, 0x01, 0x80, 0x18, 0x02, 0x80, 0x28,
  0x02, 0x40, 0x44, 0x04, 0x60, 0x83, 0xF0, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x1F, 0x04, 0x22, 0x04, 0x81, 0x20, 0x48, 0x12, 0x09, 0x06, 0x7E,
  0x11, 0x04, 0x41, 0x08, 0x82, 0x20, 0x88, 0x12, 0x04, 0x07, 0x86, 0x11,
  0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x33, 0xF0, 0xFF, 0x84, 0x02, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x10,
  0x11, 0x01, 0x20, 0x12, 0x01, 0x20, 0x22, 0x02, 0x40, 0x24, 0x02, 0x40,
  0x24, 0x04, 0x40, 0x48, 0x04, 0x80, 0x44, 0x08, 0x41, 0x03, 0xE0, 0x80,
  0x60, 0x18, 0x0A, 0x02, 0x81, 0x20, 0x48, 0x21, 0x08, 0x44, 0x11, 0x04,
  0x81, 0x20, 0x50, 0x14, 0x06, 0x01, 0x80, 0x80, 0x81, 0x81, 0x81, 0x81,
  0x82, 0x82, 0x82, 0x82, 0x84, 0x84, 0x84, 0x84, 0x88, 0x84, 0x88, 0x88,
  0x88, 0x88, 0x90, 0x50, 0x90, 0x50, 0xA0, 0x60, 0xA0, 0x60, 0xC0, 0x40,
  0xC0, 0x40, 0x80, 0x08, 0x10, 0x82, 0x08, 0x20, 0x84, 0x04, 0x80, 0x50,
  0x05, 0x00, 0x20, 0x06, 0x00, 0xA0, 0x09, 0x01, 0x10, 0x21, 0x02, 0x10,
  0x40, 0x88, 0x08, 0x80, 0xC0, 0xA0, 0x48, 0x44, 0x22, 0x21, 0x20, 0x50,
  0x30, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x1F, 0xE0, 0x08,
  0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x80, 0x20, 0x07, 0xF8, 0x0F, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80,
  0x80, 0xF0, 0x88, 0x84, 0x44, 0x44, 0x42, 0x22, 0x22, 0x21, 0x0F, 0x80,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x3E, 0x00, 0x04, 0x03, 0x02, 0x82,
  0x41, 0x11, 0x09, 0x04, 0x81, 0x80, 0x80, 0xFF, 0x89, 0x10, 0x0E, 0x98,
  0xC8, 0x68, 0x14, 0x14, 0x0A, 0x05, 0x02, 0x83, 0x41, 0x21, 0x8F, 0x40,
  0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x05, 0xE1, 0x8C, 0xC1, 0x30, 0x48,
  0x12, 0x04, 0x81, 0x40, 0x50, 0x24, 0x09, 0x84, 0x9E, 0x00, 0x0F, 0x30,
  0x20, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x7C, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x1C, 0x8C, 0x61, 0x04, 0x40, 0x88, 0x12,
  0x04, 0x40, 0x88, 0x11, 0x02, 0x20, 0xC4, 0x30, 0x7A, 0x00, 0x0E, 0x31,
  0x21, 0x41, 0x42, 0x8C, 0xF0, 0x80, 0x80, 0x80, 0x40, 0x7C, 0x00, 0xE0,
  0x20, 0x04, 0x01, 0x00, 0x20, 0x1F, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x01, 0xC0, 0x00, 0x07, 0x23, 0x18, 0x41, 0x10, 0x22, 0x04,
  0x81, 0x10, 0x22, 0x04, 0x40, 0x88, 0x31, 0x0C, 0x1E, 0x80, 0x10, 0x02,
  0x00, 0x80, 0x10, 0xFC, 0x00, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x05,
  0xE1, 0x88, 0xC1, 0x20, 0x48, 0x12, 0x08, 0x82, 0x40, 0x90, 0x24, 0x11,
  0x04, 0x81, 0x00, 0x08, 0xC0, 0x01, 0x08, 0x84, 0x21, 0x08, 0x84, 0x21,
  0x10, 0x01, 0x03, 0x00, 0x00, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0xE0, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x31, 0x10, 0x84, 0x22, 0x09, 0x02, 0x80,
  0xE0, 0x64, 0x11, 0x04, 0x21, 0x08, 0x82, 0x00, 0x08, 0x44, 0x21, 0x08,
  0x44, 0x21, 0x08, 0x44, 0x21, 0x08, 0x80, 0x17, 0x1C, 0x31, 0x44, 0xC3,
  0x09, 0x04, 0x12, 0x08, 0x24, 0x10, 0x48, 0x20, 0xA0, 0x82, 0x41, 0x04,
  0x82, 0x09, 0x04, 0x14, 0x08, 0x20, 0x17, 0x86, 0x33, 0x04, 0x81, 0x20,
  0x48, 0x22, 0x09, 0x02, 0x40, 0x90, 0x44, 0x12, 0x04, 0x0E, 0x18, 0x88,
  0x28, 0x14, 0x0C, 0x06, 0x03, 0x02, 0x81, 0x40, 0xA0, 0x8F, 0x80, 0x0B,
  0xC1, 0x8C, 0x60, 0x8C, 0x11, 0x02, 0x20, 0x44, 0x09, 0x01, 0x20, 0x44,
  0x08, 0xC2, 0x17, 0x84, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x00, 0x0E,
  0x4C, 0x62, 0x09, 0x02, 0x40, 0xA0, 0x28, 0x12, 0x04, 0x81, 0x20, 0xC8,
  0x61, 0xE8, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x00, 0x17, 0x18, 0x30,
  0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x80, 0x1E, 0x21, 0x20,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x04, 0xF8, 0x21, 0x3E, 0x44,
  0x21, 0x08, 0x84, 0x21, 0x08, 0x70, 0x20, 0xA0, 0x50, 0x28, 0x14, 0x12,
  0x0A, 0x05, 0x02, 0x82, 0x41, 0x21, 0x8F, 0x40, 0x81, 0x81, 0x82, 0x82,
  0x84, 0x44, 0x48, 0x48, 0x50, 0x50, 0x60, 0x40, 0x82, 0x0C, 0x10, 0xA1,
  0x85, 0x0C, 0x28, 0xA2, 0x45, 0x12, 0x49, 0x12, 0x28, 0xA1, 0x85, 0x0C,
  0x10, 0x40, 0x82, 0x00, 0x10, 0x44, 0x20, 0x88, 0x24, 0x0A, 0x01, 0x00,
  0xC0, 0x30, 0x12, 0x08, 0x84, 0x13, 0x04, 0x10, 0x22, 0x04, 0x41, 0x04,
  0x20, 0x88, 0x11, 0x02, 0x40, 0x48, 0x0A, 0x01, 0x40, 0x30, 0x02, 0x00,
  0x80, 0x10, 0x04, 0x00, 0x80, 0xE0, 0x00, 0x3F, 0x01, 0x02, 0x04, 0x04,
  0x08, 0x10, 0x20, 0x20, 0x40, 0x80, 0xFC, 0x06, 0x10, 0x20, 0x81, 0x02,
  0x04, 0x10, 0x21, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x81, 0x01, 0xC0,
  0xFF, 0xFF, 0xFC, 0x08, 0x06, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04,
  0x07, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x60, 0x80, 0x70,
  0x63, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 16, 5, 1, -16 },
  { 9, 5, 6, 7, 2, -16 },
  { 13, 12, 16, 12, 0, -16 },
  { 37, 9, 18, 11, 1, -17 },
  { 58, 12, 16, 15, 2, -16 },
  { 82, 11, 16, 12, 1, -16 },
  { 104, 2, 6, 4, 2, -16 },
  { 106, 6, 19, 5, 1, -16 },
  { 121, 6, 19, 5, -1, -16 },
  { 136, 8, 9, 10, 3, -17 },
  { 145, 10, 10, 11, 1, -13 },
  { 158, 3, 5, 4, -1, -2 },
  { 160, 5, 1, 6, 1, -6 },
  { 161, 1, 2, 4, 1, -2 },
  { 162, 10, 16, 7, -1, -16 },
  { 182, 9, 16, 11, 1, -16 },
  { 200, 5, 16, 11, 3, -16 },
  { 210, 10, 16, 11, 0, -16 },
  { 230, 10, 16, 11, 0, -16 },
  { 250, 10, 16, 11, 0, -16 },
  { 270, 10, 16, 11, 0, -16 },
  { 290, 10, 16, 11, 1, -16 },
  { 310, 9, 16, 11, 2, -16 },
  { 328, 9, 16, 11, 1, -16 },
  { 346, 9, 16, 11, 1, -16 },
  { 364, 4, 12, 4, 0, -12 },
  { 370, 5, 15, 4, -1, -12 },
  { 380, 10, 10, 11, 1, -13 },
  { 393, 10, 5, 11, 1, -10 },
  { 400, 10, 10, 11, 1, -13 },
  { 413, 7, 16, 8, 1, -16 },
  { 427, 14, 18, 16, 1, -16 },
  { 459, 10, 16, 10, -1, -16 },
  { 479, 10, 16, 11, 1, -16 },
  { 499, 11, 16, 11, 1, -16 },
  { 521, 11, 16, 13, 1, -16 },
  { 543, 10, 16, 10, 1, -16 },
  { 563, 10, 16, 9, 1, -16 },
  { 583, 12, 16, 13, 1, -16 },
  { 607, 12, 16, 13, 1, -16 },
  { 631, 7, 16, 6, 0, -16 },
  { 645, 8, 20, 5, -3, -16 },
  { 665, 11, 16, 11, 1, -16 },
  { 687, 7, 16, 9, 1, -16 },
  { 701, 15, 16, 16, 1, -16 },
  { 731, 12, 16, 13, 1, -16 },
  { 755, 12, 16, 14, 1, -16 },
  { 779, 10, 16, 11, 1, -16 },
  { 799, 12, 20, 14, 1, -16 },
  { 829, 10, 16, 11, 1, -16 },
  { 849, 10, 16, 10, 0, -16 },
  { 869, 9, 16, 9, 2, -16 },
  { 887, 12, 16, 13, 1, -16 },
  { 911, 10, 16, 10, 2, -16 },
  { 931, 16, 16, 17, 2, -16 },
  { 963, 12, 16, 9, -1, -16 },
  { 987, 9, 16, 9, 2, -16 },
  { 1005, 11, 16, 10, 0, -16 },
  { 1027, 8, 19, 6, 0, -16 },
  { 1046, 4, 16, 7, 2, -16 },
  { 1054, 9, 19, 6, -2, -16 },
  { 1076, 9, 9, 11, 1, -16 },
  { 1087, 8, 1, 7, -2, 2 },
  { 1088, 3, 4, 5, 3, -17 },
  { 1090, 9, 12, 11, 1, -12 },
  { 1104, 10, 17, 11, 0, -17 },
  { 1126, 8, 12, 9, 1, -12 },
  { 1138, 11, 17, 11, 1, -17 },
  { 1162, 8, 12, 10, 1, -12 },
  { 1174, 11, 22, 5, -3, -17 },
  { 1205, 11, 17, 11, 0, -12 },
  { 1229, 10, 17, 11, 0, -17 },
  { 1251, 5, 16, 4, 0, -16 },
  { 1261, 8, 21, 4, -3, -16 },
  { 1282, 10, 17, 9, 0, -17 },
  { 1304, 5, 17, 4, 0, -17 },
  { 1315, 15, 12, 16, 0, -12 },
  { 1338, 10, 12, 11, 0, -12 },
  { 1353, 9, 12, 11, 1, -12 },
  { 1367, 11, 17, 11, -1, -12 },
  { 1391, 10, 17, 11, 1, -12 },
  { 1413, 8, 12, 7, 0, -12 },
  { 1425, 8, 12, 8, 0, -12 },
  { 1437, 5, 14, 6, 1, -14 },
  { 1446, 9, 12, 11, 1, -12 },
  { 1460, 8, 12, 8, 1, -12 },
  { 1472, 13, 12, 13, 1, -12 },
  { 1492, 10, 12, 9, -1, -12 },
  { 1507, 11, 17, 8, -2, -12 },
  { 1531, 8, 12, 8, 0, -12 },
  { 1543, 7, 19, 7, 1, -16 },
  { 1560, 1, 22, 10, 5, -17 },
  { 1563, 8, 20, 7, -1, -16 },
  { 1583, 10, 2, 11, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic22pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC22PT7B_H_
