#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC57PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xE0, 0x00, 0x18, 0x39, 0xC1, 0xCE, 0x0C, 0x60, 0x63, 0x03, 0x18,
  0x38, 0xC1, 0x8C, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x10, 0x81, 0x8C, 0x0C,
  0x60, 0x63, 0x02, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x60, 0x08, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x18, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x06, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF0, 0x01, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x01,
  0xE1, 0x83, 0x03, 0x81, 0x00, 0x03, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06,
  0x03, 0x00, 0x06, 0x02, 0x00, 0x0E, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x06, 0x00, 0x07, 0x04, 0x00, 0x03, 0x8C, 0x00, 0x03,
  0xCC, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1B, 0xC0, 0x00, 0x19, 0xE0, 0x00, 0x10, 0x60, 0x00,
  0x10, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x38, 0x00,
  0x20, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x70, 0x00,
  0x60, 0x60, 0x00, 0x41, 0xC0, 0xC0, 0xC3, 0x80, 0xFF, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0E,
  0x03, 0xFC, 0x00, 0x0C, 0x06, 0x0C, 0x00, 0x18, 0x0C, 0x06, 0x00, 0x30,
  0x18, 0x06, 0x00, 0x30, 0x18, 0x06, 0x00, 0x60, 0x30, 0x06, 0x00, 0xE0,
  0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x06, 0x03, 0x80,
  0x60, 0x06, 0x03, 0x00, 0x60, 0x06, 0x06, 0x00, 0x60, 0x0C, 0x0E, 0x00,
  0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0x0C, 0x18, 0x00, 0xC0, 0x0C, 0x18, 0x00,
  0xC0, 0x18, 0x30, 0x78, 0xC0, 0x18, 0x61, 0xFE, 0xC0, 0x18, 0x63, 0x86,
  0xC0, 0x30, 0xC7, 0x03, 0xC0, 0x31, 0x86, 0x03, 0xE0, 0x61, 0x8C, 0x03,
  0x60, 0xC3, 0x0C, 0x03, 0x7F, 0x86, 0x18, 0x03, 0x3F, 0x06, 0x18, 0x03,
  0x00, 0x0C, 0x18, 0x03, 0x00, 0x1C, 0x30, 0x03, 0x00, 0x18, 0x30, 0x03,
  0x00, 0x30, 0x30, 0x03, 0x00, 0x70, 0x30, 0x03, 0x00, 0x60, 0x30, 0x06,
  0x00, 0xC0, 0x70, 0x06, 0x01, 0xC0, 0x60, 0x06, 0x01, 0x80, 0x60, 0x0C,
  0x03, 0x00, 0x60, 0x0C, 0x07, 0x00, 0x60, 0x0C, 0x06, 0x00, 0x60, 0x18,
  0x0C, 0x00, 0x30, 0x38, 0x0C, 0x00, 0x30, 0x30, 0x18, 0x00, 0x38, 0xE0,
  0x30, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x38, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x38, 0x00, 0x18, 0x01, 0x80,
  0x00, 0xC0, 0x1C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC0, 0x60, 0x07, 0x0C,
  0x01, 0x80, 0x30, 0xC0, 0x0E, 0x01, 0x8E, 0x00, 0x30, 0x18, 0x60, 0x01,
  0xC0, 0xC6, 0x00, 0x06, 0x0C, 0x30, 0x00, 0x38, 0xE1, 0x80, 0x00, 0xC6,
  0x1C, 0x00, 0x07, 0x60, 0xE0, 0x00, 0x1F, 0x07, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x07, 0x80, 0xC0, 0x00, 0x7C, 0x06, 0x00, 0x07, 0x70, 0x38, 0x00,
  0x71, 0x80, 0xE0, 0x0F, 0x0E, 0x03, 0xE7, 0xE0, 0x30, 0x0F, 0xFC, 0x01,
  0xC0, 0x0D, 0x00, 0x00, 0x00, 0x19, 0xCE, 0x63, 0x18, 0xCC, 0x63, 0x18,
  0x8C, 0x63, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x0C,
  0x03, 0x00, 0xF0, 0x20, 0x03, 0xC2, 0x00, 0x0E, 0x60, 0x00, 0x3E, 0x3F,
  0x00, 0xFF, 0xF0, 0x0E, 0x00, 0x01, 0xA0, 0x00, 0x73, 0x00, 0x0E, 0x10,
  0x01, 0xC1, 0x80, 0x38, 0x18, 0x07, 0x00, 0xC0, 0x20, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x07, 0x06,
  0x0E, 0x0C, 0x1C, 0x18, 0x18, 0x38, 0x30, 0x60, 0x60, 0xC0, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC0, 0x77, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xC0, 0xE0, 0x07,
  0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x70, 0x01, 0xC0, 0xC0, 0x01, 0x83, 0x00,
  0x03, 0x0E, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0xC0, 0x00,
  0x31, 0x80, 0x00, 0x67, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x03,
  0x30, 0x00, 0x06, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x76,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xB8, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0,
  0x00, 0x1D, 0x80, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x01, 0xCC, 0x00,
  0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x1C, 0x60, 0x00, 0x30, 0xC0, 0x00,
  0xE1, 0x80, 0x01, 0x83, 0x00, 0x07, 0x07, 0x00, 0x0C, 0x06, 0x00, 0x30,
  0x0E, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x0F, 0x3E, 0x00, 0x0F, 0xF0, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x18, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x73, 0x07,
  0x18, 0xF0, 0xCE, 0x0E, 0xE0, 0x62, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x07, 0x80, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x40, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0x80, 0x78, 0x07, 0x80,
  0x0E, 0x00, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x20, 0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06,
  0x60, 0x00, 0x03, 0x18, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x06, 0x00,
  0x01, 0x81, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x18, 0x00, 0x38, 0x0C,
  0x00, 0x0C, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x60, 0x0C,
  0x00, 0x18, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x00, 0xC0, 0x00, 0xC0,
  0x60, 0x00, 0x30, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x10, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x20, 0x00, 0x70, 0x0C, 0x00,
  0x78, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x7F, 0x00, 0x31, 0xFF, 0xC0, 0x33, 0x80, 0xE0, 0x66, 0x00, 0x70,
  0x6C, 0x00, 0x38, 0x78, 0x00, 0x18, 0x70, 0x00, 0x18, 0xE0, 0x00, 0x18,
  0xE0, 0x00, 0x18, 0xE0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x30,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x60, 0x60, 0x00, 0xE0,
  0x60, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x38, 0x07, 0x00, 0x1F, 0x3E, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFD,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0x80, 0x70, 0x01, 0x80, 0x0E, 0x00, 0xC0, 0x01, 0x80, 0x70, 0x00, 0x70,
  0x18, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00,
  0x70, 0x18, 0x00, 0x1C, 0x06, 0x00, 0x06, 0x01, 0x80, 0x03, 0x80, 0x60,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x38, 0x00, 0x70, 0x38, 0x00,
  0x0E, 0x3C, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7C, 0x70, 0x00, 0x3C, 0x0E, 0x00, 0x3C, 0x01, 0xC0, 0x1C, 0x00,
  0x38, 0x06, 0x00, 0x06, 0x03, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x30, 0x60,
  0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x30,
  0xE0, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x06, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x60, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0x3E,
  0x7F, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0xF0, 0x3C, 0x01, 0xC0, 0x0C, 0x03, 0x80, 0x0E,
  0x03, 0x00, 0x06, 0x06, 0x00, 0x07, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x07, 0x18, 0x00, 0x07,
  0x18, 0x00, 0x07, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x1E, 0x1C, 0x00, 0x3E,
  0x0E, 0x00, 0x76, 0x0F, 0x00, 0xEC, 0x07, 0xFF, 0x8C, 0x01, 0xFE, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0xFB, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x1E, 0x0F, 0x07,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x70, 0x0E, 0x08, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0xC0, 0x03, 0xFC, 0x01, 0x8C, 0x00, 0x7F, 0xF0, 0x0C, 0x60, 0x07, 0x01,
  0x80, 0x66, 0x00, 0x60, 0x0C, 0x03, 0x30, 0x06, 0x00, 0xC0, 0x19, 0x80,
  0x70, 0x06, 0x00, 0xD8, 0x03, 0x00, 0x30, 0x06, 0xC0, 0x30, 0x01, 0x80,
  0x36, 0x01, 0x80, 0x18, 0x03, 0x60, 0x18, 0x00, 0xC0, 0x1B, 0x00, 0xC0,
  0x06, 0x00, 0xD8, 0x06, 0x00, 0x30, 0x06, 0xC0, 0x60, 0x03, 0x00, 0x76,
  0x03, 0x00, 0x18, 0x03, 0x30, 0x18, 0x00, 0xC0, 0x19, 0x80, 0xC0, 0x0E,
  0x01, 0x8C, 0x06, 0x00, 0x70, 0x0C, 0x60, 0x30, 0x07, 0x80, 0xC3, 0x01,
  0x80, 0x6C, 0x0E, 0x18, 0x0E, 0x06, 0x60, 0xE0, 0xC0, 0x38, 0x73, 0x8E,
  0x06, 0x00, 0xFE, 0x0F, 0xE0, 0x30, 0x03, 0xC0, 0x1C, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x40, 0x00, 0x07,
  0x80, 0x0E, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x38, 0x30, 0x00, 0x06, 0x06,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x0E, 0x01, 0x80, 0x01,
  0x80, 0x30, 0x00, 0x70, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x80, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0,
  0x38, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x30, 0x30, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0x00, 0xFE, 0x00, 0x60, 0x01, 0xE0, 0x1C, 0x00,
  0x0C, 0x03, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x60, 0x70, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x30, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x70, 0x30,
  0x00, 0x1C, 0x06, 0x00, 0x07, 0x00, 0xC0, 0x03, 0xC0, 0x18, 0x07, 0xE0,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x78, 0x03, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x30, 0x1C, 0x00, 0x07, 0x03, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x83, 0x80, 0x00, 0x30, 0x60, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x38, 0x30, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x38, 0x30, 0x00, 0x0E, 0x06, 0x00, 0x03,
  0x80, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x1E,
  0x00, 0x60, 0x07, 0x80, 0x02, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x10, 0x00, 0x7E, 0x7F, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0x40, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x30, 0x0F, 0xC0, 0x01, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x70, 0x06, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x30, 0x1C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x1C, 0x30, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x18, 0x00, 0x07,
  0x80, 0xC0, 0x00, 0x78, 0x06, 0x00, 0x07, 0x00, 0x70, 0x00, 0xF0, 0x03,
  0x80, 0x3E, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xE0, 0x07, 0xC0, 0x1E, 0x00, 0x02, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x03,
  0xFF, 0x8C, 0x00, 0x0F, 0xFE, 0x30, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x60, 0xE0, 0x00, 0x03, 0x81, 0x80, 0x00, 0x0C, 0x07, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0x18, 0x07, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x30, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00,
  0x60, 0x1C, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x01, 0x80, 0x70, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x81, 0xC0,
  0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0xE0, 0x0C, 0x00, 0x07, 0x00, 0x30, 0x00, 0x38, 0x01, 0xC0,
  0x01, 0xC0, 0x06, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0x60, 0x03,
  0x80, 0x01, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x30, 0x07, 0x00,
  0x00, 0xC0, 0x38, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x01, 0x83, 0x80, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x00, 0x67, 0x80, 0x00, 0x03, 0xBE, 0x00, 0x00, 0x0D, 0xCC,
  0x00, 0x00, 0x36, 0x30, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x81, 0x80,
  0x00, 0x1C, 0x06, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x06, 0x00, 0xE0, 0x00, 0x38, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x03,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x60, 0x00,
  0x30, 0x03, 0x80, 0x00, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x30, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x01, 0xB0, 0x00, 0x00,
  0x76, 0x01, 0xB0, 0x00, 0x00, 0x6E, 0x01, 0xB8, 0x00, 0x00, 0xCC, 0x03,
  0x98, 0x00, 0x00, 0xCC, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x03, 0x18, 0x00,
  0x01, 0x8C, 0x03, 0x18, 0x00, 0x03, 0x18, 0x03, 0x18, 0x00, 0x07, 0x18,
  0x07, 0x18, 0x00, 0x06, 0x18, 0x06, 0x18, 0x00, 0x0E, 0x18, 0x06, 0x1C,
  0x00, 0x0C, 0x38, 0x06, 0x0C, 0x00, 0x1C, 0x30, 0x06, 0x0C, 0x00, 0x18,
  0x30, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x0C,
  0x0C, 0x00, 0x60, 0x70, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x1C, 0x0C, 0x00,
  0xC0, 0x60, 0x18, 0x0E, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x38, 0x06,
  0x07, 0x00, 0xC0, 0x30, 0x06, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x0C, 0x00,
  0xC0, 0x30, 0x06, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x18, 0x01, 0x80, 0x70,
  0x03, 0x18, 0x01, 0x80, 0x60, 0x03, 0x30, 0x01, 0x80, 0x60, 0x03, 0x70,
  0x03, 0x80, 0x60, 0x03, 0x60, 0x03, 0x00, 0xE0, 0x03, 0xE0, 0x03, 0x00,
  0xC0, 0x03, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0x80,
  0x38, 0x00, 0x00, 0xC0, 0x1E, 0x00, 0x00, 0x60, 0x1F, 0x00, 0x00, 0x30,
  0x0D, 0x80, 0x00, 0x38, 0x06, 0xE0, 0x00, 0x18, 0x03, 0x30, 0x00, 0x0C,
  0x01, 0x98, 0x00, 0x06, 0x01, 0xCE, 0x00, 0x03, 0x00, 0xC3, 0x00, 0x03,
  0x80, 0x61, 0x80, 0x01, 0x80, 0x30, 0xE0, 0x00, 0xC0, 0x18, 0x30, 0x00,
  0x60, 0x1C, 0x18, 0x00, 0x70, 0x0C, 0x0E, 0x00, 0x30, 0x06, 0x03, 0x00,
  0x18, 0x03, 0x01, 0x80, 0x0C, 0x01, 0x80, 0xE0, 0x06, 0x01, 0xC0, 0x30,
  0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x01, 0x80, 0x30, 0x03,
  0x00, 0xC0, 0x38, 0x01, 0x80, 0x60, 0x18, 0x00, 0xE0, 0x70, 0x0C, 0x00,
  0x30, 0x30, 0x06, 0x00, 0x18, 0x18, 0x03, 0x00, 0x0E, 0x0C, 0x03, 0x80,
  0x03, 0x0E, 0x01, 0x80, 0x01, 0x86, 0x00, 0xC0, 0x00, 0xE3, 0x00, 0x60,
  0x00, 0x31, 0x80, 0x30, 0x00, 0x18, 0xC0, 0x38, 0x00, 0x0E, 0x60, 0x18,
  0x00, 0x03, 0x60, 0x0C, 0x00, 0x01, 0xB0, 0x06, 0x00, 0x00, 0xF8, 0x07,
  0x00, 0x00, 0x3C, 0x03, 0x00, 0x00, 0x1E, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x70,
  0x0E, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x73, 0x00, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x07, 0x30, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x0C, 0x07, 0xE0, 0x03, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80,
  0x70, 0x00, 0x60, 0x18, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00,
  0xC0, 0xE0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06,
  0x00, 0x03, 0x81, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x70, 0x38, 0x00, 0x38,
  0x0C, 0x00, 0x3C, 0x03, 0x00, 0x7C, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x61, 0xC0,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00,
  0x1D, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x03, 0xB0,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x07, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x0C, 0x07, 0xE0, 0x03, 0x00, 0x1C, 0x01, 0xC0,
  0x03, 0x80, 0x70, 0x00, 0x60, 0x18, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x01,
  0x80, 0x00, 0xC0, 0xE0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03,
  0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x18, 0x18, 0x00,
  0x0E, 0x06, 0x00, 0x03, 0x81, 0x80, 0x01, 0xC0, 0x60, 0x00, 0xE0, 0x38,
  0x00, 0x70, 0x0C, 0x00, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0x70, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x06, 0x00, 0xE0, 0x01, 0x80, 0x18,
  0x00, 0x60, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00,
  0x0C, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0xE0, 0x1C, 0x00, 0x18, 0x06,
  0x00, 0x06, 0x01, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x30, 0x38, 0x00, 0x0C,
  0x0E, 0x00, 0x03, 0x83, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x01,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x20,
  0x00, 0x38, 0x0E, 0x00, 0x3C, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x1C, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x38, 0x0C, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x38, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0E, 0x60, 0x00,
  0x03, 0x18, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x61, 0x80, 0x00, 0x38, 0x60,
  0x00, 0x0C, 0x18, 0x00, 0x07, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0xE0,
  0x70, 0x00, 0x30, 0x1C, 0x00, 0x1C, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x03,
  0x80, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x01, 0xC0, 0x03, 0x00, 0x60, 0x00,
  0xC0, 0x38, 0x00, 0x30, 0x0C, 0x00, 0x0E, 0x07, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x60, 0x60, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xB0, 0x00, 0x0F,
  0x00, 0x01, 0xD8, 0x00, 0x07, 0x80, 0x00, 0xCC, 0x00, 0x03, 0xC0, 0x00,
  0x66, 0x00, 0x03, 0x60, 0x00, 0x73, 0x00, 0x01, 0xB0, 0x00, 0x31, 0x80,
  0x01, 0x98, 0x00, 0x38, 0xC0, 0x00, 0xCC, 0x00, 0x18, 0x60, 0x00, 0xE6,
  0x00, 0x1C, 0x30, 0x00, 0x63, 0x00, 0x0C, 0x1C, 0x00, 0x71, 0x80, 0x06,
  0x0E, 0x00, 0x30, 0xC0, 0x06, 0x07, 0x00, 0x18, 0x60, 0x03, 0x03, 0x80,
  0x18, 0x30, 0x03, 0x80, 0xC0, 0x0C, 0x18, 0x01, 0x80, 0x60, 0x0C, 0x0C,
  0x01, 0xC0, 0x30, 0x06, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x03, 0x01,
  0x80, 0x60, 0x38, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x00, 0xC0, 0xC0, 0x18,
  0x1C, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x00, 0x30, 0x60, 0x06, 0x06, 0x00,
  0x18, 0x30, 0x03, 0x06, 0x00, 0x0C, 0x30, 0x01, 0x83, 0x00, 0x06, 0x18,
  0x00, 0xC3, 0x80, 0x03, 0x1C, 0x00, 0x61, 0x80, 0x01, 0x8C, 0x00, 0x31,
  0xC0, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x00, 0x66, 0x00, 0x0C, 0x60, 0x00,
  0x33, 0x00, 0x02, 0x60, 0x00, 0x1B, 0x00, 0x01, 0x30, 0x00, 0x0D, 0x80,
  0x00, 0xB0, 0x00, 0x07, 0x80, 0x00, 0x58, 0x00, 0x03, 0xC0, 0x00, 0x2C,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0xE0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x03, 0x00, 0x18, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x70, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x60,
  0x00, 0x0C, 0x60, 0x00, 0x18, 0x70, 0x00, 0x38, 0x30, 0x00, 0x30, 0x30,
  0x00, 0x70, 0x30, 0x00, 0xE0, 0x30, 0x00, 0xC0, 0x38, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x18, 0x03, 0x00, 0x18, 0x07, 0x00, 0x18, 0x06, 0x00, 0x0C,
  0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0E,
  0x70, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x0C, 0x0C,
  0x0C, 0x0C, 0x0C, 0x04, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x60, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x30, 0x18, 0x00, 0x30,
  0x0C, 0x00, 0x18, 0x06, 0x00, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x0C, 0x00, 0x18, 0x0E, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x07,
  0x00, 0x01, 0x83, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x63, 0x80, 0x00, 0x1B,
  0x80, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0xC1, 0x81, 0x83,
  0x03, 0x03, 0x06, 0x06, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xE0, 0xC0, 0x3E,
  0x38, 0xC0, 0x38, 0x06, 0x60, 0x38, 0x01, 0xB0, 0x38, 0x00, 0xD8, 0x18,
  0x00, 0x28, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x06,
  0x00, 0x03, 0x86, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x61,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C,
  0x18, 0x00, 0x06, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01,
  0x83, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xE0, 0x60, 0x00, 0xF0, 0x30, 0x00,
  0xD0, 0x18, 0x00, 0xD8, 0x0E, 0x00, 0xCC, 0x03, 0x80, 0xE6, 0x00, 0xF3,
  0xC3, 0x00, 0x3F, 0xC1, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x1E,
  0x00, 0x1C, 0x3F, 0xE0, 0x0C, 0x78, 0x78, 0x06, 0x70, 0x0C, 0x03, 0x70,
  0x07, 0x01, 0xB0, 0x01, 0x81, 0xB0, 0x00, 0xE0, 0xF0, 0x00, 0x30, 0x78,
  0x00, 0x18, 0x38, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x0E,
  0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x63, 0x80, 0x00, 0x71,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0E,
  0x38, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x07, 0x00, 0x01,
  0x83, 0x80, 0x01, 0x83, 0x40, 0x01, 0xC1, 0xB0, 0x01, 0xC0, 0xD8, 0x01,
  0xC0, 0x66, 0x01, 0xC0, 0x21, 0xE7, 0xC0, 0x30, 0x7F, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0x01, 0xF0, 0x70, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x02, 0x01, 0xF3, 0xE0, 0x0F, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0x81, 0x80, 0x03, 0xFE, 0x18, 0x00,
  0xF8, 0xF1, 0x80, 0x1C, 0x03, 0x98, 0x03, 0x80, 0x1B, 0x00, 0x70, 0x00,
  0xF0, 0x06, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x06, 0x03, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x0C, 0x06, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x1C, 0x0E, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x78,
  0x0E, 0x00, 0x07, 0x00, 0x60, 0x00, 0xF0, 0x06, 0x00, 0x1B, 0x00, 0x60,
  0x03, 0xB0, 0x07, 0x00, 0x73, 0x00, 0x38, 0x0E, 0x60, 0x01, 0xE7, 0xC6,
  0x00, 0x0F, 0xF0, 0x60, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x07,
  0xFC, 0x01, 0xF1, 0xE0, 0x3C, 0x07, 0x07, 0x00, 0x30, 0xE0, 0x03, 0x0C,
  0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x33, 0x00, 0x07, 0x30, 0x00, 0x66,
  0x00, 0x0E, 0x60, 0x01, 0xC6, 0x00, 0xF8, 0xE0, 0xFE, 0x0F, 0xFF, 0x00,
  0xFF, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x03, 0x01, 0xF1, 0xF0, 0x0F,
  0xFE, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xCC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x11,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xFC, 0x30, 0x07, 0xC7, 0x8C, 0x03, 0x80, 0x73,
  0x01, 0xC0, 0x0C, 0x80, 0xE0, 0x01, 0xE0, 0x30, 0x00, 0x78, 0x18, 0x00,
  0x0E, 0x0E, 0x00, 0x03, 0x83, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x60,
  0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x60,
  0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x83, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x78, 0x0C, 0x00, 0x36, 0x03,
  0x00, 0x1D, 0x80, 0xE0, 0x0E, 0xE0, 0x1C, 0x07, 0x30, 0x03, 0xCF, 0x8C,
  0x00, 0x7F, 0x83, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x20, 0x03, 0x80, 0x0F, 0x87, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x81, 0xF0, 0x03, 0x87, 0xFC, 0x03, 0x1F, 0x1E, 0x03,
  0x38, 0x06, 0x03, 0x60, 0x07, 0x03, 0xC0, 0x03, 0x06, 0x80, 0x03, 0x07,
  0x80, 0x03, 0x07, 0x00, 0x03, 0x07, 0x00, 0x03, 0x06, 0x00, 0x07, 0x0E,
  0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C,
  0x00, 0x0E, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18,
  0x00, 0x0C, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30,
  0x00, 0x18, 0x30, 0x00, 0x18, 0x70, 0x00, 0x38, 0x60, 0x00, 0x30, 0x60,
  0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x70, 0xE0, 0x00, 0x60, 0x00,
  0x60, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x8F, 0x00, 0x0F, 0xE0, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x07, 0x03, 0x00, 0x0C, 0x03,
  0x00, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x07, 0x00, 0xC0, 0x06,
  0x01, 0xC0, 0x06, 0x03, 0x80, 0x06, 0x07, 0x00, 0x06, 0x0E, 0x00, 0x0C,
  0x1C, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0xF0, 0x00, 0x1D,
  0xF8, 0x00, 0x1B, 0x98, 0x00, 0x1F, 0x18, 0x00, 0x1E, 0x1C, 0x00, 0x1C,
  0x0C, 0x00, 0x38, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x30, 0x06, 0x00, 0x30,
  0x07, 0x00, 0x30, 0x03, 0x00, 0x70, 0x03, 0x00, 0x60, 0x03, 0x80, 0x60,
  0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x06, 0x1F, 0xF0,
  0x1F, 0xE0, 0x0C, 0x71, 0xF0, 0xF1, 0xE0, 0x19, 0x80, 0xE3, 0x80, 0xE0,
  0x36, 0x00, 0xCE, 0x00, 0xC0, 0x78, 0x01, 0xD8, 0x01, 0x81, 0xA0, 0x01,
  0xE0, 0x03, 0x83, 0xC0, 0x03, 0x80, 0x07, 0x07, 0x00, 0x07, 0x00, 0x0C,
  0x0E, 0x00, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x38, 0x00, 0x30, 0x70, 0x00,
  0x60, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x80, 0x03,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x00, 0x70, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0xC0, 0x01, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x00, 0x03, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x30, 0x00, 0x60, 0x00, 0x60, 0xE0, 0x00, 0xC0, 0x00, 0xC1, 0x80,
  0x01, 0x80, 0x01, 0x83, 0x00, 0x03, 0x00, 0x07, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xF0, 0x03, 0x07, 0xFC, 0x03, 0x1F, 0x1E, 0x03, 0x38, 0x06,
  0x03, 0x60, 0x07, 0x03, 0xC0, 0x03, 0x06, 0xC0, 0x03, 0x07, 0x80, 0x03,
  0x07, 0x00, 0x03, 0x07, 0x00, 0x03, 0x06, 0x00, 0x07, 0x0E, 0x00, 0x06,
  0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x1C, 0x00, 0x0E,
  0x1C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C,
  0x38, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18,
  0x30, 0x00, 0x18, 0x70, 0x00, 0x38, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30,
  0x60, 0x00, 0x30, 0x60, 0x00, 0x70, 0xE0, 0x00, 0x60, 0x00, 0x0F, 0x00,
  0x00, 0xFF, 0x80, 0x07, 0xC7, 0xC0, 0x1C, 0x01, 0xC0, 0x70, 0x01, 0x81,
  0xC0, 0x03, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x38, 0x00, 0x0C, 0x60,
  0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0x76, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xB8, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00,
  0x1B, 0x00, 0x00, 0x76, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x07,
  0x30, 0x00, 0x0C, 0x60, 0x00, 0x38, 0xC0, 0x00, 0x61, 0x80, 0x01, 0xC3,
  0x80, 0x07, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x70, 0x07, 0xEF, 0xC0, 0x03,
  0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x06, 0x0F, 0xF8,
  0x00, 0x63, 0xC3, 0xC0, 0x06, 0x70, 0x0E, 0x00, 0x6E, 0x00, 0xE0, 0x06,
  0xC0, 0x06, 0x00, 0xD8, 0x00, 0x70, 0x0F, 0x00, 0x03, 0x00, 0xF0, 0x00,
  0x30, 0x0E, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x30, 0x1C, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x0C, 0x07, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x18, 0x07, 0x00, 0x03, 0x00, 0xD0, 0x00, 0x70,
  0x0D, 0x80, 0x0E, 0x00, 0xD8, 0x01, 0xC0, 0x0C, 0xC0, 0x38, 0x00, 0xC7,
  0x9F, 0x00, 0x1C, 0x3F, 0xE0, 0x01, 0x80, 0x40, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xF0, 0xC0, 0x3E, 0x3C,
  0x60, 0x38, 0x07, 0x30, 0x38, 0x01, 0x90, 0x38, 0x00, 0x78, 0x18, 0x00,
  0x3C, 0x18, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x06, 0x00,
  0x01, 0x87, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x71, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x18,
  0x00, 0x07, 0x1C, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3,
  0x80, 0x01, 0xE1, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0xF0, 0x30, 0x00, 0xD8,
  0x18, 0x00, 0xEC, 0x0E, 0x00, 0xE6, 0x03, 0x80, 0xE6, 0x00, 0xF3, 0xE3,
  0x00, 0x3F, 0xC1, 0x80, 0x02, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xE0,
  0x61, 0xFC, 0x0C, 0x7C, 0x81, 0x9C, 0x00, 0x36, 0x00, 0x07, 0x80, 0x01,
  0xB0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x07, 0xFF, 0x00, 0xF8, 0x3E, 0x0E, 0x00, 0x20, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE1, 0x00, 0x06,
  0x0C, 0x00, 0xE0, 0x7E, 0x3E, 0x00, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x7F, 0xFE, 0xFF, 0xF8, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x98, 0x07, 0xF0, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00,
  0x71, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06,
  0x38, 0x00, 0x1C, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3,
  0x00, 0x01, 0x8E, 0x00, 0x07, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60,
  0x00, 0x30, 0xC0, 0x00, 0xE3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00,
  0x0E, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x78, 0x60, 0x00, 0xE0, 0xC0, 0x03,
  0xC1, 0x80, 0x0D, 0x83, 0x00, 0x33, 0x07, 0x00, 0xC6, 0x07, 0xDF, 0x18,
  0x07, 0xFC, 0x30, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xB0, 0x00, 0x1D, 0x80, 0x00, 0xCE, 0x00, 0x0E, 0x30, 0x00, 0x61, 0x80,
  0x06, 0x0C, 0x00, 0x30, 0x60, 0x03, 0x03, 0x00, 0x18, 0x18, 0x01, 0x80,
  0xC0, 0x0C, 0x06, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x0E, 0x07,
  0x00, 0x30, 0x30, 0x01, 0x83, 0x80, 0x0C, 0x18, 0x00, 0x61, 0xC0, 0x03,
  0x0C, 0x00, 0x18, 0xE0, 0x00, 0xC6, 0x00, 0x06, 0x70, 0x00, 0x33, 0x00,
  0x01, 0xB8, 0x00, 0x05, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x01, 0xB0, 0x00,
  0xF0, 0x00, 0xD8, 0x00, 0x78, 0x00, 0xCC, 0x00, 0x6C, 0x00, 0x67, 0x00,
  0x36, 0x00, 0x71, 0x80, 0x1B, 0x00, 0x30, 0xC0, 0x19, 0x80, 0x38, 0x60,
  0x0C, 0xC0, 0x18, 0x30, 0x0C, 0x60, 0x0C, 0x18, 0x06, 0x30, 0x0C, 0x0C,
  0x06, 0x18, 0x06, 0x06, 0x03, 0x04, 0x06, 0x03, 0x03, 0x03, 0x03, 0x01,
  0x81, 0x81, 0x83, 0x80, 0xC1, 0x80, 0xC1, 0x80, 0x60, 0xC0, 0x60, 0xC0,
  0x30, 0xC0, 0x30, 0xC0, 0x18, 0x60, 0x18, 0x60, 0x0C, 0x70, 0x0C, 0x60,
  0x06, 0x30, 0x06, 0x30, 0x03, 0x38, 0x03, 0x30, 0x01, 0x98, 0x01, 0x98,
  0x00, 0xCC, 0x00, 0xDC, 0x00, 0x6C, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x36,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x70, 0x00,
  0xE0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x0C, 0x00, 0x18,
  0x07, 0x00, 0x06, 0x03, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x60, 0x00,
  0x0C, 0x38, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0D, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x30, 0x1C, 0x00, 0x18, 0x03, 0x00,
  0x0E, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x01,
  0x80, 0x70, 0x00, 0x70, 0x38, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x70, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x0E, 0x00,
  0x30, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xE0, 0x06, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x01, 0x83, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x0C, 0x70, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x02, 0x1C, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00,
  0x23, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0xF0, 0x01, 0x70, 0x7C, 0x03, 0xC0, 0x1F, 0x9F,
  0x80, 0x03, 0xFC, 0x00, 0x00, 0x20,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 12, 41, 12, 1, -41 },
  { 63, 13, 15, 18, 6, -41 },
  { 88, 30, 41, 30, 1, -41 },
  { 242, 24, 46, 27, 2, -43 },
  { 380, 32, 42, 39, 4, -41 },
  { 548, 29, 42, 32, 1, -41 },
  { 701, 5, 15, 10, 6, -41 },
  { 711, 16, 50, 14, 2, -41 },
  { 811, 16, 50, 14, -4, -41 },
  { 911, 20, 21, 26, 7, -43 },
  { 964, 24, 26, 29, 3, -33 },
  { 1042, 8, 13, 11, -2, -6 },
  { 1055, 13, 2, 17, 2, -16 },
  { 1059, 4, 4, 11, 1, -4 },
  { 1061, 25, 41, 18, -3, -41 },
  { 1190, 23, 42, 27, 3, -41 },
  { 1311, 13, 41, 27, 8, -41 },
  { 1378, 26, 41, 27, 0, -41 },
  { 1512, 26, 42, 27, 0, -41 },
  { 1649, 26, 41, 27, 0, -41 },
  { 1783, 26, 42, 27, 1, -41 },
  { 1920, 24, 42, 27, 3, -41 },
  { 2046, 23, 41, 27, 5, -41 },
  { 2164, 26, 42, 27, 1, -41 },
  { 2301, 24, 42, 27, 2, -41 },
  { 2427, 9, 30, 11, 1, -30 },
  { 2461, 13, 37, 11, -3, -30 },
  { 2522, 24, 25, 29, 3, -33 },
  { 2597, 24, 14, 29, 3, -27 },
  { 2639, 24, 25, 29, 3, -33 },
  { 2714, 19, 41, 20, 3, -41 },
  { 2812, 37, 46, 41, 3, -41 },
  { 3025, 27, 41, 27, -3, -41 },
  { 3164, 27, 41, 30, 2, -41 },
  { 3303, 28, 42, 29, 4, -41 },
  { 3450, 29, 41, 33, 2, -41 },
  { 3599, 26, 41, 26, 2, -41 },
  { 3733, 26, 41, 24, 2, -41 },
  { 3867, 30, 42, 34, 4, -41 },
  { 4025, 32, 41, 34, 2, -41 },
  { 4189, 18, 41, 14, -1, -41 },
  { 4282, 22, 51, 12, -9, -41 },
  { 4423, 30, 41, 27, 2, -41 },
  { 4577, 18, 41, 24, 2, -41 },
  { 4670, 40, 41, 42, 2, -41 },
  { 4875, 33, 41, 34, 2, -41 },
  { 5045, 30, 42, 35, 4, -41 },
  { 5203, 26, 41, 28, 2, -41 },
  { 5337, 30, 51, 35, 4, -41 },
  { 5529, 26, 41, 28, 2, -41 },
  { 5663, 26, 42, 25, 0, -41 },
  { 5800, 24, 41, 24, 5, -41 },
  { 5923, 30, 42, 34, 4, -41 },
  { 6081, 26, 41, 27, 5, -41 },
  { 6215, 41, 41, 43, 6, -41 },
  { 6426, 32, 41, 25, -3, -41 },
  { 6590, 24, 41, 24, 5, -41 },
  { 6713, 29, 41, 26, -1, -41 },
  { 6862, 21, 50, 17, -1, -41 },
  { 6994, 8, 41, 18, 6, -41 },
  { 7035, 21, 50, 17, -4, -41 },
  { 7167, 25, 23, 28, 2, -41 },
  { 7239, 20, 2, 19, -5, 6 },
  { 7244, 7, 9, 13, 8, -44 },
  { 7252, 25, 32, 28, 2, -31 },
  { 7352, 25, 44, 29, 1, -43 },
  { 7490, 20, 32, 22, 3, -31 },
  { 7570, 28, 44, 29, 2, -43 },
  { 7724, 20, 32, 25, 3, -31 },
  { 7804, 29, 58, 14, -7, -44 },
  { 8015, 26, 45, 29, 1, -31 },
  { 8162, 24, 43, 28, 1, -43 },
  { 8291, 11, 41, 11, 1, -41 },
  { 8348, 20, 55, 11, -8, -41 },
  { 8486, 24, 43, 23, 1, -43 },
  { 8615, 12, 43, 11, 1, -43 },
  { 8680, 39, 31, 42, 1, -31 },
  { 8832, 24, 31, 28, 1, -31 },
  { 8925, 23, 32, 28, 3, -31 },
  { 9017, 28, 44, 29, -2, -31 },
  { 9171, 25, 44, 29, 2, -31 },
  { 9309, 19, 31, 19, 1, -31 },
  { 9383, 21, 32, 21, 0, -31 },
  { 9467, 15, 39, 15, 2, -38 },
  { 9541, 23, 31, 28, 3, -30 },
  { 9631, 21, 30, 21, 3, -30 },
  { 9710, 33, 30, 34, 3, -30 },
  { 9834, 26, 30, 23, -2, -30 },
  { 9932, 30, 44, 22, -6, -30 },
  { 10097, 22, 30, 21, -1, -30 },
  { 10180, 21, 50, 19, 1, -41 },
  { 10312, 2, 57, 27, 13, -43 },
  { 10327, 20, 50, 18, -3, -41 },
  { 10452, 24, 6, 29, 3, -23 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic57pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC57PT7B_H_
