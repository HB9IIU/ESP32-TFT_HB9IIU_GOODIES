#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_SemiCondensed_ExtraLightItalic
// Headers: 67

#include "NotoSans_SemiCondensed_ExtraLightItalic6pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic7pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic8pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic9pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic10pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic11pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic12pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic13pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic14pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic15pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic16pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic17pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic18pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic19pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic20pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic21pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic22pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic23pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic24pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic25pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic26pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic27pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic28pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic29pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic30pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic31pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic32pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic33pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic34pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic35pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic36pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic37pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic38pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic39pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic40pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic41pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic42pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic43pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic44pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic45pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic46pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic47pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic48pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic49pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic50pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic51pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic52pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic53pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic54pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic55pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic56pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic57pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic58pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic59pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic60pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic61pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic62pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic63pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic64pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic65pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic66pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic67pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic68pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic69pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic70pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic71pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLightItalic72pt7b.h"
