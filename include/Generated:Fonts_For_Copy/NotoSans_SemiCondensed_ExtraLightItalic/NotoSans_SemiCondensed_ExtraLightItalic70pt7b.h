#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC70PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C,
  0x06, 0x1C, 0x0E, 0x18, 0x0E, 0x38, 0x0E, 0x38, 0x0C, 0x38, 0x0C, 0x30,
  0x1C, 0x30, 0x1C, 0x30, 0x18, 0x70, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60,
  0x30, 0x60, 0x30, 0xC0, 0x30, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0x00, 0x30,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0x18, 0xFC,
  0x01, 0xE0, 0x60, 0x70, 0x0F, 0x03, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0,
  0x18, 0x00, 0x03, 0x80, 0x60, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x38, 0x06,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x07, 0x03, 0x00,
  0x00, 0x1E, 0x0C, 0x00, 0x00, 0x3C, 0x30, 0x00, 0x00, 0x79, 0xC0, 0x00,
  0x00, 0xF6, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x33, 0xC0, 0x00, 0x00,
  0xC7, 0x80, 0x00, 0x03, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x60,
  0x38, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x18, 0x07,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x00, 0x70, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x30, 0x0E, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x06, 0x01, 0xC0, 0x00,
  0x18, 0x0E, 0x02, 0x00, 0x60, 0x78, 0x0F, 0x01, 0x87, 0x80, 0x3F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x38, 0x01, 0xFF,
  0x80, 0x00, 0x30, 0x03, 0x83, 0x80, 0x00, 0x70, 0x07, 0x01, 0xC0, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x01, 0xC0, 0x1C,
  0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x03, 0x80, 0x38, 0x00, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x0E, 0x00,
  0x70, 0x00, 0xC0, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x01,
  0xC0, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x70, 0x00, 0x60, 0x01, 0x80, 0x60,
  0x00, 0xE0, 0x01, 0x80, 0xE0, 0x00, 0xE0, 0x01, 0x81, 0xC0, 0x00, 0xE0,
  0x03, 0x81, 0x80, 0x00, 0xE0, 0x03, 0x83, 0x80, 0x40, 0xC0, 0x03, 0x07,
  0x07, 0xF8, 0xC0, 0x07, 0x06, 0x0F, 0xFC, 0xC0, 0x06, 0x0E, 0x1E, 0x1E,
  0xC0, 0x0E, 0x0C, 0x38, 0x0E, 0xE0, 0x0C, 0x1C, 0x30, 0x06, 0xE0, 0x1C,
  0x38, 0x70, 0x07, 0x60, 0x38, 0x30, 0x60, 0x07, 0x70, 0x70, 0x70, 0xE0,
  0x07, 0x3F, 0xF0, 0xE0, 0xC0, 0x07, 0x1F, 0xC0, 0xC1, 0xC0, 0x07, 0x06,
  0x01, 0xC1, 0xC0, 0x06, 0x00, 0x03, 0x81, 0x80, 0x06, 0x00, 0x03, 0x03,
  0x80, 0x06, 0x00, 0x07, 0x03, 0x80, 0x06, 0x00, 0x0E, 0x03, 0x80, 0x0E,
  0x00, 0x0C, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x03, 0x00, 0x0E, 0x00, 0x38,
  0x07, 0x00, 0x0C, 0x00, 0x30, 0x07, 0x00, 0x0C, 0x00, 0x70, 0x07, 0x00,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x01,
  0xC0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x07, 0x00, 0x30, 0x03, 0x80, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x06, 0x00, 0x03, 0x00, 0xE0,
  0x0E, 0x00, 0x03, 0x81, 0xC0, 0x1C, 0x00, 0x01, 0xFF, 0x80, 0x38, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xE7, 0x00, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x3C,
  0x0E, 0x00, 0x0E, 0x0E, 0x01, 0xC0, 0x01, 0x83, 0x80, 0x1C, 0x00, 0x70,
  0xE0, 0x01, 0xC0, 0x0E, 0x38, 0x00, 0x38, 0x03, 0x87, 0x00, 0x03, 0x80,
  0x71, 0xC0, 0x00, 0x70, 0x1C, 0x30, 0x00, 0x07, 0x03, 0x8E, 0x00, 0x00,
  0xE0, 0xE1, 0xC0, 0x00, 0x0E, 0x18, 0x38, 0x00, 0x01, 0xC7, 0x06, 0x00,
  0x00, 0x1D, 0xC0, 0xC0, 0x00, 0x01, 0xF0, 0x18, 0x00, 0x00, 0x3E, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x7F,
  0x01, 0xC0, 0x00, 0x1E, 0xE0, 0x1C, 0x00, 0x07, 0x8E, 0x03, 0xC0, 0x03,
  0xE1, 0xC0, 0x3E, 0x01, 0xF0, 0x1C, 0x03, 0xFF, 0xFC, 0x03, 0x80, 0x1F,
  0xFE, 0x00, 0x38, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0E, 0x38, 0x70, 0xE1,
  0xC3, 0x0E, 0x1C, 0x38, 0x60, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0x61, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0xE0, 0x0C, 0x00, 0xFC, 0x0C, 0x00, 0x0F, 0x86,
  0x00, 0x01, 0xE3, 0x00, 0x00, 0x3D, 0x81, 0xF0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0xC8, 0x00, 0x00, 0xC6, 0x00, 0x01,
  0xC3, 0x00, 0x01, 0xC0, 0xC0, 0x01, 0xC0, 0x60, 0x01, 0xC0, 0x18, 0x01,
  0xC0, 0x0C, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x81, 0xC0,
  0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xC0, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x30, 0x70, 0x00, 0x01, 0x83, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x61,
  0xC0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x71, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x39,
  0x80, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x1C, 0x60, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x18, 0x70, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x70, 0x18, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x03, 0xC0,
  0x18, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xF6, 0x01, 0xEE,
  0x03, 0xCE, 0x0F, 0x0E, 0x1E, 0x0C, 0x7C, 0x1C, 0xF0, 0x1C, 0x60, 0x1C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x3E,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x10, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x20, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x80, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x70, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x60, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x9F, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x01, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x80, 0x00, 0x1E, 0x00, 0xC0, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xF8, 0x02, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x07, 0xE0,
  0x00, 0xE0, 0xFF, 0xE0, 0x03, 0x8F, 0xFF, 0xC0, 0x0C, 0x78, 0x07, 0x80,
  0x73, 0x80, 0x07, 0x01, 0xD8, 0x00, 0x0E, 0x06, 0xC0, 0x00, 0x38, 0x1E,
  0x00, 0x00, 0x60, 0xF8, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xF0, 0x07, 0x00,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xF8, 0x07, 0x80, 0x03, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x70, 0x01, 0x80, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x03, 0x87, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF9, 0xE0, 0x00, 0x07, 0xC1, 0xE0, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x01, 0xE0, 0x0E,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x01, 0x83, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x18, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0x3C, 0x30, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xF8, 0x38, 0x00, 0x07, 0xE0, 0x70,
  0x00, 0x3B, 0x01, 0xE0, 0x01, 0xCC, 0x03, 0xC0, 0x1E, 0x70, 0x07, 0xFF,
  0xF1, 0xC0, 0x07, 0xFF, 0x06, 0x00, 0x07, 0xE0, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x80, 0x1F, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xC0, 0x3C, 0x08, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x30, 0x00,
  0x07, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0xFF, 0xF0, 0x07, 0x06, 0x00, 0x0F,
  0xFF, 0xC0, 0x1C, 0x38, 0x00, 0x78, 0x07, 0x00, 0x70, 0xC0, 0x03, 0x80,
  0x1C, 0x01, 0xC7, 0x00, 0x1C, 0x00, 0x60, 0x07, 0x18, 0x00, 0xE0, 0x01,
  0x80, 0x1C, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x73, 0x80, 0x1C, 0x00, 0x38,
  0x01, 0xCC, 0x00, 0xE0, 0x00, 0xC0, 0x07, 0x30, 0x03, 0x00, 0x03, 0x00,
  0x1D, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0x67, 0x00, 0x70, 0x00, 0x70, 0x01,
  0x98, 0x01, 0x80, 0x01, 0x80, 0x0E, 0x60, 0x0E, 0x00, 0x0E, 0x00, 0x39,
  0x80, 0x38, 0x00, 0x38, 0x00, 0xCE, 0x00, 0xE0, 0x00, 0xC0, 0x03, 0x38,
  0x03, 0x00, 0x07, 0x00, 0x1C, 0xE0, 0x0C, 0x00, 0x1C, 0x00, 0x63, 0x80,
  0x30, 0x00, 0x70, 0x03, 0x8E, 0x00, 0xC0, 0x03, 0xC0, 0x0C, 0x38, 0x03,
  0x00, 0x1F, 0x00, 0x70, 0xE0, 0x0C, 0x00, 0x6C, 0x03, 0x83, 0x80, 0x38,
  0x03, 0x30, 0x0E, 0x0E, 0x00, 0xE0, 0x1C, 0xC0, 0x70, 0x38, 0x01, 0xC1,
  0xE3, 0x87, 0x80, 0xE0, 0x03, 0xFF, 0x07, 0xFC, 0x01, 0x80, 0x07, 0xF0,
  0x0F, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x07, 0x18,
  0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03,
  0x80, 0x7F, 0xE0, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x06,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x38, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x01, 0xC0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x06, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x00,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C,
  0x03, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x01, 0xF0, 0x01, 0x80, 0x1F,
  0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x80, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x02, 0x00, 0x07,
  0xC0, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x0E, 0x07, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x38, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x60, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x3C, 0x00, 0x60,
  0x00, 0x07, 0xC0, 0x07, 0x00, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x0F, 0x80,
  0x01, 0xC0, 0x03, 0xF8, 0x00, 0x0C, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0xF8, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x00, 0x08, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xFF, 0xE1, 0xC0, 0x00, 0x3F, 0xFF, 0x0E,
  0x00, 0x01, 0xFF, 0xF8, 0x60, 0x00, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x01, 0x80, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x01, 0x80, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x60, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x70, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x18, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x78, 0x00, 0x03, 0x00, 0x07, 0x80, 0x00,
  0x18, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x03, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x0E, 0x3E, 0x00, 0x00, 0x00,
  0x63, 0xF0, 0x00, 0x00, 0x03, 0x3B, 0x80, 0x00, 0x00, 0x3B, 0x8E, 0x00,
  0x00, 0x01, 0xF8, 0x70, 0x00, 0x00, 0x0F, 0x81, 0x80, 0x00, 0x00, 0x78,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x60, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x36, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x0D, 0x80, 0x00, 0x00, 0x0E,
  0xE0, 0x07, 0x60, 0x00, 0x00, 0x03, 0xB0, 0x01, 0xDC, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x77, 0x00, 0x00, 0x00, 0x77, 0x00, 0x19, 0xC0, 0x00, 0x00,
  0x39, 0xC0, 0x06, 0x70, 0x00, 0x00, 0x0E, 0x60, 0x03, 0x8C, 0x00, 0x00,
  0x07, 0x18, 0x00, 0xE3, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x38, 0xC0, 0x00,
  0x00, 0xE3, 0x80, 0x0C, 0x30, 0x00, 0x00, 0x30, 0xE0, 0x07, 0x0E, 0x00,
  0x00, 0x1C, 0x30, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x70, 0xE0,
  0x00, 0x03, 0x87, 0x00, 0x18, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x06, 0x06,
  0x00, 0x00, 0x70, 0x70, 0x03, 0x81, 0x80, 0x00, 0x38, 0x18, 0x00, 0xE0,
  0x60, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x18, 0x00, 0x07, 0x03, 0x80, 0x0C,
  0x07, 0x00, 0x01, 0x80, 0xE0, 0x03, 0x01, 0xC0, 0x00, 0xE0, 0x30, 0x01,
  0xC0, 0x70, 0x00, 0x30, 0x0C, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07, 0x00,
  0x1C, 0x03, 0x00, 0x0E, 0x01, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x80, 0x70,
  0x03, 0x80, 0x30, 0x01, 0xC0, 0x18, 0x00, 0xE0, 0x0C, 0x00, 0x70, 0x06,
  0x00, 0x38, 0x03, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x03, 0x00, 0x38, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x01, 0x80,
  0x0C, 0x00, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x30,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x0E,
  0x00, 0x1C, 0x00, 0xE0, 0x01, 0x83, 0x80, 0x06, 0x00, 0x38, 0x00, 0x71,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x70, 0x00, 0xE0, 0x03, 0x00, 0x07,
  0x38, 0x00, 0x38, 0x00, 0xC0, 0x01, 0xCC, 0x00, 0x0C, 0x00, 0x70, 0x00,
  0x37, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x0D, 0x80, 0x01, 0xC0, 0x07, 0x00,
  0x03, 0xE0, 0x00, 0x70, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x06, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x01, 0x80, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x03, 0xE0, 0x00,
  0x00, 0x70, 0x01, 0xB0, 0x00, 0x00, 0x30, 0x01, 0xDC, 0x00, 0x00, 0x18,
  0x00, 0xEE, 0x00, 0x00, 0x1C, 0x00, 0x73, 0x00, 0x00, 0x0E, 0x00, 0x31,
  0xC0, 0x00, 0x07, 0x00, 0x18, 0xE0, 0x00, 0x03, 0x00, 0x1C, 0x30, 0x00,
  0x03, 0x80, 0x0E, 0x1C, 0x00, 0x01, 0xC0, 0x07, 0x0E, 0x00, 0x00, 0xE0,
  0x03, 0x03, 0x00, 0x00, 0x70, 0x03, 0x81, 0xC0, 0x00, 0x30, 0x01, 0xC0,
  0xE0, 0x00, 0x38, 0x00, 0xE0, 0x30, 0x00, 0x1C, 0x00, 0x70, 0x1C, 0x00,
  0x0E, 0x00, 0x30, 0x0E, 0x00, 0x06, 0x00, 0x38, 0x03, 0x00, 0x03, 0x00,
  0x1C, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x06, 0x00,
  0x30, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00,
  0x60, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x06, 0x00, 0x38, 0x00,
  0x1C, 0x07, 0x00, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x0E, 0x00, 0x07, 0x01,
  0xC0, 0x06, 0x00, 0x01, 0xC0, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x60, 0x03,
  0x80, 0x00, 0x70, 0x70, 0x01, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0xC0, 0x00,
  0x0E, 0x1C, 0x00, 0x60, 0x00, 0x07, 0x0C, 0x00, 0x70, 0x00, 0x01, 0xC6,
  0x00, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x1C, 0x00, 0x00, 0x73, 0x80, 0x0C,
  0x00, 0x00, 0x1D, 0xC0, 0x06, 0x00, 0x00, 0x0E, 0xC0, 0x07, 0x00, 0x00,
  0x07, 0x60, 0x03, 0x80, 0x00, 0x01, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x0C, 0xE0, 0x00,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x39,
  0x80, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x70, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x07,
  0xE0, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x0E, 0x03, 0xFE, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x03,
  0x80, 0x01, 0xE0, 0x01, 0x80, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xF0, 0x03, 0x00, 0x01,
  0xF0, 0x03, 0x80, 0x03, 0xE0, 0x01, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x00, 0x0C, 0xE0, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x00, 0x1C,
  0x30, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0E, 0x03,
  0xFE, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x01, 0xE0, 0x01, 0x80,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x1C,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x30, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x01, 0xE0,
  0x07, 0x00, 0x01, 0xE0, 0x03, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x60, 0x07, 0x00,
  0x00, 0x70, 0x01, 0x80, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x38, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x06, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x03,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x38, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x38, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x38, 0x00, 0x70, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x70, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0xE0, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x30, 0x03,
  0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x0C,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x76, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x73, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x39, 0x80, 0x00, 0x1D,
  0x80, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x0E,
  0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x18, 0x00, 0x07,
  0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x03,
  0x86, 0x00, 0x03, 0x83, 0x00, 0x01, 0x83, 0x00, 0x03, 0x81, 0xC0, 0x01,
  0xC1, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0xC0, 0x01, 0xC0, 0x70, 0x00,
  0xE0, 0x60, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x30, 0x00, 0x60, 0x1C, 0x00,
  0x30, 0x18, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x07, 0x00,
  0x18, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x0C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x06, 0x00, 0x38, 0x07, 0x00, 0x38, 0x07, 0x00, 0x1C,
  0x03, 0x80, 0x1C, 0x03, 0x80, 0x0E, 0x01, 0x80, 0x0E, 0x03, 0x80, 0x07,
  0x01, 0xC0, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0x81, 0xC0, 0x01,
  0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x60, 0x00, 0xE0, 0x60, 0x00,
  0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x38, 0x30, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00,
  0x07, 0x0C, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0x8E, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x67, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x1B, 0x80,
  0x00, 0x0D, 0xC0, 0x00, 0x0D, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0x03, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00,
  0x30, 0x38, 0x00, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x00, 0x3D, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x07, 0x03,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x1C, 0x01, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x07, 0x00, 0x03, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x40, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x80,
  0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0xC0, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0x98, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x30, 0x07, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x0E, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x70, 0x70,
  0x38, 0x18, 0x1C, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x70, 0x03, 0xFF, 0xE1, 0x80, 0x1E, 0x01, 0xC6, 0x00,
  0xF0, 0x03, 0x18, 0x07, 0x00, 0x06, 0xE0, 0x38, 0x00, 0x1B, 0x81, 0xE0,
  0x00, 0x3C, 0x07, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x7C,
  0x0E, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x0D, 0x80, 0x70, 0x00, 0x66, 0x01,
  0xC0, 0x03, 0x98, 0x03, 0x80, 0x1C, 0xE0, 0x0F, 0x01, 0xE3, 0x00, 0x1F,
  0xFE, 0x0C, 0x00, 0x3F, 0xF0, 0x30, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0xE0, 0xFF, 0xC0, 0x01, 0xC3, 0xFF, 0xE0, 0x03, 0x0E, 0x03,
  0xE0, 0x06, 0x78, 0x01, 0xC0, 0x1C, 0xC0, 0x01, 0xC0, 0x3B, 0x00, 0x03,
  0x80, 0x6E, 0x00, 0x03, 0x00, 0xF8, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x0E,
  0x07, 0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x03, 0x83, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC1, 0xE0, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x38, 0x0D, 0x80, 0x00,
  0xF0, 0x1B, 0x00, 0x01, 0xC0, 0x77, 0x00, 0x07, 0x00, 0xE7, 0x00, 0x3C,
  0x01, 0x87, 0x00, 0xF0, 0x03, 0x0F, 0xFF, 0xC0, 0x0E, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x0F, 0x80, 0x30, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x04, 0x03, 0xE0, 0x0C, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0xC0, 0x38, 0x00, 0x0F, 0xFC, 0x0C, 0x00, 0x0F, 0xFF, 0xC7, 0x00,
  0x07, 0xC0, 0x71, 0xC0, 0x03, 0xC0, 0x0E, 0x70, 0x01, 0xC0, 0x01, 0xD8,
  0x00, 0xE0, 0x00, 0x36, 0x00, 0x78, 0x00, 0x0D, 0x80, 0x1C, 0x00, 0x01,
  0xE0, 0x0E, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x1C, 0x03, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00,
  0x3E, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x06, 0xC0, 0x0E, 0x00,
  0x03, 0xB0, 0x01, 0xC0, 0x01, 0xDC, 0x00, 0x70, 0x00, 0xE7, 0x00, 0x0E,
  0x00, 0x71, 0x80, 0x03, 0xC0, 0x78, 0x60, 0x00, 0x7F, 0xFC, 0x18, 0x00,
  0x0F, 0xFC, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xF0, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x78, 0x00, 0xE0, 0x3C, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x07,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x0E,
  0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE0, 0xC0, 0x00,
  0xF0, 0x70, 0x00, 0xF8, 0x1C, 0x01, 0xFC, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x01, 0x00, 0x7C, 0x01, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x02, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0x03, 0x00, 0x0F, 0xFF, 0xC3,
  0x00, 0x1F, 0x01, 0xC3, 0x00, 0x3C, 0x00, 0xE7, 0x00, 0x70, 0x00, 0x77,
  0x00, 0xE0, 0x00, 0x36, 0x01, 0xE0, 0x00, 0x36, 0x01, 0xC0, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x03, 0xE0, 0x38, 0x00, 0x03, 0xE0, 0x38, 0x00, 0x07, 0xC0,
  0x38, 0x00, 0x06, 0xC0, 0x38, 0x00, 0x0F, 0xC0, 0x1C, 0x00, 0x1D, 0xC0,
  0x1C, 0x00, 0x39, 0xC0, 0x0E, 0x00, 0x71, 0x80, 0x0F, 0x01, 0xE1, 0x80,
  0x07, 0xFF, 0xC3, 0x80, 0x03, 0xFF, 0x03, 0x80, 0x00, 0x38, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x80, 0x00, 0xF0, 0x00,
  0xE0, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38,
  0x03, 0xC0, 0x01, 0xC1, 0xFF, 0xC0, 0x0E, 0x1F, 0xFF, 0x00, 0x63, 0xC0,
  0x3C, 0x03, 0x3C, 0x00, 0xE0, 0x3B, 0x80, 0x03, 0x01, 0xD8, 0x00, 0x1C,
  0x0D, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x38, 0x3C,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x60, 0x60, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x30, 0x00, 0x38,
  0x01, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x38, 0x00, 0x30, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0xE0, 0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x30, 0x3C, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x06,
  0x1E, 0x00, 0x00, 0x31, 0xF8, 0x00, 0x03, 0x9D, 0xC0, 0x00, 0x1D, 0xCE,
  0x00, 0x00, 0xDC, 0x38, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x3C, 0x06, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x06,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0xC0, 0x06, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38,
  0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0xC3, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xC7, 0x81, 0xE0, 0xF0,
  0x3C, 0x00, 0xCE, 0x00, 0xE1, 0xC0, 0x0E, 0x01, 0xDC, 0x00, 0x73, 0x80,
  0x0E, 0x01, 0x98, 0x00, 0x77, 0x00, 0x06, 0x01, 0xB0, 0x00, 0x36, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x06, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x06, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x03, 0x83, 0xFF, 0x80, 0x0C, 0x1F, 0xFF,
  0x00, 0x31, 0xE0, 0x1E, 0x00, 0xCF, 0x00, 0x38, 0x07, 0x70, 0x00, 0x70,
  0x1D, 0x80, 0x01, 0xC0, 0x6C, 0x00, 0x07, 0x01, 0xF0, 0x00, 0x1C, 0x0F,
  0x80, 0x00, 0x70, 0x3C, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x18, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0x80,
  0xE0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0xE0, 0x78, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x31, 0xC0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x03, 0x38, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0x60, 0x00, 0x07,
  0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x03, 0x80, 0x03, 0xC0, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x1F, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x03,
  0xFE, 0x00, 0x01, 0x83, 0xFF, 0xE0, 0x00, 0x61, 0xC0, 0x7C, 0x00, 0x18,
  0xE0, 0x07, 0x00, 0x0E, 0x70, 0x00, 0xE0, 0x03, 0xB8, 0x00, 0x38, 0x00,
  0xDC, 0x00, 0x06, 0x00, 0x36, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x70,
  0x07, 0xC0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x0C, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x1B, 0x00, 0x01, 0xE0, 0x06, 0xC0, 0x00,
  0x70, 0x03, 0xB8, 0x00, 0x38, 0x00, 0xE7, 0x00, 0x3C, 0x00, 0x38, 0xE0,
  0x1E, 0x00, 0x0E, 0x3F, 0xFF, 0x00, 0x03, 0x03, 0xFF, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x30, 0x03, 0xFF, 0xF0, 0xC0, 0x1F, 0x01, 0xC3, 0x00, 0xF0,
  0x03, 0x9C, 0x07, 0x00, 0x07, 0x70, 0x38, 0x00, 0x0D, 0x81, 0xE0, 0x00,
  0x36, 0x07, 0x00, 0x00, 0x78, 0x38, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x61, 0xC0,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x78,
  0x38, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0F, 0x83, 0x80, 0x00, 0x7C, 0x0E,
  0x00, 0x01, 0xB0, 0x38, 0x00, 0x0F, 0xC0, 0x70, 0x00, 0x77, 0x01, 0xC0,
  0x03, 0x9C, 0x03, 0x80, 0x1C, 0x60, 0x0F, 0x01, 0xE1, 0x80, 0x1F, 0xFF,
  0x0E, 0x00, 0x3F, 0xF0, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x03, 0x83, 0xFC,
  0x06, 0x1F, 0xF8, 0x0C, 0x78, 0x00, 0x19, 0xC0, 0x00, 0x77, 0x00, 0x00,
  0xEC, 0x00, 0x01, 0xB0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x3E, 0x00, 0xF0, 0x3C, 0x00, 0x08,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x30, 0x00, 0x38, 0x1E, 0x00, 0x78,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0xDF, 0xFF, 0xE0, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x03, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x07, 0x03, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x1B, 0x03, 0x80, 0x00, 0xD8, 0x1C, 0x00, 0x0D, 0xC0, 0xE0, 0x00,
  0xCE, 0x03, 0x80, 0x1E, 0x60, 0x1E, 0x01, 0xC3, 0x00, 0x7F, 0xFC, 0x18,
  0x01, 0xFF, 0x81, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x38,
  0x30, 0x00, 0x18, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x0E,
  0x03, 0x80, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x06, 0x01, 0xC0, 0x03, 0x00,
  0xE0, 0x01, 0x80, 0xE0, 0x00, 0xC0, 0x70, 0x00, 0x70, 0x70, 0x00, 0x38,
  0x38, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x03,
  0x8C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x66, 0x00, 0x00, 0x37, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x0E, 0xE0, 0x00, 0x7C, 0x00, 0x0E,
  0xE0, 0x00, 0x6C, 0x00, 0x0C, 0xE0, 0x00, 0xEC, 0x00, 0x1C, 0xE0, 0x00,
  0xCC, 0x00, 0x18, 0xE0, 0x01, 0xCC, 0x00, 0x38, 0xE0, 0x01, 0x8C, 0x00,
  0x38, 0xE0, 0x03, 0x8C, 0x00, 0x70, 0xE0, 0x03, 0x8C, 0x00, 0x70, 0xE0,
  0x03, 0x0C, 0x00, 0xE0, 0xE0, 0x07, 0x0C, 0x00, 0xE0, 0xE0, 0x06, 0x0C,
  0x00, 0xC0, 0x60, 0x0E, 0x0C, 0x01, 0xC0, 0x60, 0x0C, 0x0C, 0x01, 0x80,
  0x60, 0x1C, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x80, 0x60, 0x38,
  0x0E, 0x07, 0x00, 0x60, 0x30, 0x0E, 0x07, 0x00, 0x60, 0x70, 0x0E, 0x06,
  0x00, 0x60, 0x60, 0x0E, 0x0E, 0x00, 0x60, 0xE0, 0x0E, 0x0C, 0x00, 0x60,
  0xC0, 0x0E, 0x1C, 0x00, 0x61, 0xC0, 0x0E, 0x18, 0x00, 0x61, 0x80, 0x06,
  0x38, 0x00, 0x63, 0x80, 0x06, 0x38, 0x00, 0x63, 0x80, 0x06, 0x30, 0x00,
  0x67, 0x00, 0x06, 0x70, 0x00, 0x67, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00,
  0x06, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x70,
  0x03, 0xC0, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x70, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x18, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3B, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x20, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x09, 0xFF, 0xE0, 0x00,
  0x5F, 0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0xFC, 0x00, 0x1F, 0xFF, 0x40,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x18, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 14, 50, 15, 2, -50 },
  { 89, 16, 18, 21, 7, -50 },
  { 125, 36, 50, 37, 2, -50 },
  { 350, 30, 57, 33, 2, -53 },
  { 564, 40, 52, 48, 5, -51 },
  { 824, 35, 52, 39, 2, -51 },
  { 1052, 7, 18, 12, 7, -50 },
  { 1068, 20, 61, 17, 2, -50 },
  { 1221, 20, 61, 17, -5, -50 },
  { 1374, 25, 26, 32, 8, -53 },
  { 1456, 29, 33, 36, 4, -41 },
  { 1576, 10, 17, 13, -3, -8 },
  { 1598, 16, 2, 21, 2, -20 },
  { 1602, 4, 5, 14, 2, -5 },
  { 1605, 30, 50, 22, -3, -50 },
  { 1793, 29, 52, 33, 3, -51 },
  { 1982, 16, 50, 33, 10, -50 },
  { 2082, 32, 51, 33, 0, -51 },
  { 2286, 32, 52, 33, 0, -51 },
  { 2494, 32, 50, 33, 0, -50 },
  { 2694, 32, 51, 33, 1, -50 },
  { 2898, 30, 52, 33, 4, -51 },
  { 3093, 29, 50, 33, 6, -50 },
  { 3275, 31, 52, 33, 2, -51 },
  { 3477, 30, 52, 33, 2, -51 },
  { 3672, 12, 37, 14, 1, -37 },
  { 3728, 16, 46, 14, -3, -37 },
  { 3820, 29, 31, 36, 4, -41 },
  { 3933, 29, 17, 36, 4, -33 },
  { 3995, 29, 31, 36, 4, -41 },
  { 4108, 22, 51, 25, 4, -51 },
  { 4249, 46, 56, 51, 3, -50 },
  { 4571, 33, 50, 33, -4, -50 },
  { 4778, 34, 50, 36, 2, -50 },
  { 4991, 34, 52, 35, 5, -51 },
  { 5212, 37, 50, 41, 2, -50 },
  { 5444, 33, 50, 32, 2, -50 },
  { 5651, 33, 50, 30, 2, -50 },
  { 5858, 37, 52, 42, 5, -51 },
  { 6099, 40, 50, 42, 2, -50 },
  { 6349, 22, 50, 18, -1, -50 },
  { 6487, 27, 62, 15, -11, -50 },
  { 6697, 37, 50, 33, 2, -50 },
  { 6929, 22, 50, 30, 2, -50 },
  { 7067, 50, 50, 51, 2, -50 },
  { 7380, 41, 50, 42, 2, -50 },
  { 7637, 37, 52, 43, 4, -51 },
  { 7878, 33, 50, 34, 2, -50 },
  { 8085, 37, 63, 43, 4, -51 },
  { 8377, 33, 50, 35, 2, -50 },
  { 8584, 32, 52, 31, 0, -51 },
  { 8792, 29, 50, 29, 6, -50 },
  { 8974, 37, 51, 42, 5, -50 },
  { 9210, 32, 50, 33, 7, -50 },
  { 9410, 49, 50, 53, 8, -50 },
  { 9717, 39, 50, 30, -4, -50 },
  { 9961, 30, 50, 29, 6, -50 },
  { 10149, 36, 50, 32, -1, -50 },
  { 10374, 26, 61, 20, -1, -50 },
  { 10573, 11, 50, 22, 7, -50 },
  { 10642, 26, 61, 20, -5, -50 },
  { 10841, 30, 28, 35, 3, -50 },
  { 10946, 24, 2, 24, -6, 7 },
  { 10952, 8, 12, 16, 10, -54 },
  { 10964, 30, 39, 34, 3, -38 },
  { 11111, 31, 54, 35, 1, -53 },
  { 11321, 25, 39, 27, 3, -38 },
  { 11443, 34, 54, 35, 3, -53 },
  { 11673, 26, 39, 31, 3, -38 },
  { 11800, 36, 71, 17, -9, -54 },
  { 12120, 32, 55, 35, 1, -38 },
  { 12340, 29, 53, 34, 2, -53 },
  { 12533, 14, 50, 14, 1, -50 },
  { 12621, 25, 67, 14, -10, -50 },
  { 12831, 29, 53, 28, 1, -53 },
  { 13024, 14, 53, 14, 1, -53 },
  { 13117, 48, 38, 52, 1, -38 },
  { 13345, 30, 38, 34, 1, -38 },
  { 13488, 28, 39, 35, 3, -38 },
  { 13625, 34, 54, 35, -2, -38 },
  { 13855, 30, 54, 35, 3, -38 },
  { 14058, 23, 38, 23, 2, -38 },
  { 14168, 25, 39, 26, 0, -38 },
  { 14290, 17, 47, 19, 3, -46 },
  { 14390, 29, 38, 34, 3, -37 },
  { 14528, 25, 37, 26, 4, -37 },
  { 14644, 40, 37, 42, 4, -37 },
  { 14829, 33, 37, 28, -3, -37 },
  { 14982, 38, 54, 26, -8, -37 },
  { 15239, 27, 37, 26, -1, -37 },
  { 15364, 25, 61, 23, 2, -50 },
  { 15555, 3, 70, 33, 16, -53 },
  { 15582, 25, 61, 23, -4, -50 },
  { 15773, 29, 7, 36, 4, -28 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic70pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC70PT7B_H_
