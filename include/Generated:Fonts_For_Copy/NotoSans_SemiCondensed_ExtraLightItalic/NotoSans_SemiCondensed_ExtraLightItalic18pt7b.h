#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC18PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x12, 0x22, 0x22, 0x44, 0x00, 0xC0, 0x59, 0x9A, 0xA0, 0x04,
  0x82, 0x20, 0x90, 0x24, 0x3F, 0xC4, 0x41, 0x20, 0x48, 0xFF, 0x89, 0x02,
  0x41, 0x10, 0x48, 0x00, 0x02, 0x04, 0x1F, 0x24, 0x24, 0x28, 0x18, 0x08,
  0x0E, 0x0A, 0x12, 0x12, 0xFC, 0x10, 0x10, 0x38, 0x52, 0x24, 0x8A, 0x24,
  0x8A, 0x22, 0xB9, 0x55, 0xA9, 0x0A, 0x44, 0x92, 0x24, 0x89, 0x43, 0x80,
  0x0E, 0x08, 0x84, 0x42, 0x21, 0x20, 0x60, 0x60, 0x49, 0x44, 0xC1, 0xA0,
  0xD0, 0x67, 0xD8, 0xF8, 0x18, 0x88, 0x84, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x10, 0x82, 0x10, 0x84, 0x21, 0x08, 0x84, 0x22, 0x11, 0x10,
  0x10, 0x23, 0x41, 0xF3, 0x19, 0x02, 0x00, 0x10, 0x10, 0x10, 0x10, 0xFF,
  0x10, 0x10, 0x10, 0x10, 0x29, 0x40, 0xF0, 0xC0, 0x01, 0x02, 0x02, 0x04,
  0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0x80, 0x1C, 0x45, 0x0A,
  0x14, 0x30, 0x60, 0xC1, 0x83, 0x0A, 0x14, 0x47, 0x00, 0x35, 0xA2, 0x22,
  0x44, 0x44, 0x48, 0x80, 0x1E, 0x21, 0x01, 0x01, 0x01, 0x02, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0xFE, 0x1E, 0x21, 0x01, 0x01, 0x01, 0x02, 0x1C,
  0x02, 0x02, 0x02, 0x02, 0x02, 0xFC, 0x01, 0x03, 0x05, 0x09, 0x0A, 0x12,
  0x22, 0x42, 0x42, 0xFF, 0x04, 0x04, 0x04, 0x1F, 0x88, 0x04, 0x04, 0x02,
  0x01, 0xE0, 0x08, 0x04, 0x01, 0x01, 0x00, 0x80, 0x4F, 0xC0, 0x0F, 0x10,
  0x20, 0x40, 0x40, 0xBC, 0xC2, 0x82, 0x82, 0x82, 0x84, 0x84, 0x78, 0x7F,
  0x01, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0xC0,
  0x0E, 0x11, 0x21, 0x21, 0x11, 0x12, 0x1C, 0x22, 0x42, 0x81, 0x82, 0x42,
  0x7C, 0x0E, 0x11, 0x21, 0x21, 0x41, 0x41, 0x23, 0x3D, 0x02, 0x02, 0x04,
  0x04, 0xF8, 0x24, 0x00, 0x00, 0x18, 0x11, 0x00, 0x00, 0x00, 0x24, 0x48,
  0x07, 0x18, 0x60, 0x80, 0x60, 0x18, 0x06, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x30, 0x0C, 0x03, 0x0C, 0x30, 0x40, 0x80, 0x78, 0x10, 0x41,
  0x08, 0x42, 0x10, 0x41, 0x00, 0x00, 0x80, 0x07, 0x81, 0x86, 0x20, 0x24,
  0x01, 0x47, 0x98, 0x91, 0x91, 0x19, 0x12, 0x91, 0x29, 0x22, 0x9D, 0xC8,
  0x00, 0x80, 0x06, 0x10, 0x1E, 0x00, 0x02, 0x01, 0x01, 0x40, 0xA0, 0x90,
  0x48, 0x44, 0x3E, 0x21, 0x10, 0x90, 0x48, 0x18, 0x08, 0x3E, 0x21, 0x21,
  0x41, 0x41, 0x42, 0x7C, 0x42, 0x82, 0x82, 0x82, 0x84, 0xF8, 0x0F, 0x88,
  0x08, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x08, 0x03,
  0xC0, 0x3E, 0x10, 0x88, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x81, 0x81, 0x40,
  0xA0, 0x90, 0x8F, 0x80, 0x3F, 0x20, 0x20, 0x40, 0x40, 0x40, 0x7C, 0x40,
  0x80, 0x80, 0x80, 0x80, 0xF8, 0x3F, 0x20, 0x20, 0x40, 0x40, 0x40, 0x7C,
  0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x0F, 0xC4, 0x02, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x72, 0x02, 0x80, 0xA0, 0x48, 0x11, 0x04, 0x3F, 0x00, 0x20,
  0x48, 0x12, 0x09, 0x02, 0x40, 0x90, 0x27, 0xF1, 0x04, 0x81, 0x20, 0x48,
  0x12, 0x04, 0x82, 0x00, 0x38, 0x84, 0x22, 0x10, 0x84, 0x22, 0x10, 0x8E,
  0x00, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40,
  0x82, 0x04, 0x70, 0x20, 0x90, 0x88, 0x88, 0x84, 0x82, 0x81, 0xC0, 0x90,
  0x88, 0x44, 0x21, 0x10, 0x88, 0x60, 0x21, 0x08, 0x84, 0x21, 0x08, 0x84,
  0x21, 0x0F, 0x80, 0x20, 0x12, 0x03, 0x30, 0x35, 0x05, 0x50, 0x55, 0x0A,
  0x50, 0xA5, 0x12, 0x92, 0x28, 0xA4, 0x8C, 0x48, 0xC4, 0x88, 0x40, 0x20,
  0x48, 0x13, 0x05, 0x42, 0x48, 0x92, 0x24, 0x89, 0x12, 0x85, 0x21, 0x48,
  0x32, 0x0C, 0x82, 0x00, 0x0F, 0x04, 0x22, 0x05, 0x01, 0x40, 0x60, 0x18,
  0x06, 0x02, 0x80, 0xA0, 0x28, 0x11, 0x08, 0x3C, 0x00, 0x3E, 0x21, 0x21,
  0x41, 0x41, 0x42, 0x46, 0x78, 0x80, 0x80, 0x80, 0x80, 0x80, 0x0F, 0x04,
  0x22, 0x05, 0x01, 0x40, 0x60, 0x18, 0x06, 0x02, 0x80, 0xA0, 0x28, 0x11,
  0x08, 0x3C, 0x02, 0x00, 0x40, 0x10, 0x3E, 0x21, 0x21, 0x41, 0x41, 0x42,
  0x44, 0x78, 0x88, 0x88, 0x84, 0x84, 0x84, 0x1F, 0x20, 0x20, 0x20, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x02, 0x02, 0x04, 0xF8, 0xFE, 0x20, 0x81, 0x02,
  0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x00, 0x20, 0x48, 0x12, 0x05,
  0x02, 0x40, 0x90, 0x24, 0x0A, 0x04, 0x81, 0x20, 0x48, 0x12, 0x08, 0x7C,
  0x00, 0x81, 0x82, 0x82, 0x84, 0x84, 0x88, 0x88, 0x90, 0x90, 0xA0, 0xA0,
  0xC0, 0x40, 0x82, 0x0C, 0x30, 0xA1, 0x85, 0x14, 0x48, 0xA2, 0x49, 0x12,
  0x49, 0x12, 0x48, 0xA2, 0x85, 0x14, 0x30, 0xC1, 0x86, 0x08, 0x20, 0x00,
  0x10, 0x44, 0x20, 0x88, 0x24, 0x0A, 0x03, 0x00, 0x40, 0x30, 0x14, 0x08,
  0x82, 0x21, 0x08, 0x81, 0x00, 0x83, 0x0A, 0x14, 0x48, 0x8A, 0x18, 0x20,
  0x40, 0x81, 0x02, 0x08, 0x00, 0x3F, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20,
  0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x0F, 0xE0, 0x1C, 0x42, 0x08, 0x20,
  0x82, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x38, 0x92, 0x49, 0x12, 0x49,
  0x22, 0x1C, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41,
  0x38, 0x08, 0x30, 0x51, 0x24, 0x48, 0x60, 0x80, 0xFE, 0xA4, 0x1A, 0x4D,
  0x0C, 0x18, 0x30, 0x61, 0x42, 0x8D, 0xE8, 0x10, 0x10, 0x10, 0x20, 0x2E,
  0x31, 0x21, 0x21, 0x41, 0x41, 0x41, 0x42, 0xC2, 0xBC, 0x1C, 0x84, 0x20,
  0x82, 0x08, 0x20, 0x81, 0xE0, 0x01, 0x01, 0x01, 0x01, 0x19, 0x25, 0x42,
  0x82, 0x82, 0x82, 0x84, 0x84, 0x8C, 0xF4, 0x18, 0x94, 0x61, 0x9B, 0x88,
  0x20, 0x81, 0xE0, 0x03, 0x82, 0x01, 0x00, 0x81, 0xE0, 0x40, 0x20, 0x10,
  0x08, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x60, 0x00,
  0x0C, 0x89, 0x48, 0x48, 0x24, 0x12, 0x09, 0x08, 0x84, 0x46, 0x3D, 0x00,
  0x80, 0x80, 0x47, 0xC0, 0x10, 0x10, 0x10, 0x20, 0x2E, 0x31, 0x21, 0x21,
  0x41, 0x41, 0x42, 0x42, 0x42, 0x82, 0x10, 0x02, 0x22, 0x24, 0x44, 0x44,
  0x80, 0x04, 0x00, 0x02, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x20, 0x82,
  0x08, 0xC0, 0x10, 0x10, 0x10, 0x20, 0x21, 0x22, 0x24, 0x28, 0x50, 0x68,
  0x48, 0x48, 0x44, 0x84, 0x11, 0x12, 0x22, 0x22, 0x44, 0x44, 0x48, 0x2E,
  0x63, 0x29, 0x21, 0x12, 0x11, 0x42, 0x14, 0x21, 0x42, 0x14, 0x21, 0x44,
  0x28, 0x42, 0x2E, 0x31, 0x21, 0x21, 0x41, 0x41, 0x42, 0x42, 0x42, 0x82,
  0x1C, 0x45, 0x0C, 0x18, 0x30, 0x60, 0xC2, 0x84, 0xF0, 0x2E, 0x31, 0x21,
  0x21, 0x41, 0x41, 0x41, 0x42, 0x42, 0xBC, 0x80, 0x80, 0x80, 0x80, 0x19,
  0x25, 0x42, 0x82, 0x82, 0x82, 0x84, 0x84, 0x8C, 0xF4, 0x04, 0x08, 0x08,
  0x08, 0x2C, 0xC2, 0x08, 0x41, 0x04, 0x10, 0x42, 0x00, 0x1E, 0x41, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x09, 0xF0, 0x24, 0xF4, 0x44, 0x88, 0x88, 0x8E,
  0x42, 0x85, 0x0C, 0x18, 0x30, 0xA1, 0x42, 0x8D, 0xE8, 0x83, 0x0A, 0x14,
  0x48, 0x92, 0x24, 0x50, 0x40, 0x80, 0x84, 0x63, 0x18, 0xC6, 0x52, 0x94,
  0xA9, 0x4A, 0x53, 0x18, 0xC6, 0x21, 0x00, 0x20, 0x88, 0x84, 0x82, 0x80,
  0x80, 0x40, 0x50, 0x48, 0x44, 0x61, 0x00, 0x10, 0x44, 0x21, 0x08, 0x44,
  0x11, 0x04, 0x80, 0xA0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x40, 0x10, 0x38,
  0x00, 0x3E, 0x08, 0x10, 0x41, 0x04, 0x08, 0x20, 0x81, 0xF0, 0x06, 0x10,
  0x40, 0x81, 0x02, 0x04, 0x10, 0xE0, 0x40, 0x81, 0x04, 0x08, 0x10, 0x18,
  0xFF, 0xFF, 0xC0, 0x18, 0x10, 0x41, 0x08, 0x20, 0x82, 0x0C, 0x41, 0x04,
  0x10, 0x82, 0x30, 0xFF,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 13, 4, 0, -13 },
  { 8, 4, 5, 6, 2, -13 },
  { 11, 10, 13, 10, 0, -13 },
  { 28, 8, 15, 9, 0, -14 },
  { 43, 10, 13, 12, 1, -13 },
  { 60, 9, 13, 10, 0, -13 },
  { 75, 1, 5, 3, 2, -13 },
  { 76, 5, 16, 4, 1, -13 },
  { 86, 5, 16, 4, -1, -13 },
  { 96, 7, 7, 8, 2, -14 },
  { 103, 8, 9, 9, 1, -11 },
  { 112, 3, 4, 3, -1, -2 },
  { 114, 4, 1, 5, 1, -5 },
  { 115, 2, 1, 4, 0, -1 },
  { 116, 8, 13, 6, -1, -13 },
  { 129, 7, 13, 9, 1, -13 },
  { 141, 4, 13, 9, 3, -13 },
  { 148, 8, 13, 9, 0, -13 },
  { 161, 8, 13, 9, 0, -13 },
  { 174, 8, 13, 9, 0, -13 },
  { 187, 9, 13, 9, 0, -13 },
  { 202, 8, 13, 9, 1, -13 },
  { 215, 8, 13, 9, 1, -13 },
  { 228, 8, 13, 9, 0, -13 },
  { 241, 8, 13, 9, 0, -13 },
  { 254, 3, 10, 4, 0, -10 },
  { 258, 4, 12, 4, -1, -10 },
  { 264, 8, 8, 9, 1, -10 },
  { 272, 8, 5, 9, 1, -9 },
  { 277, 8, 8, 9, 1, -10 },
  { 285, 6, 13, 6, 1, -13 },
  { 295, 12, 15, 13, 1, -13 },
  { 318, 9, 13, 9, -1, -13 },
  { 333, 8, 13, 9, 1, -13 },
  { 346, 9, 13, 9, 1, -13 },
  { 361, 9, 13, 10, 1, -13 },
  { 376, 8, 13, 8, 1, -13 },
  { 389, 8, 13, 8, 1, -13 },
  { 402, 10, 13, 11, 1, -13 },
  { 419, 10, 13, 11, 1, -13 },
  { 436, 5, 13, 5, 0, -13 },
  { 445, 7, 16, 4, -3, -13 },
  { 459, 9, 13, 9, 1, -13 },
  { 474, 5, 13, 8, 1, -13 },
  { 483, 12, 13, 13, 1, -13 },
  { 503, 10, 13, 11, 1, -13 },
  { 520, 10, 13, 11, 1, -13 },
  { 537, 8, 13, 9, 1, -13 },
  { 550, 10, 16, 11, 1, -13 },
  { 570, 8, 13, 9, 1, -13 },
  { 583, 8, 13, 8, 0, -13 },
  { 596, 7, 13, 8, 2, -13 },
  { 608, 10, 13, 11, 1, -13 },
  { 625, 8, 13, 9, 2, -13 },
  { 638, 13, 13, 14, 2, -13 },
  { 660, 10, 13, 8, -1, -13 },
  { 677, 7, 13, 8, 2, -13 },
  { 689, 9, 13, 8, 0, -13 },
  { 704, 6, 16, 5, 0, -13 },
  { 716, 3, 13, 6, 2, -13 },
  { 721, 6, 16, 5, -1, -13 },
  { 733, 7, 7, 9, 1, -13 },
  { 740, 7, 1, 6, -2, 2 },
  { 741, 2, 3, 4, 3, -14 },
  { 742, 7, 10, 9, 1, -10 },
  { 751, 8, 14, 9, 0, -14 },
  { 765, 6, 10, 7, 1, -10 },
  { 773, 8, 14, 9, 1, -14 },
  { 787, 6, 10, 8, 1, -10 },
  { 795, 9, 18, 4, -2, -14 },
  { 816, 9, 14, 9, 0, -10 },
  { 832, 8, 14, 9, 0, -14 },
  { 846, 4, 13, 4, 0, -13 },
  { 853, 6, 17, 4, -2, -13 },
  { 866, 8, 14, 7, 0, -14 },
  { 880, 4, 14, 4, 0, -14 },
  { 887, 12, 10, 13, 0, -10 },
  { 902, 8, 10, 9, 0, -10 },
  { 912, 7, 10, 9, 1, -10 },
  { 921, 8, 14, 9, 0, -10 },
  { 935, 8, 14, 9, 1, -10 },
  { 949, 6, 10, 6, 0, -10 },
  { 957, 7, 10, 7, 0, -10 },
  { 966, 4, 12, 5, 1, -12 },
  { 972, 7, 10, 9, 1, -10 },
  { 981, 7, 10, 7, 1, -10 },
  { 990, 10, 10, 11, 1, -10 },
  { 1003, 9, 10, 7, -1, -10 },
  { 1015, 10, 14, 7, -2, -10 },
  { 1033, 7, 10, 7, 0, -10 },
  { 1042, 7, 16, 6, 0, -13 },
  { 1056, 1, 18, 8, 4, -14 },
  { 1059, 6, 16, 6, -1, -13 },
  { 1071, 8, 1, 9, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic18pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC18PT7B_H_
