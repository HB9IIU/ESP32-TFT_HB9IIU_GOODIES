#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC69PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xE0, 0x00, 0x1C, 0x07, 0x1C, 0x06, 0x1C, 0x0E, 0x18, 0x0E, 0x18,
  0x0E, 0x38, 0x0C, 0x38, 0x0C, 0x38, 0x1C, 0x30, 0x1C, 0x30, 0x18, 0x30,
  0x18, 0x70, 0x18, 0x60, 0x18, 0x60, 0x30, 0x60, 0x30, 0x60, 0x30, 0xC0,
  0x30, 0xC0, 0x30, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x06, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x06, 0x00, 0x30, 0x10, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x18, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x03, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x03, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x60, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x3E, 0x30, 0x7C, 0x01, 0xC0, 0xC0, 0x20, 0x0E, 0x03,
  0x00, 0x00, 0x70, 0x0C, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x38, 0x06, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x3C,
  0x60, 0x00, 0x00, 0x7D, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0D, 0xF0,
  0x00, 0x00, 0x31, 0xE0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x18, 0x0E, 0x00, 0x00, 0x60, 0x38, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80,
  0x70, 0x00, 0x06, 0x03, 0x80, 0x80, 0x18, 0x1C, 0x03, 0xC0, 0x61, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x08, 0x03, 0xFE, 0x00, 0x00, 0x60,
  0x0F, 0x9E, 0x00, 0x01, 0xC0, 0x3C, 0x1C, 0x00, 0x07, 0x00, 0x60, 0x1C,
  0x00, 0x0C, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x30, 0x00, 0xE0,
  0x0E, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x70, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x03, 0x80, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x30, 0x00, 0xE0, 0x01, 0x80, 0xE0,
  0x01, 0xC0, 0x07, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x06, 0x00, 0x06, 0x00,
  0x18, 0x1C, 0x00, 0x0C, 0x00, 0x30, 0x70, 0x3F, 0x18, 0x00, 0xE0, 0xC1,
  0xFF, 0x30, 0x01, 0x83, 0x87, 0x8F, 0x60, 0x07, 0x0E, 0x1C, 0x0E, 0xC0,
  0x0C, 0x18, 0x70, 0x0F, 0xC0, 0x38, 0x70, 0xE0, 0x1F, 0x80, 0xE1, 0xC3,
  0x80, 0x3B, 0x83, 0xC3, 0x06, 0x00, 0x37, 0xDF, 0x0E, 0x1C, 0x00, 0x67,
  0xF8, 0x18, 0x38, 0x01, 0xC3, 0xE0, 0x60, 0x60, 0x03, 0x80, 0x01, 0xC1,
  0xC0, 0x07, 0x00, 0x03, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x06, 0x00, 0x1C,
  0x00, 0x38, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x38, 0x00, 0x60, 0x01, 0xC0,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x01, 0x80, 0x06,
  0x00, 0x38, 0x03, 0x00, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x38, 0x01, 0x80,
  0x0C, 0x00, 0x70, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x1C, 0x00, 0x30, 0x03,
  0x80, 0x30, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x01, 0xC0, 0x70, 0x06, 0x00, 0x01, 0xC1, 0xC0, 0x1C, 0x00, 0x03, 0xFF,
  0x00, 0x70, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7E, 0x7C, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x00, 0x0C, 0x78, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1E, 0xE0,
  0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x07, 0x80,
  0xE0, 0x01, 0xC3, 0x80, 0x18, 0x00, 0x71, 0xC0, 0x07, 0x00, 0x18, 0xE0,
  0x00, 0xE0, 0x0E, 0x38, 0x00, 0x38, 0x03, 0x1C, 0x00, 0x07, 0x01, 0xC6,
  0x00, 0x01, 0xC0, 0xE3, 0x80, 0x00, 0x38, 0x38, 0xE0, 0x00, 0x0E, 0x1C,
  0x38, 0x00, 0x01, 0xC6, 0x0C, 0x00, 0x00, 0x33, 0x83, 0x00, 0x00, 0x0F,
  0xC0, 0xC0, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00,
  0x3E, 0x03, 0x80, 0x00, 0x1F, 0x80, 0xE0, 0x00, 0x0E, 0x70, 0x1C, 0x00,
  0x07, 0x1C, 0x07, 0x80, 0x07, 0x83, 0x80, 0xF8, 0x07, 0xC0, 0xE0, 0x1F,
  0xFF, 0xC0, 0x1C, 0x01, 0xFF, 0xE0, 0x03, 0x80, 0x0F, 0x80, 0x00, 0x00,
  0x1C, 0x71, 0xC6, 0x18, 0xE3, 0x8E, 0x30, 0xC3, 0x1C, 0x61, 0x86, 0x18,
  0xC3, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x01, 0x80, 0x30, 0x01,
  0xF0, 0x18, 0x00, 0x3C, 0x0C, 0x00, 0x07, 0x86, 0x00, 0x00, 0xF3, 0x00,
  0x60, 0x1D, 0x0F, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xD8, 0x00, 0x01, 0xC6, 0x00, 0x01, 0xC3, 0x00, 0x01, 0xC0,
  0xC0, 0x03, 0xC0, 0x60, 0x03, 0xC0, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x40,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x38,
  0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x30,
  0x1C, 0x06, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x6F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0x38, 0x03, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x0E, 0x30, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x18, 0xE0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x0E, 0x30, 0x00, 0x00, 0x71, 0x80, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x18, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x61,
  0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x07, 0x80,
  0x1C, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x7E, 0x00, 0xFE, 0x03, 0xCE, 0x07, 0x8C, 0x1F, 0x0C,
  0x3C, 0x1C, 0x78, 0x1C, 0xE0, 0x1C, 0x40, 0x18, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xF8, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x02, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFB, 0xF8, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x20, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x1D, 0x80, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x01, 0x83, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x00, 0xE0, 0x06, 0x00,
  0x01, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x30, 0x03, 0x80,
  0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xC0, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x80, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x1E, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x81, 0xFF, 0x00, 0x18, 0x3F, 0xFE, 0x00, 0xC7, 0xC0, 0xF8, 0x0E,
  0x70, 0x01, 0xC0, 0x77, 0x00, 0x07, 0x03, 0x60, 0x00, 0x1C, 0x1E, 0x00,
  0x00, 0xE1, 0xF0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x18, 0x78, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x38, 0x60, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x7C, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0xF0, 0x07,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x1E, 0x00, 0x03, 0x80, 0x78, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x03,
  0xDF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7D,
  0xE0, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x70, 0x0F, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x0F,
  0x80, 0x3E, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x01, 0xC0, 0x0E, 0x00, 0x03, 0x00, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x60, 0x70, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x03, 0x83, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x38, 0x30, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x3E, 0x0E, 0x00, 0x01,
  0xF0, 0x1C, 0x00, 0x0E, 0xC0, 0x70, 0x00, 0x77, 0x00, 0xF0, 0x03, 0x9C,
  0x01, 0xF0, 0xFC, 0x60, 0x03, 0xFF, 0xC1, 0x80, 0x03, 0xFC, 0x0E, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x20,
  0x07, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x0F, 0x03, 0xE0, 0x78, 0x07, 0x00, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x01,
  0xFE, 0x7E, 0x03, 0x80, 0x3C, 0x08, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00,
  0x00, 0x0C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0xFC, 0x00,
  0x60, 0xC0, 0x00, 0xFF, 0xF8, 0x03, 0x0E, 0x00, 0x1E, 0x03, 0x80, 0x18,
  0x60, 0x01, 0xC0, 0x0C, 0x00, 0xC7, 0x00, 0x1C, 0x00, 0xE0, 0x06, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x33, 0x80, 0x1C, 0x00, 0x30, 0x01, 0x9C, 0x00,
  0xE0, 0x01, 0x80, 0x0C, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0x66, 0x00, 0x60,
  0x00, 0xE0, 0x07, 0x70, 0x07, 0x00, 0x06, 0x00, 0x3B, 0x80, 0x30, 0x00,
  0x30, 0x01, 0xD8, 0x01, 0x80, 0x03, 0x80, 0x0C, 0xC0, 0x1C, 0x00, 0x1C,
  0x00, 0x6E, 0x00, 0xE0, 0x00, 0xC0, 0x07, 0x70, 0x06, 0x00, 0x0E, 0x00,
  0x3B, 0x80, 0x30, 0x00, 0x70, 0x01, 0x9C, 0x01, 0x80, 0x03, 0x80, 0x1C,
  0xE0, 0x1C, 0x00, 0x38, 0x00, 0xC7, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x38,
  0x03, 0x00, 0x1E, 0x00, 0x61, 0xC0, 0x18, 0x00, 0xF0, 0x07, 0x0E, 0x00,
  0xC0, 0x0D, 0x80, 0x70, 0x70, 0x07, 0x00, 0xCE, 0x07, 0x03, 0x80, 0x1C,
  0x1E, 0x30, 0x70, 0x1C, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0xE0, 0x01, 0xFC,
  0x07, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x07, 0x18, 0x00,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x03, 0x83, 0x00,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x70, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x01, 0x87, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x3F, 0x00, 0x06, 0x00,
  0x03, 0xC0, 0x03, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x60, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x80, 0x38, 0x00, 0x0F, 0x00,
  0x1C, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x07, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x01, 0xF0, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x18, 0x00,
  0x00, 0x78, 0x0C, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x78, 0x07, 0x00,
  0x00, 0x78, 0x03, 0x80, 0x00, 0xF8, 0x01, 0x80, 0x1F, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x0F, 0x80,
  0x07, 0x00, 0x0F, 0x80, 0x00, 0x40, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x38, 0x01, 0xFC, 0x00, 0x03,
  0x00, 0x03, 0xE0, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x18, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00,
  0x70, 0x03, 0x00, 0x00, 0x1E, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x0F, 0xC0, 0x00,
  0x60, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xCF, 0xFC,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xFE, 0x1C, 0x00,
  0x03, 0xFF, 0xF0, 0xC0, 0x00, 0x1F, 0xFF, 0x06, 0x00, 0x00, 0x00, 0x38,
  0x30, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x38, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x18, 0x00, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x0E, 0x1F, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x70, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x0C, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x00, 0x0C, 0x7E, 0x00,
  0x00, 0x00, 0x67, 0x70, 0x00, 0x00, 0x07, 0x71, 0x80, 0x00, 0x00, 0x3F,
  0x0E, 0x00, 0x00, 0x01, 0xF0, 0x70, 0x00, 0x00, 0x0F, 0x01, 0x80, 0x00,
  0x00, 0xF0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x03, 0xB0, 0x00, 0x00, 0x01, 0xB8, 0x01, 0xD8, 0x00, 0x00, 0x01, 0xDC,
  0x00, 0xCC, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x00, 0x00, 0xEE,
  0x00, 0x73, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x73,
  0x80, 0x1C, 0xE0, 0x00, 0x00, 0x71, 0x80, 0x0C, 0x70, 0x00, 0x00, 0x38,
  0xC0, 0x06, 0x18, 0x00, 0x00, 0x38, 0xE0, 0x07, 0x0C, 0x00, 0x00, 0x18,
  0x70, 0x03, 0x86, 0x00, 0x00, 0x1C, 0x38, 0x01, 0xC3, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0xC1, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x60, 0xE0, 0x00, 0x06,
  0x0E, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x38, 0x38, 0x00, 0x07,
  0x03, 0x80, 0x1C, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x0C, 0x06, 0x00, 0x03,
  0x81, 0xC0, 0x06, 0x03, 0x00, 0x01, 0xC0, 0xE0, 0x07, 0x01, 0x80, 0x01,
  0xC0, 0x70, 0x03, 0x80, 0xE0, 0x00, 0xC0, 0x30, 0x01, 0xC0, 0x70, 0x00,
  0xE0, 0x18, 0x00, 0xC0, 0x38, 0x00, 0x60, 0x1C, 0x00, 0xE0, 0x1C, 0x00,
  0x70, 0x0E, 0x00, 0x70, 0x06, 0x00, 0x30, 0x07, 0x00, 0x38, 0x03, 0x00,
  0x38, 0x03, 0x00, 0x18, 0x01, 0x80, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0E,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x01,
  0x83, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xC3, 0x80, 0x07, 0x00, 0x38, 0x00,
  0x61, 0x80, 0x03, 0x00, 0x18, 0x00, 0x39, 0xC0, 0x03, 0x80, 0x0C, 0x00,
  0x1D, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0xE0, 0x00, 0xE0, 0x07, 0x00,
  0x07, 0xE0, 0x00, 0x60, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x30, 0x01, 0x80,
  0x00, 0xF0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x06, 0x00, 0x3E, 0x00,
  0x00, 0x06, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x7E, 0x00, 0x00, 0x0E,
  0x00, 0x76, 0x00, 0x00, 0x0E, 0x00, 0x67, 0x00, 0x00, 0x0C, 0x00, 0x67,
  0x00, 0x00, 0x1C, 0x00, 0xE3, 0x00, 0x00, 0x1C, 0x00, 0xE3, 0x80, 0x00,
  0x1C, 0x00, 0xE3, 0x80, 0x00, 0x18, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x00,
  0xC1, 0xC0, 0x00, 0x38, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0xC0,
  0x00, 0x38, 0x01, 0xC0, 0xE0, 0x00, 0x30, 0x01, 0x80, 0xE0, 0x00, 0x30,
  0x01, 0x80, 0x60, 0x00, 0x70, 0x03, 0x80, 0x70, 0x00, 0x70, 0x03, 0x80,
  0x70, 0x00, 0x70, 0x03, 0x80, 0x30, 0x00, 0x60, 0x03, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x0C,
  0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x01, 0xC0,
  0x0E, 0x00, 0x06, 0x01, 0x80, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x0C, 0x00,
  0x07, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x83,
  0x80, 0x1C, 0x00, 0x03, 0x83, 0x00, 0x18, 0x00, 0x01, 0x83, 0x00, 0x18,
  0x00, 0x01, 0xC7, 0x00, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x38, 0x00, 0x00,
  0xC7, 0x00, 0x38, 0x00, 0x00, 0xE6, 0x00, 0x30, 0x00, 0x00, 0xE6, 0x00,
  0x30, 0x00, 0x00, 0x6E, 0x00, 0x70, 0x00, 0x00, 0x7E, 0x00, 0x70, 0x00,
  0x00, 0x7E, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x00, 0x3C,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x03, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00,
  0x0E, 0x30, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x00, 0x38, 0x30, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x38, 0x03, 0xF8, 0x00, 0x30, 0x00, 0x7C, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x60, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x03,
  0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x03, 0xC0, 0x07,
  0x00, 0x3F, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x03, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00,
  0x0E, 0x30, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x00, 0x38, 0x30, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x38, 0x03, 0xF8, 0x00, 0x30,
  0x00, 0x7C, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x00, 0x60, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x78, 0x03, 0x00, 0x00, 0xF0, 0x03, 0x00, 0x03, 0xE0, 0x07, 0x00,
  0x1F, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x06, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x38, 0x00, 0x07, 0x00, 0x30, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x02, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x38, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x00, 0x70, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x03, 0x00,
  0x00, 0x1C, 0x06, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x30, 0x00, 0xE0, 0x00, 0x60, 0x03, 0x80, 0x00, 0xC0, 0x07, 0x00,
  0x01, 0x80, 0x1C, 0x00, 0x03, 0x00, 0x38, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x0C,
  0x70, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1C, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x18, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0x86, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x3B, 0x80, 0x00, 0x70, 0x60, 0x00, 0x0C, 0xE0, 0x00, 0x1C, 0x18, 0x00,
  0x07, 0x38, 0x00, 0x06, 0x06, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x63, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x38, 0xE0, 0x00, 0x70, 0x18,
  0x00, 0x0C, 0x38, 0x00, 0x1C, 0x06, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x01,
  0x80, 0x01, 0x83, 0x80, 0x03, 0x80, 0x60, 0x00, 0xE0, 0xE0, 0x00, 0xC0,
  0x18, 0x00, 0x38, 0x18, 0x00, 0x70, 0x06, 0x00, 0x1C, 0x06, 0x00, 0x18,
  0x01, 0x80, 0x07, 0x01, 0x80, 0x0E, 0x00, 0x60, 0x01, 0x80, 0x60, 0x03,
  0x80, 0x18, 0x00, 0xE0, 0x18, 0x01, 0xC0, 0x07, 0x00, 0x30, 0x06, 0x00,
  0x70, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0x1C, 0x03, 0x80, 0x18, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x06,
  0x01, 0xC0, 0x01, 0xC0, 0x70, 0x01, 0x80, 0x70, 0x00, 0x70, 0x1C, 0x00,
  0x60, 0x38, 0x00, 0x1C, 0x06, 0x00, 0x18, 0x0E, 0x00, 0x07, 0x03, 0x80,
  0x06, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x01, 0x81, 0xC0, 0x00, 0x70, 0x70,
  0x00, 0x60, 0x60, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x38, 0x00, 0x07, 0x0E,
  0x00, 0x06, 0x0E, 0x00, 0x01, 0xC3, 0x00, 0x01, 0x87, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x61, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x18, 0x60, 0x00, 0x07,
  0x18, 0x00, 0x06, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x67, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x19, 0x80, 0x00,
  0x07, 0x60, 0x00, 0x06, 0x60, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00,
  0x30, 0x38, 0x00, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x1C, 0x18, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x06, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x30,
  0x01, 0xC0, 0x01, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x70, 0x0E,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x63, 0x80, 0x00, 0x03,
  0x38, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xE0, 0x38, 0x0E, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0E, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x80, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x1C,
  0x07, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0x80,
  0x60, 0x18, 0x07, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x70, 0x01, 0x80, 0x03, 0x80, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x01,
  0x80, 0x01, 0x80, 0x1C, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01,
  0x87, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x18, 0x1C, 0x0C, 0x06, 0x06, 0x03,
  0x00, 0x07, 0xF0, 0x18, 0x00, 0xFF, 0xE0, 0xC0, 0x1F, 0x87, 0x86, 0x01,
  0xE0, 0x0E, 0x70, 0x1E, 0x00, 0x33, 0x01, 0xE0, 0x00, 0xD8, 0x0E, 0x00,
  0x06, 0xC0, 0xE0, 0x00, 0x3E, 0x0E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x03,
  0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1B,
  0x03, 0x80, 0x00, 0xD8, 0x0E, 0x00, 0x0D, 0xC0, 0x70, 0x00, 0xCE, 0x01,
  0xC0, 0x0C, 0x60, 0x0F, 0x01, 0xC3, 0x00, 0x3F, 0xFC, 0x18, 0x00, 0xFF,
  0xC1, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x3F, 0xC0, 0x00, 0xE1, 0xFF, 0xE0,
  0x01, 0x87, 0x83, 0xE0, 0x03, 0x1C, 0x01, 0xC0, 0x0E, 0x70, 0x01, 0xC0,
  0x1D, 0xC0, 0x01, 0xC0, 0x37, 0x00, 0x03, 0x80, 0x6C, 0x00, 0x07, 0x01,
  0xF0, 0x00, 0x06, 0x03, 0xE0, 0x00, 0x0C, 0x07, 0x80, 0x00, 0x1C, 0x0F,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x03, 0x03, 0x80, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x03, 0x81, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0xC0, 0xF0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x06, 0x03, 0xC0, 0x00, 0x1C,
  0x06, 0xC0, 0x00, 0x70, 0x0D, 0x80, 0x01, 0xE0, 0x3B, 0x80, 0x07, 0x80,
  0x63, 0x00, 0x1E, 0x00, 0xC7, 0x80, 0xF8, 0x01, 0x87, 0xFF, 0xE0, 0x07,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x1F, 0x81, 0xC0, 0x1E, 0x00, 0x20, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x18, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0xF0,
  0x38, 0x00, 0x1F, 0xFE, 0x1C, 0x00, 0x3F, 0x0F, 0x8E, 0x00, 0x3C, 0x00,
  0xC6, 0x00, 0x3C, 0x00, 0x33, 0x00, 0x3C, 0x00, 0x1B, 0x80, 0x3C, 0x00,
  0x07, 0xC0, 0x1C, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x01, 0xE0, 0x0E, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x07, 0x80,
  0x38, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x03, 0xE0, 0x0E, 0x00, 0x03, 0xF0,
  0x07, 0x00, 0x01, 0xB8, 0x01, 0xC0, 0x01, 0xD8, 0x00, 0xE0, 0x01, 0xCC,
  0x00, 0x38, 0x01, 0xC6, 0x00, 0x1E, 0x03, 0xC3, 0x00, 0x07, 0xFF, 0xC3,
  0x80, 0x01, 0xFF, 0x81, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0x87, 0xC0, 0x1F, 0x00, 0xE0, 0x1E,
  0x00, 0x38, 0x1E, 0x00, 0x1C, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x0E,
  0x00, 0x03, 0x87, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xE3,
  0x80, 0x00, 0x71, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0xF0,
  0x70, 0x03, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x08, 0x07, 0xC0, 0x1C, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x03, 0x00, 0x07, 0xFF, 0x83,
  0x00, 0x1F, 0x87, 0xC7, 0x00, 0x3C, 0x00, 0xC6, 0x00, 0x78, 0x00, 0x66,
  0x00, 0xF0, 0x00, 0x66, 0x01, 0xE0, 0x00, 0x3E, 0x01, 0xC0, 0x00, 0x3E,
  0x03, 0x80, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38,
  0x0C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x07, 0xC0,
  0x38, 0x00, 0x0F, 0xC0, 0x38, 0x00, 0x0D, 0xC0, 0x1C, 0x00, 0x1D, 0x80,
  0x1C, 0x00, 0x39, 0x80, 0x0E, 0x00, 0x73, 0x80, 0x0F, 0x01, 0xE3, 0x80,
  0x07, 0xFF, 0xC3, 0x80, 0x03, 0xFF, 0x03, 0x00, 0x00, 0x78, 0x03, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0xA0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x0F, 0xF0,
  0x01, 0xC3, 0xFF, 0xC0, 0x18, 0x7C, 0x3E, 0x01, 0x8E, 0x00, 0xE0, 0x39,
  0x80, 0x07, 0x03, 0xB0, 0x00, 0x70, 0x36, 0x00, 0x03, 0x03, 0xE0, 0x00,
  0x30, 0x3C, 0x00, 0x03, 0x07, 0x80, 0x00, 0x30, 0x78, 0x00, 0x03, 0x07,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x1C, 0x18, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x18,
  0x38, 0x00, 0x03, 0x83, 0x00, 0x00, 0x38, 0x30, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x30, 0x70, 0x00, 0x03, 0x07, 0x00, 0x00, 0x70, 0x60, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x08, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x06, 0x00, 0x07,
  0x00, 0x30, 0x00, 0x70, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xE0, 0x07, 0x00, 0x06, 0x00, 0x70, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80,
  0x78, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xC0, 0x38, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x70, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0xC3, 0xC0, 0x00, 0x06, 0x3E, 0x00, 0x00, 0x73, 0xB8, 0x00, 0x03, 0xB9,
  0xC0, 0x00, 0x1B, 0x86, 0x00, 0x00, 0xF8, 0x38, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x78, 0x06, 0x00, 0x03, 0x80, 0x38, 0x00, 0x18, 0x01, 0xC0, 0x00,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x18, 0x00, 0x38, 0x00, 0xC0, 0x00, 0xC0, 0x0E, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x7F, 0x00, 0x1F, 0xE0, 0x01, 0x83, 0xFF, 0x00, 0xFF, 0xE0, 0x03,
  0x1F, 0x1F, 0x03, 0xC3, 0xE0, 0x06, 0x70, 0x07, 0x0E, 0x00, 0xE0, 0x1D,
  0xC0, 0x0E, 0x38, 0x01, 0xC0, 0x33, 0x00, 0x0C, 0xE0, 0x01, 0xC0, 0x6C,
  0x00, 0x1D, 0x80, 0x03, 0x80, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x7F, 0x80, 0x06, 0x0F, 0xFF, 0x00, 0x30, 0xF8, 0x7C,
  0x01, 0x8E, 0x00, 0xF0, 0x1C, 0xE0, 0x03, 0x80, 0xCC, 0x00, 0x1C, 0x06,
  0xC0, 0x00, 0x60, 0x3E, 0x00, 0x03, 0x03, 0xE0, 0x00, 0x18, 0x1E, 0x00,
  0x00, 0xC0, 0xF0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x70, 0x30, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0xC0, 0xE0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x70, 0x30, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0E, 0x06,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x18, 0x1C, 0x00,
  0x00, 0xC0, 0xE0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x01, 0xC0, 0x3C, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x07, 0x30, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x3C, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x01, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x18, 0x0F, 0xF0, 0x00, 0x06, 0x0F,
  0xFF, 0x00, 0x01, 0x87, 0xC3, 0xE0, 0x00, 0x63, 0x80, 0x3C, 0x00, 0x39,
  0xC0, 0x07, 0x00, 0x0C, 0xE0, 0x00, 0xE0, 0x03, 0x70, 0x00, 0x38, 0x00,
  0xD8, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x1F, 0x00, 0x00, 0x60,
  0x07, 0x80, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x3C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00,
  0x06, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x68, 0x00, 0x07, 0x00, 0x1B, 0x00, 0x03, 0xC0, 0x0E, 0xC0, 0x01,
  0xE0, 0x03, 0x98, 0x00, 0xF0, 0x00, 0xE7, 0x80, 0xF8, 0x00, 0x30, 0xFF,
  0xFC, 0x00, 0x0C, 0x0F, 0xFC, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x0C, 0x00, 0x7F, 0xF8, 0x30, 0x07,
  0xE1, 0xF1, 0xC0, 0x3C, 0x01, 0xC6, 0x01, 0xE0, 0x01, 0x98, 0x0F, 0x00,
  0x06, 0x60, 0x38, 0x00, 0x0F, 0x81, 0xC0, 0x00, 0x3E, 0x0E, 0x00, 0x00,
  0xF0, 0x38, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x0C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07,
  0x83, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x1F, 0x03, 0x80, 0x00, 0xFC, 0x0E, 0x00, 0x03, 0x70, 0x1C,
  0x00, 0x1D, 0x80, 0x70, 0x00, 0xE6, 0x00, 0xE0, 0x07, 0x38, 0x03, 0xC0,
  0x78, 0xE0, 0x07, 0xFF, 0xC3, 0x80, 0x0F, 0xFC, 0x0C, 0x00, 0x07, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0xFE, 0x03, 0x07, 0xFC, 0x06, 0x1F, 0x10, 0x0C, 0x70, 0x00, 0x39, 0xC0,
  0x00, 0x66, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x3E, 0x07, 0xE0, 0x3C, 0x00, 0x60, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x60, 0x00, 0x70, 0x3C, 0x00, 0xF0, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x07, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x78, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x18, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x07, 0x03, 0x00, 0x00, 0x38, 0x18, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x60, 0x70, 0x00, 0x07, 0x03, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x07, 0x03, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x07, 0x03, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x07, 0x03, 0x00, 0x00, 0x78, 0x38, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1F, 0x03, 0x80,
  0x01, 0xF8, 0x1C, 0x00, 0x0D, 0x80, 0xE0, 0x01, 0xCC, 0x03, 0x80, 0x1C,
  0x60, 0x1E, 0x03, 0xC3, 0x00, 0x7F, 0xFC, 0x38, 0x01, 0xFF, 0x81, 0x80,
  0x01, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xB0, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x71, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x38, 0x18,
  0x00, 0x1C, 0x0C, 0x00, 0x1C, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x0E, 0x01,
  0xC0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x03, 0x00, 0xE0, 0x01, 0x80, 0xE0,
  0x00, 0xC0, 0x60, 0x00, 0x60, 0x70, 0x00, 0x30, 0x30, 0x00, 0x1C, 0x38,
  0x00, 0x0E, 0x18, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8C, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x37, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x06, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0xE0, 0x00, 0x78, 0x00, 0x0C, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0xE0, 0x00, 0xF8, 0x00, 0x18, 0xE0, 0x00, 0xDC, 0x00, 0x38, 0xE0,
  0x01, 0xDC, 0x00, 0x38, 0xE0, 0x01, 0x9C, 0x00, 0x70, 0xE0, 0x03, 0x9C,
  0x00, 0x70, 0xE0, 0x03, 0x1C, 0x00, 0x60, 0xE0, 0x07, 0x1C, 0x00, 0xE0,
  0xE0, 0x07, 0x1C, 0x00, 0xC0, 0xE0, 0x06, 0x0C, 0x01, 0xC0, 0xE0, 0x0E,
  0x0C, 0x01, 0x80, 0xE0, 0x0C, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x0C, 0x03,
  0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0x60, 0x38, 0x0C, 0x07, 0x00, 0x60,
  0x30, 0x0C, 0x06, 0x00, 0x60, 0x70, 0x0C, 0x0E, 0x00, 0x60, 0x60, 0x0C,
  0x0C, 0x00, 0x60, 0xE0, 0x0C, 0x1C, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x00,
  0x61, 0xC0, 0x0C, 0x38, 0x00, 0x61, 0x80, 0x0E, 0x38, 0x00, 0x63, 0x80,
  0x0E, 0x30, 0x00, 0x63, 0x00, 0x0E, 0x70, 0x00, 0x67, 0x00, 0x0E, 0x60,
  0x00, 0x66, 0x00, 0x0E, 0xE0, 0x00, 0x66, 0x00, 0x0E, 0xC0, 0x00, 0x6E,
  0x00, 0x0E, 0xC0, 0x00, 0x6C, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x03, 0x80, 0x0C, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0x06, 0x0E, 0x00,
  0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x5F, 0xFF, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x7C,
  0x00, 0x3F, 0xBF, 0x40, 0x00, 0x7F, 0xF2, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 14, 49, 15, 2, -49 },
  { 87, 16, 18, 21, 7, -49 },
  { 123, 36, 49, 37, 2, -49 },
  { 344, 30, 56, 33, 2, -52 },
  { 554, 39, 51, 47, 5, -50 },
  { 803, 34, 51, 38, 2, -50 },
  { 1020, 6, 18, 12, 7, -49 },
  { 1034, 20, 60, 17, 2, -49 },
  { 1184, 20, 60, 17, -5, -49 },
  { 1334, 25, 26, 32, 8, -52 },
  { 1416, 29, 32, 35, 4, -40 },
  { 1532, 10, 16, 13, -3, -7 },
  { 1552, 16, 3, 20, 2, -20 },
  { 1558, 4, 5, 14, 2, -5 },
  { 1561, 30, 49, 21, -3, -49 },
  { 1745, 29, 51, 33, 3, -50 },
  { 1930, 16, 49, 33, 10, -49 },
  { 2028, 31, 50, 33, 0, -50 },
  { 2222, 32, 51, 33, 0, -50 },
  { 2426, 31, 50, 33, 0, -50 },
  { 2620, 32, 50, 33, 1, -49 },
  { 2820, 29, 51, 33, 4, -50 },
  { 3005, 28, 49, 33, 6, -49 },
  { 3177, 31, 51, 33, 2, -50 },
  { 3375, 30, 51, 33, 2, -50 },
  { 3567, 11, 37, 14, 1, -37 },
  { 3618, 16, 46, 14, -3, -37 },
  { 3710, 29, 30, 35, 4, -40 },
  { 3819, 29, 17, 35, 4, -33 },
  { 3881, 29, 30, 35, 4, -40 },
  { 3990, 22, 50, 24, 4, -50 },
  { 4128, 45, 55, 50, 3, -49 },
  { 4438, 33, 49, 33, -4, -49 },
  { 4641, 33, 49, 36, 2, -49 },
  { 4844, 34, 51, 35, 4, -50 },
  { 5061, 36, 49, 40, 2, -49 },
  { 5282, 32, 49, 32, 2, -49 },
  { 5478, 32, 49, 29, 2, -49 },
  { 5674, 37, 51, 42, 4, -50 },
  { 5910, 39, 49, 41, 2, -49 },
  { 6149, 22, 49, 17, -1, -49 },
  { 6284, 26, 61, 15, -11, -49 },
  { 6483, 37, 49, 33, 2, -49 },
  { 6710, 22, 49, 29, 2, -49 },
  { 6845, 49, 49, 51, 2, -49 },
  { 7146, 40, 49, 42, 2, -49 },
  { 7391, 37, 51, 43, 4, -50 },
  { 7627, 32, 49, 34, 2, -49 },
  { 7823, 37, 62, 43, 4, -50 },
  { 8110, 32, 49, 34, 2, -49 },
  { 8306, 32, 51, 31, 0, -50 },
  { 8510, 29, 49, 29, 6, -49 },
  { 8688, 37, 50, 41, 5, -49 },
  { 8920, 31, 49, 33, 7, -49 },
  { 9110, 50, 49, 52, 7, -49 },
  { 9417, 39, 49, 30, -4, -49 },
  { 9656, 29, 49, 29, 6, -49 },
  { 9834, 35, 49, 31, -1, -49 },
  { 10049, 26, 60, 20, -1, -49 },
  { 10244, 10, 49, 22, 7, -49 },
  { 10306, 26, 60, 20, -5, -49 },
  { 10501, 29, 28, 34, 3, -49 },
  { 10603, 24, 2, 23, -6, 7 },
  { 10609, 8, 11, 16, 10, -53 },
  { 10620, 29, 38, 34, 3, -37 },
  { 10758, 31, 53, 35, 1, -52 },
  { 10964, 25, 38, 27, 3, -37 },
  { 11083, 33, 53, 35, 3, -52 },
  { 11302, 25, 38, 30, 3, -37 },
  { 11421, 35, 70, 17, -9, -53 },
  { 11728, 32, 54, 35, 1, -37 },
  { 11944, 28, 52, 34, 2, -52 },
  { 12126, 14, 50, 14, 1, -50 },
  { 12214, 24, 67, 14, -9, -50 },
  { 12415, 29, 52, 28, 1, -52 },
  { 12604, 14, 52, 13, 1, -52 },
  { 12695, 47, 37, 51, 1, -37 },
  { 12913, 29, 37, 34, 1, -37 },
  { 13048, 28, 38, 34, 3, -37 },
  { 13181, 34, 53, 35, -2, -37 },
  { 13407, 30, 53, 35, 3, -37 },
  { 13606, 23, 37, 23, 2, -37 },
  { 13713, 25, 38, 26, 0, -37 },
  { 13832, 17, 46, 19, 3, -45 },
  { 13930, 29, 38, 34, 3, -37 },
  { 14068, 25, 37, 26, 4, -37 },
  { 14184, 40, 37, 41, 4, -37 },
  { 14369, 32, 37, 28, -3, -37 },
  { 14517, 38, 54, 26, -8, -37 },
  { 14774, 27, 37, 25, -1, -37 },
  { 14899, 24, 60, 22, 2, -49 },
  { 15079, 2, 70, 32, 16, -53 },
  { 15097, 25, 60, 22, -4, -49 },
  { 15285, 29, 7, 35, 4, -28 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic69pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC69PT7B_H_
