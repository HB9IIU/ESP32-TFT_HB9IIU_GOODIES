#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC56PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E,
  0x00, 0x38, 0x39, 0xC1, 0x8C, 0x0C, 0x60, 0x63, 0x06, 0x18, 0x31, 0x81,
  0x8C, 0x0C, 0x60, 0x43, 0x06, 0x10, 0x31, 0x81, 0x8C, 0x0C, 0x60, 0xC0,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x04, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18,
  0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30,
  0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x18, 0x06, 0x00, 0x01, 0x80, 0x30, 0x07, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xF0, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x04, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x08, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x30, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x08, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0xF1,
  0x1F, 0x01, 0xC3, 0x02, 0x03, 0x03, 0x00, 0x07, 0x03, 0x00, 0x06, 0x02,
  0x00, 0x06, 0x02, 0x00, 0x0E, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x0E, 0x06,
  0x00, 0x06, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x8C,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x11, 0xC0, 0x00, 0x10, 0xE0, 0x00, 0x30,
  0x60, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x20, 0x30, 0x00, 0x60,
  0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x60, 0x00, 0x40,
  0xE0, 0x00, 0xC1, 0xC0, 0xC0, 0xC3, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x0C, 0x07, 0x3C, 0x00, 0x18, 0x0E, 0x0C, 0x00, 0x30, 0x0C,
  0x0C, 0x00, 0x30, 0x18, 0x06, 0x00, 0x60, 0x38, 0x06, 0x00, 0xC0, 0x30,
  0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x06, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x00, 0x60, 0x0C, 0x06, 0x00, 0x60, 0x0C, 0x0C, 0x00, 0xC0,
  0x0C, 0x0C, 0x00, 0xC0, 0x0C, 0x18, 0x00, 0xC0, 0x0C, 0x38, 0x00, 0xC0,
  0x18, 0x30, 0x00, 0xC0, 0x18, 0x61, 0xFC, 0xC0, 0x18, 0xE3, 0xDE, 0xC0,
  0x30, 0xC7, 0x06, 0xC0, 0x31, 0x86, 0x06, 0xC0, 0x61, 0x8C, 0x03, 0x60,
  0xC3, 0x0C, 0x03, 0x73, 0xC6, 0x18, 0x03, 0x3F, 0x06, 0x18, 0x03, 0x04,
  0x0C, 0x30, 0x03, 0x00, 0x18, 0x30, 0x06, 0x00, 0x18, 0x30, 0x06, 0x00,
  0x30, 0x30, 0x06, 0x00, 0x60, 0x60, 0x06, 0x00, 0x60, 0x60, 0x06, 0x00,
  0xC0, 0x60, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03,
  0x00, 0x60, 0x0C, 0x07, 0x00, 0x60, 0x18, 0x06, 0x00, 0x60, 0x18, 0x0C,
  0x00, 0x60, 0x30, 0x1C, 0x00, 0x70, 0x60, 0x18, 0x00, 0x38, 0xE0, 0x30,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0x3C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x30, 0x06,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x60, 0x07, 0x00, 0x06, 0x00, 0x70, 0x00,
  0x60, 0x07, 0x00, 0x0E, 0x00, 0x60, 0x00, 0xE0, 0x06, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x38, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x03, 0x86, 0x00, 0x00, 0x70, 0x30, 0x03, 0x0C, 0x03, 0x80, 0x31, 0x80,
  0x18, 0x06, 0x38, 0x01, 0xC0, 0x63, 0x00, 0x0C, 0x0C, 0x60, 0x00, 0xE0,
  0xC6, 0x00, 0x06, 0x18, 0x60, 0x00, 0x73, 0x8E, 0x00, 0x03, 0x30, 0xC0,
  0x00, 0x1E, 0x0C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1C, 0x06, 0x00, 0x03,
  0xE0, 0x60, 0x00, 0x76, 0x07, 0x00, 0x0E, 0x70, 0x38, 0x03, 0x83, 0x01,
  0xF3, 0xF0, 0x38, 0x0F, 0xFC, 0x01, 0xC0, 0x08, 0x00, 0x00, 0x39, 0xCC,
  0x63, 0x19, 0x8C, 0x63, 0x11, 0x8C, 0x60, 0x00, 0x07, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x80, 0x20, 0x0E,
  0x06, 0x00, 0xF0, 0x60, 0x03, 0xC6, 0x00, 0x0F, 0x40, 0x70, 0x3D, 0xFF,
  0x00, 0xFE, 0x00, 0x1E, 0x00, 0x03, 0x20, 0x00, 0x63, 0x00, 0x0C, 0x30,
  0x03, 0x81, 0x80, 0x70, 0x18, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x06, 0x0C,
  0x38, 0x61, 0xC3, 0x06, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x77, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xF3,
  0xC0, 0x07, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x70, 0x01, 0x80, 0xC0, 0x03,
  0x03, 0x80, 0x07, 0x06, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18,
  0xC0, 0x00, 0x31, 0x80, 0x00, 0x67, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98,
  0x00, 0x03, 0x30, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0x33, 0x00,
  0x00, 0x66, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xB8, 0x00, 0x07, 0x60, 0x00,
  0x0E, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0xE6, 0x00, 0x01,
  0x8C, 0x00, 0x03, 0x18, 0x00, 0x0E, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30,
  0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x06, 0x07, 0x00, 0x1C, 0x06,
  0x00, 0x30, 0x0E, 0x00, 0xC0, 0x0E, 0x07, 0x00, 0x1F, 0x7C, 0x00, 0x0F,
  0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x03, 0x80, 0x7C, 0x07, 0x60,
  0xF3, 0x0E, 0x38, 0xE1, 0x9C, 0x0C, 0x40, 0x60, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x1E, 0x00, 0xE0, 0x0C,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xF3, 0xE0, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x03, 0x80,
  0x20, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x20, 0x00, 0x38, 0x0E, 0x00,
  0x1C, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xB0, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x60, 0x70, 0x00, 0x60, 0x30, 0x00,
  0x70, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x30, 0x07, 0x00,
  0x38, 0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x18, 0x00, 0x60,
  0x18, 0x00, 0x60, 0x1C, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x0C,
  0x0C, 0x00, 0x06, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x08, 0x00, 0x1C,
  0x06, 0x00, 0x3C, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xC7, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x1E, 0x00, 0x30, 0xFF, 0x80, 0x33, 0xC3, 0xC0, 0x67,
  0x00, 0xE0, 0x6C, 0x00, 0x70, 0x78, 0x00, 0x30, 0x70, 0x00, 0x38, 0xF0,
  0x00, 0x18, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xE0, 0x60,
  0x00, 0xC0, 0x60, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x38, 0x07, 0x00, 0x1F,
  0x7E, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x8F,
  0x80, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x06, 0x00,
  0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x81, 0xC0, 0x00, 0xC0, 0xE0,
  0x00, 0x60, 0x70, 0x00, 0x30, 0x18, 0x00, 0x38, 0x0C, 0x00, 0x18, 0x06,
  0x00, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x38, 0x00,
  0x0E, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x9C, 0x00,
  0x0F, 0x07, 0x00, 0x0E, 0x00, 0xC0, 0x0E, 0x00, 0x30, 0x0C, 0x00, 0x1C,
  0x0C, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x31, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x0C, 0x70, 0x00,
  0x0E, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x07, 0x00, 0x03, 0x01, 0xC0,
  0x03, 0x80, 0x70, 0x07, 0x80, 0x1F, 0x3F, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7D, 0xF8,
  0x00, 0xE0, 0x1C, 0x01, 0x80, 0x0C, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x07, 0x1C, 0x00, 0x07,
  0x18, 0x00, 0x07, 0x18, 0x00, 0x07, 0x18, 0x00, 0x07, 0x18, 0x00, 0x07,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0E,
  0x18, 0x00, 0x1E, 0x1C, 0x00, 0x36, 0x0C, 0x00, 0x7C, 0x0E, 0x00, 0xEC,
  0x07, 0xC7, 0x8C, 0x03, 0xFF, 0x1C, 0x00, 0x78, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0xF3, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x1E, 0x0F, 0x07, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x20, 0x01, 0xFF, 0x81, 0xFD, 0xF0, 0x60, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x1C, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x0C, 0x00, 0x30, 0xE0, 0x03, 0xFF, 0x01, 0x86, 0x00, 0x78, 0x78,
  0x0C, 0x70, 0x07, 0x01, 0x80, 0x63, 0x00, 0x60, 0x0C, 0x03, 0x18, 0x07,
  0x00, 0x60, 0x19, 0x80, 0x30, 0x03, 0x00, 0xCC, 0x03, 0x00, 0x30, 0x06,
  0x60, 0x38, 0x01, 0x80, 0x36, 0x01, 0x80, 0x0C, 0x01, 0xB0, 0x0C, 0x00,
  0x60, 0x19, 0x80, 0xC0, 0x06, 0x00, 0xCC, 0x06, 0x00, 0x30, 0x06, 0x60,
  0x30, 0x01, 0x80, 0x33, 0x01, 0x80, 0x1C, 0x03, 0x18, 0x0C, 0x00, 0xC0,
  0x19, 0x80, 0x60, 0x0E, 0x01, 0x8C, 0x03, 0x00, 0x70, 0x0C, 0x60, 0x18,
  0x07, 0x80, 0xC1, 0x80, 0xC0, 0x64, 0x0E, 0x0C, 0x03, 0x06, 0x30, 0xE0,
  0x60, 0x1F, 0xE1, 0xFC, 0x03, 0x00, 0x3C, 0x03, 0xC0, 0x18, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x04, 0x00, 0x00, 0x78,
  0x01, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0x60,
  0x00, 0x01, 0x98, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x18,
  0x30, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x60, 0x30, 0x00, 0x38, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x07, 0x00, 0xC0,
  0x01, 0x80, 0x30, 0x00, 0xE0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0x60, 0x06, 0x00, 0x18, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x70,
  0x00, 0x60, 0x18, 0x00, 0x18, 0x0E, 0x00, 0x06, 0x03, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x60, 0x60, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0x00, 0x3E, 0x00, 0xE0, 0x01,
  0xC0, 0x18, 0x00, 0x1C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C,
  0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x01, 0x80,
  0x00, 0xE0, 0x30, 0x00, 0x38, 0x06, 0x00, 0x0E, 0x00, 0xC0, 0x07, 0x80,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xC0, 0x07, 0x80, 0x18, 0x00,
  0x38, 0x07, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x03,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x70,
  0x00, 0x0E, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x70, 0x30, 0x00, 0x1C,
  0x06, 0x00, 0x0F, 0x01, 0x80, 0x07, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xBF,
  0x80, 0x1E, 0x00, 0x30, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x08, 0x00, 0x7F, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x30, 0x07, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x18, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x70, 0x06, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x30, 0x18, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0x83,
  0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x18, 0x70, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x01, 0x83, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0xE0, 0x18, 0x00, 0x0E, 0x00, 0xC0, 0x01, 0xE0, 0x0E, 0x00,
  0x1E, 0x00, 0x60, 0x07, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x78, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x80, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x7F, 0xF3, 0x00, 0x07, 0xFF, 0x18, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x0E, 0x18, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x60, 0x0E,
  0x00, 0x03, 0x00, 0x38, 0x00, 0x38, 0x00, 0xFE, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x0C, 0x03, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x1C, 0x03, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x07, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x1C, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0xFF,
  0xC0, 0x1F, 0xE0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x07,
  0xF8, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x10, 0x78, 0x00, 0xFF, 0x80,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x18, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x38, 0x00, 0x30, 0x03, 0x80, 0x03, 0x80, 0x38,
  0x00, 0x18, 0x03, 0x80, 0x00, 0xC0, 0x38, 0x00, 0x06, 0x03, 0x80, 0x00,
  0x30, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x18, 0x38, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x06, 0x38, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x03, 0x3E, 0x00,
  0x00, 0x19, 0xB0, 0x00, 0x00, 0xD8, 0xC0, 0x00, 0x07, 0x86, 0x00, 0x00,
  0x78, 0x38, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x07, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xC0, 0x03, 0x00, 0x07, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0xE0, 0x0E, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x03, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x0D, 0x80, 0x00,
  0x01, 0xB0, 0x1B, 0x00, 0x00, 0x03, 0xC0, 0x36, 0x00, 0x00, 0x0D, 0x80,
  0x6C, 0x00, 0x00, 0x3B, 0x00, 0xD8, 0x00, 0x00, 0x66, 0x03, 0xB0, 0x00,
  0x01, 0xDC, 0x06, 0x60, 0x00, 0x03, 0x30, 0x0C, 0x60, 0x00, 0x0E, 0x60,
  0x18, 0xC0, 0x00, 0x18, 0xC0, 0x31, 0x80, 0x00, 0x61, 0x80, 0xC3, 0x00,
  0x00, 0xC6, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x03, 0x0C, 0x00, 0x0E, 0x18,
  0x06, 0x18, 0x00, 0x18, 0x30, 0x1C, 0x30, 0x00, 0x70, 0xE0, 0x30, 0x30,
  0x00, 0xC1, 0x80, 0x60, 0x60, 0x03, 0x83, 0x00, 0xC0, 0xC0, 0x06, 0x06,
  0x01, 0x81, 0x80, 0x18, 0x0C, 0x07, 0x03, 0x00, 0x30, 0x38, 0x0C, 0x06,
  0x00, 0xC0, 0x60, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x1C, 0x03, 0x01, 0xC0, 0x30, 0x30, 0x0E, 0x03, 0x00,
  0x60, 0xE0, 0x18, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x0C, 0x01, 0x87, 0x00,
  0x60, 0x18, 0x03, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x30, 0x03, 0x00, 0xC0,
  0x0C, 0x60, 0x06, 0x01, 0x80, 0x0D, 0x80, 0x0C, 0x03, 0x00, 0x1B, 0x00,
  0x18, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x18, 0x00, 0x78, 0x00, 0xC0, 0x30,
  0x00, 0xE0, 0x01, 0x80, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x07, 0x01, 0xF0, 0x00,
  0x06, 0x01, 0xB0, 0x00, 0x06, 0x01, 0xB0, 0x00, 0x06, 0x01, 0xB8, 0x00,
  0x06, 0x01, 0x98, 0x00, 0x0C, 0x03, 0x18, 0x00, 0x0C, 0x03, 0x1C, 0x00,
  0x0C, 0x03, 0x0C, 0x00, 0x0C, 0x03, 0x0C, 0x00, 0x1C, 0x03, 0x0E, 0x00,
  0x18, 0x06, 0x06, 0x00, 0x18, 0x06, 0x06, 0x00, 0x18, 0x06, 0x06, 0x00,
  0x18, 0x06, 0x03, 0x00, 0x38, 0x0E, 0x03, 0x00, 0x30, 0x0C, 0x03, 0x00,
  0x30, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80,
  0x70, 0x1C, 0x00, 0xC0, 0x60, 0x18, 0x00, 0xC0, 0x60, 0x18, 0x00, 0xC0,
  0x60, 0x18, 0x00, 0x60, 0xE0, 0x18, 0x00, 0x60, 0xC0, 0x38, 0x00, 0x60,
  0xC0, 0x30, 0x00, 0x30, 0xC0, 0x30, 0x00, 0x30, 0xC0, 0x30, 0x00, 0x31,
  0xC0, 0x30, 0x00, 0x19, 0x80, 0x60, 0x00, 0x19, 0x80, 0x60, 0x00, 0x19,
  0x80, 0x60, 0x00, 0x0D, 0x80, 0x60, 0x00, 0x0D, 0x80, 0xE0, 0x00, 0x0F,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x0E,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x38, 0x18, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x1C, 0x03,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xFD,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0C, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x01,
  0x80, 0x03, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06,
  0x03, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x1C, 0x0C, 0x00,
  0x06, 0x03, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x06, 0x00, 0x03, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xE0,
  0x30, 0x00, 0xF0, 0x0C, 0x00, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x0E,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E,
  0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x07,
  0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x1C, 0x03, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x1C, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0C, 0x01, 0xE0, 0x07,
  0x00, 0x1C, 0x01, 0x80, 0x03, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18,
  0x06, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x30, 0x00,
  0x1C, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x60, 0x60,
  0x00, 0x38, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x07, 0x03, 0x80, 0x03, 0x80,
  0xC0, 0x01, 0xC0, 0x30, 0x01, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x01, 0xC0, 0x70, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x06, 0x00,
  0xE0, 0x01, 0x80, 0x18, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x70, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x70, 0x00, 0xE0,
  0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0xC0, 0xE0, 0x00,
  0x70, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFB, 0xFC, 0x01, 0xE0, 0x06,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x0C, 0x00, 0x3C, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x07, 0x03,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x80, 0x01, 0xFB, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x66, 0x00, 0x00, 0x39, 0x80, 0x00, 0x0C, 0x60, 0x00,
  0x07, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x30, 0x60,
  0x00, 0x1C, 0x18, 0x00, 0x06, 0x06, 0x00, 0x03, 0x81, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x70, 0x18, 0x00, 0x18, 0x03, 0x00, 0x0E, 0x00, 0xC0, 0x03,
  0x00, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x00, 0xC0,
  0x0C, 0x00, 0x30, 0x07, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0xE0, 0x00,
  0xC0, 0x30, 0x00, 0x30, 0x1C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x60, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x06, 0x18, 0x00, 0x01, 0x8E,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0xC0, 0x00, 0x38, 0x00, 0x06, 0xC0, 0x00,
  0x78, 0x00, 0x0C, 0xC0, 0x00, 0x78, 0x00, 0x0C, 0xC0, 0x00, 0x78, 0x00,
  0x1C, 0xC0, 0x00, 0xD8, 0x00, 0x18, 0xC0, 0x00, 0xD8, 0x00, 0x38, 0xC0,
  0x01, 0x98, 0x00, 0x30, 0xC0, 0x01, 0x98, 0x00, 0x30, 0xC0, 0x03, 0x18,
  0x00, 0x60, 0xC0, 0x03, 0x18, 0x00, 0x60, 0xC0, 0x07, 0x08, 0x00, 0xE0,
  0xC0, 0x06, 0x0C, 0x00, 0xC0, 0xC0, 0x06, 0x0C, 0x01, 0xC0, 0xC0, 0x0C,
  0x0C, 0x01, 0x80, 0xE0, 0x0C, 0x0C, 0x01, 0x80, 0xE0, 0x18, 0x0C, 0x03,
  0x00, 0xE0, 0x18, 0x0C, 0x03, 0x00, 0x60, 0x30, 0x0C, 0x07, 0x00, 0x60,
  0x30, 0x0C, 0x06, 0x00, 0x60, 0x70, 0x0C, 0x0E, 0x00, 0x60, 0x60, 0x0C,
  0x0C, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x00,
  0x60, 0xC0, 0x0C, 0x18, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x00, 0x61, 0x80,
  0x0C, 0x30, 0x00, 0x63, 0x00, 0x0C, 0x70, 0x00, 0x63, 0x00, 0x0C, 0x60,
  0x00, 0x67, 0x00, 0x0C, 0x60, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x00, 0x66,
  0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x0D,
  0x80, 0x00, 0x78, 0x00, 0x0D, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x60, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x38, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x18, 0x07, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0xC1, 0xC0, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x07, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x60, 0x03, 0x80,
  0x00, 0xC0, 0x06, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x70, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x60, 0x00, 0x0C, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x38, 0x60, 0x00, 0x30, 0x30, 0x00, 0x60, 0x30,
  0x00, 0xE0, 0x30, 0x00, 0xC0, 0x30, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x18,
  0x03, 0x00, 0x18, 0x07, 0x00, 0x18, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x0C,
  0x1C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0E,
  0x60, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x20,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x10, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x03, 0x03, 0x03, 0x03, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0D,
  0x80, 0x00, 0x1C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30,
  0x60, 0x00, 0x60, 0x60, 0x00, 0xE0, 0x60, 0x00, 0xC0, 0x30, 0x01, 0x80,
  0x30, 0x03, 0x80, 0x30, 0x03, 0x00, 0x18, 0x07, 0x00, 0x18, 0x06, 0x00,
  0x18, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x18, 0x00, 0x0E, 0x30, 0x00,
  0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0xE0, 0xC1, 0x81, 0x83, 0x03, 0x02, 0x06, 0x06, 0x00, 0x3F, 0x83,
  0x00, 0x7F, 0xE3, 0x01, 0xE0, 0x63, 0x03, 0x80, 0x33, 0x07, 0x00, 0x1E,
  0x06, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x0C,
  0x18, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x1C,
  0x70, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18,
  0x60, 0x00, 0x38, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x70,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0x60, 0x00, 0xE0, 0x60, 0x01, 0xE0,
  0x60, 0x03, 0x60, 0x70, 0x06, 0x60, 0x38, 0x0C, 0x40, 0x1E, 0x78, 0xC0,
  0x0F, 0xF0, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x1F, 0x80, 0x0C, 0x3F, 0xF0, 0x06, 0x38, 0x1C, 0x03, 0x30, 0x06, 0x01,
  0xB0, 0x03, 0x81, 0xB0, 0x00, 0xC0, 0xF0, 0x00, 0x60, 0x78, 0x00, 0x38,
  0x38, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03,
  0x86, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x61, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x38, 0x00,
  0x06, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x07, 0x00, 0x03, 0x83, 0x80,
  0x01, 0x83, 0x40, 0x01, 0xC1, 0xA0, 0x01, 0xC0, 0xD8, 0x01, 0xC0, 0x66,
  0x01, 0xC0, 0x63, 0xE7, 0xC0, 0x30, 0x7F, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x03, 0xC0, 0x20, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x20, 0x1F, 0x3E,
  0x00, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x3F, 0x83, 0x00, 0x1F, 0xF8, 0xE0, 0x0F, 0x03, 0x98,
  0x03, 0x80, 0x1B, 0x00, 0xE0, 0x03, 0x60, 0x18, 0x00, 0x2C, 0x07, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x70, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x30, 0x30, 0x00, 0x06, 0x06, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x30, 0x18,
  0x00, 0x06, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x0F,
  0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x78, 0x06, 0x00, 0x0F, 0x00, 0xC0,
  0x03, 0x60, 0x18, 0x00, 0xC8, 0x03, 0x80, 0x3B, 0x00, 0x38, 0x0E, 0x60,
  0x03, 0xCF, 0x0C, 0x00, 0x3F, 0xC1, 0x80, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x0F, 0xFC, 0x01, 0xC0, 0xE0, 0x38, 0x07, 0x06, 0x00, 0x30,
  0xC0, 0x03, 0x1C, 0x00, 0x31, 0x80, 0x03, 0x30, 0x00, 0x73, 0x00, 0x06,
  0x60, 0x00, 0xE6, 0x00, 0x1C, 0x60, 0x07, 0x8E, 0x03, 0xE0, 0xFF, 0xF8,
  0x0F, 0xF8, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x30, 0x1E, 0x1F, 0x00,
  0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1C, 0x10, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xDE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x60, 0x03, 0xFF, 0x0C, 0x01, 0xE0, 0x73, 0x00, 0x70, 0x03, 0x60, 0x1C,
  0x00, 0x6C, 0x03, 0x00, 0x05, 0x80, 0xE0, 0x00, 0xE0, 0x18, 0x00, 0x1C,
  0x06, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x06, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x38, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x38, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x0E,
  0x00, 0x0F, 0x00, 0xC0, 0x01, 0xE0, 0x18, 0x00, 0x6C, 0x03, 0x00, 0x1B,
  0x00, 0x70, 0x07, 0x60, 0x07, 0x01, 0xCC, 0x00, 0x79, 0xE1, 0x80, 0x07,
  0xF8, 0x70, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x83, 0xF8, 0x03, 0x0F, 0xFC, 0x03, 0x3C, 0x0E, 0x03,
  0x70, 0x06, 0x03, 0x60, 0x06, 0x06, 0xC0, 0x07, 0x07, 0x80, 0x07, 0x07,
  0x00, 0x07, 0x07, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0C,
  0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x18,
  0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x38,
  0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x38, 0x30,
  0x00, 0x30, 0x70, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60,
  0x00, 0x70, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x38, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0xC0, 0xC0, 0x03, 0x01,
  0x80, 0x0C, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30,
  0x0E, 0x00, 0x60, 0x38, 0x00, 0xC0, 0xE0, 0x01, 0x83, 0x80, 0x06, 0x0E,
  0x00, 0x0C, 0x38, 0x00, 0x18, 0xE0, 0x00, 0x33, 0xC0, 0x00, 0xEF, 0x80,
  0x01, 0x9B, 0x80, 0x03, 0x63, 0x00, 0x07, 0x86, 0x00, 0x0E, 0x06, 0x00,
  0x38, 0x0C, 0x00, 0x60, 0x1C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x70, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x30, 0x01, 0xC0, 0x60,
  0x01, 0x81, 0xC0, 0x03, 0x03, 0x00, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x00, 0x03, 0x07, 0xF0, 0x0F,
  0xE0, 0x0C, 0x7F, 0xE0, 0xFF, 0xC0, 0x33, 0x81, 0x87, 0x03, 0x80, 0xD8,
  0x07, 0x38, 0x06, 0x02, 0xC0, 0x0D, 0xC0, 0x1C, 0x1A, 0x00, 0x36, 0x00,
  0x30, 0x78, 0x00, 0xF0, 0x00, 0xC1, 0xC0, 0x03, 0x80, 0x03, 0x07, 0x00,
  0x0E, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x00, 0x60, 0xE0, 0x00, 0xC0, 0x01,
  0x83, 0x00, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x30, 0x00,
  0x60, 0x00, 0x61, 0xC0, 0x01, 0x80, 0x03, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x18, 0x00, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC0, 0x00, 0xC1, 0x80, 0x03,
  0x00, 0x07, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x30, 0x00, 0x60,
  0xC0, 0x01, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x18,
  0x00, 0x38, 0x70, 0x00, 0x60, 0x00, 0xC1, 0x80, 0x01, 0x80, 0x03, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x00, 0x30, 0xE0, 0x00, 0xC0,
  0x01, 0x83, 0x00, 0x03, 0x00, 0x06, 0x00, 0x03, 0x03, 0xF8, 0x03, 0x0F,
  0xFC, 0x03, 0x3C, 0x0E, 0x03, 0x70, 0x06, 0x03, 0x60, 0x07, 0x06, 0xC0,
  0x07, 0x07, 0x80, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x06, 0x06, 0x00,
  0x06, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00,
  0x0C, 0x1C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00,
  0x1C, 0x18, 0x00, 0x18, 0x38, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00,
  0x18, 0x30, 0x00, 0x38, 0x30, 0x00, 0x30, 0x70, 0x00, 0x30, 0x60, 0x00,
  0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x70, 0xE0, 0x00, 0x60, 0xC0, 0x00,
  0x60, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0x81, 0xE0, 0x1C, 0x00,
  0xE0, 0x70, 0x00, 0xC0, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x8E, 0x00, 0x03,
  0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0xE0, 0x00, 0x19, 0x80, 0x00, 0x33,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x07, 0x60,
  0x00, 0x0C, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x37, 0x00, 0x00, 0xEE, 0x00,
  0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x38, 0x60, 0x00,
  0x60, 0xE0, 0x01, 0xC0, 0xC0, 0x07, 0x01, 0xE0, 0x1C, 0x01, 0xF3, 0xF0,
  0x00, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x7E, 0x00, 0x06,
  0x1F, 0xF8, 0x00, 0x63, 0x81, 0xC0, 0x06, 0x60, 0x0C, 0x00, 0x6C, 0x00,
  0xE0, 0x0D, 0x80, 0x06, 0x00, 0xF0, 0x00, 0x60, 0x0F, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60,
  0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0xC0, 0x70, 0x00, 0x0C, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x18,
  0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x30, 0x0F, 0x00, 0x07, 0x00, 0xD0,
  0x00, 0xE0, 0x0D, 0x80, 0x1C, 0x00, 0xCC, 0x03, 0x80, 0x0C, 0xF9, 0xF0,
  0x01, 0x83, 0xFC, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC1, 0x80, 0x3F, 0xF0, 0xC0, 0x78, 0x1C, 0xC0,
  0x70, 0x03, 0x60, 0x70, 0x01, 0xB0, 0x30, 0x00, 0x58, 0x38, 0x00, 0x38,
  0x18, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x0E, 0x00, 0x03,
  0x86, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x61, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x38, 0x00,
  0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x87, 0x00, 0x03, 0x83, 0x80,
  0x03, 0xC0, 0xC0, 0x01, 0xE0, 0x60, 0x01, 0xB0, 0x30, 0x01, 0xB0, 0x1C,
  0x01, 0xD8, 0x07, 0x01, 0xCC, 0x01, 0xE7, 0x86, 0x00, 0x7F, 0x87, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x07, 0xE0, 0x61, 0xFC, 0x0C, 0xE0,
  0x01, 0xB8, 0x00, 0x26, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0x80,
  0x70, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x0C, 0x00, 0xE0, 0xFC, 0x7C, 0x03, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x07,
  0xFF, 0x7F, 0xFC, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x1C, 0x60, 0x3F, 0x80, 0x10, 0x00, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03,
  0x06, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06,
  0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x18, 0x00, 0x0C,
  0x18, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x38, 0x00, 0x18,
  0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x38, 0x70, 0x00, 0x30,
  0x60, 0x00, 0x30, 0x60, 0x00, 0x70, 0x60, 0x00, 0x70, 0x60, 0x00, 0x60,
  0x60, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0x60, 0x03, 0x60,
  0x60, 0x06, 0x40, 0x70, 0x1C, 0xC0, 0x3E, 0xF8, 0xC0, 0x1F, 0xE0, 0xC0,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xB0, 0x00, 0x19, 0x80,
  0x00, 0xCC, 0x00, 0x0C, 0x70, 0x00, 0x63, 0x80, 0x06, 0x0C, 0x00, 0x30,
  0x60, 0x03, 0x03, 0x00, 0x38, 0x18, 0x01, 0x80, 0xC0, 0x1C, 0x06, 0x00,
  0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x0C, 0x07, 0x00, 0x70, 0x30, 0x01,
  0x83, 0x80, 0x0C, 0x18, 0x00, 0x61, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0xC0,
  0x00, 0xC6, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0xB0, 0x00, 0x0D,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x03,
  0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x0E,
  0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0x60, 0x0C, 0xC0, 0x18, 0x60, 0x18,
  0xC0, 0x30, 0x60, 0x18, 0xC0, 0x30, 0x60, 0x30, 0xC0, 0x70, 0x60, 0x30,
  0xC0, 0x60, 0x60, 0x60, 0xC0, 0xE0, 0x60, 0x60, 0xC0, 0xC0, 0x60, 0xC0,
  0xC0, 0xC0, 0x60, 0xC0, 0xC1, 0x80, 0x61, 0x80, 0xC1, 0x80, 0x61, 0x80,
  0xC3, 0x00, 0x63, 0x00, 0x43, 0x00, 0x63, 0x00, 0x67, 0x00, 0x66, 0x00,
  0x66, 0x00, 0x66, 0x00, 0x66, 0x00, 0x6E, 0x00, 0x6C, 0x00, 0x6C, 0x00,
  0x6C, 0x00, 0x6C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x60, 0x00, 0xE0, 0x1C, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x18, 0x07, 0x00, 0x06, 0x03, 0x80, 0x01, 0x80, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0x30, 0x00,
  0x03, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x60, 0x60, 0x00, 0x30, 0x18,
  0x00, 0x18, 0x07, 0x00, 0x0E, 0x00, 0xC0, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x0E, 0x00, 0xC0, 0x01, 0x80, 0x70, 0x00, 0x60, 0x38, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0,
  0x06, 0x00, 0x03, 0x80, 0x38, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x07,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x18, 0x1C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x02, 0x3C, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x0B, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x0F,
  0xC0, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0x7D, 0xF8, 0x03, 0xE0,
  0x3E, 0x0E, 0x80, 0x07, 0xFC, 0x80, 0x01, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 12, 40, 12, 1, -40 },
  { 61, 13, 14, 17, 6, -40 },
  { 84, 29, 40, 30, 1, -40 },
  { 229, 24, 46, 27, 2, -43 },
  { 367, 32, 42, 38, 4, -41 },
  { 535, 28, 42, 31, 1, -41 },
  { 682, 5, 14, 10, 6, -40 },
  { 691, 16, 49, 14, 2, -40 },
  { 789, 16, 49, 14, -4, -40 },
  { 887, 20, 21, 26, 7, -42 },
  { 940, 24, 26, 29, 3, -33 },
  { 1018, 7, 13, 10, -2, -6 },
  { 1030, 13, 2, 16, 2, -16 },
  { 1034, 4, 4, 11, 1, -4 },
  { 1036, 24, 40, 17, -2, -40 },
  { 1156, 23, 42, 27, 3, -41 },
  { 1277, 13, 40, 27, 8, -40 },
  { 1342, 25, 41, 27, 0, -41 },
  { 1471, 26, 42, 27, 0, -41 },
  { 1608, 25, 40, 27, 0, -40 },
  { 1733, 25, 41, 27, 1, -40 },
  { 1862, 24, 42, 27, 3, -41 },
  { 1988, 23, 40, 27, 5, -40 },
  { 2103, 25, 42, 27, 1, -41 },
  { 2235, 24, 42, 27, 2, -41 },
  { 2361, 9, 30, 11, 1, -30 },
  { 2395, 13, 37, 11, -3, -30 },
  { 2456, 24, 24, 29, 3, -32 },
  { 2528, 24, 13, 29, 3, -26 },
  { 2567, 24, 24, 29, 3, -32 },
  { 2639, 18, 41, 20, 3, -41 },
  { 2732, 37, 45, 40, 2, -40 },
  { 2941, 26, 40, 27, -3, -40 },
  { 3071, 27, 40, 29, 2, -40 },
  { 3206, 27, 42, 28, 4, -41 },
  { 3348, 29, 40, 33, 2, -40 },
  { 3493, 26, 40, 26, 2, -40 },
  { 3623, 26, 40, 24, 2, -40 },
  { 3753, 29, 42, 34, 4, -41 },
  { 3906, 32, 40, 33, 2, -40 },
  { 4066, 18, 40, 14, -1, -40 },
  { 4156, 21, 50, 12, -9, -40 },
  { 4288, 29, 40, 27, 2, -40 },
  { 4433, 17, 40, 24, 2, -40 },
  { 4518, 39, 40, 41, 2, -40 },
  { 4713, 32, 40, 34, 2, -40 },
  { 4873, 29, 42, 35, 4, -41 },
  { 5026, 26, 40, 27, 2, -40 },
  { 5156, 29, 51, 35, 4, -41 },
  { 5341, 26, 40, 28, 2, -40 },
  { 5471, 26, 42, 25, 0, -41 },
  { 5608, 23, 40, 24, 5, -40 },
  { 5723, 30, 41, 33, 4, -40 },
  { 5877, 26, 40, 26, 5, -40 },
  { 6007, 40, 40, 42, 6, -40 },
  { 6207, 31, 40, 24, -3, -40 },
  { 6362, 24, 40, 24, 5, -40 },
  { 6482, 29, 40, 25, -1, -40 },
  { 6627, 21, 49, 16, -1, -40 },
  { 6756, 8, 40, 18, 6, -40 },
  { 6796, 21, 49, 16, -4, -40 },
  { 6925, 24, 23, 28, 2, -40 },
  { 6994, 19, 1, 19, -5, 6 },
  { 6997, 7, 9, 13, 8, -43 },
  { 7005, 24, 31, 28, 2, -30 },
  { 7098, 25, 44, 28, 1, -43 },
  { 7236, 20, 31, 22, 3, -30 },
  { 7314, 27, 44, 28, 2, -43 },
  { 7463, 20, 31, 24, 3, -30 },
  { 7541, 28, 56, 14, -7, -43 },
  { 7737, 27, 43, 28, 0, -30 },
  { 7883, 24, 43, 27, 1, -43 },
  { 8012, 11, 40, 11, 1, -40 },
  { 8067, 20, 53, 11, -8, -40 },
  { 8200, 23, 43, 22, 1, -43 },
  { 8324, 11, 43, 11, 1, -43 },
  { 8384, 38, 30, 42, 1, -30 },
  { 8527, 24, 30, 27, 1, -30 },
  { 8617, 23, 31, 28, 2, -30 },
  { 8707, 28, 43, 28, -2, -30 },
  { 8858, 25, 43, 28, 2, -30 },
  { 8993, 19, 30, 18, 1, -30 },
  { 9065, 20, 31, 21, 0, -30 },
  { 9143, 14, 38, 15, 2, -37 },
  { 9210, 24, 31, 27, 2, -30 },
  { 9303, 21, 30, 21, 3, -30 },
  { 9382, 32, 30, 33, 3, -30 },
  { 9502, 26, 30, 22, -2, -30 },
  { 9600, 30, 44, 21, -6, -30 },
  { 9765, 22, 30, 21, -1, -30 },
  { 9848, 20, 49, 18, 1, -40 },
  { 9971, 2, 57, 26, 13, -43 },
  { 9986, 20, 49, 18, -3, -40 },
  { 10109, 24, 5, 29, 3, -22 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic56pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC56PT7B_H_
