#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC55PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x07, 0x01, 0xE0, 0x38, 0x00, 0x38, 0x33, 0x03, 0x30, 0x73,
  0x06, 0x30, 0x66, 0x06, 0x60, 0x66, 0x0C, 0x60, 0xC4, 0x0C, 0xC0, 0xCC,
  0x08, 0xC1, 0x88, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0xC0, 0x10, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x07, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x06, 0x01, 0x80, 0x00, 0x30, 0x0C,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x04, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18,
  0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0xF1, 0x87, 0x01, 0xC1, 0x81, 0x03, 0x81, 0x00, 0x03, 0x01, 0x00, 0x03,
  0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x02, 0x00, 0x07,
  0x02, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x01, 0x86, 0x00, 0x01,
  0xE4, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x09, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x18, 0x70, 0x00,
  0x18, 0x30, 0x00, 0x10, 0x18, 0x00, 0x10, 0x18, 0x00, 0x30, 0x18, 0x00,
  0x30, 0x18, 0x00, 0x30, 0x30, 0x00, 0x20, 0x30, 0x00, 0x60, 0x70, 0x00,
  0x60, 0xE0, 0x40, 0x61, 0xC0, 0xFE, 0x7F, 0x80, 0x3F, 0xFE, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x30, 0x18, 0x70, 0x00, 0xC0, 0x60, 0x60, 0x03, 0x81, 0x80, 0xC0, 0x06,
  0x03, 0x01, 0x80, 0x18, 0x0C, 0x03, 0x00, 0x30, 0x18, 0x06, 0x00, 0xC0,
  0x60, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x30, 0x18, 0x03,
  0x00, 0x60, 0x60, 0x0C, 0x00, 0xC0, 0xC0, 0x18, 0x01, 0x83, 0x00, 0x30,
  0x06, 0x0C, 0x00, 0x60, 0x0C, 0x18, 0x00, 0xC0, 0x18, 0x60, 0xF1, 0x80,
  0x61, 0x87, 0xFB, 0x00, 0xC3, 0x1C, 0x36, 0x01, 0x8C, 0x70, 0x3C, 0x06,
  0x30, 0xC0, 0x78, 0x18, 0x63, 0x00, 0xD8, 0x71, 0x86, 0x01, 0xBF, 0xC7,
  0x18, 0x03, 0x1E, 0x0C, 0x30, 0x06, 0x00, 0x30, 0x60, 0x0C, 0x00, 0xE1,
  0x80, 0x18, 0x01, 0x83, 0x00, 0x30, 0x06, 0x06, 0x00, 0xC0, 0x0C, 0x0C,
  0x01, 0x80, 0x30, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x00, 0xC0, 0x30, 0x18, 0x01, 0x80, 0x60, 0x30, 0x03, 0x01,
  0x80, 0xC0, 0x06, 0x07, 0x03, 0x00, 0x0C, 0x0C, 0x06, 0x00, 0x0C, 0x70,
  0x18, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70,
  0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x06, 0x03, 0x80, 0x00, 0x60, 0x70,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x33, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x07, 0x06, 0x00, 0x30, 0xE0, 0x30, 0x06, 0x1C, 0x03, 0x80, 0x63,
  0x80, 0x18, 0x0E, 0x30, 0x01, 0xC0, 0xC6, 0x00, 0x0C, 0x1C, 0x60, 0x00,
  0xE1, 0x86, 0x00, 0x06, 0x30, 0xE0, 0x00, 0x37, 0x0C, 0x00, 0x03, 0x60,
  0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x3C, 0x06, 0x00,
  0x06, 0xE0, 0x70, 0x01, 0xC6, 0x03, 0x80, 0x38, 0x70, 0x1F, 0x3F, 0x03,
  0x00, 0xFF, 0xC0, 0x18, 0x00, 0x80, 0x00, 0x00, 0x39, 0x8C, 0x63, 0x31,
  0x8C, 0x62, 0x31, 0x8C, 0x40, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x01, 0x00,
  0xC0, 0x38, 0x18, 0x03, 0xC2, 0x00, 0x1C, 0x40, 0x00, 0xE8, 0x7C, 0x07,
  0xFF, 0x80, 0xE0, 0x00, 0x36, 0x00, 0x0C, 0x40, 0x03, 0x0C, 0x00, 0xC1,
  0x80, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x06, 0x0C, 0x38, 0x61, 0xC3, 0x06, 0x18, 0x30, 0xC1, 0x86, 0x0C,
  0x00, 0xFF, 0xFF, 0xFF, 0x67, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x7F, 0xC0, 0x01, 0xC1, 0xC0, 0x07, 0x01, 0xC0, 0x18,
  0x01, 0x80, 0x60, 0x01, 0x81, 0xC0, 0x03, 0x03, 0x00, 0x06, 0x0E, 0x00,
  0x0C, 0x18, 0x00, 0x18, 0x70, 0x00, 0x38, 0xC0, 0x00, 0x71, 0x80, 0x00,
  0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x70, 0x00, 0x0C,
  0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x6E, 0x00, 0x01, 0xD8,
  0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x39, 0x80,
  0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x8C, 0x00, 0x06, 0x18, 0x00,
  0x0C, 0x30, 0x00, 0x38, 0x60, 0x00, 0x60, 0xC0, 0x01, 0xC1, 0x80, 0x03,
  0x03, 0x00, 0x0E, 0x03, 0x00, 0x38, 0x06, 0x00, 0xE0, 0x06, 0x03, 0x80,
  0x0F, 0xBE, 0x00, 0x07, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x0F,
  0x03, 0xF0, 0x73, 0x0E, 0x63, 0x86, 0x70, 0x6E, 0x06, 0x80, 0xE0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x0C, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x07, 0x80, 0x3C,
  0x00, 0xE0, 0x18, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x08, 0x00, 0x0E, 0x07, 0x00, 0x1E, 0x03,
  0xF0, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x60, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x70, 0x30, 0x00, 0x30, 0x18,
  0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x38, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x1C, 0x00,
  0x60, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x1C, 0x0C, 0x00,
  0x0C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x10, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xE1, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x10, 0x00, 0x38, 0x0C, 0x00, 0x78, 0x07, 0xE3,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFD, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0x02, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x7F, 0x00, 0x31,
  0xFF, 0xC0, 0x67, 0x01, 0xE0, 0x6C, 0x00, 0x60, 0x78, 0x00, 0x70, 0x70,
  0x00, 0x30, 0xF0, 0x00, 0x30, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x38, 0xC0,
  0x00, 0x38, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0xE0, 0xE0, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x70, 0x03, 0x80, 0x38,
  0x07, 0x00, 0x1E, 0x7E, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x0E,
  0x07, 0x80, 0x0C, 0x00, 0xE0, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x1C, 0x06,
  0x00, 0x06, 0x03, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0,
  0xC0, 0x00, 0xE0, 0x60, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x30,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x38, 0x00, 0x60, 0x70, 0x00, 0x18, 0x70,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x0E,
  0x00, 0x1C, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0x30, 0x1C, 0x00,
  0x1C, 0x1C, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x18, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x03, 0x00, 0x0E, 0x01,
  0xE0, 0x0E, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xC0, 0x03, 0xC1, 0xE0, 0x0E, 0x00,
  0xC0, 0x38, 0x01, 0xC0, 0x60, 0x01, 0x81, 0x80, 0x03, 0x87, 0x00, 0x03,
  0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x31,
  0x80, 0x00, 0x63, 0x00, 0x00, 0xCE, 0x00, 0x01, 0x9C, 0x00, 0x03, 0x38,
  0x00, 0x0E, 0x30, 0x00, 0x1C, 0x60, 0x00, 0x70, 0xC0, 0x01, 0xE1, 0xC0,
  0x07, 0xC1, 0xC0, 0x1D, 0x81, 0xC0, 0xE7, 0x01, 0xFF, 0x8C, 0x00, 0xFC,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x3C, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x03,
  0x81, 0xC1, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x3C, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0x81, 0xE0, 0xF0, 0x40, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x03, 0x80, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x7F, 0x80, 0x60, 0xC0, 0x0F, 0xFE, 0x03, 0x0E, 0x00, 0xE0,
  0x30, 0x18, 0x60, 0x0E, 0x01, 0x80, 0x63, 0x00, 0xE0, 0x18, 0x06, 0x30,
  0x06, 0x00, 0xC0, 0x31, 0x80, 0x60, 0x06, 0x01, 0x8C, 0x07, 0x00, 0x30,
  0x0C, 0xC0, 0x30, 0x03, 0x00, 0x66, 0x01, 0x80, 0x18, 0x03, 0x30, 0x18,
  0x00, 0xC0, 0x19, 0x80, 0xC0, 0x06, 0x01, 0x8C, 0x06, 0x00, 0x60, 0x0C,
  0x60, 0x30, 0x03, 0x00, 0x66, 0x01, 0x80, 0x38, 0x06, 0x30, 0x0C, 0x01,
  0xC0, 0x31, 0x80, 0x60, 0x1E, 0x03, 0x0C, 0x03, 0x00, 0xB0, 0x38, 0x60,
  0x18, 0x0D, 0x81, 0x81, 0x80, 0xE0, 0xCC, 0x38, 0x0C, 0x03, 0xFC, 0x3F,
  0x80, 0x60, 0x0F, 0x80, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x01, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x60, 0x00, 0x03, 0x18, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x08,
  0x00, 0x07, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x30,
  0x0C, 0x00, 0x1C, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x03, 0x80, 0x30, 0x00,
  0xC0, 0x0C, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x01, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x60, 0x38, 0x00,
  0x18, 0x0C, 0x00, 0x06, 0x07, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0xE0,
  0x00, 0x18, 0x30, 0x00, 0x06, 0x1C, 0x00, 0x01, 0x86, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1C,
  0x00, 0x70, 0x06, 0x00, 0x0E, 0x01, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x30,
  0x18, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x01, 0x81, 0x80,
  0x00, 0xE0, 0x60, 0x00, 0x70, 0x18, 0x00, 0x38, 0x0E, 0x00, 0x3C, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x30, 0x0F, 0xC0, 0x0C, 0x00, 0x38,
  0x07, 0x00, 0x07, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x18, 0x00,
  0x06, 0x06, 0x00, 0x01, 0x83, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30,
  0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x30,
  0x60, 0x00, 0x1C, 0x18, 0x00, 0x06, 0x06, 0x00, 0x07, 0x83, 0x80, 0x03,
  0xC0, 0xC0, 0x03, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x3C, 0x00,
  0x20, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x40, 0x03, 0xF1, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xC0, 0x0F, 0x00, 0x18, 0x00, 0x38, 0x01, 0x80, 0x01, 0xC0,
  0x18, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x60, 0x38, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x0C, 0x38, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x18, 0x30, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x1C, 0x06, 0x00, 0x03, 0x80, 0x60, 0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x00,
  0xC0, 0x0F, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xC0, 0x7E, 0x00, 0xF0, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFC, 0x60, 0x00, 0xFF, 0xE3, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x01, 0x80, 0x70, 0x00,
  0x0C, 0x03, 0xC0, 0x00, 0x60, 0x0F, 0x00, 0x0E, 0x00, 0x1F, 0x9F, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x60, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x60, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x60, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x0F, 0xD0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x03, 0x0F, 0x00, 0x1F,
  0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x78, 0x06, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x70, 0x03, 0x00, 0x07, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xC0, 0x07, 0x00, 0x06, 0x00, 0x70, 0x00, 0x70, 0x07, 0x00, 0x03, 0x00,
  0x70, 0x00, 0x18, 0x07, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x63, 0xC0, 0x00, 0x03, 0x36,
  0x00, 0x00, 0x1B, 0x30, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x0F, 0x06, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00,
  0xC0, 0x38, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x18, 0x00, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x07, 0x00, 0x18, 0x00, 0x18, 0x01,
  0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x0D, 0x00, 0x00, 0x03, 0x60, 0x1B, 0x00,
  0x00, 0x06, 0xC0, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x6C, 0x00, 0x00, 0x36,
  0x01, 0x98, 0x00, 0x00, 0xCC, 0x03, 0x30, 0x00, 0x03, 0x98, 0x06, 0x60,
  0x00, 0x06, 0x70, 0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x18, 0x80, 0x00, 0x31,
  0x80, 0x61, 0x80, 0x00, 0xE3, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x01, 0x86,
  0x00, 0x06, 0x18, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x0E, 0x18, 0x00, 0x30,
  0x60, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x30, 0x60, 0x01, 0x81, 0x80, 0x60,
  0x40, 0x07, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x03, 0x01, 0x80, 0x38,
  0x18, 0x06, 0x03, 0x00, 0x60, 0x30, 0x0C, 0x06, 0x01, 0xC0, 0xE0, 0x18,
  0x0C, 0x03, 0x01, 0x80, 0x30, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18,
  0x06, 0x01, 0x80, 0x20, 0x60, 0x0C, 0x03, 0x00, 0x60, 0xC0, 0x38, 0x06,
  0x00, 0xC3, 0x00, 0x60, 0x1C, 0x01, 0x8E, 0x00, 0xC0, 0x30, 0x03, 0x18,
  0x01, 0x80, 0x60, 0x06, 0x70, 0x03, 0x00, 0xC0, 0x0C, 0xC0, 0x0C, 0x01,
  0x80, 0x1B, 0x00, 0x18, 0x07, 0x00, 0x16, 0x00, 0x30, 0x0C, 0x00, 0x38,
  0x00, 0x60, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x0C, 0x07, 0x80, 0x00,
  0x18, 0x0F, 0x00, 0x00, 0x30, 0x1B, 0x00, 0x00, 0xC0, 0x36, 0x00, 0x01,
  0x80, 0x6C, 0x00, 0x03, 0x01, 0x8C, 0x00, 0x06, 0x03, 0x18, 0x00, 0x1C,
  0x06, 0x30, 0x00, 0x30, 0x0C, 0x30, 0x00, 0x60, 0x18, 0x60, 0x00, 0xC0,
  0x60, 0xC0, 0x01, 0x80, 0xC0, 0xC0, 0x07, 0x01, 0x81, 0x80, 0x0C, 0x03,
  0x03, 0x00, 0x18, 0x0E, 0x03, 0x00, 0x30, 0x18, 0x06, 0x00, 0x60, 0x30,
  0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x03, 0x80,
  0x30, 0x0C, 0x06, 0x00, 0x30, 0x38, 0x0C, 0x00, 0x60, 0x60, 0x18, 0x00,
  0xC0, 0xC0, 0x30, 0x00, 0xC1, 0x80, 0xC0, 0x01, 0x83, 0x01, 0x80, 0x03,
  0x0E, 0x03, 0x00, 0x03, 0x18, 0x06, 0x00, 0x06, 0x30, 0x1C, 0x00, 0x0C,
  0x60, 0x30, 0x00, 0x0C, 0xC0, 0x60, 0x00, 0x1B, 0x80, 0xC0, 0x00, 0x36,
  0x01, 0x80, 0x00, 0x7C, 0x07, 0x00, 0x00, 0x78, 0x0C, 0x00, 0x00, 0xF0,
  0x18, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x00, 0x38, 0x01,
  0xC0, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x03, 0x38, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x70, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x07, 0x06, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0C, 0x07,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x0F, 0xEF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x70, 0x07, 0x80, 0x30, 0x00, 0xE0, 0x18, 0x00,
  0x30, 0x0C, 0x00, 0x1C, 0x06, 0x00, 0x06, 0x07, 0x00, 0x03, 0x03, 0x00,
  0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x60,
  0x00, 0x18, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x0E,
  0x00, 0x06, 0x06, 0x00, 0x07, 0x03, 0x00, 0x07, 0x01, 0x80, 0x0F, 0x00,
  0xC0, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x00,
  0x38, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x03, 0x38, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03,
  0x70, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x07, 0x06, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x0C, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x70, 0x07,
  0x80, 0x30, 0x00, 0xE0, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x1C, 0x06, 0x00,
  0x06, 0x07, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0x30, 0x60, 0x00, 0x38, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x06, 0x00, 0x0E, 0x03,
  0x00, 0x0E, 0x01, 0x80, 0x3E, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0x60, 0x1C, 0x00, 0x30, 0x06, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x01, 0x80,
  0x0E, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0E,
  0x01, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xE0, 0x30, 0x00,
  0x30, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x0C, 0x0C, 0x00, 0x07, 0x06, 0x00,
  0x01, 0x83, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x1F, 0x83, 0xE0, 0x1E, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x06, 0x00, 0x1E, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x07, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x07, 0x03, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x0F, 0xDF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18,
  0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06,
  0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x00,
  0x60, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x30, 0x00, 0x30,
  0x18, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0x86, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x1B, 0x00, 0x01, 0xE0, 0x00,
  0x36, 0x00, 0x03, 0xC0, 0x00, 0xEC, 0x00, 0x0D, 0x80, 0x01, 0x98, 0x00,
  0x1B, 0x00, 0x07, 0x30, 0x00, 0x36, 0x00, 0x0C, 0x60, 0x00, 0xCC, 0x00,
  0x18, 0xC0, 0x01, 0x98, 0x00, 0x61, 0x80, 0x06, 0x30, 0x00, 0xC3, 0x00,
  0x0C, 0x60, 0x03, 0x06, 0x00, 0x30, 0xC0, 0x06, 0x0C, 0x00, 0x61, 0x80,
  0x1C, 0x18, 0x01, 0xC3, 0x00, 0x30, 0x30, 0x03, 0x06, 0x00, 0x60, 0x60,
  0x06, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x18, 0x03, 0x01, 0x80, 0x30, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x70, 0x0C,
  0x06, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x30, 0x38, 0x06,
  0x06, 0x00, 0x30, 0x60, 0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x00,
  0xC3, 0x00, 0x30, 0x60, 0x01, 0x86, 0x00, 0x61, 0xC0, 0x03, 0x18, 0x00,
  0xC3, 0x00, 0x06, 0x30, 0x00, 0x86, 0x00, 0x0C, 0xC0, 0x01, 0x18, 0x00,
  0x19, 0x80, 0x02, 0x30, 0x00, 0x36, 0x00, 0x04, 0xC0, 0x00, 0x6C, 0x00,
  0x09, 0x80, 0x00, 0xD8, 0x00, 0x16, 0x00, 0x01, 0xE0, 0x00, 0x2C, 0x00,
  0x03, 0xC0, 0x00, 0x58, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0x38, 0x00, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x06, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x18, 0x0E, 0x00,
  0x00, 0x38, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x0C,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x30,
  0x01, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x19, 0x80,
  0x00, 0x63, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x1C, 0x00,
  0x38, 0x18, 0x00, 0x60, 0x30, 0x01, 0x80, 0x60, 0x07, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x38, 0x01, 0x80, 0x60, 0x03, 0x01, 0x80, 0x06, 0x07, 0x00,
  0x0E, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x18, 0xE0, 0x00, 0x31, 0x80, 0x00,
  0x66, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x40, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x0C, 0x0C,
  0x0C, 0x0C, 0x0C, 0x04, 0x06, 0x06, 0x06, 0x06, 0x06, 0x02, 0x03, 0x03,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x19, 0x80, 0x00, 0x38, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0xC0, 0x60,
  0x01, 0x80, 0x30, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x18,
  0x06, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x0C,
  0x38, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x07,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0xC1, 0x86, 0x0C, 0x30, 0x60, 0x83, 0x04,
  0x00, 0x06, 0x00, 0x00, 0x7F, 0xC3, 0x00, 0xF1, 0xE2, 0x01, 0xC0, 0x66,
  0x03, 0x80, 0x36, 0x06, 0x00, 0x16, 0x0E, 0x00, 0x1E, 0x0C, 0x00, 0x1C,
  0x18, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x1C,
  0x30, 0x00, 0x18, 0x70, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18,
  0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0xE0, 0x00, 0x30, 0xC0, 0x00, 0x70,
  0xC0, 0x00, 0x70, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xE0,
  0x60, 0x01, 0x60, 0x60, 0x03, 0x60, 0x70, 0x06, 0x40, 0x38, 0x0C, 0xC0,
  0x1C, 0x78, 0xC0, 0x0F, 0xE0, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0xC0,
  0x03, 0x0F, 0xF8, 0x03, 0x1C, 0x3C, 0x03, 0x30, 0x0E, 0x03, 0x60, 0x06,
  0x06, 0xC0, 0x07, 0x07, 0x80, 0x03, 0x07, 0x80, 0x03, 0x07, 0x00, 0x03,
  0x0F, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x18, 0x00, 0x07, 0x18, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0C,
  0x38, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x38, 0x00, 0x38, 0x78, 0x00, 0x30,
  0x68, 0x00, 0x70, 0x6C, 0x00, 0xE0, 0x46, 0x01, 0xC0, 0xC7, 0xCF, 0x80,
  0xC1, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0x00, 0x07, 0xFF, 0x00,
  0xF8, 0x70, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0xC0, 0x10, 0x1F, 0x1E, 0x00, 0x7F, 0xE0, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x30, 0x00, 0xFF, 0x86, 0x00,
  0x3C, 0x78, 0xC0, 0x0E, 0x01, 0x98, 0x03, 0x00, 0x17, 0x00, 0xC0, 0x03,
  0xC0, 0x38, 0x00, 0x38, 0x06, 0x00, 0x07, 0x01, 0x80, 0x00, 0xE0, 0x30,
  0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C,
  0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x06, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x70, 0x18, 0x00, 0x0E, 0x03, 0x80, 0x03, 0xC0, 0x70, 0x00,
  0xF8, 0x06, 0x00, 0x1E, 0x00, 0xC0, 0x06, 0xC0, 0x1C, 0x01, 0x98, 0x01,
  0xC0, 0x63, 0x00, 0x1C, 0x78, 0x40, 0x01, 0xFE, 0x18, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xF8, 0x01, 0xE1, 0xC0, 0x38, 0x0E,
  0x07, 0x00, 0x60, 0xE0, 0x06, 0x1C, 0x00, 0x71, 0x80, 0x06, 0x30, 0x00,
  0x63, 0x00, 0x06, 0x60, 0x00, 0xC6, 0x00, 0x1C, 0x60, 0x07, 0x8E, 0x01,
  0xE0, 0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x20,
  0x1E, 0x1E, 0x00, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x82, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x07, 0xFC, 0x30, 0x03, 0xC7, 0x8C, 0x01, 0xC0, 0x33, 0x00, 0xE0,
  0x04, 0xC0, 0x60, 0x01, 0xE0, 0x38, 0x00, 0x38, 0x0C, 0x00, 0x0E, 0x06,
  0x00, 0x03, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C,
  0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x60, 0x60, 0x00,
  0x18, 0x18, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xC0,
  0x00, 0x30, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x03, 0x80, 0x03, 0xC0,
  0xE0, 0x01, 0xE0, 0x18, 0x00, 0x78, 0x06, 0x00, 0x36, 0x01, 0xC0, 0x19,
  0x80, 0x30, 0x0C, 0x60, 0x07, 0x1E, 0x30, 0x00, 0xFF, 0x0C, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x02, 0x00, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x61, 0xFF, 0x00, 0xC7, 0x8F,
  0x01, 0x98, 0x07, 0x03, 0x60, 0x06, 0x0D, 0x80, 0x0C, 0x1E, 0x00, 0x18,
  0x38, 0x00, 0x30, 0x70, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x80, 0x01, 0x86,
  0x00, 0x07, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x70, 0x00, 0x30, 0xC0,
  0x00, 0x61, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x06, 0x00, 0x06, 0x1C, 0x00,
  0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01,
  0x86, 0x00, 0x03, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30,
  0x60, 0x00, 0x61, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x1C, 0x03, 0x80, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x01, 0xC0,
  0xC0, 0x06, 0x01, 0x80, 0x18, 0x03, 0x00, 0x70, 0x0C, 0x01, 0xC0, 0x18,
  0x07, 0x00, 0x30, 0x1C, 0x00, 0x60, 0x70, 0x01, 0xC1, 0xC0, 0x03, 0x07,
  0x00, 0x06, 0x1C, 0x00, 0x0C, 0x70, 0x00, 0x18, 0xE0, 0x00, 0x63, 0xC0,
  0x00, 0xCD, 0x80, 0x01, 0xB3, 0x80, 0x03, 0xC3, 0x00, 0x07, 0x06, 0x00,
  0x1C, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x1C, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x70, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x30,
  0x00, 0xC0, 0xE0, 0x01, 0x81, 0x80, 0x03, 0x80, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x03, 0x80, 0x07, 0x00, 0x18,
  0x7F, 0x80, 0xFF, 0x00, 0xCF, 0x1E, 0x1E, 0x3C, 0x06, 0xE0, 0x31, 0xC0,
  0x70, 0x26, 0x01, 0xD8, 0x01, 0x83, 0x60, 0x06, 0xC0, 0x0C, 0x1E, 0x00,
  0x3C, 0x00, 0x60, 0xE0, 0x01, 0xC0, 0x03, 0x07, 0x00, 0x0E, 0x00, 0x18,
  0x30, 0x00, 0x60, 0x00, 0xC3, 0x80, 0x07, 0x00, 0x06, 0x18, 0x00, 0x30,
  0x00, 0x60, 0xC0, 0x01, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x70,
  0x00, 0x60, 0x00, 0xC3, 0x00, 0x07, 0x00, 0x06, 0x18, 0x00, 0x30, 0x00,
  0x60, 0xC0, 0x01, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x70, 0x00,
  0x60, 0x00, 0xC3, 0x00, 0x06, 0x00, 0x0E, 0x18, 0x00, 0x30, 0x00, 0x60,
  0xC0, 0x01, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xE0,
  0x00, 0xC3, 0x00, 0x06, 0x00, 0x0E, 0x18, 0x00, 0x30, 0x00, 0x60, 0xC0,
  0x01, 0x80, 0x03, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x06, 0x1F, 0xF0, 0x0C, 0x78, 0xF0, 0x19, 0x80,
  0x70, 0x26, 0x00, 0x60, 0xD8, 0x00, 0xC1, 0xE0, 0x01, 0x83, 0x80, 0x03,
  0x07, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x60, 0x00, 0x70,
  0xC0, 0x00, 0xC1, 0x80, 0x01, 0x87, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18,
  0x00, 0x1C, 0x30, 0x00, 0x30, 0x60, 0x00, 0x61, 0xC0, 0x00, 0xC3, 0x00,
  0x01, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x60, 0x00,
  0x30, 0xC0, 0x00, 0xE1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x0E, 0x00, 0x06,
  0x18, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xC3,
  0xC0, 0x0E, 0x01, 0xC0, 0x38, 0x01, 0x80, 0xE0, 0x01, 0x83, 0x80, 0x03,
  0x06, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0xE0, 0x00, 0x19,
  0x80, 0x00, 0x33, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xD8, 0x00, 0x03, 0x30,
  0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x77, 0x00,
  0x00, 0xCE, 0x00, 0x01, 0x9C, 0x00, 0x07, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x38, 0x60, 0x00, 0x60, 0xE0, 0x01, 0x80, 0xC0, 0x06, 0x01, 0xC0, 0x38,
  0x01, 0xF3, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x30, 0xFF, 0x80, 0x0C, 0x78, 0xF0, 0x03, 0x38, 0x0E, 0x00,
  0x98, 0x01, 0x80, 0x6C, 0x00, 0x70, 0x1E, 0x00, 0x0C, 0x07, 0x80, 0x03,
  0x01, 0xC0, 0x00, 0xC0, 0x70, 0x00, 0x30, 0x38, 0x00, 0x0C, 0x0E, 0x00,
  0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x0C, 0x18,
  0x00, 0x07, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18,
  0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00,
  0x60, 0x38, 0x00, 0x38, 0x1E, 0x00, 0x0C, 0x06, 0x80, 0x07, 0x01, 0xB0,
  0x03, 0x80, 0x66, 0x01, 0xC0, 0x19, 0xE3, 0xE0, 0x0C, 0x3F, 0xE0, 0x03,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xC3,
  0x00, 0xF1, 0xE3, 0x01, 0xC0, 0x33, 0x03, 0x00, 0x13, 0x07, 0x00, 0x1E,
  0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0C,
  0x38, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0C,
  0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x38,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0x30, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x70,
  0xE0, 0x00, 0xF0, 0xE0, 0x01, 0xF0, 0x60, 0x01, 0xE0, 0x60, 0x03, 0x60,
  0x70, 0x06, 0x60, 0x38, 0x0C, 0x60, 0x3C, 0x78, 0xC0, 0x0F, 0xF0, 0xC0,
  0x03, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x61, 0xFC, 0x0C, 0x79, 0x01, 0x98,
  0x00, 0x26, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFE, 0x03, 0xE1, 0xF0, 0x70,
  0x02, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x0C, 0x00,
  0xE0, 0xF8, 0x3C, 0x03, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x1F, 0xFF, 0x7F,
  0xFC, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x18, 0x0F, 0xE0,
  0x04, 0x00, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x60,
  0x00, 0x30, 0xC0, 0x00, 0xE1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x0E, 0x00,
  0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00,
  0xC3, 0x00, 0x01, 0x86, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x70, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x06,
  0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x38, 0x00, 0x78, 0x70, 0x00, 0xA0, 0xE0,
  0x03, 0xC0, 0xC0, 0x0D, 0x81, 0xC0, 0x73, 0x01, 0xE7, 0xC6, 0x01, 0xFE,
  0x08, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x06, 0xC0, 0x00,
  0x6C, 0x00, 0x0C, 0xC0, 0x01, 0xCC, 0x00, 0x18, 0xE0, 0x03, 0x86, 0x00,
  0x30, 0x60, 0x07, 0x06, 0x00, 0x60, 0x60, 0x0E, 0x06, 0x00, 0xC0, 0x60,
  0x1C, 0x06, 0x01, 0x80, 0x60, 0x30, 0x06, 0x03, 0x00, 0x70, 0x60, 0x03,
  0x06, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00,
  0x33, 0x00, 0x03, 0x30, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x03,
  0x80, 0x06, 0xC0, 0x03, 0x80, 0x06, 0xC0, 0x06, 0x80, 0x0C, 0xC0, 0x06,
  0x80, 0x0C, 0xC0, 0x0C, 0x80, 0x18, 0xC0, 0x0C, 0x80, 0x18, 0xC0, 0x18,
  0x80, 0x30, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x18, 0xC0, 0x70, 0x40, 0x30,
  0xC0, 0x60, 0x60, 0x30, 0xC0, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0x60, 0x60,
  0xC0, 0xC0, 0x60, 0xC0, 0xC1, 0x80, 0x60, 0xC0, 0xC1, 0x80, 0x61, 0x80,
  0xC3, 0x00, 0x61, 0x80, 0xC3, 0x00, 0x63, 0x00, 0xC7, 0x00, 0x63, 0x00,
  0xC6, 0x00, 0x66, 0x00, 0xC6, 0x00, 0x66, 0x00, 0xCC, 0x00, 0x6C, 0x00,
  0xCC, 0x00, 0x6C, 0x00, 0xD8, 0x00, 0x68, 0x00, 0x58, 0x00, 0x78, 0x00,
  0x50, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x01, 0x80, 0x30, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x0C, 0x01, 0xC0, 0x03, 0x01, 0xC0, 0x01, 0x80, 0xC0,
  0x00, 0xC0, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x0C, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x33, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x38, 0x60, 0x00, 0x18, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x18,
  0x06, 0x00, 0x1C, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x0C,
  0x00, 0x18, 0x0E, 0x00, 0x0C, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x70, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x0E, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60,
  0x38, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x08, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x90, 0x00, 0x1E, 0x00, 0x07, 0xE0,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xC0, 0x02,
  0x7F, 0xE0, 0x07, 0x81, 0xF0, 0x1E, 0x00, 0x7F, 0xE8, 0x00, 0x3F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 11, 39, 12, 1, -39 },
  { 55, 12, 14, 17, 6, -39 },
  { 76, 29, 39, 29, 1, -39 },
  { 218, 24, 45, 26, 1, -42 },
  { 353, 31, 41, 38, 4, -40 },
  { 512, 28, 41, 31, 1, -40 },
  { 656, 5, 14, 9, 6, -39 },
  { 665, 15, 48, 14, 2, -39 },
  { 755, 16, 48, 14, -4, -39 },
  { 851, 19, 21, 25, 7, -42 },
  { 901, 23, 25, 28, 3, -32 },
  { 973, 7, 13, 10, -2, -6 },
  { 985, 12, 2, 16, 2, -16 },
  { 988, 4, 4, 11, 1, -4 },
  { 990, 23, 39, 17, -2, -39 },
  { 1103, 23, 41, 26, 3, -40 },
  { 1221, 12, 39, 26, 8, -39 },
  { 1280, 25, 40, 26, 0, -40 },
  { 1405, 25, 41, 26, 0, -40 },
  { 1534, 25, 40, 26, 0, -40 },
  { 1659, 25, 40, 26, 1, -39 },
  { 1784, 24, 41, 26, 3, -40 },
  { 1907, 23, 39, 26, 4, -39 },
  { 2020, 25, 41, 26, 1, -40 },
  { 2149, 23, 41, 26, 2, -40 },
  { 2267, 9, 29, 11, 1, -29 },
  { 2300, 13, 36, 11, -3, -29 },
  { 2359, 23, 24, 28, 3, -32 },
  { 2428, 23, 13, 28, 3, -26 },
  { 2466, 23, 24, 28, 3, -32 },
  { 2535, 18, 40, 19, 3, -40 },
  { 2625, 37, 44, 40, 2, -39 },
  { 2829, 26, 39, 26, -3, -39 },
  { 2956, 26, 39, 29, 2, -39 },
  { 3083, 27, 41, 28, 4, -40 },
  { 3222, 28, 39, 32, 2, -39 },
  { 3359, 25, 39, 25, 2, -39 },
  { 3481, 25, 39, 23, 2, -39 },
  { 3603, 29, 41, 33, 4, -40 },
  { 3752, 31, 39, 33, 2, -39 },
  { 3904, 18, 39, 14, -1, -39 },
  { 3992, 21, 49, 12, -9, -39 },
  { 4121, 29, 39, 26, 2, -39 },
  { 4263, 17, 39, 23, 2, -39 },
  { 4346, 39, 39, 40, 2, -39 },
  { 4537, 31, 39, 33, 2, -39 },
  { 4689, 28, 41, 34, 4, -40 },
  { 4833, 25, 39, 27, 2, -39 },
  { 4955, 28, 49, 34, 4, -40 },
  { 5127, 25, 39, 27, 2, -39 },
  { 5249, 25, 41, 24, 0, -40 },
  { 5378, 23, 39, 23, 5, -39 },
  { 5491, 29, 40, 33, 4, -39 },
  { 5636, 25, 39, 26, 5, -39 },
  { 5758, 39, 39, 41, 6, -39 },
  { 5949, 31, 39, 24, -3, -39 },
  { 6101, 23, 39, 23, 5, -39 },
  { 6214, 28, 39, 25, -1, -39 },
  { 6351, 21, 48, 16, -1, -39 },
  { 6477, 8, 39, 18, 6, -39 },
  { 6516, 21, 48, 16, -4, -39 },
  { 6642, 24, 22, 27, 2, -39 },
  { 6708, 19, 2, 19, -5, 5 },
  { 6713, 6, 9, 13, 8, -42 },
  { 6720, 24, 31, 27, 2, -30 },
  { 6813, 24, 43, 28, 1, -42 },
  { 6942, 20, 31, 21, 2, -30 },
  { 7020, 27, 43, 28, 2, -42 },
  { 7166, 20, 31, 24, 3, -30 },
  { 7244, 28, 55, 13, -7, -42 },
  { 7437, 26, 43, 28, 0, -30 },
  { 7577, 23, 42, 27, 1, -42 },
  { 7698, 11, 40, 11, 1, -40 },
  { 7753, 19, 53, 11, -7, -40 },
  { 7879, 23, 42, 22, 1, -42 },
  { 8000, 11, 42, 11, 1, -42 },
  { 8058, 37, 30, 41, 1, -30 },
  { 8197, 23, 30, 27, 1, -30 },
  { 8284, 23, 31, 27, 2, -30 },
  { 8374, 26, 43, 28, -1, -30 },
  { 8514, 24, 43, 28, 2, -30 },
  { 8643, 19, 30, 18, 1, -30 },
  { 8715, 20, 31, 21, 0, -30 },
  { 8793, 14, 37, 15, 2, -36 },
  { 8858, 23, 30, 27, 2, -29 },
  { 8945, 20, 29, 20, 3, -29 },
  { 9018, 32, 29, 33, 3, -29 },
  { 9134, 25, 29, 22, -2, -29 },
  { 9225, 30, 42, 21, -6, -29 },
  { 9383, 22, 29, 20, -1, -29 },
  { 9463, 20, 48, 18, 1, -39 },
  { 9583, 2, 55, 26, 13, -42 },
  { 9597, 20, 48, 18, -3, -39 },
  { 9717, 23, 5, 28, 3, -22 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic55pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC55PT7B_H_
