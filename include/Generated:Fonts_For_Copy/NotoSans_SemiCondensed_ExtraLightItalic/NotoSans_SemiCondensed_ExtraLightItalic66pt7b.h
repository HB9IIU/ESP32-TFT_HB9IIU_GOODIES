#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC66PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x30, 0x18, 0x60, 0x31,
  0xC0, 0xE3, 0x81, 0xC6, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x70, 0x38, 0xE0,
  0x71, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x0C, 0x06, 0x30, 0x18, 0x60, 0x30,
  0xC0, 0x60, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x0E, 0x00, 0x60, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00,
  0x30, 0x03, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x0C, 0x00,
  0x00, 0x30, 0x03, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x07, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x7C, 0x60,
  0xF0, 0x07, 0x83, 0x00, 0x80, 0x70, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x38, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x0F, 0x60, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x6F,
  0x80, 0x00, 0x03, 0x1E, 0x00, 0x00, 0x18, 0x78, 0x00, 0x00, 0xC1, 0xC0,
  0x00, 0x0C, 0x07, 0x00, 0x00, 0x60, 0x38, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x60,
  0x1C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x0E, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x0C, 0x0F, 0x01, 0x80, 0x61, 0xF0, 0x0F, 0xE3, 0x7E, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0x00, 0xF7, 0xC0, 0x00, 0x70, 0x0E, 0x06,
  0x00, 0x03, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x06, 0x01, 0xC0, 0x01, 0x80,
  0x70, 0x06, 0x00, 0x18, 0x03, 0x00, 0x30, 0x01, 0xC0, 0x38, 0x01, 0x80,
  0x0C, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x1C, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x60, 0x06, 0x00, 0x38, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x70,
  0x03, 0x80, 0x0C, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x38, 0x00, 0xC0, 0x03,
  0x03, 0x80, 0x06, 0x00, 0x38, 0x18, 0x00, 0x30, 0x01, 0x81, 0xC0, 0x01,
  0x80, 0x0C, 0x1C, 0x0F, 0x0C, 0x00, 0xE0, 0xC1, 0xFE, 0x60, 0x07, 0x0E,
  0x1E, 0x7B, 0x00, 0x30, 0xE1, 0xC0, 0xD8, 0x03, 0x86, 0x1C, 0x07, 0xC0,
  0x18, 0x70, 0xC0, 0x3F, 0x01, 0x87, 0x0E, 0x00, 0xF8, 0x1C, 0x30, 0x60,
  0x06, 0xF7, 0xC3, 0x87, 0x00, 0x33, 0xFC, 0x18, 0x30, 0x01, 0x87, 0x01,
  0x83, 0x80, 0x0C, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x00, 0xC0, 0xC0, 0x07,
  0x00, 0x0C, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x70, 0x01, 0x80, 0x06, 0x03,
  0x80, 0x0C, 0x00, 0x70, 0x18, 0x00, 0x60, 0x07, 0x00, 0xC0, 0x07, 0x00,
  0x30, 0x06, 0x00, 0x30, 0x03, 0x80, 0x30, 0x01, 0x80, 0x38, 0x01, 0x80,
  0x1C, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x1C, 0x00, 0x60, 0x06, 0x01, 0xC0,
  0x03, 0x00, 0x70, 0x0C, 0x00, 0x18, 0x03, 0x00, 0xE0, 0x00, 0xE0, 0x30,
  0x0E, 0x00, 0x07, 0x03, 0x80, 0x60, 0x00, 0x1E, 0xF8, 0x07, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x60, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x30, 0x0F, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF3,
  0x00, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x20, 0xE0,
  0x38, 0x00, 0x60, 0xE0, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x00, 0x38, 0xE0,
  0x01, 0xC0, 0x18, 0xE0, 0x00, 0xE0, 0x1C, 0x70, 0x00, 0x38, 0x0C, 0x70,
  0x00, 0x0C, 0x0E, 0x38, 0x00, 0x07, 0x0E, 0x18, 0x00, 0x01, 0x86, 0x0C,
  0x00, 0x00, 0xE7, 0x06, 0x00, 0x00, 0x3F, 0x03, 0x00, 0x00, 0x1F, 0x01,
  0x80, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x60, 0x00, 0x03, 0xE0,
  0x38, 0x00, 0x07, 0xB0, 0x1E, 0x00, 0x07, 0x9C, 0x07, 0x00, 0x07, 0x06,
  0x01, 0xE0, 0x0F, 0x03, 0x80, 0x7F, 0xFF, 0x00, 0xE0, 0x1F, 0xFE, 0x00,
  0x70, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x61, 0x8E, 0x38, 0xC3, 0x0C,
  0x71, 0xC6, 0x18, 0x61, 0x8C, 0x30, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xF0, 0x18, 0x00, 0x7C, 0x18, 0x00, 0x1E,
  0x18, 0x00, 0x07, 0x98, 0x07, 0x01, 0xF3, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0x78, 0x00, 0x00, 0xD8, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x0C, 0x00, 0x06,
  0x06, 0x00, 0x1C, 0x06, 0x00, 0x38, 0x07, 0x00, 0x70, 0x03, 0x00, 0x20,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x1C, 0x0E, 0x06,
  0x06, 0x03, 0x03, 0x01, 0x81, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x6F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xDF, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x0C, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x60,
  0x38, 0x00, 0x06, 0x03, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x06, 0x38, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x01, 0xC6, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x18, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x38, 0x06, 0x00, 0x07, 0x00, 0x70, 0x00, 0x70, 0x03, 0x00,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x3C,
  0x01, 0xF8, 0x07, 0xF0, 0x1C, 0xE0, 0xF1, 0x83, 0xC3, 0x1E, 0x0E, 0xF8,
  0x1C, 0xC0, 0x31, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0x80, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x80, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xF0, 0x03, 0x80, 0x0F, 0x80, 0x03, 0x80, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x0C, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x07, 0x00,
  0x18, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0E,
  0x00, 0x30, 0x00, 0x30, 0x01, 0xC0, 0x00, 0xC0, 0x0E, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x60, 0x0E, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x06, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xDF, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x30, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0x3C, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x1F, 0xC0, 0x01, 0x87, 0xFF, 0x80,
  0x1C, 0x7C, 0x3E, 0x00, 0xE7, 0x00, 0x38, 0x06, 0x60, 0x00, 0xE0, 0x36,
  0x00, 0x07, 0x03, 0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x01, 0x87, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0xE0, 0x0C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x30, 0x00,
  0x38, 0x03, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38,
  0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x70, 0x18,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0xE0, 0x1E, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x00, 0xE0,
  0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0E,
  0x18, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x3C, 0x03, 0x80, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xC0, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0xE0, 0x38, 0x00, 0x06, 0x03, 0x80, 0x00, 0x70, 0x70, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x1C, 0x00, 0x00,
  0x31, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x3E, 0x0E, 0x00, 0x07, 0xE0, 0x70, 0x00, 0xEE, 0x07, 0x80, 0x1C, 0xC0,
  0x3F, 0x1F, 0x8C, 0x00, 0xFF, 0xE1, 0xC0, 0x03, 0xF0, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x08, 0x01, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x03,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xFC,
  0x07, 0xFF, 0xF0, 0x38, 0x03, 0xC1, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x03, 0xE0, 0x01, 0xC1, 0x80, 0x03, 0xFF, 0xC0, 0x18, 0x70, 0x00,
  0xF9, 0xF8, 0x03, 0x0C, 0x00, 0x78, 0x07, 0x00, 0x63, 0x80, 0x1E, 0x00,
  0xC0, 0x0C, 0x60, 0x03, 0x00, 0x18, 0x01, 0x9C, 0x00, 0xE0, 0x03, 0x00,
  0x33, 0x00, 0x38, 0x00, 0xE0, 0x06, 0x60, 0x06, 0x00, 0x18, 0x00, 0xDC,
  0x01, 0xC0, 0x03, 0x00, 0x3B, 0x80, 0x30, 0x00, 0x60, 0x07, 0x60, 0x0E,
  0x00, 0x1C, 0x00, 0xCC, 0x01, 0x80, 0x03, 0x00, 0x1B, 0x80, 0x30, 0x00,
  0x60, 0x03, 0x70, 0x0E, 0x00, 0x1C, 0x00, 0xEE, 0x01, 0xC0, 0x03, 0x80,
  0x19, 0x80, 0x30, 0x00, 0x60, 0x03, 0x30, 0x06, 0x00, 0x1C, 0x00, 0xE6,
  0x00, 0xC0, 0x03, 0x80, 0x18, 0xC0, 0x18, 0x00, 0xF0, 0x07, 0x18, 0x03,
  0x00, 0x1E, 0x00, 0xC3, 0x00, 0x70, 0x06, 0xC0, 0x38, 0x60, 0x0E, 0x01,
  0x98, 0x0E, 0x0C, 0x00, 0xE0, 0x73, 0x03, 0x81, 0xC0, 0x1F, 0x3C, 0x39,
  0xE0, 0x38, 0x01, 0xFF, 0x07, 0xF8, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x06, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x07, 0x30, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x38, 0x30, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01,
  0xC0, 0x18, 0x00, 0x03, 0x80, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0xC0,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x06, 0x38, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x06, 0x70, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x70, 0x01, 0xF8, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x06, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x70, 0x03, 0x00,
  0x01, 0xE0, 0x03, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x07, 0x00, 0x7F, 0x00, 0x06, 0x00, 0x07, 0x80, 0x06, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x60, 0x0E, 0x00,
  0x00, 0x70, 0x0C, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x30, 0x1C, 0x00,
  0x00, 0x30, 0x1C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x70, 0x18, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0F, 0x00, 0x60, 0x00,
  0x3E, 0x00, 0x60, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x10, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x30, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0x00,
  0x7F, 0x00, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x1C,
  0x03, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00,
  0x30, 0x1C, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0xE0, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x03, 0xC0, 0x07,
  0x00, 0x03, 0xE0, 0x01, 0x80, 0x03, 0xF0, 0x00, 0x60, 0x1F, 0xF0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x06, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x1F, 0xFF, 0x0C, 0x00, 0x03, 0xFF, 0xE1, 0x80, 0x00, 0x7F,
  0xFC, 0x70, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00,
  0x30, 0x1C, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x07,
  0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x18, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x01, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x03, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x30, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x06, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0x03, 0x00, 0x1E, 0x00, 0x00, 0x60, 0x07, 0x80, 0x00,
  0x1C, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x60, 0x1E, 0x00,
  0x00, 0x0C, 0x07, 0x80, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0x70, 0x78,
  0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x01, 0x87, 0x80, 0x00, 0x00, 0x31,
  0xE0, 0x00, 0x00, 0x0E, 0x7E, 0x00, 0x00, 0x01, 0xCF, 0xC0, 0x00, 0x00,
  0x3B, 0x98, 0x00, 0x00, 0x06, 0xC3, 0x80, 0x00, 0x00, 0xF0, 0x30, 0x00,
  0x00, 0x3C, 0x07, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0C,
  0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0x60, 0x06, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x0D, 0x80, 0x00, 0x00, 0x1B,
  0x80, 0x1B, 0x00, 0x00, 0x00, 0x76, 0x00, 0x77, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0xEE, 0x00, 0x00, 0x03, 0xB8, 0x01, 0x9C, 0x00, 0x00, 0x0E, 0x70,
  0x03, 0x18, 0x00, 0x00, 0x1C, 0xC0, 0x06, 0x30, 0x00, 0x00, 0x71, 0x80,
  0x1C, 0x60, 0x00, 0x00, 0xE3, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x8E, 0x00,
  0x61, 0x80, 0x00, 0x06, 0x1C, 0x00, 0xC3, 0x80, 0x00, 0x1C, 0x30, 0x03,
  0x87, 0x00, 0x00, 0x30, 0x60, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x0E,
  0x0C, 0x00, 0x01, 0x83, 0x80, 0x18, 0x18, 0x00, 0x07, 0x07, 0x00, 0x30,
  0x30, 0x00, 0x1C, 0x0C, 0x00, 0xE0, 0x60, 0x00, 0x38, 0x18, 0x01, 0xC0,
  0xC0, 0x00, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x01, 0x80, 0xE0, 0x06, 0x03,
  0x80, 0x07, 0x01, 0xC0, 0x0C, 0x07, 0x00, 0x0C, 0x03, 0x00, 0x38, 0x06,
  0x00, 0x38, 0x06, 0x00, 0x70, 0x0C, 0x00, 0x60, 0x1C, 0x00, 0xC0, 0x18,
  0x01, 0xC0, 0x38, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60,
  0x0E, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0,
  0x70, 0x07, 0x00, 0x30, 0x03, 0x81, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x03,
  0x00, 0x18, 0x01, 0xC0, 0x06, 0x0E, 0x00, 0x30, 0x03, 0x80, 0x0C, 0x18,
  0x00, 0xE0, 0x07, 0x00, 0x18, 0x70, 0x01, 0xC0, 0x0C, 0x00, 0x30, 0xC0,
  0x03, 0x80, 0x18, 0x00, 0x73, 0x80, 0x06, 0x00, 0x70, 0x00, 0xE6, 0x00,
  0x0C, 0x00, 0xE0, 0x01, 0xDC, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xF0, 0x00,
  0x70, 0x03, 0x00, 0x03, 0xE0, 0x00, 0xC0, 0x06, 0x00, 0x07, 0x80, 0x01,
  0x80, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x1F, 0x00, 0x00, 0x06, 0x00, 0x6C, 0x00,
  0x00, 0x18, 0x01, 0xB0, 0x00, 0x00, 0xE0, 0x06, 0xE0, 0x00, 0x03, 0x80,
  0x39, 0x80, 0x00, 0x0E, 0x00, 0xE6, 0x00, 0x00, 0x30, 0x03, 0x1C, 0x00,
  0x00, 0xC0, 0x0C, 0x30, 0x00, 0x07, 0x00, 0x30, 0xC0, 0x00, 0x1C, 0x01,
  0xC3, 0x80, 0x00, 0x60, 0x07, 0x06, 0x00, 0x01, 0x80, 0x18, 0x18, 0x00,
  0x0E, 0x00, 0x60, 0x70, 0x00, 0x38, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0x0E,
  0x03, 0x00, 0x03, 0x00, 0x38, 0x0E, 0x00, 0x0C, 0x00, 0xC0, 0x18, 0x00,
  0x70, 0x03, 0x00, 0x60, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x38, 0x03,
  0x80, 0x18, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x01, 0x80, 0x38, 0x03, 0x80,
  0x07, 0x00, 0xC0, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x30, 0x00, 0x30, 0x1C,
  0x00, 0xC0, 0x00, 0xE0, 0x70, 0x07, 0x00, 0x03, 0x81, 0x80, 0x1C, 0x00,
  0x06, 0x06, 0x00, 0x60, 0x00, 0x1C, 0x38, 0x01, 0x80, 0x00, 0x70, 0xE0,
  0x0E, 0x00, 0x00, 0xC3, 0x80, 0x38, 0x00, 0x03, 0x8C, 0x00, 0xE0, 0x00,
  0x0E, 0x30, 0x03, 0x00, 0x00, 0x18, 0xC0, 0x0C, 0x00, 0x00, 0x77, 0x00,
  0x70, 0x00, 0x01, 0xDC, 0x01, 0xC0, 0x00, 0x03, 0x60, 0x07, 0x00, 0x00,
  0x0F, 0x80, 0x18, 0x00, 0x00, 0x3E, 0x00, 0x60, 0x00, 0x00, 0x78, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x07, 0x80, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xC0, 0x1F, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x07, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x01, 0x80, 0x70, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0xE0, 0x18,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x70, 0x03, 0x80, 0x03, 0xC0, 0x06, 0x00, 0x7F, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x03,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00,
  0x07, 0x06, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xC0, 0x1F, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x03, 0x80, 0x0C, 0x00, 0x03, 0x80, 0x18, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x38, 0x06, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xC0, 0x38, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x3C, 0x01, 0xC0, 0x01, 0xF0,
  0x03, 0x80, 0x1F, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x70, 0x03, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x01,
  0x80, 0x0E, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x01, 0xC0,
  0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x0C, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x0C, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0x04, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x80, 0x00, 0x3C, 0x03, 0xC0,
  0x07, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x18, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x0E,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x38, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x30,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0xE0, 0x0C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x70,
  0x03, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x70, 0x00,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x18, 0x07, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x06, 0x03, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x01, 0x83, 0x80, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0D,
  0xC0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xB0, 0x00,
  0x07, 0x38, 0x00, 0x03, 0x60, 0x00, 0x0C, 0x70, 0x00, 0x0E, 0xC0, 0x00,
  0x38, 0xE0, 0x00, 0x19, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x73, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x87, 0x00, 0x03, 0x8C, 0x00, 0x0E,
  0x0E, 0x00, 0x06, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x30, 0x00, 0x30,
  0x38, 0x00, 0x30, 0x60, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xC0, 0x01, 0x80,
  0x60, 0x01, 0xC1, 0x80, 0x07, 0x00, 0xC0, 0x03, 0x03, 0x00, 0x0E, 0x01,
  0x80, 0x0E, 0x07, 0x00, 0x38, 0x03, 0x00, 0x18, 0x0E, 0x00, 0x70, 0x06,
  0x00, 0x70, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x38, 0x03, 0x80, 0x18,
  0x03, 0x80, 0x70, 0x06, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x1C, 0x00, 0x60,
  0x1C, 0x01, 0xC0, 0x30, 0x00, 0xC0, 0x38, 0x03, 0x80, 0xE0, 0x01, 0x80,
  0x60, 0x07, 0x01, 0xC0, 0x03, 0x01, 0xC0, 0x0E, 0x03, 0x00, 0x06, 0x03,
  0x00, 0x1C, 0x0E, 0x00, 0x0C, 0x0E, 0x00, 0x38, 0x18, 0x00, 0x18, 0x18,
  0x00, 0x30, 0x70, 0x00, 0x30, 0x70, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0xC3, 0x80, 0x00, 0xC3, 0x80, 0x01, 0x87, 0x00, 0x01, 0x87, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x38, 0x00, 0x06, 0x38, 0x00,
  0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x19, 0xC0, 0x00, 0x19, 0xC0, 0x00,
  0x33, 0x00, 0x00, 0x33, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xB0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x00, 0x38,
  0x18, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x18, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x18, 0x70, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x06, 0x03, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x1C,
  0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x01, 0x80, 0x07, 0x00, 0x18,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0xC0, 0x01, 0xC0, 0x1C,
  0x00, 0x0C, 0x03, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x06, 0x38,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x80, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x18, 0x18, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70,
  0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x0C, 0x00, 0x60,
  0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0x70, 0x03, 0x00, 0x03, 0x00, 0x70,
  0x00, 0x30, 0x06, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x18, 0x1C, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xC1, 0xC3, 0x83, 0x83, 0x07, 0x06, 0x06,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0x03, 0x00, 0x7F, 0xF8, 0x70,
  0x0F, 0x01, 0xC6, 0x01, 0xE0, 0x06, 0x60, 0x38, 0x00, 0x66, 0x07, 0x00,
  0x03, 0xE0, 0x70, 0x00, 0x3E, 0x0E, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x1C,
  0x1C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x18, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03,
  0x86, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x1E, 0x0C,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x06, 0xC0, 0xE0, 0x00,
  0xDC, 0x07, 0x00, 0x1D, 0x80, 0x70, 0x03, 0x98, 0x03, 0xC0, 0xF1, 0x80,
  0x1F, 0xFC, 0x18, 0x00, 0xFF, 0x83, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x20, 0x00, 0x18, 0x1F, 0xF0, 0x01, 0xC3, 0xFF,
  0xC0, 0x0E, 0x38, 0x0F, 0x00, 0x63, 0x80, 0x3C, 0x03, 0x30, 0x00, 0xE0,
  0x1B, 0x00, 0x03, 0x01, 0xF8, 0x00, 0x1C, 0x0F, 0x80, 0x00, 0xE0, 0x78,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x00, 0xC1, 0xE0, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0x30, 0x70, 0x00, 0x01, 0x83, 0x00, 0x00, 0x1C,
  0x18, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x30, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x18,
  0x3C, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0C, 0x0F, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x0E, 0x03, 0x40, 0x00, 0x70, 0x3B, 0x00, 0x07, 0x01, 0x9C, 0x00,
  0xF0, 0x0C, 0x70, 0x0F, 0x00, 0x61, 0xFF, 0xF0, 0x07, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0xF8, 0x02, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0xC0, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x1F, 0xF8, 0x30, 0x00,
  0x7F, 0xFC, 0x30, 0x00, 0xF8, 0x0E, 0x30, 0x01, 0xE0, 0x07, 0x70, 0x03,
  0x80, 0x03, 0x70, 0x07, 0x00, 0x01, 0x60, 0x07, 0x00, 0x01, 0xE0, 0x0E,
  0x00, 0x01, 0xE0, 0x1C, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x01, 0xE0, 0x18,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x0F, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x1E, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0xE0,
  0x00, 0x7E, 0x00, 0xE0, 0x00, 0xEC, 0x00, 0x70, 0x01, 0xCC, 0x00, 0x70,
  0x03, 0x8C, 0x00, 0x3C, 0x0F, 0x0C, 0x00, 0x1F, 0xFE, 0x18, 0x00, 0x0F,
  0xF8, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0xF8, 0x1E, 0x01, 0xE0, 0x06, 0x03, 0xC0,
  0x07, 0x03, 0x80, 0x07, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0C, 0x00,
  0x07, 0x1C, 0x00, 0x07, 0x18, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x30, 0x00,
  0x1C, 0x30, 0x00, 0x78, 0x70, 0x00, 0xF0, 0x70, 0x07, 0xE0, 0x7F, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x20, 0x1E, 0x00,
  0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x20, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xBE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0F, 0xFC, 0x1C, 0x00, 0x7F, 0xFC, 0x30, 0x01, 0xE0, 0x1C, 0x60, 0x07,
  0x80, 0x1C, 0xC0, 0x1C, 0x00, 0x1B, 0x80, 0x78, 0x00, 0x16, 0x00, 0xE0,
  0x00, 0x3C, 0x03, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xF0, 0x1C, 0x00,
  0x01, 0xE0, 0x30, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x70,
  0x18, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x0F, 0x00,
  0xC0, 0x00, 0x1E, 0x01, 0x80, 0x00, 0x7C, 0x03, 0x80, 0x00, 0xF8, 0x07,
  0x00, 0x03, 0xF0, 0x0E, 0x00, 0x0E, 0xC0, 0x0E, 0x00, 0x39, 0x80, 0x1C,
  0x00, 0xE7, 0x00, 0x1C, 0x07, 0x8E, 0x00, 0x1F, 0xFE, 0x18, 0x00, 0x1F,
  0xF0, 0x30, 0x00, 0x0F, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x40, 0x00, 0xF0,
  0x00, 0xC0, 0x03, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x0C, 0x0F,
  0xF8, 0x00, 0xC3, 0xFF, 0xC0, 0x1C, 0x70, 0x1E, 0x01, 0xCC, 0x00, 0xE0,
  0x19, 0x80, 0x07, 0x01, 0xB0, 0x00, 0x70, 0x3E, 0x00, 0x07, 0x03, 0xE0,
  0x00, 0x30, 0x3C, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x06, 0x07, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x1C, 0x1C,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x81, 0x80, 0x00,
  0x38, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x30, 0x38, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x70, 0x30, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x10, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00,
  0x18, 0x01, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x38, 0x07, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x30, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x70, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x06, 0x3C, 0x00, 0x00, 0xE7,
  0xE0, 0x00, 0x0C, 0xEE, 0x00, 0x00, 0xDC, 0x60, 0x00, 0x0F, 0x87, 0x00,
  0x01, 0xF0, 0x70, 0x00, 0x1E, 0x03, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x18,
  0x01, 0x80, 0x01, 0x80, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xE0, 0x03, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x60, 0x07,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x70, 0x06, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x38, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x06, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x31, 0xFF, 0xE0,
  0x7F, 0xF8, 0x03, 0x1E, 0x07, 0x07, 0x01, 0xE0, 0x19, 0xC0, 0x1C, 0x70,
  0x07, 0x00, 0xDC, 0x00, 0x67, 0x00, 0x1C, 0x06, 0xC0, 0x03, 0x70, 0x00,
  0xE0, 0x7C, 0x00, 0x1B, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x18, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x18, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x18, 0x00, 0x06, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x0C, 0x0F, 0xF8, 0x01, 0xC3, 0xFF, 0xC0, 0x18, 0x70, 0x1E, 0x01, 0x9C,
  0x00, 0xF0, 0x19, 0x80, 0x07, 0x01, 0xB0, 0x00, 0x70, 0x3E, 0x00, 0x07,
  0x03, 0xE0, 0x00, 0x30, 0x3C, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0C, 0x0E,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x1C, 0x1C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x81,
  0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x30, 0x38, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x70, 0x30, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x06, 0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x7C, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x07, 0x01, 0xE0,
  0x00, 0x70, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x18,
  0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x60, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x1B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x03, 0x38, 0x00, 0x00, 0x67, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x03, 0x80,
  0x03, 0xC0, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x7C, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x1F, 0xF0, 0x00, 0x18, 0x7F, 0xF8, 0x00, 0x30, 0xE0, 0x3C, 0x00,
  0x31, 0xC0, 0x1E, 0x00, 0x33, 0x80, 0x0E, 0x00, 0x37, 0x00, 0x06, 0x00,
  0x7E, 0x00, 0x07, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03, 0x00, 0xF0, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x18, 0x07, 0x80, 0x00, 0x38, 0x07, 0x80, 0x00, 0x38, 0x07,
  0x80, 0x00, 0x70, 0x07, 0x80, 0x00, 0xE0, 0x06, 0x80, 0x00, 0xE0, 0x0E,
  0xC0, 0x01, 0xC0, 0x0E, 0xE0, 0x07, 0x80, 0x0C, 0x70, 0x0F, 0x00, 0x0C,
  0x3F, 0xFE, 0x00, 0x0C, 0x1F, 0xF8, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xFF, 0xC1, 0xC0, 0x1F, 0xFF, 0x0C, 0x01, 0xF0, 0x1C, 0x60, 0x1E, 0x00,
  0x73, 0x01, 0xC0, 0x01, 0xB8, 0x1C, 0x00, 0x0D, 0x80, 0xE0, 0x00, 0x3C,
  0x0E, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x78, 0x30,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x30, 0x70, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C,
  0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x30, 0x70,
  0x00, 0x03, 0x83, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x0F, 0x06, 0x00, 0x00, 0x70, 0x30, 0x00, 0x07, 0x81, 0x80, 0x00, 0x7C,
  0x0E, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x3F, 0x03, 0x80, 0x03, 0xB0, 0x0E,
  0x00, 0x39, 0x80, 0x70, 0x03, 0x9C, 0x01, 0xC0, 0x38, 0xE0, 0x07, 0xFF,
  0x86, 0x00, 0x1F, 0xF0, 0x30, 0x00, 0x3C, 0x01, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x10, 0x01, 0x83, 0xFC, 0x03, 0x0F, 0xF0, 0x0C, 0x78, 0x00,
  0x19, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0x60, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xE0, 0x0E, 0x03, 0x80, 0x02, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x80, 0x01, 0xC0, 0xE0,
  0x03, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xFF, 0xC0, 0x7F,
  0xC0, 0x0F, 0x00, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x1C, 0x1C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x30, 0x30,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x70, 0x30, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x3C, 0x0C, 0x00, 0x07, 0xC0, 0xC0, 0x00, 0x7C, 0x0E, 0x00, 0x0D, 0x80,
  0xE0, 0x01, 0x98, 0x0E, 0x00, 0x39, 0x80, 0x78, 0x0E, 0x18, 0x03, 0xFF,
  0xC3, 0x00, 0x1F, 0xF8, 0x30, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xB0, 0x00, 0x03, 0x98, 0x00, 0x01, 0x8C, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x70, 0x70, 0x00,
  0x30, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x18, 0x06, 0x00, 0x1C, 0x03, 0x00,
  0x0C, 0x01, 0x80, 0x0E, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x07, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x03,
  0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0x30, 0x60, 0x00,
  0x18, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x38, 0x00, 0x03, 0x18, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x6C, 0x00, 0x0F, 0x00,
  0x03, 0xB0, 0x00, 0x3C, 0x00, 0x0C, 0xC0, 0x00, 0xF0, 0x00, 0x73, 0x00,
  0x06, 0xC0, 0x01, 0x8C, 0x00, 0x1B, 0x00, 0x0E, 0x30, 0x00, 0xEC, 0x00,
  0x30, 0xC0, 0x03, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0xE0, 0x07, 0x0E, 0x00,
  0x63, 0x80, 0x18, 0x38, 0x03, 0x8E, 0x00, 0xE0, 0xE0, 0x0C, 0x38, 0x03,
  0x03, 0x80, 0x70, 0x60, 0x1C, 0x0E, 0x01, 0x81, 0x80, 0x60, 0x38, 0x0E,
  0x06, 0x03, 0x80, 0xE0, 0x30, 0x18, 0x0C, 0x03, 0x81, 0xC0, 0x60, 0x30,
  0x0E, 0x06, 0x01, 0x81, 0xC0, 0x38, 0x38, 0x06, 0x06, 0x00, 0xE0, 0xC0,
  0x18, 0x38, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x06, 0x18, 0x01, 0x87, 0x00,
  0x18, 0x60, 0x06, 0x18, 0x00, 0x63, 0x80, 0x18, 0xE0, 0x01, 0x8C, 0x00,
  0x63, 0x00, 0x06, 0x70, 0x01, 0x8C, 0x00, 0x19, 0x80, 0x06, 0x70, 0x00,
  0x6E, 0x00, 0x1D, 0x80, 0x01, 0xB0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x00, 0x38,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x60, 0x38, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00,
  0x39, 0x80, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x38, 0x07, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x01, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x0C, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x38, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x1C, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x06, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0xDC,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x8F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x17, 0xFF, 0xC0, 0x03, 0xF0, 0x1F,
  0x00, 0x7C, 0x00, 0x7F, 0x7E, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 13, 47, 14, 2, -47 },
  { 78, 15, 17, 20, 7, -47 },
  { 110, 35, 47, 35, 1, -47 },
  { 316, 29, 54, 31, 2, -50 },
  { 512, 37, 49, 45, 5, -48 },
  { 739, 33, 49, 37, 2, -48 },
  { 942, 6, 17, 11, 7, -47 },
  { 955, 19, 57, 16, 2, -47 },
  { 1091, 18, 57, 16, -4, -47 },
  { 1220, 24, 25, 30, 8, -50 },
  { 1295, 28, 31, 34, 4, -39 },
  { 1404, 9, 16, 12, -3, -7 },
  { 1422, 15, 2, 19, 2, -19 },
  { 1426, 4, 5, 13, 2, -5 },
  { 1429, 29, 47, 20, -3, -47 },
  { 1600, 28, 49, 32, 3, -48 },
  { 1772, 15, 47, 32, 9, -47 },
  { 1861, 30, 48, 32, 0, -48 },
  { 2041, 31, 49, 32, 0, -48 },
  { 2231, 30, 47, 32, 0, -47 },
  { 2408, 30, 48, 32, 1, -47 },
  { 2588, 29, 49, 32, 3, -48 },
  { 2766, 28, 47, 32, 5, -47 },
  { 2931, 29, 49, 32, 2, -48 },
  { 3109, 28, 49, 32, 2, -48 },
  { 3281, 11, 35, 13, 1, -35 },
  { 3330, 15, 44, 13, -3, -35 },
  { 3413, 27, 29, 34, 4, -38 },
  { 3511, 27, 16, 34, 4, -31 },
  { 3565, 28, 29, 34, 4, -38 },
  { 3667, 21, 48, 23, 4, -48 },
  { 3793, 43, 53, 48, 3, -47 },
  { 4078, 32, 47, 31, -4, -47 },
  { 4266, 32, 47, 34, 2, -47 },
  { 4454, 33, 49, 33, 4, -48 },
  { 4657, 34, 47, 38, 2, -47 },
  { 4857, 31, 47, 30, 2, -47 },
  { 5040, 31, 47, 28, 2, -47 },
  { 5223, 35, 49, 40, 4, -48 },
  { 5438, 38, 47, 39, 2, -47 },
  { 5662, 21, 47, 17, -1, -47 },
  { 5786, 25, 59, 14, -10, -47 },
  { 5971, 35, 47, 32, 2, -47 },
  { 6177, 21, 47, 28, 2, -47 },
  { 6301, 47, 47, 49, 2, -47 },
  { 6578, 38, 47, 40, 2, -47 },
  { 6802, 35, 49, 41, 4, -48 },
  { 7017, 31, 47, 32, 2, -47 },
  { 7200, 35, 59, 41, 4, -48 },
  { 7459, 31, 47, 33, 2, -47 },
  { 7642, 30, 49, 29, 0, -48 },
  { 7826, 27, 47, 28, 6, -47 },
  { 7985, 36, 48, 39, 4, -47 },
  { 8201, 30, 47, 31, 6, -47 },
  { 8378, 47, 47, 50, 7, -47 },
  { 8655, 37, 47, 28, -4, -47 },
  { 8873, 28, 47, 28, 6, -47 },
  { 9038, 34, 47, 30, -1, -47 },
  { 9238, 25, 57, 19, -1, -47 },
  { 9417, 10, 47, 21, 7, -47 },
  { 9476, 24, 57, 19, -4, -47 },
  { 9647, 28, 27, 33, 3, -47 },
  { 9742, 22, 2, 22, -5, 7 },
  { 9748, 7, 10, 15, 10, -50 },
  { 9757, 28, 37, 32, 3, -36 },
  { 9887, 29, 51, 33, 1, -50 },
  { 10072, 24, 37, 26, 3, -36 },
  { 10183, 32, 51, 33, 3, -50 },
  { 10387, 24, 37, 29, 3, -36 },
  { 10498, 33, 66, 16, -8, -50 },
  { 10771, 31, 52, 33, 1, -36 },
  { 10973, 28, 50, 32, 1, -50 },
  { 11148, 13, 48, 13, 1, -48 },
  { 11226, 23, 64, 13, -9, -48 },
  { 11410, 28, 50, 26, 1, -50 },
  { 11585, 14, 50, 13, 1, -50 },
  { 11673, 45, 36, 49, 1, -36 },
  { 11876, 28, 36, 32, 1, -36 },
  { 12002, 27, 37, 33, 3, -36 },
  { 12127, 32, 51, 33, -2, -36 },
  { 12331, 29, 51, 33, 3, -36 },
  { 12516, 23, 36, 22, 1, -36 },
  { 12620, 24, 37, 25, 0, -36 },
  { 12731, 16, 44, 18, 3, -43 },
  { 12819, 28, 36, 32, 3, -35 },
  { 12945, 25, 35, 24, 3, -35 },
  { 13055, 38, 35, 39, 4, -35 },
  { 13222, 30, 35, 26, -2, -35 },
  { 13354, 35, 51, 25, -7, -35 },
  { 13578, 26, 35, 24, -1, -35 },
  { 13692, 23, 57, 21, 2, -47 },
  { 13856, 3, 66, 31, 15, -50 },
  { 13881, 24, 58, 21, -4, -47 },
  { 14055, 28, 6, 34, 4, -26 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic66pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC66PT7B_H_
