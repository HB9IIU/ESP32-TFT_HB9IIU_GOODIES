#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC63PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x00, 0x18, 0x1C, 0xE0,
  0x73, 0x81, 0x8C, 0x06, 0x30, 0x38, 0xC0, 0xE7, 0x03, 0x18, 0x0C, 0x60,
  0x31, 0x81, 0xC6, 0x06, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x8C, 0x0C, 0x30,
  0x30, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30,
  0x07, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x30, 0x06, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x1C, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x18, 0x03, 0x80, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x38, 0x03,
  0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0xF8,
  0x41, 0xE0, 0x3C, 0x18, 0x04, 0x07, 0x03, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x30, 0x0C, 0x00, 0x0E, 0x01, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x38, 0x0C,
  0x00, 0x07, 0x01, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x38, 0x30, 0x00, 0x03, 0x86, 0x00, 0x00, 0x3C, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x02, 0xF8, 0x00, 0x00, 0xC7, 0x80, 0x00, 0x18, 0x78,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x60, 0x70, 0x00, 0x18, 0x0E, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x60, 0x18, 0x00, 0x0C, 0x07, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x30,
  0x38, 0x10, 0x04, 0x1E, 0x03, 0xE1, 0x8F, 0x80, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0C,
  0x03, 0xFF, 0x00, 0x01, 0x80, 0x70, 0x30, 0x00, 0x38, 0x06, 0x03, 0x80,
  0x03, 0x00, 0xE0, 0x18, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x0E, 0x01, 0x80,
  0x18, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x80,
  0x30, 0x01, 0x80, 0x30, 0x03, 0x00, 0x18, 0x06, 0x00, 0x70, 0x03, 0x80,
  0xE0, 0x07, 0x00, 0x38, 0x0C, 0x00, 0x60, 0x03, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x38, 0x00, 0x60, 0x03, 0x03, 0x00, 0x06, 0x00, 0x70, 0x60, 0x00,
  0x60, 0x06, 0x0E, 0x00, 0x0E, 0x00, 0x60, 0xC1, 0xFC, 0xE0, 0x0E, 0x1C,
  0x3F, 0xEE, 0x00, 0xC3, 0x87, 0x06, 0x60, 0x1C, 0x30, 0xE0, 0x76, 0x01,
  0x87, 0x1C, 0x03, 0x60, 0x38, 0x61, 0x80, 0x37, 0x07, 0x0C, 0x38, 0x03,
  0x3F, 0xE1, 0xC3, 0x00, 0x31, 0xFC, 0x18, 0x30, 0x03, 0x03, 0x03, 0x06,
  0x00, 0x30, 0x00, 0x70, 0x60, 0x03, 0x00, 0x06, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0xE0, 0x07, 0x00, 0x1C, 0x0C, 0x00, 0x60, 0x01, 0x80, 0xC0, 0x06,
  0x00, 0x30, 0x0C, 0x00, 0x60, 0x07, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x18,
  0x00, 0xC0, 0x18, 0x03, 0x80, 0x0C, 0x01, 0x80, 0x70, 0x00, 0xC0, 0x30,
  0x06, 0x00, 0x0C, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0xE0, 0x0C, 0x00, 0x07,
  0xBC, 0x01, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x01, 0x80, 0x38, 0x00, 0x07, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x60, 0x01, 0xC0, 0x00, 0xC0,
  0x03, 0x80, 0x01, 0x80, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x30, 0x07,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0xE3, 0xC0,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x38, 0xE0, 0x0E, 0x00, 0x63,
  0x80, 0x0C, 0x00, 0xC6, 0x00, 0x1C, 0x03, 0x9C, 0x00, 0x18, 0x06, 0x30,
  0x00, 0x38, 0x1C, 0xE0, 0x00, 0x38, 0x71, 0x80, 0x00, 0x70, 0xC3, 0x00,
  0x00, 0x73, 0x86, 0x00, 0x00, 0x6E, 0x0C, 0x00, 0x00, 0xF8, 0x18, 0x00,
  0x00, 0xF0, 0x30, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x1F, 0x81, 0xC0, 0x00, 0x73, 0x01, 0xC0, 0x03, 0xC7, 0x03, 0xC0, 0x1E,
  0x07, 0x03, 0xFF, 0xF8, 0x0E, 0x01, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x19, 0xCE, 0x63, 0x19, 0xCC, 0x63, 0x19, 0x8C, 0x63, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x3C, 0x0C, 0x00, 0x78, 0x30, 0x00, 0x78, 0xC0, 0x00,
  0x7B, 0x03, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xC0, 0x00, 0x19,
  0x00, 0x00, 0xC6, 0x00, 0x0E, 0x18, 0x00, 0x70, 0x30, 0x03, 0x80, 0xC0,
  0x1C, 0x01, 0x80, 0x60, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x0C,
  0x0E, 0x06, 0x03, 0x03, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0xEF, 0xEE,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0xF0, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x1C, 0x00,
  0x18, 0x06, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0x30, 0x70,
  0x00, 0x0C, 0x18, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x31,
  0xC0, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x18, 0x00, 0x00, 0xCE, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x60, 0x00, 0x03, 0x98,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x07,
  0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x0E, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x01, 0x80, 0x01, 0x80,
  0x60, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0xF0, 0x1C,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0xF0, 0x07, 0xC0, 0x7F, 0x03, 0x98, 0x3C, 0x61, 0xE1, 0x9E,
  0x0E, 0xF0, 0x39, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x10, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x20, 0x00, 0x0E, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x39, 0x80, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x30,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x60,
  0x0C, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x70, 0x06, 0x00, 0x07, 0x00, 0x30,
  0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x06, 0x00, 0x38, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x30,
  0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xCF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x04, 0x00, 0x07, 0x80,
  0x38, 0x00, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x3E, 0x00, 0x0C, 0x3F, 0xF8, 0x03, 0x8F,
  0xDF, 0x80, 0x67, 0x80, 0x78, 0x0D, 0xC0, 0x03, 0x83, 0xF0, 0x00, 0x70,
  0x7C, 0x00, 0x06, 0x0F, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x18, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x18,
  0x00, 0x07, 0x03, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x06, 0x00, 0x0E,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x01, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xC0, 0x3C, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x60, 0x18, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x70, 0x18, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70,
  0x38, 0x00, 0x06, 0x03, 0x80, 0x00, 0x60, 0x38, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0xC0, 0x18, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x00, 0x70, 0x0E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF0, 0xE0,
  0x00, 0x3C, 0x07, 0x00, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x38,
  0x00, 0x0C, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3C, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x03,
  0x80, 0x03, 0x00, 0x60, 0x00, 0x70, 0x1C, 0x00, 0x06, 0x07, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x0E, 0x18, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x83, 0x00, 0x01, 0xF0,
  0x70, 0x00, 0x7E, 0x0F, 0x00, 0x1D, 0x80, 0xF0, 0x07, 0x30, 0x0F, 0xCF,
  0xCE, 0x00, 0xFF, 0xE1, 0x80, 0x03, 0xE0, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x40, 0x0F, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x70,
  0x3C, 0x0F, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x03,
  0xC0, 0xF0, 0x3C, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x81, 0xC0, 0x3C, 0x10, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x7F, 0xC0, 0x0C, 0x30, 0x00, 0xFF, 0xF8, 0x06, 0x38, 0x00, 0xF0,
  0x18, 0x03, 0x18, 0x00, 0xE0, 0x0C, 0x01, 0x8C, 0x00, 0xE0, 0x0E, 0x00,
  0xCE, 0x00, 0xE0, 0x06, 0x00, 0x66, 0x00, 0x60, 0x03, 0x00, 0x37, 0x00,
  0x60, 0x01, 0x80, 0x1B, 0x80, 0x70, 0x01, 0xC0, 0x1D, 0x80, 0x30, 0x00,
  0xC0, 0x0E, 0xC0, 0x18, 0x00, 0x60, 0x06, 0xE0, 0x1C, 0x00, 0x30, 0x03,
  0x70, 0x0C, 0x00, 0x38, 0x01, 0xB0, 0x06, 0x00, 0x18, 0x01, 0xD8, 0x07,
  0x00, 0x0C, 0x00, 0xCC, 0x03, 0x80, 0x0E, 0x00, 0x66, 0x01, 0xC0, 0x07,
  0x00, 0x73, 0x00, 0xE0, 0x07, 0x00, 0x31, 0x80, 0x70, 0x03, 0x80, 0x38,
  0xC0, 0x38, 0x03, 0xC0, 0x18, 0x60, 0x1C, 0x01, 0xA0, 0x18, 0x30, 0x06,
  0x01, 0x98, 0x1C, 0x18, 0x03, 0x83, 0x8E, 0x3C, 0x0C, 0x00, 0xFF, 0x83,
  0xFC, 0x07, 0x00, 0x3F, 0x00, 0xF8, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x01, 0x80, 0x00, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x1C, 0x60,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x86, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x30, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x38,
  0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x07, 0x00, 0x30, 0x00, 0x38, 0x00,
  0xC0, 0x00, 0xE0, 0x03, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xE0, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x70, 0x00, 0x38, 0x03, 0x80, 0x00, 0x60, 0x0E, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x0C,
  0xE0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x06,
  0x00, 0x7F, 0x00, 0x18, 0x00, 0x1E, 0x00, 0x60, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x0C, 0x07, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x60, 0x38, 0x00, 0x01, 0x80,
  0xE0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x80, 0x30,
  0x00, 0x1C, 0x01, 0xC0, 0x01, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x60, 0x1F, 0xE0, 0x01, 0x80, 0x03, 0xC0, 0x0E, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0x80, 0x00, 0x0E, 0x06,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x1E,
  0x01, 0x80, 0x00, 0xF0, 0x06, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x40,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x18, 0x03, 0xF8, 0x00, 0x0C, 0x00, 0x1E, 0x00,
  0x06, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x38,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x7C, 0x00,
  0x38, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1E,
  0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x3F, 0xFC, 0x38, 0x00, 0x0F, 0xFF, 0x0E, 0x00, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x81, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x03, 0x80, 0x18, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x03, 0x80, 0x06, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x00, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x30, 0x03, 0x80, 0x00, 0x18, 0x03, 0x80, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03,
  0x03, 0x80, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x00, 0x73, 0xE0, 0x00, 0x00, 0x33, 0xB0, 0x00, 0x00,
  0x1B, 0x9C, 0x00, 0x00, 0x1F, 0x8E, 0x00, 0x00, 0x0F, 0x83, 0x00, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0x03, 0x80, 0x60, 0x00, 0x01, 0x80, 0x38, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x60, 0x03, 0x80,
  0x00, 0x30, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xB0, 0x03, 0x70, 0x00, 0x00, 0x1D, 0x80, 0x19, 0x80, 0x00, 0x00,
  0xCC, 0x00, 0xCC, 0x00, 0x00, 0x0E, 0xE0, 0x0E, 0x60, 0x00, 0x00, 0x67,
  0x00, 0x73, 0x00, 0x00, 0x07, 0x30, 0x03, 0x18, 0x00, 0x00, 0x71, 0x80,
  0x18, 0xC0, 0x00, 0x03, 0x1C, 0x00, 0xC7, 0x00, 0x00, 0x38, 0xE0, 0x0E,
  0x38, 0x00, 0x01, 0x86, 0x00, 0x70, 0xC0, 0x00, 0x1C, 0x30, 0x03, 0x06,
  0x00, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x00, 0x0E, 0x1C, 0x00, 0xC1, 0x80,
  0x00, 0x60, 0xE0, 0x0E, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x70, 0x60, 0x00,
  0x30, 0x30, 0x03, 0x03, 0x80, 0x03, 0x01, 0x80, 0x18, 0x1C, 0x00, 0x38,
  0x1C, 0x01, 0xC0, 0x60, 0x01, 0x80, 0xE0, 0x0E, 0x03, 0x00, 0x1C, 0x06,
  0x00, 0x60, 0x18, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x0E, 0x03, 0x80,
  0x18, 0x06, 0x00, 0x60, 0x1C, 0x01, 0xC0, 0x30, 0x07, 0x00, 0xC0, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0x60, 0x0E, 0x03, 0x80, 0x30, 0x03, 0x00,
  0x30, 0x18, 0x03, 0x80, 0x18, 0x01, 0x81, 0x80, 0x1C, 0x01, 0xC0, 0x0C,
  0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x0E,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x60, 0x03, 0x80, 0x18, 0x00, 0xE7, 0x00,
  0x1C, 0x01, 0xC0, 0x07, 0x30, 0x00, 0xC0, 0x0E, 0x00, 0x1B, 0x80, 0x06,
  0x00, 0x60, 0x00, 0xD8, 0x00, 0x30, 0x03, 0x00, 0x07, 0xC0, 0x03, 0x80,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x0C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x78, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x78, 0x00, 0x00, 0x60, 0x0F, 0xC0, 0x00, 0x06, 0x00, 0xCC, 0x00,
  0x00, 0x60, 0x0C, 0xC0, 0x00, 0x0E, 0x00, 0xCE, 0x00, 0x00, 0xE0, 0x1C,
  0x60, 0x00, 0x0C, 0x01, 0xC6, 0x00, 0x00, 0xC0, 0x18, 0x70, 0x00, 0x1C,
  0x01, 0x83, 0x00, 0x01, 0xC0, 0x18, 0x30, 0x00, 0x18, 0x03, 0x83, 0x80,
  0x01, 0x80, 0x38, 0x18, 0x00, 0x18, 0x03, 0x01, 0x80, 0x03, 0x80, 0x30,
  0x1C, 0x00, 0x38, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x70, 0x0C, 0x00, 0x30,
  0x07, 0x00, 0xE0, 0x03, 0x00, 0x60, 0x06, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x07, 0x00, 0xE0, 0x07, 0x00, 0x60, 0x0E, 0x00, 0x30, 0x06, 0x00, 0xE0,
  0x03, 0x00, 0xE0, 0x0C, 0x00, 0x38, 0x0E, 0x00, 0xC0, 0x01, 0x80, 0xE0,
  0x1C, 0x00, 0x18, 0x0C, 0x01, 0xC0, 0x01, 0xC0, 0xC0, 0x18, 0x00, 0x0C,
  0x1C, 0x01, 0x80, 0x00, 0xC1, 0xC0, 0x18, 0x00, 0x0E, 0x18, 0x03, 0x80,
  0x00, 0x61, 0x80, 0x38, 0x00, 0x06, 0x18, 0x03, 0x00, 0x00, 0x73, 0x80,
  0x30, 0x00, 0x03, 0x38, 0x03, 0x00, 0x00, 0x33, 0x00, 0x70, 0x00, 0x03,
  0xB0, 0x07, 0x00, 0x00, 0x1B, 0x00, 0x60, 0x00, 0x01, 0xF0, 0x06, 0x00,
  0x00, 0x1F, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x01, 0x80, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x03, 0x38,
  0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x03,
  0x70, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x74, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x18, 0x03, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x06, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x70, 0x18, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x18, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x03,
  0x00, 0x01, 0xC0, 0x18, 0x00, 0x3C, 0x01, 0xC0, 0x0F, 0xC0, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x03, 0x80, 0x00, 0x70, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x07, 0x01, 0x80, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00,
  0x0C, 0x70, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00,
  0x01, 0x9C, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x00, 0x0E, 0xC0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x03, 0x70, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x03, 0x80, 0x60, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x18, 0x03, 0xF0, 0x00, 0xC0,
  0x03, 0xC0, 0x06, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x00,
  0xE0, 0x18, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x06, 0x03, 0x80, 0x00, 0x70, 0x18, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x70, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x38, 0x03, 0x00, 0x07, 0x80, 0x18, 0x00, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x18, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0,
  0x01, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x70, 0x03, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0xF0, 0x07, 0x80,
  0x01, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xE0, 0x20, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x70, 0x18, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x70,
  0x18, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0x70, 0x18, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x38, 0x0C,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0C, 0x70,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x38, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x1C,
  0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x60, 0x0E,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x30, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00,
  0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xE0,
  0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x70, 0x00, 0x30, 0x03, 0x00, 0x01,
  0x80, 0x38, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x1C, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x31, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xB0, 0x00, 0x03, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xCC,
  0x00, 0x01, 0xB0, 0x00, 0x0E, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x63, 0x00,
  0x00, 0xEC, 0x00, 0x07, 0x18, 0x00, 0x06, 0x60, 0x00, 0x30, 0xC0, 0x00,
  0x73, 0x00, 0x03, 0x86, 0x00, 0x03, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x38,
  0xC0, 0x00, 0xC1, 0x80, 0x01, 0x86, 0x00, 0x0E, 0x0C, 0x00, 0x0C, 0x30,
  0x00, 0x60, 0x60, 0x00, 0xE1, 0x80, 0x07, 0x03, 0x00, 0x06, 0x0C, 0x00,
  0x30, 0x18, 0x00, 0x70, 0x60, 0x03, 0x80, 0xE0, 0x03, 0x03, 0x00, 0x1C,
  0x07, 0x00, 0x38, 0x18, 0x00, 0xC0, 0x38, 0x01, 0x80, 0xC0, 0x0E, 0x01,
  0xC0, 0x1C, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x30, 0x07, 0x00, 0x70,
  0x06, 0x01, 0x80, 0x30, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x1C, 0x03,
  0x00, 0x60, 0x18, 0x00, 0xE0, 0x38, 0x03, 0x00, 0xC0, 0x07, 0x01, 0x80,
  0x18, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0xC0, 0x60, 0x01, 0xC0, 0xC0, 0x06,
  0x07, 0x00, 0x0E, 0x0E, 0x00, 0x30, 0x30, 0x00, 0x70, 0x60, 0x01, 0x83,
  0x80, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x60, 0xC0,
  0x00, 0x61, 0x80, 0x03, 0x0E, 0x00, 0x03, 0x1C, 0x00, 0x18, 0x60, 0x00,
  0x18, 0xC0, 0x00, 0xC7, 0x00, 0x00, 0xCE, 0x00, 0x06, 0x30, 0x00, 0x06,
  0x60, 0x00, 0x33, 0x80, 0x00, 0x37, 0x00, 0x01, 0x98, 0x00, 0x01, 0xB0,
  0x00, 0x0C, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x6E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x70, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x01, 0x80,
  0xE0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00,
  0x0C, 0x38, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00, 0x0E, 0x60, 0x00,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x06, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x01, 0x80, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x39,
  0x80, 0x00, 0x1C, 0x60, 0x00, 0x06, 0x18, 0x00, 0x03, 0x87, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x38, 0x0C, 0x00, 0x1C, 0x03, 0x00,
  0x06, 0x00, 0xE0, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x06, 0x00, 0x70, 0x01,
  0x80, 0x38, 0x00, 0x70, 0x0C, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x03, 0x80,
  0x00, 0xC0, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x73, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x07, 0x03, 0x80,
  0x00, 0xC0, 0x30, 0x00, 0x38, 0x06, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x38, 0x03, 0x80, 0x03, 0x00,
  0xE0, 0x00, 0x60, 0x18, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x18, 0x38, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x31, 0x80, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xE0, 0xC1, 0xC1, 0x83, 0x83, 0x03, 0x06, 0x06, 0x04, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xFC, 0x30, 0x0F, 0x87, 0x8C, 0x07, 0x80, 0x63, 0x03, 0x80,
  0x0C, 0xC1, 0xC0, 0x01, 0x60, 0x60, 0x00, 0x78, 0x38, 0x00, 0x1E, 0x1C,
  0x00, 0x07, 0x86, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C,
  0x30, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x71, 0x80, 0x00,
  0x18, 0xE0, 0x00, 0x06, 0x38, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x07,
  0x83, 0x80, 0x03, 0x60, 0xE0, 0x01, 0xF8, 0x18, 0x00, 0xEC, 0x07, 0x00,
  0x73, 0x00, 0xE0, 0x38, 0xC0, 0x3F, 0xFC, 0x30, 0x03, 0xFC, 0x1C, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0xFC, 0x00, 0x1C, 0x3F, 0xF0, 0x01,
  0x87, 0x87, 0x80, 0x19, 0xE0, 0x1C, 0x01, 0x98, 0x00, 0xE0, 0x3B, 0x00,
  0x0E, 0x03, 0x60, 0x00, 0x60, 0x3E, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x70,
  0x38, 0x00, 0x07, 0x07, 0x80, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x18, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x30, 0x38,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0x60, 0x7C, 0x00, 0x0E, 0x06, 0x60, 0x01,
  0xC0, 0x66, 0x00, 0x38, 0x06, 0x30, 0x0F, 0x00, 0x63, 0xFF, 0xE0, 0x0C,
  0x0F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0xF0, 0x0F, 0xC1, 0xC0, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x60, 0x1F,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0x80, 0x00, 0xFC, 0x06, 0x00, 0x0F, 0xFC, 0x18, 0x00, 0xF8, 0x78, 0xE0,
  0x07, 0x80, 0x73, 0x00, 0x38, 0x00, 0x6C, 0x01, 0xC0, 0x01, 0xB0, 0x06,
  0x00, 0x02, 0xC0, 0x38, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x38, 0x06, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x1C, 0x03, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x03, 0xC0, 0x30, 0x00,
  0x0F, 0x00, 0xC0, 0x00, 0x7C, 0x03, 0x80, 0x03, 0xE0, 0x0E, 0x00, 0x1D,
  0x80, 0x18, 0x00, 0x66, 0x00, 0x70, 0x07, 0x18, 0x00, 0xE0, 0x38, 0x60,
  0x03, 0xFF, 0xC3, 0x00, 0x03, 0xFE, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xE1, 0xE0, 0x0F, 0x00, 0xE0,
  0x3C, 0x00, 0xC0, 0xF0, 0x01, 0xC1, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x1C,
  0x00, 0x0E, 0x38, 0x00, 0x18, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x00,
  0x03, 0x8E, 0x00, 0x1E, 0x18, 0x00, 0x78, 0x30, 0x0F, 0xC0, 0x7F, 0xFE,
  0x01, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x08, 0x0E, 0x00, 0x60, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0x82, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x87, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0xC0, 0x0F, 0x87, 0x86, 0x00, 0xF0, 0x06, 0x70, 0x0E, 0x00, 0x1B, 0x00,
  0xE0, 0x00, 0xD8, 0x06, 0x00, 0x02, 0xC0, 0x70, 0x00, 0x1E, 0x07, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x18, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x07, 0x03, 0x00, 0x00, 0x38, 0x18, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x0F, 0x01,
  0x80, 0x00, 0x78, 0x0C, 0x00, 0x07, 0xC0, 0x60, 0x00, 0x7C, 0x03, 0x80,
  0x07, 0x60, 0x0C, 0x00, 0x33, 0x00, 0x70, 0x07, 0x38, 0x01, 0xC0, 0x71,
  0xC0, 0x0F, 0xFF, 0x0C, 0x00, 0x1F, 0xF0, 0x60, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x40, 0x01, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x3F, 0x80, 0x0E, 0x1F, 0xF8, 0x01, 0x87, 0x87,
  0x80, 0x33, 0x80, 0x38, 0x06, 0xE0, 0x03, 0x01, 0xD8, 0x00, 0x70, 0x36,
  0x00, 0x0E, 0x07, 0x80, 0x01, 0xC0, 0xF0, 0x00, 0x38, 0x1C, 0x00, 0x07,
  0x07, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x03, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00,
  0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x0E, 0x0E,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x06, 0x06, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x06, 0x07, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x18, 0x18, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x01, 0x07, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x07, 0x01, 0x80, 0x03, 0x80,
  0x60, 0x01, 0xC0, 0x18, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x00, 0xC0, 0x1C, 0x00, 0x30, 0x0E, 0x00, 0x0C, 0x07, 0x00, 0x07, 0x03,
  0x80, 0x01, 0x81, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x0E,
  0x38, 0x00, 0x03, 0x8F, 0x00, 0x00, 0xC7, 0xC0, 0x00, 0x33, 0x30, 0x00,
  0x0D, 0x8E, 0x00, 0x07, 0xC3, 0x80, 0x01, 0xE0, 0x60, 0x00, 0x70, 0x1C,
  0x00, 0x18, 0x03, 0x00, 0x06, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0x70, 0x07, 0x00, 0x0C, 0x01,
  0xC0, 0x03, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x1C, 0x06, 0x00, 0x07,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x30, 0x7F, 0xC0, 0x3F, 0xE0, 0x06, 0x3C, 0x7C,
  0x1E, 0x1E, 0x00, 0xCE, 0x03, 0x87, 0x00, 0xE0, 0x1B, 0x80, 0x39, 0xC0,
  0x0C, 0x06, 0xC0, 0x03, 0x70, 0x01, 0xC0, 0xD8, 0x00, 0x6C, 0x00, 0x38,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x60, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x83, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x18, 0x00, 0x0C,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0x81, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x30,
  0x00, 0x18, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x38, 0x00, 0x0C, 0x00, 0x06,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x00, 0x07, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0xE0, 0x00,
  0x30, 0x00, 0x18, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x30, 0x7F, 0xE0, 0x06, 0x1E, 0x1E, 0x00,
  0xCF, 0x00, 0xE0, 0x1B, 0x80, 0x0C, 0x07, 0x60, 0x01, 0xC0, 0xD8, 0x00,
  0x38, 0x1E, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x1C, 0x1C,
  0x00, 0x03, 0x03, 0x80, 0x00, 0x60, 0x70, 0x00, 0x0C, 0x0C, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x30, 0x30, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x30,
  0x30, 0x00, 0x06, 0x06, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38, 0x38, 0x00,
  0x07, 0x07, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x07, 0x07,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x3E, 0x1F, 0x00, 0x3C, 0x01, 0xC0, 0x38, 0x00, 0x70,
  0x38, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x67, 0x00, 0x00, 0x37, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x19, 0x80, 0x00, 0x1C, 0xC0,
  0x00, 0x0E, 0x60, 0x00, 0x06, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x06,
  0x00, 0x03, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x78, 0x07, 0x80,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x60, 0xFF, 0xC0, 0x00, 0xC3, 0xC3, 0xC0, 0x01, 0x8E,
  0x01, 0xC0, 0x03, 0x30, 0x01, 0xC0, 0x0E, 0xC0, 0x03, 0x80, 0x1B, 0x00,
  0x03, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x78, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x1C, 0x03, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x18, 0x07, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x06, 0x00, 0x78,
  0x00, 0x1C, 0x01, 0xD0, 0x00, 0x70, 0x03, 0x30, 0x01, 0xC0, 0x06, 0x30,
  0x0F, 0x00, 0x0C, 0x7F, 0xFC, 0x00, 0x38, 0x3F, 0xE0, 0x00, 0x70, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xFE, 0x0C, 0x03, 0xE1, 0xE1, 0x80, 0xF0, 0x0E, 0x70, 0x38, 0x00,
  0xEC, 0x0E, 0x00, 0x0D, 0x81, 0x80, 0x00, 0xB0, 0x70, 0x00, 0x1E, 0x1C,
  0x00, 0x03, 0x83, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x18,
  0x60, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x1C, 0x30, 0x00,
  0x07, 0x06, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x3C, 0x18, 0x00, 0x07, 0x83,
  0x00, 0x01, 0xF0, 0x70, 0x00, 0x7C, 0x0E, 0x00, 0x0D, 0x80, 0xC0, 0x03,
  0x30, 0x1C, 0x00, 0xCE, 0x01, 0xC0, 0x71, 0xC0, 0x3F, 0xFC, 0x30, 0x01,
  0xFF, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x06, 0x0F, 0xE0,
  0x18, 0xF8, 0x80, 0x67, 0x00, 0x01, 0xB8, 0x00, 0x0C, 0xC0, 0x00, 0x36,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xC1,
  0xF8, 0x1C, 0x00, 0x20, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x20, 0x00, 0x70, 0x70, 0x03, 0xC0,
  0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x3F, 0xFF, 0x3F, 0xFF, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x06, 0x0C, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C,
  0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x70, 0x60, 0x00, 0x1C,
  0x38, 0x00, 0x06, 0x0E, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x70, 0x60, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x83,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x78, 0x30, 0x00, 0x1E, 0x0C, 0x00, 0x0F,
  0x83, 0x00, 0x06, 0xC0, 0xE0, 0x03, 0xB0, 0x38, 0x01, 0xCC, 0x07, 0x00,
  0xE3, 0x01, 0xFF, 0xF1, 0x80, 0x1F, 0xF0, 0x60, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x73, 0x00, 0x00, 0xC6,
  0x00, 0x03, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x30, 0x60,
  0x00, 0xE0, 0xE0, 0x01, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x0C, 0x03, 0x00,
  0x38, 0x06, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x0E,
  0x00, 0x60, 0x18, 0x00, 0xC0, 0x70, 0x01, 0xC0, 0xC0, 0x03, 0x83, 0x80,
  0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0C, 0x70, 0x00, 0x18, 0xC0, 0x00,
  0x33, 0x80, 0x00, 0x66, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xB0, 0x00, 0x03,
  0x60, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x06, 0xC0, 0x01, 0xE0, 0x00,
  0xEC, 0x00, 0x1E, 0x00, 0x0C, 0xC0, 0x03, 0xE0, 0x01, 0xCC, 0x00, 0x36,
  0x00, 0x18, 0xC0, 0x07, 0x60, 0x03, 0x8C, 0x00, 0x66, 0x00, 0x30, 0xC0,
  0x0E, 0x60, 0x03, 0x0C, 0x00, 0xC7, 0x00, 0x70, 0xC0, 0x0C, 0x70, 0x06,
  0x0C, 0x01, 0x87, 0x00, 0xE0, 0xC0, 0x18, 0x30, 0x0C, 0x0C, 0x03, 0x03,
  0x01, 0xC0, 0xC0, 0x30, 0x30, 0x18, 0x0C, 0x07, 0x03, 0x03, 0x80, 0xC0,
  0x60, 0x30, 0x30, 0x0C, 0x0E, 0x03, 0x03, 0x00, 0xE0, 0xC0, 0x30, 0x70,
  0x0E, 0x1C, 0x03, 0x06, 0x00, 0xE1, 0x80, 0x30, 0xE0, 0x0E, 0x38, 0x03,
  0x0C, 0x00, 0xE3, 0x00, 0x31, 0xC0, 0x0E, 0x70, 0x03, 0x18, 0x00, 0xE6,
  0x00, 0x31, 0x80, 0x0E, 0xE0, 0x03, 0x30, 0x00, 0x6C, 0x00, 0x33, 0x00,
  0x06, 0xC0, 0x03, 0x70, 0x00, 0x78, 0x00, 0x36, 0x00, 0x07, 0x80, 0x03,
  0x60, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x06, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x38, 0x00, 0x38,
  0x03, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0xC1, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0xCE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x73, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x03, 0x83, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x38,
  0x03, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x1C, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x60, 0x0E, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00,
  0xE0, 0x01, 0x80, 0x00, 0x38, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x18, 0x07, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x01, 0x83,
  0x80, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x07,
  0x18, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x0D, 0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x20, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x0F,
  0xE0, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x02, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x1F,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x5F,
  0xFE, 0x00, 0x1F, 0x03, 0xE0, 0x1F, 0x00, 0x3F, 0x3E, 0x80, 0x03, 0xFF,
  0x00, 0x00, 0x1E, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 12, 45, 14, 2, -45 },
  { 69, 14, 16, 19, 7, -45 },
  { 97, 33, 45, 33, 1, -45 },
  { 283, 27, 52, 30, 2, -48 },
  { 459, 36, 47, 43, 4, -46 },
  { 671, 31, 47, 35, 2, -46 },
  { 854, 5, 16, 11, 7, -45 },
  { 864, 18, 55, 16, 2, -45 },
  { 988, 18, 55, 16, -4, -45 },
  { 1112, 22, 24, 29, 8, -48 },
  { 1178, 26, 29, 32, 4, -37 },
  { 1273, 9, 15, 12, -3, -7 },
  { 1290, 14, 2, 19, 2, -18 },
  { 1294, 4, 4, 13, 2, -4 },
  { 1296, 28, 45, 20, -3, -45 },
  { 1454, 26, 47, 30, 3, -46 },
  { 1607, 14, 45, 30, 9, -45 },
  { 1686, 29, 46, 30, 0, -46 },
  { 1853, 29, 47, 30, 0, -46 },
  { 2024, 29, 45, 30, 0, -45 },
  { 2188, 29, 46, 30, 1, -45 },
  { 2355, 27, 47, 30, 3, -46 },
  { 2514, 26, 45, 30, 5, -45 },
  { 2661, 28, 47, 30, 2, -46 },
  { 2826, 27, 47, 30, 2, -46 },
  { 2985, 10, 34, 13, 1, -34 },
  { 3028, 14, 42, 13, -3, -34 },
  { 3102, 26, 28, 32, 4, -37 },
  { 3193, 26, 15, 32, 4, -30 },
  { 3242, 26, 28, 32, 4, -37 },
  { 3333, 20, 46, 22, 4, -46 },
  { 3448, 41, 51, 45, 3, -45 },
  { 3710, 30, 45, 30, -4, -45 },
  { 3879, 30, 45, 33, 2, -45 },
  { 4048, 31, 47, 32, 4, -46 },
  { 4231, 33, 45, 37, 2, -45 },
  { 4417, 29, 45, 29, 2, -45 },
  { 4581, 29, 45, 27, 2, -45 },
  { 4745, 34, 47, 38, 4, -46 },
  { 4945, 36, 45, 38, 2, -45 },
  { 5148, 20, 45, 16, -1, -45 },
  { 5261, 24, 56, 13, -10, -45 },
  { 5429, 33, 45, 30, 2, -45 },
  { 5615, 20, 45, 27, 2, -45 },
  { 5728, 45, 45, 46, 2, -45 },
  { 5982, 36, 45, 38, 2, -45 },
  { 6185, 33, 47, 39, 4, -46 },
  { 6379, 29, 45, 31, 2, -45 },
  { 6543, 33, 57, 39, 4, -46 },
  { 6779, 29, 45, 31, 2, -45 },
  { 6943, 29, 47, 28, 0, -46 },
  { 7114, 26, 45, 27, 6, -45 },
  { 7261, 34, 46, 37, 4, -45 },
  { 7457, 29, 45, 30, 6, -45 },
  { 7621, 45, 45, 47, 7, -45 },
  { 7875, 36, 45, 27, -4, -45 },
  { 8078, 26, 45, 27, 6, -45 },
  { 8225, 32, 45, 29, -1, -45 },
  { 8405, 24, 55, 18, -1, -45 },
  { 8570, 10, 45, 20, 6, -45 },
  { 8627, 23, 55, 18, -4, -45 },
  { 8786, 27, 26, 31, 2, -45 },
  { 8874, 21, 2, 21, -5, 6 },
  { 8880, 7, 10, 14, 9, -48 },
  { 8889, 26, 35, 31, 3, -34 },
  { 9003, 28, 49, 32, 1, -48 },
  { 9175, 22, 35, 25, 3, -34 },
  { 9272, 30, 49, 32, 3, -48 },
  { 9456, 23, 35, 27, 3, -34 },
  { 9557, 32, 63, 15, -8, -48 },
  { 9809, 29, 49, 32, 1, -34 },
  { 9987, 27, 48, 31, 1, -48 },
  { 10149, 13, 45, 12, 1, -45 },
  { 10223, 23, 60, 13, -9, -45 },
  { 10396, 26, 48, 25, 1, -48 },
  { 10552, 13, 48, 12, 1, -48 },
  { 10630, 43, 34, 47, 1, -34 },
  { 10813, 27, 34, 31, 1, -34 },
  { 10928, 25, 35, 31, 3, -34 },
  { 11038, 31, 49, 32, -2, -34 },
  { 11228, 27, 49, 32, 3, -34 },
  { 11394, 22, 34, 21, 1, -34 },
  { 11488, 23, 35, 24, 0, -34 },
  { 11589, 16, 42, 17, 2, -41 },
  { 11673, 26, 34, 31, 3, -33 },
  { 11784, 23, 33, 23, 3, -33 },
  { 11879, 36, 33, 38, 4, -33 },
  { 12028, 29, 33, 25, -2, -33 },
  { 12148, 34, 48, 24, -7, -33 },
  { 12352, 25, 33, 23, -1, -33 },
  { 12456, 22, 55, 20, 2, -45 },
  { 12608, 2, 63, 29, 15, -48 },
  { 12624, 22, 55, 20, -3, -45 },
  { 12776, 26, 6, 32, 4, -25 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic63pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC63PT7B_H_
