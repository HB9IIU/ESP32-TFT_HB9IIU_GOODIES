#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC43PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03,
  0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x07, 0x03, 0x00,
  0x21, 0xB0, 0xD8, 0x6C, 0x24, 0x12, 0x1B, 0x0D, 0x84, 0x82, 0x41, 0x21,
  0x80, 0x00, 0x10, 0x10, 0x00, 0x40, 0x40, 0x03, 0x03, 0x00, 0x08, 0x08,
  0x00, 0x20, 0x20, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x10, 0x10, 0x00,
  0x40, 0xC0, 0x03, 0x03, 0x01, 0xFF, 0xFF, 0xC0, 0x20, 0x20, 0x01, 0x81,
  0x80, 0x06, 0x04, 0x00, 0x10, 0x10, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00,
  0x08, 0x08, 0x00, 0x20, 0x20, 0x01, 0x81, 0x80, 0xFF, 0xFF, 0xF0, 0x10,
  0x10, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x08, 0x08, 0x00, 0x20, 0x60,
  0x01, 0x81, 0x80, 0x04, 0x04, 0x00, 0x10, 0x10, 0x00, 0xC0, 0xC0, 0x03,
  0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x07, 0xF8, 0x03, 0xDF, 0xC0, 0xC2, 0x10, 0x30, 0xC0, 0x0C, 0x10,
  0x01, 0x82, 0x00, 0x30, 0x40, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x40,
  0x01, 0x88, 0x00, 0x19, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x26, 0x00, 0x04, 0x60, 0x01, 0x86, 0x00, 0x20, 0xC0, 0x04, 0x18,
  0x00, 0x83, 0x00, 0x10, 0x60, 0x06, 0x08, 0x00, 0x83, 0x08, 0x10, 0xC1,
  0xFB, 0xF0, 0x0F, 0xF0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x07, 0xC0, 0x06, 0x0C, 0xE0, 0x04, 0x18,
  0x60, 0x0C, 0x30, 0x20, 0x18, 0x30, 0x20, 0x10, 0x20, 0x20, 0x30, 0x60,
  0x20, 0x60, 0x60, 0x20, 0x40, 0x40, 0x20, 0xC0, 0xC0, 0x61, 0x80, 0xC0,
  0x61, 0x00, 0xC0, 0x43, 0x00, 0xC0, 0x42, 0x1C, 0xC0, 0xC6, 0x7E, 0xC0,
  0x8C, 0xC3, 0xC1, 0x88, 0x81, 0xC3, 0x19, 0x81, 0x66, 0x31, 0x01, 0x3C,
  0x23, 0x01, 0x00, 0x63, 0x01, 0x00, 0xC2, 0x01, 0x00, 0x82, 0x03, 0x01,
  0x86, 0x03, 0x03, 0x06, 0x03, 0x02, 0x06, 0x02, 0x06, 0x06, 0x06, 0x0C,
  0x06, 0x06, 0x08, 0x06, 0x0C, 0x18, 0x06, 0x0C, 0x30, 0x03, 0x18, 0x60,
  0x03, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x3F, 0x00, 0x01, 0x8E, 0x00, 0x0C,
  0x18, 0x00, 0x60, 0x30, 0x01, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x0C,
  0x00, 0xC0, 0x30, 0x03, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x10, 0x30, 0x00,
  0x63, 0x80, 0x01, 0x98, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xF8,
  0x00, 0x06, 0x20, 0x00, 0x70, 0xC0, 0x33, 0x81, 0x81, 0x8C, 0x06, 0x06,
  0x60, 0x0C, 0x31, 0x00, 0x30, 0xCC, 0x00, 0x66, 0x30, 0x01, 0x90, 0xC0,
  0x03, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x38, 0x30, 0x01, 0xB0, 0x60, 0x0C,
  0xC0, 0xE1, 0xE1, 0x81, 0xFE, 0x06, 0x00, 0x2D, 0xB4, 0xB6, 0x92, 0x00,
  0x00, 0x18, 0x01, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x40, 0x80, 0xE0, 0x80, 0x39,
  0x80, 0x0F, 0x0F, 0x03, 0xFF, 0x03, 0x80, 0x04, 0x80, 0x08, 0xC0, 0x30,
  0x40, 0x60, 0x60, 0x20, 0x60, 0x00, 0x30, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x30, 0xC6, 0x18, 0xC3,
  0x08, 0x61, 0x08, 0x00, 0xFF, 0xC0, 0x7F, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x79, 0xC0, 0x38, 0x18, 0x18, 0x06, 0x06, 0x00, 0xC3, 0x00, 0x30,
  0x80, 0x0C, 0x60, 0x03, 0x10, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0x80,
  0x03, 0x60, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x09, 0x00, 0x02, 0x40, 0x01,
  0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x04, 0xC0, 0x03, 0x30, 0x00, 0xCC,
  0x00, 0x23, 0x00, 0x18, 0xC0, 0x04, 0x30, 0x03, 0x0C, 0x01, 0x81, 0x80,
  0x60, 0x60, 0x30, 0x0C, 0x38, 0x01, 0xFC, 0x00, 0x00, 0xC0, 0x70, 0x78,
  0x32, 0x39, 0x9C, 0x6C, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x00,
  0x3F, 0x00, 0x1F, 0x3C, 0x03, 0x80, 0xE0, 0x20, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0x3C, 0x07, 0x80,
  0x60, 0x20, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x80, 0x0E, 0x0E, 0x03, 0xC0, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xA0, 0x00, 0x1E, 0x00, 0x03, 0x60,
  0x00, 0x64, 0x00, 0x0C, 0x40, 0x00, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x0C,
  0x00, 0x60, 0x80, 0x04, 0x08, 0x00, 0xC1, 0x80, 0x18, 0x18, 0x03, 0x01,
  0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x03, 0x03, 0x00,
  0x20, 0x60, 0x02, 0x04, 0x00, 0x60, 0xFF, 0xFF, 0xE0, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x3F, 0xF0, 0x03, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x08,
  0x01, 0xC1, 0xC0, 0xE0, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0x88,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x0F, 0x00, 0x4F, 0xF8, 0x1B, 0x01, 0x83, 0xC0, 0x18, 0x70, 0x03, 0x0C,
  0x00, 0x23, 0x80, 0x04, 0x60, 0x00, 0x8C, 0x00, 0x11, 0x80, 0x02, 0x30,
  0x00, 0xC6, 0x00, 0x18, 0xC0, 0x02, 0x18, 0x00, 0xC1, 0x00, 0x18, 0x30,
  0x06, 0x06, 0x01, 0x80, 0x70, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xCF,
  0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1C, 0x70,
  0x0E, 0x03, 0x01, 0x80, 0x30, 0x60, 0x06, 0x0C, 0x00, 0x41, 0x00, 0x08,
  0x20, 0x03, 0x04, 0x00, 0x60, 0xC0, 0x08, 0x18, 0x03, 0x01, 0x80, 0xC0,
  0x30, 0x30, 0x03, 0x98, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0x1C, 0x01,
  0x81, 0xC0, 0xE0, 0x18, 0x18, 0x01, 0x86, 0x00, 0x11, 0x80, 0x03, 0x30,
  0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x23, 0x00, 0x0C, 0x30,
  0x03, 0x07, 0x00, 0xE0, 0x70, 0x78, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x3C, 0xE0, 0x0C, 0x06, 0x03, 0x00, 0x60, 0x40, 0x0C, 0x18, 0x00, 0x82,
  0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x62, 0x00, 0x0C, 0x40, 0x01, 0x98,
  0x00, 0x33, 0x00, 0x0C, 0x20, 0x01, 0x84, 0x00, 0x70, 0xC0, 0x1E, 0x0C,
  0x06, 0xC1, 0xE3, 0x90, 0x0F, 0xC6, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x01, 0x03, 0x80, 0x3F, 0xC0, 0x00, 0x06,
  0x1C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x1C, 0x30, 0x00, 0x00, 0xC0, 0x70, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01,
  0x80, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0C, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x08, 0x00, 0x00, 0x07, 0xE0,
  0x79, 0xE1, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x38, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x30,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x03, 0x08, 0x00, 0x00,
  0x31, 0x80, 0x3F, 0x03, 0x10, 0x0F, 0x38, 0x33, 0x01, 0x81, 0x81, 0x20,
  0x30, 0x10, 0x16, 0x06, 0x03, 0x03, 0x60, 0x40, 0x30, 0x34, 0x0C, 0x02,
  0x03, 0xC0, 0x80, 0x20, 0x3C, 0x08, 0x06, 0x02, 0xC1, 0x80, 0x60, 0x6C,
  0x18, 0x04, 0x06, 0x81, 0x80, 0xC0, 0x48, 0x18, 0x0C, 0x0C, 0x81, 0x81,
  0xC0, 0x88, 0x18, 0x34, 0x18, 0xC0, 0xC6, 0x63, 0x0C, 0x07, 0xC3, 0xE0,
  0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x40,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x28, 0x00, 0x06, 0xC0, 0x00, 0x4C, 0x00,
  0x0C, 0xC0, 0x00, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x0C, 0x00, 0x30, 0x40,
  0x02, 0x04, 0x00, 0x60, 0x40, 0x04, 0x04, 0x00, 0xC0, 0x40, 0x08, 0x06,
  0x01, 0x80, 0x60, 0x10, 0x06, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x06, 0x00,
  0x60, 0xC0, 0x06, 0x0C, 0x00, 0x21, 0x80, 0x02, 0x18, 0x00, 0x23, 0x00,
  0x02, 0x30, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x30, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xC0, 0x1C, 0x06, 0x00,
  0x60, 0x30, 0x01, 0x81, 0x00, 0x0C, 0x08, 0x00, 0x60, 0xC0, 0x03, 0x06,
  0x00, 0x18, 0x30, 0x00, 0x81, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x06,
  0x06, 0x00, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x18, 0x01, 0x80, 0xC0,
  0x06, 0x06, 0x00, 0x30, 0x20, 0x00, 0xC1, 0x00, 0x06, 0x18, 0x00, 0x30,
  0xC0, 0x01, 0x86, 0x00, 0x08, 0x20, 0x00, 0xC1, 0x00, 0x06, 0x18, 0x00,
  0x60, 0xC0, 0x07, 0x06, 0x00, 0x70, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x03, 0xE7, 0xC0, 0x70, 0x04, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x03, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x0C, 0x03, 0x80, 0x18, 0x01, 0x80, 0x30, 0x01,
  0x80, 0x40, 0x01, 0x80, 0x80, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x04,
  0x0C, 0x00, 0x0C, 0x10, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61,
  0x80, 0x00, 0xC3, 0x00, 0x01, 0x04, 0x00, 0x02, 0x18, 0x00, 0x0C, 0x30,
  0x00, 0x18, 0x60, 0x00, 0x30, 0x80, 0x00, 0xC1, 0x00, 0x01, 0x86, 0x00,
  0x03, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x20, 0x00, 0x60, 0xC0, 0x01,
  0x81, 0x80, 0x06, 0x03, 0x00, 0x38, 0x06, 0x01, 0xE0, 0x0F, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x1F, 0xFF, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xF9, 0xFC, 0x07, 0x00,
  0x10, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x04, 0xC0, 0x0F, 0xF1, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC4, 0x00,
  0x01, 0x88, 0x00, 0x03, 0x18, 0x00, 0x04, 0x30, 0x00, 0x18, 0x60, 0x00,
  0x30, 0xC0, 0x00, 0x60, 0x80, 0x00, 0x81, 0x80, 0x01, 0x01, 0x80, 0x06,
  0x03, 0x80, 0x0C, 0x03, 0xC0, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x40, 0x60, 0x00, 0x60, 0x30,
  0x00, 0x30, 0x10, 0x00, 0x18, 0x08, 0x00, 0x08, 0x0C, 0x00, 0x04, 0x06,
  0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x00, 0x01, 0x81, 0x80, 0x00, 0x80,
  0xC0, 0x00, 0x40, 0x60, 0x00, 0x60, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x18, 0x00, 0x08, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x02, 0x00, 0x03,
  0x01, 0x00, 0x01, 0x01, 0x80, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00,
  0x60, 0x20, 0x00, 0x30, 0x30, 0x00, 0x10, 0x18, 0x00, 0x08, 0x0C, 0x00,
  0x0C, 0x06, 0x00, 0x06, 0x02, 0x00, 0x03, 0x03, 0x00, 0x01, 0x00, 0x01,
  0xFC, 0x0F, 0xE0, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x07, 0xF0, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x06, 0x02, 0x00, 0x18, 0x0C,
  0x00, 0x60, 0x18, 0x01, 0x80, 0x30, 0x06, 0x00, 0x40, 0x18, 0x00, 0x80,
  0x60, 0x03, 0x01, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x10, 0x60,
  0x00, 0x61, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x98, 0x00, 0x02, 0x78, 0x00,
  0x05, 0xB0, 0x00, 0x1E, 0x20, 0x00, 0x38, 0x60, 0x00, 0x60, 0xC0, 0x00,
  0x80, 0x80, 0x01, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x18,
  0x06, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x18, 0x06, 0x00, 0x30, 0x08, 0x00, 0x20, 0x30, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x03, 0xC0, 0x58, 0x00, 0x0D, 0x80, 0xB0, 0x00, 0x1A, 0x03, 0x20, 0x00,
  0x64, 0x06, 0x40, 0x00, 0x98, 0x0C, 0x80, 0x03, 0x30, 0x11, 0x00, 0x04,
  0x60, 0x63, 0x00, 0x18, 0x80, 0xC6, 0x00, 0x61, 0x01, 0x8C, 0x00, 0xC6,
  0x02, 0x18, 0x03, 0x0C, 0x04, 0x10, 0x06, 0x18, 0x18, 0x20, 0x18, 0x20,
  0x30, 0x40, 0x20, 0xC0, 0x60, 0x80, 0xC1, 0x80, 0x81, 0x81, 0x03, 0x01,
  0x03, 0x06, 0x04, 0x06, 0x06, 0x08, 0x08, 0x0C, 0x0C, 0x30, 0x30, 0x18,
  0x08, 0xC0, 0x60, 0x20, 0x11, 0x80, 0xC0, 0xC0, 0x26, 0x01, 0x01, 0x80,
  0x4C, 0x02, 0x03, 0x00, 0xF0, 0x0C, 0x06, 0x01, 0xC0, 0x18, 0x08, 0x03,
  0x80, 0x30, 0x30, 0x06, 0x00, 0x40, 0x00, 0x01, 0x80, 0x01, 0x80, 0xC0,
  0x00, 0xC0, 0xE0, 0x00, 0x60, 0x78, 0x00, 0x20, 0x3C, 0x00, 0x10, 0x12,
  0x00, 0x18, 0x09, 0x80, 0x0C, 0x0C, 0xC0, 0x06, 0x06, 0x20, 0x02, 0x03,
  0x18, 0x01, 0x01, 0x0C, 0x01, 0x81, 0x82, 0x00, 0xC0, 0xC1, 0x80, 0x60,
  0x60, 0xC0, 0x20, 0x20, 0x20, 0x30, 0x10, 0x18, 0x18, 0x18, 0x0C, 0x0C,
  0x0C, 0x02, 0x06, 0x06, 0x01, 0x82, 0x02, 0x00, 0xC3, 0x01, 0x00, 0x21,
  0x81, 0x80, 0x18, 0xC0, 0xC0, 0x0C, 0x40, 0x60, 0x06, 0x20, 0x20, 0x01,
  0xB0, 0x30, 0x00, 0xD8, 0x18, 0x00, 0x6C, 0x0C, 0x00, 0x1C, 0x06, 0x00,
  0x0E, 0x02, 0x00, 0x07, 0x03, 0x00, 0x01, 0x80, 0x00, 0x3F, 0x80, 0x03,
  0xC7, 0x80, 0x18, 0x03, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x18, 0x30, 0x00,
  0x31, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x30, 0x00, 0x04, 0xC0, 0x00, 0x16,
  0x00, 0x00, 0x58, 0x00, 0x01, 0x60, 0x00, 0x05, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xB0, 0x00, 0x06, 0x80, 0x00, 0x1A, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30,
  0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00,
  0x60, 0x30, 0x07, 0x00, 0x70, 0x78, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xF8, 0x03, 0x00, 0xE0, 0x30, 0x06, 0x03, 0x00, 0x30, 0x20,
  0x03, 0x02, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x04,
  0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0xC0,
  0x80, 0x38, 0x18, 0x3F, 0x01, 0xFF, 0x80, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xC7, 0x80, 0x18, 0x03,
  0x00, 0xC0, 0x06, 0x06, 0x00, 0x18, 0x30, 0x00, 0x31, 0x80, 0x00, 0xC6,
  0x00, 0x03, 0x30, 0x00, 0x04, 0xC0, 0x00, 0x16, 0x00, 0x00, 0x58, 0x00,
  0x01, 0x60, 0x00, 0x05, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0x80,
  0x00, 0x1A, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00,
  0x63, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x30, 0x07, 0x00,
  0x70, 0x78, 0x00, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0x00, 0xE0, 0x30, 0x06, 0x03,
  0x00, 0x30, 0x20, 0x03, 0x02, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30,
  0x60, 0x03, 0x04, 0x00, 0x30, 0xC0, 0x02, 0x0C, 0x00, 0x60, 0xC0, 0x0C,
  0x0C, 0x01, 0xC0, 0x80, 0x70, 0x1F, 0xFC, 0x01, 0x81, 0x80, 0x18, 0x18,
  0x01, 0x01, 0x80, 0x10, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x40, 0x20, 0x06, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x30, 0x60,
  0x03, 0x04, 0x00, 0x30, 0xC0, 0x01, 0x80, 0x00, 0x3F, 0xC0, 0x0F, 0xBF,
  0x03, 0x80, 0x20, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x80, 0x0C, 0x0E, 0x03, 0x80, 0x7F, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x20, 0x80,
  0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x04, 0x18, 0x00,
  0x08, 0x20, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x01,
  0x04, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30,
  0xC0, 0x00, 0x41, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18,
  0x00, 0x08, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x81, 0x80,
  0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x18, 0x06, 0x00, 0x60, 0x07, 0x07,
  0x80, 0x07, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x06, 0xC0, 0x00,
  0x6C, 0x00, 0x0C, 0xC0, 0x00, 0xC4, 0x00, 0x18, 0x40, 0x01, 0x84, 0x00,
  0x30, 0x40, 0x03, 0x04, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0xC0, 0x60,
  0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0x60, 0x30, 0x06,
  0x06, 0x00, 0x20, 0x60, 0x02, 0x0C, 0x00, 0x20, 0xC0, 0x02, 0x18, 0x00,
  0x21, 0x80, 0x02, 0x30, 0x00, 0x33, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xA0, 0x01,
  0xC0, 0x06, 0x80, 0x0F, 0x00, 0x12, 0x00, 0x2C, 0x00, 0xC8, 0x01, 0x90,
  0x03, 0x20, 0x06, 0x40, 0x18, 0x80, 0x11, 0x00, 0x62, 0x00, 0xC4, 0x01,
  0x08, 0x02, 0x10, 0x0C, 0x20, 0x18, 0x40, 0x20, 0xC0, 0x41, 0x01, 0x83,
  0x03, 0x04, 0x06, 0x0C, 0x0C, 0x10, 0x30, 0x30, 0x60, 0x40, 0xC0, 0xC1,
  0x81, 0x02, 0x03, 0x04, 0x04, 0x18, 0x0C, 0x30, 0x10, 0x40, 0x30, 0x80,
  0x43, 0x00, 0xC6, 0x01, 0x0C, 0x03, 0x10, 0x04, 0x60, 0x0C, 0xC0, 0x11,
  0x80, 0x33, 0x00, 0x44, 0x00, 0xD8, 0x01, 0x30, 0x03, 0x60, 0x04, 0x80,
  0x0D, 0x00, 0x16, 0x00, 0x3C, 0x00, 0x50, 0x00, 0xE0, 0x01, 0x40, 0x03,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x01, 0x80,
  0x60, 0x01, 0x80, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x80, 0x06, 0x00, 0xC0,
  0x03, 0x00, 0xC0, 0x00, 0x80, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x60,
  0x00, 0x08, 0x60, 0x00, 0x06, 0x20, 0x00, 0x03, 0x30, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x09, 0x80, 0x00, 0x0C, 0x40, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x04, 0x00, 0x06, 0x03, 0x00, 0x06,
  0x01, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x20, 0x03, 0x00, 0x18, 0x03,
  0x00, 0x0C, 0x01, 0x00, 0x02, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xF0,
  0x00, 0x6C, 0x00, 0x19, 0x00, 0x0C, 0x40, 0x06, 0x18, 0x01, 0x86, 0x00,
  0xC0, 0x80, 0x60, 0x20, 0x18, 0x0C, 0x0C, 0x03, 0x02, 0x00, 0xC1, 0x80,
  0x10, 0xC0, 0x04, 0x20, 0x01, 0x98, 0x00, 0x6C, 0x00, 0x0B, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0xC0, 0x81, 0x02, 0x06, 0x0C, 0x18, 0x10, 0x20, 0x40, 0xC1, 0x83,
  0x06, 0x04, 0x08, 0x10, 0x30, 0x60, 0xC0, 0x81, 0x02, 0x06, 0x0C, 0x18,
  0x10, 0x20, 0x40, 0xC1, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x07, 0x80, 0x03, 0x60, 0x00, 0xC8, 0x00, 0x63, 0x00, 0x10,
  0xC0, 0x0C, 0x10, 0x06, 0x06, 0x01, 0x00, 0x80, 0xC0, 0x20, 0x60, 0x0C,
  0x18, 0x01, 0x0C, 0x00, 0x62, 0x00, 0x19, 0x80, 0x02, 0xC0, 0x00, 0xF0,
  0x00, 0x30, 0x7F, 0xFF, 0xFF, 0xFC, 0xC3, 0x18, 0x61, 0x0C, 0x20, 0x01,
  0xF8, 0x40, 0xE7, 0x30, 0x60, 0x6C, 0x30, 0x0A, 0x18, 0x03, 0x8C, 0x00,
  0x63, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0x10, 0x00, 0xCC, 0x00, 0x33,
  0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0x8C, 0x00, 0x62, 0x00, 0x18, 0x80,
  0x0E, 0x30, 0x03, 0x0C, 0x01, 0xC3, 0x00, 0xD0, 0x60, 0x6C, 0x1C, 0x33,
  0x03, 0xF8, 0x80, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0xFC, 0x06, 0x71, 0xC0, 0xD8, 0x0C, 0x1E, 0x01,
  0x82, 0x80, 0x10, 0x70, 0x03, 0x1C, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01,
  0x8C, 0x00, 0x31, 0x00, 0x04, 0x60, 0x00, 0x8C, 0x00, 0x31, 0x80, 0x06,
  0x20, 0x00, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x01, 0x87, 0x00, 0x30,
  0xA0, 0x0C, 0x36, 0x03, 0x06, 0x61, 0xC0, 0x87, 0xF0, 0x00, 0x01, 0xFE,
  0x07, 0x0C, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x07, 0x06, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x7E, 0x10, 0x07,
  0x1C, 0x80, 0x60, 0x2C, 0x06, 0x00, 0xE0, 0x60, 0x07, 0x06, 0x00, 0x30,
  0x30, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x80, 0x03, 0x0C, 0x00,
  0x10, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x07, 0x04,
  0x00, 0x30, 0x20, 0x01, 0x81, 0x80, 0x1C, 0x0C, 0x01, 0xE0, 0x60, 0x1A,
  0x01, 0x81, 0x90, 0x0E, 0x18, 0x80, 0x3F, 0x8C, 0x00, 0x00, 0xF8, 0x03,
  0x8E, 0x06, 0x06, 0x0C, 0x03, 0x18, 0x03, 0x30, 0x03, 0x30, 0x02, 0x60,
  0x06, 0x60, 0x0C, 0x40, 0x38, 0x41, 0xF0, 0xFF, 0x80, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x38, 0x30, 0x1F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0xF0, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x02,
  0x30, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x18, 0x07, 0x1C, 0x80,
  0x60, 0x24, 0x06, 0x00, 0xE0, 0x60, 0x07, 0x06, 0x00, 0x30, 0x30, 0x01,
  0x83, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x80, 0x03, 0x0C, 0x00, 0x10, 0x60,
  0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x07, 0x04, 0x00, 0x30,
  0x20, 0x03, 0x81, 0x80, 0x1C, 0x0C, 0x01, 0xE0, 0x60, 0x1A, 0x01, 0x81,
  0x90, 0x0E, 0x19, 0x80, 0x3F, 0x8C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x02, 0x00, 0x60, 0x1C, 0x1E, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x43, 0xF0, 0x33, 0xCE,
  0x0D, 0x80, 0xC3, 0xC0, 0x30, 0xA0, 0x0C, 0x30, 0x03, 0x1C, 0x00, 0xC6,
  0x00, 0x31, 0x80, 0x08, 0x40, 0x02, 0x10, 0x01, 0x8C, 0x00, 0x63, 0x00,
  0x18, 0xC0, 0x04, 0x20, 0x01, 0x08, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C,
  0x60, 0x02, 0x10, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x04, 0x00,
  0x03, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x0C, 0x0C, 0x0C,
  0x0C, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x60,
  0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x46, 0x00, 0xF8, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x0C, 0x30, 0x06, 0x0C, 0x03, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x20, 0x60,
  0x18, 0x30, 0x06, 0x18, 0x01, 0x8C, 0x00, 0x46, 0x00, 0x13, 0x80, 0x0D,
  0xA0, 0x03, 0xCC, 0x00, 0xE3, 0x00, 0x30, 0x40, 0x18, 0x18, 0x06, 0x06,
  0x01, 0x80, 0xC0, 0x40, 0x30, 0x10, 0x04, 0x0C, 0x01, 0x83, 0x00, 0x60,
  0xC0, 0x0C, 0x00, 0x01, 0x01, 0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0x06,
  0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10,
  0x30, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0,
  0x04, 0x7E, 0x07, 0xE0, 0x67, 0x38, 0x63, 0x83, 0x60, 0x44, 0x0C, 0x16,
  0x03, 0x40, 0x30, 0xA0, 0x1C, 0x01, 0x86, 0x00, 0xE0, 0x0C, 0x70, 0x06,
  0x00, 0x63, 0x00, 0x30, 0x03, 0x18, 0x01, 0x80, 0x10, 0x80, 0x08, 0x01,
  0x84, 0x00, 0xC0, 0x0C, 0x60, 0x06, 0x00, 0x63, 0x00, 0x30, 0x02, 0x18,
  0x01, 0x00, 0x10, 0x80, 0x08, 0x01, 0x8C, 0x00, 0xC0, 0x0C, 0x60, 0x06,
  0x00, 0x63, 0x00, 0x30, 0x02, 0x18, 0x01, 0x00, 0x10, 0x80, 0x18, 0x01,
  0x8C, 0x00, 0xC0, 0x0C, 0x60, 0x06, 0x00, 0x63, 0x00, 0x20, 0x02, 0x00,
  0x04, 0x3F, 0x03, 0x3C, 0xE0, 0xD8, 0x0C, 0x3C, 0x03, 0x0A, 0x00, 0xC3,
  0x00, 0x31, 0xC0, 0x0C, 0x60, 0x03, 0x18, 0x00, 0x86, 0x00, 0x21, 0x00,
  0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x42, 0x00, 0x31, 0x80, 0x0C,
  0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x21, 0x00, 0x18, 0xC0, 0x06, 0x30,
  0x01, 0x8C, 0x00, 0x40, 0x01, 0xFC, 0x01, 0xC7, 0x01, 0x80, 0xC1, 0x80,
  0x31, 0x80, 0x19, 0x80, 0x0C, 0xC0, 0x02, 0xC0, 0x01, 0x60, 0x00, 0xA0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x05,
  0x80, 0x06, 0xC0, 0x03, 0x60, 0x03, 0x30, 0x01, 0x88, 0x01, 0x86, 0x01,
  0x81, 0xC3, 0x80, 0x7F, 0x00, 0x01, 0x0F, 0xC0, 0x19, 0xC7, 0x00, 0xD8,
  0x0C, 0x07, 0x80, 0x60, 0x28, 0x01, 0x01, 0xC0, 0x0C, 0x1C, 0x00, 0x60,
  0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x00, 0x04, 0x18, 0x00,
  0x20, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x20, 0x00, 0xC1, 0x00, 0x0C, 0x18,
  0x00, 0x60, 0xC0, 0x06, 0x07, 0x00, 0x30, 0x28, 0x03, 0x03, 0x60, 0x30,
  0x19, 0x87, 0x00, 0xC7, 0xF0, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x60, 0x73,
  0xC8, 0x18, 0x09, 0x06, 0x01, 0xE1, 0x80, 0x1C, 0x60, 0x03, 0x0C, 0x00,
  0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x33, 0x00, 0x04, 0x60, 0x00,
  0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x01, 0xC6, 0x00, 0x30, 0x80, 0x06,
  0x18, 0x01, 0xC3, 0x00, 0x78, 0x60, 0x1A, 0x06, 0x06, 0x40, 0xE1, 0x98,
  0x0F, 0xE3, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x3C, 0x33, 0xD0, 0xD8, 0x02, 0xC0, 0x0A, 0x00,
  0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFC, 0x07, 0x1F,
  0x0C, 0x02, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x80, 0x30, 0xE0, 0xE0, 0x7F, 0xC0, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00,
  0x80, 0xFF, 0xFF, 0xF0, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80,
  0x30, 0x04, 0x00, 0x80, 0x10, 0x03, 0x08, 0x3E, 0x00, 0x18, 0x00, 0xC6,
  0x00, 0x31, 0x80, 0x08, 0x40, 0x02, 0x10, 0x01, 0x8C, 0x00, 0x63, 0x00,
  0x18, 0xC0, 0x04, 0x20, 0x01, 0x08, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C,
  0x60, 0x02, 0x10, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x0C, 0x30,
  0x03, 0x0C, 0x01, 0x43, 0x00, 0xF0, 0xC0, 0x6C, 0x18, 0x72, 0x03, 0xF8,
  0x80, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x06, 0x40, 0x04, 0x40, 0x0C, 0x40,
  0x08, 0x40, 0x18, 0x60, 0x10, 0x60, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60,
  0xC0, 0x60, 0xC0, 0x21, 0x80, 0x21, 0x80, 0x23, 0x00, 0x23, 0x00, 0x26,
  0x00, 0x36, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0xC0,
  0x0C, 0x01, 0xA0, 0x06, 0x00, 0xD0, 0x07, 0x00, 0x48, 0x03, 0x80, 0x64,
  0x03, 0xC0, 0x22, 0x01, 0x60, 0x31, 0x01, 0x90, 0x10, 0x80, 0x88, 0x18,
  0x40, 0xC4, 0x0C, 0x20, 0x42, 0x0C, 0x10, 0x61, 0x06, 0x08, 0x20, 0x82,
  0x04, 0x30, 0x43, 0x02, 0x10, 0x21, 0x01, 0x18, 0x11, 0x80, 0xC8, 0x0C,
  0x80, 0x6C, 0x06, 0xC0, 0x36, 0x03, 0x60, 0x1A, 0x01, 0xA0, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0x80, 0x18, 0x00, 0x02,
  0x00, 0x30, 0x30, 0x06, 0x03, 0x00, 0x40, 0x10, 0x0C, 0x01, 0x81, 0x80,
  0x18, 0x30, 0x00, 0x86, 0x00, 0x0C, 0x60, 0x00, 0x4C, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0D, 0x00, 0x01, 0x98,
  0x00, 0x31, 0x80, 0x06, 0x08, 0x00, 0x60, 0xC0, 0x0C, 0x0C, 0x01, 0x80,
  0x40, 0x30, 0x06, 0x02, 0x00, 0x20, 0xE0, 0x03, 0x00, 0x00, 0x80, 0x02,
  0x01, 0x00, 0x0C, 0x02, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x60, 0x00,
  0x80, 0xC0, 0x01, 0x03, 0x00, 0x02, 0x06, 0x00, 0x04, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x66, 0x00, 0x00, 0xC8,
  0x00, 0x00, 0xB0, 0x00, 0x01, 0x40, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x06, 0x00,
  0x7C, 0x01, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x03, 0xE0, 0x07, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0xF0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0x80, 0x03, 0xE0, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x78, 0x00, 0xF0, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x0F, 0x80,
  0x1C, 0x00, 0x00, 0x7F, 0x00, 0x78, 0xF0, 0x38, 0x0F, 0xFA, 0x00, 0x78,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 9, 31, 9, 1, -31 },
  { 36, 9, 11, 13, 5, -31 },
  { 49, 22, 31, 23, 1, -31 },
  { 135, 19, 36, 21, 1, -33 },
  { 221, 24, 32, 29, 3, -31 },
  { 317, 22, 31, 24, 1, -31 },
  { 403, 3, 11, 7, 5, -31 },
  { 408, 13, 38, 11, 1, -31 },
  { 470, 12, 38, 11, -3, -31 },
  { 527, 16, 16, 20, 5, -33 },
  { 559, 19, 20, 22, 2, -25 },
  { 607, 6, 11, 8, -2, -5 },
  { 616, 10, 1, 13, 1, -12 },
  { 618, 3, 3, 9, 1, -3 },
  { 620, 19, 31, 13, -2, -31 },
  { 694, 18, 31, 21, 2, -31 },
  { 764, 10, 31, 21, 6, -31 },
  { 803, 20, 31, 21, 0, -31 },
  { 881, 20, 31, 21, 0, -31 },
  { 959, 20, 31, 21, 0, -31 },
  { 1037, 19, 31, 21, 1, -31 },
  { 1111, 19, 31, 21, 2, -31 },
  { 1185, 18, 31, 21, 3, -31 },
  { 1255, 19, 31, 21, 1, -31 },
  { 1329, 19, 31, 21, 1, -31 },
  { 1403, 7, 23, 9, 1, -23 },
  { 1424, 10, 29, 9, -2, -23 },
  { 1461, 18, 19, 22, 3, -25 },
  { 1504, 18, 10, 22, 3, -20 },
  { 1527, 18, 19, 22, 3, -25 },
  { 1570, 14, 31, 15, 2, -31 },
  { 1625, 28, 35, 31, 2, -31 },
  { 1748, 20, 31, 20, -2, -31 },
  { 1826, 21, 31, 22, 1, -31 },
  { 1908, 21, 31, 22, 3, -31 },
  { 1990, 23, 31, 25, 1, -31 },
  { 2080, 20, 31, 20, 1, -31 },
  { 2158, 20, 31, 18, 1, -31 },
  { 2236, 23, 31, 26, 3, -31 },
  { 2326, 25, 31, 26, 1, -31 },
  { 2423, 14, 31, 11, -1, -31 },
  { 2478, 17, 39, 9, -7, -31 },
  { 2561, 23, 31, 21, 1, -31 },
  { 2651, 14, 31, 18, 1, -31 },
  { 2706, 31, 31, 32, 1, -31 },
  { 2827, 25, 31, 26, 1, -31 },
  { 2924, 22, 31, 27, 3, -31 },
  { 3010, 20, 31, 21, 1, -31 },
  { 3088, 22, 38, 27, 3, -31 },
  { 3193, 20, 31, 21, 1, -31 },
  { 3271, 20, 31, 19, 0, -31 },
  { 3349, 18, 31, 18, 4, -31 },
  { 3419, 23, 31, 26, 3, -31 },
  { 3509, 20, 31, 20, 4, -31 },
  { 3587, 30, 31, 32, 5, -31 },
  { 3704, 25, 31, 19, -3, -31 },
  { 3801, 18, 31, 18, 4, -31 },
  { 3871, 22, 31, 20, -1, -31 },
  { 3957, 16, 38, 13, -1, -31 },
  { 4033, 7, 31, 14, 4, -31 },
  { 4061, 16, 38, 13, -3, -31 },
  { 4137, 18, 18, 21, 2, -31 },
  { 4178, 15, 2, 14, -4, 4 },
  { 4182, 5, 7, 10, 6, -33 },
  { 4187, 18, 23, 21, 2, -23 },
  { 4239, 19, 33, 22, 1, -33 },
  { 4318, 15, 23, 17, 2, -23 },
  { 4362, 21, 33, 22, 2, -33 },
  { 4449, 16, 23, 19, 2, -23 },
  { 4495, 22, 43, 11, -6, -33 },
  { 4614, 21, 33, 22, 0, -23 },
  { 4701, 18, 33, 21, 1, -33 },
  { 4776, 8, 31, 8, 1, -31 },
  { 4807, 15, 41, 9, -6, -31 },
  { 4884, 18, 33, 17, 1, -33 },
  { 4959, 8, 33, 8, 1, -33 },
  { 4992, 29, 23, 32, 1, -23 },
  { 5076, 18, 23, 21, 1, -23 },
  { 5128, 17, 23, 21, 2, -23 },
  { 5177, 21, 33, 22, -1, -23 },
  { 5264, 19, 33, 22, 2, -23 },
  { 5343, 14, 23, 14, 1, -23 },
  { 5384, 16, 23, 16, 0, -23 },
  { 5430, 11, 28, 12, 2, -28 },
  { 5469, 18, 23, 21, 2, -23 },
  { 5521, 16, 23, 16, 2, -23 },
  { 5567, 25, 23, 26, 2, -23 },
  { 5639, 20, 23, 17, -2, -23 },
  { 5697, 23, 33, 16, -5, -23 },
  { 5792, 17, 23, 16, -1, -23 },
  { 5841, 15, 38, 14, 1, -31 },
  { 5913, 1, 43, 20, 10, -33 },
  { 5919, 15, 38, 14, -2, -31 },
  { 5991, 18, 4, 22, 3, -17 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic43pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC43PT7B_H_
