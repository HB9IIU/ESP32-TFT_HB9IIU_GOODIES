#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC33PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x43, 0x0C, 0x20, 0x82, 0x18, 0x41, 0x04, 0x30, 0x82,
  0x08, 0x21, 0x80, 0x00, 0x00, 0x0C, 0x30, 0x23, 0x23, 0x22, 0x62, 0x42,
  0x42, 0x44, 0x44, 0xC4, 0x00, 0x82, 0x00, 0x41, 0x00, 0x20, 0x80, 0x20,
  0xC0, 0x10, 0x40, 0x08, 0x20, 0x0C, 0x30, 0x04, 0x10, 0x3F, 0xFF, 0x83,
  0x04, 0x01, 0x04, 0x00, 0x82, 0x00, 0x41, 0x00, 0x41, 0x80, 0x20, 0x81,
  0xFF, 0xFC, 0xFF, 0xFE, 0x08, 0x20, 0x04, 0x10, 0x02, 0x08, 0x02, 0x0C,
  0x01, 0x04, 0x00, 0x82, 0x00, 0x83, 0x00, 0x00, 0x20, 0x01, 0x00, 0x04,
  0x00, 0xFF, 0x0C, 0x44, 0x62, 0x01, 0x08, 0x04, 0x20, 0x10, 0x80, 0x42,
  0x01, 0x90, 0x03, 0x40, 0x07, 0x00, 0x06, 0x00, 0x16, 0x00, 0x88, 0x02,
  0x10, 0x08, 0x40, 0x21, 0x01, 0x84, 0x04, 0x22, 0x11, 0x8F, 0xF8, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x00, 0x0F, 0x00, 0x43, 0x30, 0x10,
  0xC2, 0x06, 0x10, 0x40, 0x86, 0x08, 0x20, 0x81, 0x0C, 0x10, 0x21, 0x02,
  0x0C, 0x40, 0xC1, 0x08, 0x18, 0x22, 0x03, 0x04, 0x8F, 0x61, 0x12, 0x3C,
  0x24, 0x82, 0x89, 0x90, 0x4E, 0x26, 0x08, 0x08, 0x81, 0x03, 0x10, 0x20,
  0x42, 0x0C, 0x10, 0xC1, 0x06, 0x18, 0x20, 0x83, 0x0C, 0x20, 0x61, 0x0C,
  0x04, 0x63, 0x00, 0xF8, 0x00, 0xF0, 0x03, 0x18, 0x06, 0x08, 0x04, 0x0C,
  0x04, 0x08, 0x04, 0x08, 0x04, 0x08, 0x04, 0x10, 0x04, 0x30, 0x06, 0x60,
  0x03, 0x80, 0x07, 0x00, 0x0D, 0x00, 0x11, 0x81, 0x20, 0x81, 0x40, 0x42,
  0xC0, 0x62, 0x80, 0x24, 0x80, 0x3C, 0x80, 0x18, 0x80, 0x38, 0xC0, 0x68,
  0x60, 0xCC, 0x3F, 0x06, 0x24, 0xB4, 0x92, 0xC0, 0x00, 0x80, 0x80, 0xC0,
  0xC0, 0x40, 0x40, 0x60, 0x20, 0x30, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01,
  0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xC0,
  0x20, 0x10, 0x0C, 0x02, 0x00, 0x02, 0x01, 0x80, 0x40, 0x20, 0x18, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01,
  0x00, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x10, 0x10, 0x18, 0x08, 0x08, 0x0C,
  0x0C, 0x00, 0x02, 0x00, 0x20, 0x02, 0x0C, 0x20, 0x62, 0x01, 0xCF, 0x07,
  0x00, 0xA0, 0x12, 0x06, 0x10, 0x41, 0x00, 0x18, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x3F, 0xFF, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x13,
  0x32, 0x64, 0xC8, 0xFF, 0xFE, 0xF0, 0x00, 0x04, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x40, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x01, 0xE0, 0x31, 0x83, 0x06, 0x30, 0x11, 0x00, 0x98, 0x04, 0x80, 0x2C,
  0x01, 0x40, 0x0A, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0A, 0x00,
  0x50, 0x02, 0x80, 0x34, 0x01, 0x20, 0x19, 0x00, 0x88, 0x0C, 0x60, 0x41,
  0x04, 0x07, 0xC0, 0x02, 0x0C, 0x69, 0xBC, 0x50, 0x81, 0x06, 0x0C, 0x10,
  0x20, 0x41, 0x82, 0x04, 0x08, 0x10, 0x60, 0x81, 0x02, 0x0C, 0x18, 0x20,
  0x00, 0xF0, 0x06, 0x38, 0x10, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x7F, 0xF8, 0x00, 0xF0, 0x0E,
  0x18, 0x30, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0xE0, 0x3E, 0x00, 0x0E, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x30, 0x18, 0x3F, 0xC0, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xA0, 0x02, 0x40, 0x0C, 0x80, 0x13, 0x00, 0x44, 0x01, 0x08, 0x06,
  0x10, 0x18, 0x20, 0x20, 0xC0, 0x81, 0x02, 0x02, 0x0C, 0x04, 0x30, 0x08,
  0x40, 0x31, 0xFF, 0xFC, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x20, 0x03, 0xFF, 0x03, 0xFE, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x1F,
  0xE0, 0x08, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0xC0,
  0xE0, 0x7F, 0x80, 0x00, 0x7C, 0x06, 0x10, 0x60, 0x03, 0x00, 0x08, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x04, 0x04, 0xFC, 0x14, 0x08,
  0xE0, 0x33, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x48, 0x03,
  0x20, 0x08, 0x80, 0x63, 0x03, 0x06, 0x18, 0x0F, 0xC0, 0x7F, 0xFB, 0xFF,
  0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00,
  0x01, 0xF0, 0x0E, 0x30, 0x30, 0x30, 0x40, 0x20, 0x80, 0x63, 0x00, 0xC6,
  0x01, 0x04, 0x02, 0x08, 0x08, 0x18, 0x20, 0x19, 0x80, 0x1C, 0x00, 0xEC,
  0x03, 0x0C, 0x08, 0x0C, 0x20, 0x08, 0xC0, 0x11, 0x00, 0x32, 0x00, 0x64,
  0x00, 0x88, 0x01, 0x18, 0x04, 0x18, 0x18, 0x1F, 0xC0, 0x01, 0xE0, 0x18,
  0xE0, 0xC0, 0x86, 0x03, 0x10, 0x04, 0xC0, 0x12, 0x00, 0x48, 0x01, 0x20,
  0x04, 0x80, 0x32, 0x00, 0xC8, 0x07, 0x30, 0x38, 0x61, 0xA0, 0xF8, 0x80,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x3F, 0x00, 0x08, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC6, 0x00, 0x01, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x18, 0x10, 0x10, 0x30, 0x20, 0x60,
  0xC0, 0x00, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x03, 0x00, 0x00, 0x1F, 0x1C, 0x60, 0x0C, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x80, 0x60, 0x30, 0x10, 0x08, 0x04, 0x03, 0x00,
  0x80, 0x60, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x7F, 0xC0, 0x07, 0x00, 0xC0, 0x30, 0x01, 0x01, 0x80, 0x02, 0x0C, 0x00,
  0x0C, 0x20, 0x00, 0x11, 0x01, 0xF8, 0x4C, 0x0C, 0x41, 0x20, 0x41, 0x04,
  0x82, 0x04, 0x14, 0x10, 0x30, 0x50, 0x40, 0x81, 0x43, 0x02, 0x0D, 0x08,
  0x08, 0x24, 0x20, 0x60, 0xB0, 0x81, 0x06, 0xC2, 0x0C, 0x13, 0x0C, 0x68,
  0x84, 0x1F, 0x3C, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x14, 0x00, 0x14, 0x00, 0x24, 0x00, 0x24, 0x00,
  0x44, 0x00, 0x44, 0x00, 0x84, 0x00, 0x84, 0x01, 0x06, 0x01, 0x06, 0x02,
  0x02, 0x02, 0x02, 0x07, 0xFE, 0x0C, 0x02, 0x08, 0x02, 0x18, 0x02, 0x10,
  0x02, 0x30, 0x02, 0x20, 0x02, 0x60, 0x03, 0x40, 0x03, 0xC0, 0x03, 0x07,
  0xE0, 0x07, 0xFC, 0x04, 0x06, 0x0C, 0x03, 0x08, 0x01, 0x08, 0x01, 0x08,
  0x03, 0x08, 0x02, 0x18, 0x02, 0x10, 0x04, 0x10, 0x18, 0x1F, 0xE0, 0x30,
  0x30, 0x30, 0x08, 0x20, 0x0C, 0x20, 0x04, 0x20, 0x04, 0x60, 0x04, 0x40,
  0x04, 0x40, 0x0C, 0x40, 0x18, 0x40, 0x30, 0xC0, 0xE0, 0xFF, 0x80, 0x00,
  0x7E, 0x01, 0xC3, 0x03, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x10, 0x0F, 0xF0, 0x07,
  0xC0, 0x03, 0xFE, 0x01, 0x01, 0x81, 0x80, 0x60, 0x80, 0x10, 0x40, 0x0C,
  0x20, 0x02, 0x30, 0x01, 0x18, 0x00, 0x88, 0x00, 0x44, 0x00, 0x22, 0x00,
  0x13, 0x00, 0x19, 0x80, 0x0C, 0x80, 0x04, 0x40, 0x02, 0x20, 0x03, 0x30,
  0x01, 0x10, 0x01, 0x88, 0x01, 0x84, 0x01, 0x82, 0x01, 0x83, 0x07, 0x01,
  0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0xFF,
  0xC3, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x7F, 0xF0, 0x07,
  0xFE, 0x0F, 0xFC, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0xFF, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x00, 0x7E, 0x00, 0x70,
  0xF0, 0x70, 0x04, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x3F, 0x30, 0x10, 0xC8, 0x00, 0x32, 0x00, 0x08, 0x80, 0x02, 0x30, 0x00,
  0x8C, 0x00, 0x61, 0x00, 0x18, 0x60, 0x04, 0x08, 0x01, 0x03, 0x80, 0xC0,
  0x3F, 0xE0, 0x04, 0x00, 0x60, 0x80, 0x0C, 0x10, 0x01, 0x06, 0x00, 0x20,
  0x80, 0x04, 0x10, 0x01, 0x82, 0x00, 0x20, 0x40, 0x04, 0x18, 0x00, 0x82,
  0x00, 0x10, 0x40, 0x06, 0x0F, 0xFF, 0x83, 0x00, 0x10, 0x60, 0x02, 0x08,
  0x00, 0x41, 0x00, 0x18, 0x20, 0x02, 0x0C, 0x00, 0x41, 0x00, 0x08, 0x20,
  0x03, 0x04, 0x00, 0x60, 0x80, 0x08, 0x30, 0x01, 0x04, 0x00, 0x20, 0x07,
  0xE0, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x07, 0xE0, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x9C, 0x0F, 0x00, 0x04, 0x00, 0x82, 0x00, 0x81, 0x00, 0x81,
  0x80, 0xC0, 0x80, 0xC0, 0x40, 0xC0, 0x20, 0xC0, 0x30, 0xC0, 0x18, 0xC0,
  0x08, 0xC0, 0x04, 0xC0, 0x02, 0xE0, 0x03, 0xD0, 0x01, 0x8C, 0x00, 0x82,
  0x00, 0x41, 0x00, 0x20, 0xC0, 0x30, 0x20, 0x10, 0x18, 0x08, 0x04, 0x04,
  0x02, 0x02, 0x01, 0x83, 0x00, 0x41, 0x00, 0x30, 0x04, 0x01, 0x00, 0x40,
  0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30,
  0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C,
  0x03, 0xFF, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x38, 0x70,
  0x00, 0x70, 0xA0, 0x01, 0x61, 0x40, 0x02, 0x82, 0xC0, 0x09, 0x0C, 0x80,
  0x12, 0x19, 0x00, 0x4C, 0x22, 0x01, 0x90, 0x44, 0x02, 0x20, 0x88, 0x0C,
  0x43, 0x10, 0x10, 0x86, 0x20, 0x63, 0x08, 0x60, 0x84, 0x10, 0x42, 0x08,
  0x20, 0x84, 0x10, 0xC1, 0x10, 0x61, 0x02, 0x60, 0xC2, 0x04, 0x81, 0x04,
  0x0B, 0x02, 0x08, 0x14, 0x04, 0x30, 0x38, 0x18, 0x40, 0x60, 0x20, 0x04,
  0x00, 0x20, 0xC0, 0x04, 0x18, 0x01, 0x87, 0x00, 0x20, 0xB0, 0x04, 0x12,
  0x00, 0x82, 0x40, 0x10, 0xCC, 0x06, 0x18, 0x80, 0x82, 0x10, 0x10, 0x43,
  0x02, 0x08, 0x20, 0xC3, 0x04, 0x18, 0x60, 0xC2, 0x08, 0x08, 0x41, 0x01,
  0x08, 0x20, 0x33, 0x0C, 0x02, 0x41, 0x00, 0x48, 0x20, 0x0D, 0x04, 0x00,
  0xA0, 0x80, 0x1C, 0x30, 0x03, 0x04, 0x00, 0x20, 0x00, 0xF8, 0x01, 0xC7,
  0x01, 0x80, 0xC1, 0x80, 0x31, 0x80, 0x08, 0x80, 0x04, 0xC0, 0x02, 0x40,
  0x01, 0x60, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x02, 0x80, 0x01, 0x40, 0x01, 0xB0, 0x00,
  0x88, 0x00, 0xC4, 0x00, 0xC3, 0x00, 0xC0, 0xC0, 0xC0, 0x3F, 0xC0, 0x07,
  0xC0, 0x0F, 0xF0, 0x10, 0x30, 0x60, 0x30, 0x80, 0x21, 0x00, 0x42, 0x00,
  0x8C, 0x01, 0x18, 0x02, 0x20, 0x0C, 0x40, 0x10, 0x80, 0x43, 0x03, 0x07,
  0xF8, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x00, 0xF8, 0x01, 0xC7,
  0x01, 0x80, 0xC1, 0x80, 0x31, 0x80, 0x08, 0x80, 0x04, 0xC0, 0x02, 0x40,
  0x01, 0x60, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x02, 0x80, 0x01, 0x40, 0x01, 0xB0, 0x00,
  0x88, 0x00, 0xC4, 0x00, 0xC3, 0x00, 0xC0, 0xC0, 0xC0, 0x3F, 0xC0, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x07, 0xC0, 0x0F, 0xF0, 0x10, 0x30, 0x60, 0x30, 0x80, 0x21, 0x00, 0x42,
  0x00, 0x8C, 0x01, 0x18, 0x06, 0x20, 0x0C, 0x40, 0x30, 0x80, 0xC3, 0xFF,
  0x07, 0xF0, 0x08, 0x30, 0x10, 0x20, 0x20, 0x40, 0xC0, 0xC1, 0x01, 0x82,
  0x01, 0x04, 0x02, 0x08, 0x06, 0x30, 0x04, 0x40, 0x08, 0x00, 0xF8, 0x07,
  0x1C, 0x10, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x00, 0x06, 0x20, 0x38, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x20, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x42, 0x00, 0x31, 0x80, 0x0C, 0x40, 0x02, 0x10, 0x00, 0x84,
  0x00, 0x21, 0x00, 0x18, 0xC0, 0x04, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00,
  0x31, 0x80, 0x0C, 0x60, 0x02, 0x10, 0x00, 0x84, 0x00, 0x21, 0x00, 0x18,
  0xC0, 0x06, 0x30, 0x01, 0x0C, 0x00, 0x43, 0x00, 0x20, 0xC0, 0x08, 0x10,
  0x04, 0x06, 0x06, 0x00, 0x7F, 0x00, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x16,
  0x00, 0x6C, 0x00, 0x88, 0x03, 0x10, 0x04, 0x20, 0x18, 0x40, 0x20, 0x80,
  0xC1, 0x01, 0x02, 0x06, 0x04, 0x08, 0x08, 0x30, 0x10, 0x40, 0x31, 0x80,
  0x62, 0x00, 0xCC, 0x00, 0x90, 0x01, 0x60, 0x02, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x80, 0x10, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x14,
  0x03, 0x80, 0x68, 0x05, 0x00, 0x90, 0x1A, 0x01, 0x20, 0x24, 0x04, 0x40,
  0x48, 0x08, 0x81, 0x10, 0x31, 0x02, 0x20, 0x42, 0x0C, 0x41, 0x84, 0x10,
  0x82, 0x08, 0x61, 0x04, 0x10, 0x82, 0x10, 0x23, 0x04, 0x20, 0x44, 0x08,
  0xC0, 0x88, 0x11, 0x01, 0x20, 0x26, 0x02, 0x40, 0x48, 0x05, 0x80, 0x90,
  0x0A, 0x01, 0x40, 0x1C, 0x02, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0x02, 0x00, 0x60, 0x40, 0x18, 0x0C, 0x02, 0x00, 0x80, 0x80, 0x10, 0x30,
  0x03, 0x04, 0x00, 0x21, 0x00, 0x04, 0x60, 0x00, 0x98, 0x00, 0x1A, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x40, 0x00, 0x48, 0x00,
  0x19, 0x80, 0x02, 0x10, 0x00, 0x82, 0x00, 0x20, 0x40, 0x0C, 0x0C, 0x01,
  0x00, 0x80, 0x40, 0x10, 0x18, 0x03, 0x06, 0x00, 0x20, 0x80, 0x0E, 0x00,
  0x2C, 0x01, 0x90, 0x0C, 0x40, 0x21, 0x01, 0x86, 0x04, 0x08, 0x20, 0x21,
  0x80, 0x84, 0x02, 0x20, 0x0D, 0x80, 0x14, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xF0, 0x7F, 0x06, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80,
  0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00,
  0xFC, 0x00, 0xC6, 0x10, 0x84, 0x21, 0x0C, 0x21, 0x08, 0x42, 0x18, 0x42,
  0x10, 0x84, 0x30, 0x84, 0x21, 0x03, 0xF0, 0x3F, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0xFC,
  0x00, 0x00, 0x40, 0x03, 0x00, 0x1C, 0x00, 0x48, 0x02, 0x20, 0x18, 0x80,
  0x41, 0x03, 0x04, 0x08, 0x10, 0x40, 0x23, 0x00, 0x88, 0x03, 0x40, 0x07,
  0x00, 0x10, 0xFF, 0xF0, 0x84, 0x42, 0x10, 0x01, 0xC0, 0x1D, 0x90, 0xC1,
  0x46, 0x05, 0x30, 0x0C, 0x80, 0x26, 0x00, 0x90, 0x02, 0x40, 0x19, 0x00,
  0x64, 0x01, 0x30, 0x04, 0xC0, 0x33, 0x00, 0xC4, 0x07, 0x10, 0x28, 0x61,
  0xA0, 0xF8, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x06, 0x38, 0x13, 0x38, 0x58, 0x21, 0xC0, 0xC6, 0x01,
  0x30, 0x04, 0xC0, 0x12, 0x00, 0x48, 0x01, 0x60, 0x0D, 0x80, 0x24, 0x00,
  0x90, 0x06, 0x40, 0x13, 0x80, 0xCA, 0x02, 0x2C, 0x30, 0x9F, 0x80, 0x01,
  0xE0, 0x73, 0x0C, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x41, 0xF8, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x01, 0xC6, 0x07, 0x76, 0x0C, 0x14, 0x10, 0x0C,
  0x30, 0x0C, 0x20, 0x0C, 0x60, 0x0C, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08,
  0xC0, 0x18, 0xC0, 0x10, 0xC0, 0x30, 0xC0, 0x30, 0x40, 0x50, 0x40, 0xF0,
  0x61, 0xA0, 0x3F, 0x20, 0x03, 0x80, 0xE6, 0x18, 0x23, 0x03, 0x60, 0x24,
  0x02, 0x40, 0x68, 0x0C, 0x8F, 0x0F, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x83, 0xF8, 0x00, 0x0F, 0x80, 0x08, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x03, 0xF8, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20,
  0x01, 0x20, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xBB, 0x06, 0x0A,
  0x0C, 0x06, 0x18, 0x06, 0x10, 0x06, 0x30, 0x06, 0x20, 0x04, 0x20, 0x04,
  0x20, 0x04, 0x60, 0x0C, 0x60, 0x08, 0x60, 0x18, 0x60, 0x18, 0x20, 0x28,
  0x20, 0x78, 0x30, 0xD0, 0x1F, 0x90, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0xE3, 0x80, 0x3E, 0x00, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x38,
  0x13, 0xB8, 0x50, 0x21, 0x80, 0x86, 0x03, 0x30, 0x08, 0xC0, 0x22, 0x00,
  0x88, 0x02, 0x20, 0x19, 0x80, 0x44, 0x01, 0x10, 0x04, 0x40, 0x33, 0x00,
  0xCC, 0x02, 0x20, 0x08, 0x80, 0x20, 0x04, 0x30, 0xC0, 0x00, 0x00, 0x84,
  0x10, 0x41, 0x0C, 0x20, 0x82, 0x18, 0x61, 0x04, 0x10, 0xC3, 0x08, 0x20,
  0x00, 0x20, 0x0C, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x30, 0x2C, 0x07, 0x00, 0x04, 0x00, 0x20, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x18, 0x81,
  0x84, 0x18, 0x21, 0x83, 0x18, 0x11, 0x80, 0x98, 0x05, 0xC0, 0x7A, 0x03,
  0x90, 0x18, 0xC0, 0x82, 0x04, 0x18, 0x60, 0x42, 0x02, 0x10, 0x18, 0x80,
  0x40, 0x04, 0x10, 0xC3, 0x08, 0x20, 0x86, 0x10, 0x41, 0x04, 0x30, 0x82,
  0x08, 0x61, 0x84, 0x10, 0x43, 0x08, 0x20, 0x80, 0x00, 0xE0, 0x70, 0x4C,
  0xC6, 0x61, 0x41, 0x20, 0xC6, 0x07, 0x01, 0x18, 0x08, 0x04, 0xC0, 0x60,
  0x13, 0x01, 0x80, 0xC8, 0x04, 0x02, 0x20, 0x10, 0x09, 0x80, 0x40, 0x26,
  0x03, 0x01, 0x90, 0x08, 0x06, 0x40, 0x20, 0x11, 0x00, 0x80, 0x4C, 0x02,
  0x01, 0x30, 0x18, 0x0C, 0x80, 0x40, 0x22, 0x01, 0x00, 0x80, 0x00, 0xE0,
  0x4E, 0xE1, 0x40, 0x86, 0x03, 0x18, 0x0C, 0xC0, 0x23, 0x00, 0x88, 0x02,
  0x20, 0x09, 0x80, 0x66, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0xCC, 0x03,
  0x30, 0x08, 0x80, 0x22, 0x01, 0x80, 0x01, 0xE0, 0x1C, 0xC0, 0xC1, 0x86,
  0x02, 0x30, 0x0C, 0x80, 0x36, 0x00, 0x50, 0x03, 0x40, 0x0D, 0x00, 0x34,
  0x00, 0xB0, 0x02, 0xC0, 0x19, 0x00, 0x44, 0x03, 0x18, 0x18, 0x20, 0xC0,
  0x7E, 0x00, 0x00, 0x38, 0x04, 0xCE, 0x05, 0x82, 0x07, 0x03, 0x06, 0x01,
  0x0C, 0x01, 0x0C, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08, 0x03, 0x18, 0x02,
  0x10, 0x02, 0x10, 0x06, 0x10, 0x04, 0x30, 0x0C, 0x28, 0x08, 0x2C, 0x30,
  0x27, 0xE0, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x0E, 0xEC, 0x30, 0x50,
  0xC0, 0x63, 0x00, 0xC4, 0x01, 0x98, 0x03, 0x20, 0x04, 0x40, 0x08, 0x80,
  0x11, 0x00, 0x66, 0x00, 0x8C, 0x03, 0x18, 0x06, 0x10, 0x14, 0x20, 0x78,
  0x61, 0xA0, 0x7E, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x00, 0xE2, 0x74, 0x50, 0x0C,
  0x01, 0x80, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x00, 0x03, 0xC0, 0xC7, 0x10,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x81, 0x8F, 0xF0, 0x08,
  0x04, 0x02, 0x01, 0x01, 0x8B, 0xF8, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04,
  0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x03, 0xC0,
  0x10, 0x04, 0x40, 0x11, 0x00, 0xCC, 0x02, 0x20, 0x08, 0x80, 0x22, 0x00,
  0x88, 0x06, 0x60, 0x11, 0x00, 0x44, 0x01, 0x10, 0x0C, 0x40, 0x33, 0x01,
  0x84, 0x0A, 0x10, 0x68, 0x3E, 0x20, 0x80, 0x38, 0x02, 0x80, 0x48, 0x0C,
  0x80, 0x8C, 0x18, 0xC1, 0x0C, 0x30, 0x42, 0x04, 0x60, 0x44, 0x04, 0xC0,
  0x48, 0x05, 0x80, 0x50, 0x07, 0x00, 0x60, 0x00, 0x80, 0xC0, 0x70, 0x18,
  0x0A, 0x07, 0x03, 0x40, 0xA0, 0x48, 0x34, 0x19, 0x04, 0x82, 0x20, 0x90,
  0x44, 0x22, 0x10, 0x84, 0x62, 0x11, 0x0C, 0x82, 0x21, 0x90, 0x48, 0x16,
  0x09, 0x02, 0x81, 0xC0, 0x70, 0x28, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x20,
  0x00, 0x08, 0x06, 0x18, 0x10, 0x10, 0x60, 0x21, 0x80, 0x22, 0x00, 0x48,
  0x00, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x05, 0x00, 0x12, 0x00, 0x46, 0x01,
  0x84, 0x06, 0x08, 0x08, 0x18, 0x20, 0x10, 0xC0, 0x30, 0x02, 0x00, 0xC0,
  0x80, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x01, 0x03, 0x00, 0x40, 0x80, 0x10,
  0x60, 0x04, 0x10, 0x01, 0x08, 0x00, 0x42, 0x00, 0x11, 0x00, 0x04, 0x40,
  0x01, 0xA0, 0x00, 0x28, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xC0, 0x0C, 0x00,
  0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x10, 0x01, 0x80, 0x18, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xC0, 0x00, 0x10,
  0x1E, 0x01, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x00, 0xE0, 0x06, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x02, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x02,
  0x00, 0x3C, 0x00, 0x40, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x70, 0x0E, 0x01,
  0x80, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x0C, 0x01, 0x80, 0xF0, 0x00, 0x7E, 0x06, 0x0E, 0x78, 0x0F,
  0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 24, 7, 1, -24 },
  { 19, 8, 9, 10, 3, -24 },
  { 28, 17, 24, 18, 1, -24 },
  { 79, 14, 27, 16, 1, -25 },
  { 127, 19, 24, 23, 2, -24 },
  { 184, 16, 24, 18, 1, -24 },
  { 232, 3, 9, 6, 3, -24 },
  { 236, 9, 29, 8, 1, -24 },
  { 269, 9, 29, 8, -2, -24 },
  { 302, 12, 12, 15, 4, -25 },
  { 320, 14, 15, 17, 2, -19 },
  { 347, 4, 8, 6, -1, -4 },
  { 351, 8, 2, 10, 1, -10 },
  { 353, 2, 2, 7, 1, -2 },
  { 354, 14, 24, 10, -1, -24 },
  { 396, 13, 24, 16, 2, -24 },
  { 435, 7, 24, 16, 5, -24 },
  { 456, 15, 24, 16, 0, -24 },
  { 501, 15, 24, 16, 0, -24 },
  { 546, 15, 24, 16, 0, -24 },
  { 591, 16, 24, 16, 0, -24 },
  { 639, 14, 24, 16, 2, -24 },
  { 681, 13, 24, 16, 3, -24 },
  { 720, 15, 24, 16, 1, -24 },
  { 765, 14, 24, 16, 1, -24 },
  { 807, 5, 18, 7, 1, -18 },
  { 819, 8, 22, 7, -2, -18 },
  { 841, 14, 14, 17, 2, -19 },
  { 866, 14, 8, 17, 2, -16 },
  { 880, 14, 14, 17, 2, -19 },
  { 905, 10, 24, 12, 2, -24 },
  { 935, 22, 26, 24, 1, -23 },
  { 1007, 16, 24, 16, -2, -24 },
  { 1055, 16, 24, 17, 1, -24 },
  { 1103, 16, 24, 17, 2, -24 },
  { 1151, 17, 24, 19, 1, -24 },
  { 1202, 15, 24, 15, 1, -24 },
  { 1247, 15, 24, 14, 1, -24 },
  { 1292, 18, 24, 20, 2, -24 },
  { 1346, 19, 24, 20, 1, -24 },
  { 1403, 11, 24, 8, -1, -24 },
  { 1436, 12, 30, 7, -5, -24 },
  { 1481, 17, 24, 16, 1, -24 },
  { 1532, 10, 24, 14, 1, -24 },
  { 1562, 23, 24, 24, 1, -24 },
  { 1631, 19, 24, 20, 1, -24 },
  { 1688, 17, 24, 21, 2, -24 },
  { 1739, 15, 24, 16, 1, -24 },
  { 1784, 17, 30, 21, 2, -24 },
  { 1848, 15, 24, 16, 1, -24 },
  { 1893, 15, 24, 15, 0, -24 },
  { 1938, 14, 24, 14, 3, -24 },
  { 1980, 18, 24, 20, 2, -24 },
  { 2034, 15, 24, 16, 3, -24 },
  { 2079, 23, 24, 25, 4, -24 },
  { 2148, 19, 24, 14, -2, -24 },
  { 2205, 14, 24, 14, 3, -24 },
  { 2247, 17, 24, 15, -1, -24 },
  { 2298, 12, 29, 10, 0, -24 },
  { 2342, 5, 24, 11, 3, -24 },
  { 2357, 12, 29, 10, -2, -24 },
  { 2401, 14, 14, 16, 1, -24 },
  { 2426, 12, 1, 11, -3, 3 },
  { 2428, 4, 5, 8, 5, -25 },
  { 2431, 14, 18, 16, 1, -18 },
  { 2463, 14, 25, 17, 1, -25 },
  { 2507, 12, 18, 13, 1, -18 },
  { 2534, 16, 25, 17, 1, -25 },
  { 2584, 12, 18, 14, 2, -18 },
  { 2611, 17, 33, 8, -4, -25 },
  { 2682, 16, 26, 17, 0, -18 },
  { 2734, 14, 25, 16, 1, -25 },
  { 2778, 6, 24, 7, 1, -24 },
  { 2796, 11, 32, 7, -4, -24 },
  { 2840, 13, 25, 13, 1, -25 },
  { 2881, 6, 25, 6, 1, -25 },
  { 2900, 22, 18, 24, 1, -18 },
  { 2950, 14, 18, 16, 1, -18 },
  { 2982, 14, 18, 16, 1, -18 },
  { 3014, 16, 26, 17, -1, -18 },
  { 3066, 15, 26, 17, 1, -18 },
  { 3115, 11, 18, 11, 1, -18 },
  { 3140, 12, 18, 12, 0, -18 },
  { 3167, 9, 22, 9, 1, -22 },
  { 3192, 14, 17, 16, 1, -17 },
  { 3222, 12, 17, 12, 2, -17 },
  { 3248, 19, 17, 20, 2, -17 },
  { 3289, 15, 17, 13, -1, -17 },
  { 3321, 18, 25, 12, -4, -17 },
  { 3378, 13, 17, 12, -1, -17 },
  { 3406, 12, 29, 11, 1, -24 },
  { 3450, 1, 33, 15, 8, -25 },
  { 3455, 12, 29, 11, -2, -24 },
  { 3499, 14, 3, 17, 2, -13 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic33pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC33PT7B_H_
