#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC14PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x94, 0x92, 0x10, 0x55, 0xAA, 0x12, 0x12, 0x14, 0x7F, 0x24,
  0x24, 0xFE, 0x48, 0x48, 0x50, 0x08, 0x72, 0x92, 0x50, 0xC1, 0x85, 0x26,
  0xA7, 0x08, 0x72, 0x92, 0x94, 0x98, 0xAF, 0xF5, 0x29, 0x29, 0x49, 0xCE,
  0x1C, 0x48, 0x91, 0x41, 0x0E, 0x52, 0xC5, 0x84, 0xF4, 0x5A, 0x12, 0x24,
  0x44, 0x88, 0x88, 0x84, 0x11, 0x11, 0x11, 0x11, 0x22, 0x48, 0x21, 0x36,
  0xCA, 0x08, 0x20, 0x82, 0x3F, 0x20, 0x80, 0x56, 0xF0, 0x80, 0x04, 0x10,
  0x82, 0x10, 0x42, 0x08, 0x42, 0x00, 0x39, 0x18, 0x61, 0x86, 0x28, 0xA2,
  0x93, 0x80, 0x3C, 0x94, 0x92, 0x50, 0x3C, 0x10, 0x41, 0x04, 0x21, 0x08,
  0x43, 0xE0, 0x3C, 0x10, 0x41, 0x38, 0x20, 0x41, 0x0B, 0xC0, 0x04, 0x31,
  0x45, 0x25, 0x28, 0xBF, 0x08, 0x20, 0x1E, 0x40, 0x82, 0x07, 0x80, 0x81,
  0x02, 0x09, 0xE0, 0x3D, 0x04, 0x20, 0xFA, 0x28, 0xA2, 0x8B, 0xC0, 0x7C,
  0x10, 0x84, 0x10, 0x82, 0x10, 0x42, 0x00, 0x1C, 0x44, 0x89, 0x21, 0x8D,
  0x21, 0x42, 0x84, 0xF0, 0x3C, 0x94, 0x51, 0x44, 0xF0, 0x42, 0x0B, 0xC0,
  0x20, 0x00, 0x20, 0x10, 0x00, 0x02, 0x44, 0x80, 0x0C, 0xCC, 0x10, 0x30,
  0x30, 0xFC, 0x00, 0x3F, 0xC0, 0xC0, 0xC6, 0x62, 0x00, 0xF1, 0x11, 0x24,
  0x88, 0x08, 0x1E, 0x10, 0x90, 0x33, 0xDA, 0x4D, 0x26, 0x95, 0x5A, 0x92,
  0x40, 0x1F, 0x00, 0x04, 0x18, 0x30, 0xA1, 0x24, 0x4F, 0xA1, 0x43, 0x04,
  0x3E, 0x44, 0x89, 0x17, 0xC8, 0x90, 0xA1, 0x45, 0xF0, 0x3E, 0x81, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x80, 0xF0, 0x3C, 0x22, 0x21, 0x21, 0x41, 0x41,
  0x42, 0x42, 0x44, 0xF8, 0x3E, 0x40, 0x81, 0x03, 0xC8, 0x10, 0x20, 0x41,
  0xF0, 0x3E, 0x40, 0x81, 0x04, 0x0F, 0x90, 0x20, 0x41, 0x00, 0x3E, 0x81,
  0x04, 0x08, 0x11, 0xE0, 0xC2, 0x84, 0xF8, 0x21, 0x21, 0x21, 0x21, 0x7F,
  0x42, 0x42, 0x42, 0x42, 0x82, 0x32, 0x22, 0x24, 0x44, 0x4C, 0x08, 0x42,
  0x11, 0x08, 0x42, 0x11, 0x09, 0xC0, 0x21, 0x22, 0x24, 0x28, 0x50, 0x70,
  0x48, 0x48, 0x48, 0x84, 0x21, 0x08, 0x44, 0x21, 0x08, 0x47, 0xC0, 0x20,
  0x48, 0x13, 0x0C, 0xC5, 0x51, 0x54, 0xA5, 0x29, 0x52, 0x48, 0xA2, 0x20,
  0x20, 0x98, 0x8C, 0x46, 0x24, 0x92, 0x49, 0x28, 0x8C, 0x46, 0x41, 0x00,
  0x3C, 0x85, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x84, 0xF0, 0x3C, 0x44, 0x89,
  0x14, 0x4F, 0x10, 0x20, 0x41, 0x00, 0x3C, 0x85, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x84, 0xD0, 0x40, 0x40, 0x3C, 0x44, 0x89, 0x14, 0x4F, 0x12, 0x24,
  0x49, 0x08, 0x3D, 0x04, 0x10, 0x20, 0x60, 0x81, 0x0B, 0xC0, 0xFC, 0x82,
  0x08, 0x20, 0x84, 0x10, 0x41, 0x00, 0x42, 0x85, 0x0C, 0x18, 0x30, 0x61,
  0x42, 0x84, 0xF0, 0x83, 0x0A, 0x14, 0x48, 0x8A, 0x14, 0x30, 0x40, 0x80,
  0x88, 0xE2, 0x29, 0x8A, 0xA4, 0xA9, 0x2A, 0x8C, 0xA2, 0x30, 0x84, 0x22,
  0x00, 0x11, 0x12, 0x14, 0x14, 0x08, 0x18, 0x18, 0x24, 0x44, 0x84, 0x86,
  0x24, 0x94, 0x61, 0x84, 0x10, 0x41, 0x00, 0x3E, 0x08, 0x10, 0x41, 0x04,
  0x08, 0x20, 0x81, 0xF0, 0x39, 0x08, 0x84, 0x21, 0x08, 0x84, 0x21, 0xC0,
  0x91, 0x24, 0x92, 0x24, 0x18, 0x42, 0x11, 0x08, 0x42, 0x11, 0x09, 0xC0,
  0x10, 0xC4, 0x92, 0x8A, 0x10, 0xF8, 0xA4, 0x35, 0x28, 0xA2, 0x8A, 0x29,
  0x3C, 0x20, 0x82, 0x0E, 0x65, 0x14, 0x51, 0x45, 0x1F, 0x80, 0x3A, 0x21,
  0x08, 0x42, 0x1E, 0x04, 0x10, 0x4D, 0x4A, 0x28, 0xA2, 0x8A, 0x4F, 0x00,
  0x32, 0x63, 0x2E, 0x42, 0x1E, 0x06, 0x10, 0x20, 0xE0, 0x82, 0x04, 0x08,
  0x10, 0x20, 0x81, 0x02, 0x18, 0x00, 0x18, 0x4D, 0x12, 0x28, 0x50, 0xA2,
  0x3C, 0x08, 0x13, 0xC0, 0x20, 0x82, 0x0E, 0x65, 0x14, 0x51, 0x46, 0x18,
  0x80, 0x20, 0x24, 0x92, 0x90, 0x08, 0x00, 0x21, 0x08, 0x42, 0x21, 0x08,
  0x4C, 0x00, 0x20, 0x82, 0x09, 0x49, 0x45, 0x1C, 0x52, 0x48, 0x80, 0x24,
  0x94, 0x92, 0x52, 0x00, 0x19, 0x89, 0x94, 0x45, 0x11, 0x44, 0x52, 0x28,
  0x8A, 0x22, 0x18, 0x94, 0x51, 0x45, 0x18, 0x62, 0x32, 0x63, 0x18, 0xC6,
  0x3E, 0x19, 0x94, 0x51, 0x45, 0x14, 0x7E, 0x82, 0x08, 0x00, 0x31, 0x38,
  0xA2, 0x8A, 0x29, 0x3C, 0x10, 0x41, 0x00, 0x19, 0x10, 0x84, 0x22, 0x10,
  0x3A, 0x10, 0x82, 0x08, 0x5E, 0x4E, 0x49, 0x24, 0xC0, 0x8C, 0x63, 0x18,
  0xCB, 0xC0, 0x8C, 0xA5, 0x4A, 0x62, 0x00, 0x91, 0xB2, 0xAA, 0xAC, 0xCC,
  0x88, 0x88, 0x26, 0x28, 0x60, 0x82, 0x89, 0x31, 0x00, 0x11, 0x12, 0x12,
  0x14, 0x14, 0x18, 0x10, 0x10, 0x10, 0xE0, 0x78, 0x84, 0x44, 0x43, 0xC0,
  0x08, 0x88, 0x42, 0x13, 0x08, 0x42, 0x10, 0xC0, 0xFF, 0xFC, 0x10, 0x42,
  0x21, 0x08, 0x62, 0x21, 0x09, 0x80, 0x66, 0x60,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 10, 3, 0, -10 },
  { 5, 4, 4, 4, 1, -10 },
  { 7, 8, 10, 7, 0, -10 },
  { 17, 6, 12, 7, 0, -11 },
  { 26, 8, 10, 10, 1, -10 },
  { 36, 7, 10, 8, 0, -10 },
  { 45, 2, 4, 2, 1, -10 },
  { 46, 4, 12, 3, 0, -10 },
  { 52, 4, 12, 3, -1, -10 },
  { 58, 5, 6, 6, 2, -11 },
  { 62, 6, 6, 7, 1, -8 },
  { 67, 2, 4, 3, -1, -2 },
  { 68, 4, 1, 4, 0, -4 },
  { 69, 1, 1, 3, 0, -1 },
  { 70, 6, 10, 4, -1, -10 },
  { 78, 6, 10, 7, 1, -10 },
  { 86, 3, 10, 7, 2, -10 },
  { 90, 6, 10, 7, 0, -10 },
  { 98, 6, 10, 7, 0, -10 },
  { 106, 6, 10, 7, 0, -10 },
  { 114, 7, 10, 7, 0, -10 },
  { 123, 6, 10, 7, 1, -10 },
  { 131, 6, 10, 7, 1, -10 },
  { 139, 7, 10, 7, 0, -10 },
  { 148, 6, 10, 7, 0, -10 },
  { 156, 3, 7, 3, 0, -7 },
  { 159, 4, 9, 3, -1, -7 },
  { 164, 6, 6, 7, 1, -8 },
  { 169, 6, 4, 7, 1, -7 },
  { 172, 6, 6, 7, 1, -8 },
  { 177, 4, 10, 5, 1, -10 },
  { 182, 9, 11, 10, 1, -10 },
  { 195, 7, 10, 7, -1, -10 },
  { 204, 7, 10, 7, 0, -10 },
  { 213, 7, 10, 7, 1, -10 },
  { 222, 8, 10, 8, 0, -10 },
  { 232, 7, 10, 6, 0, -10 },
  { 241, 7, 10, 6, 0, -10 },
  { 250, 7, 10, 8, 1, -10 },
  { 259, 8, 10, 8, 0, -10 },
  { 269, 4, 10, 4, 0, -10 },
  { 274, 5, 12, 3, -2, -10 },
  { 282, 8, 10, 7, 0, -10 },
  { 292, 5, 10, 6, 0, -10 },
  { 299, 10, 10, 10, 0, -10 },
  { 312, 9, 10, 8, 0, -10 },
  { 324, 7, 10, 9, 1, -10 },
  { 333, 7, 10, 7, 0, -10 },
  { 342, 7, 12, 9, 1, -10 },
  { 353, 7, 10, 7, 0, -10 },
  { 362, 6, 10, 6, 0, -10 },
  { 370, 6, 10, 6, 1, -10 },
  { 378, 7, 10, 8, 1, -10 },
  { 387, 7, 10, 7, 1, -10 },
  { 396, 10, 10, 11, 2, -10 },
  { 409, 8, 10, 6, -1, -10 },
  { 419, 6, 10, 6, 1, -10 },
  { 427, 7, 10, 6, 0, -10 },
  { 436, 5, 12, 4, 0, -10 },
  { 444, 3, 10, 4, 1, -10 },
  { 448, 5, 12, 4, -1, -10 },
  { 456, 6, 6, 7, 1, -10 },
  { 461, 5, 1, 5, -1, 1 },
  { 462, 2, 3, 3, 2, -11 },
  { 463, 6, 8, 7, 1, -8 },
  { 469, 6, 11, 7, 0, -11 },
  { 478, 5, 8, 5, 1, -8 },
  { 483, 6, 11, 7, 1, -11 },
  { 492, 5, 8, 6, 1, -8 },
  { 497, 7, 14, 3, -2, -11 },
  { 510, 7, 11, 7, 0, -8 },
  { 520, 6, 11, 7, 0, -11 },
  { 529, 3, 10, 3, 0, -10 },
  { 533, 5, 13, 3, -2, -10 },
  { 542, 6, 11, 6, 0, -11 },
  { 551, 3, 11, 3, 0, -11 },
  { 556, 10, 8, 10, 0, -8 },
  { 566, 6, 8, 7, 0, -8 },
  { 572, 5, 8, 7, 1, -8 },
  { 577, 6, 11, 7, 0, -8 },
  { 586, 6, 11, 7, 1, -8 },
  { 595, 5, 8, 5, 0, -8 },
  { 600, 5, 8, 5, 0, -8 },
  { 605, 3, 9, 4, 1, -9 },
  { 609, 5, 7, 7, 1, -7 },
  { 614, 5, 7, 5, 1, -7 },
  { 619, 8, 7, 8, 1, -7 },
  { 626, 7, 7, 6, -1, -7 },
  { 633, 8, 10, 5, -2, -7 },
  { 643, 5, 7, 5, 0, -7 },
  { 648, 5, 12, 5, 0, -10 },
  { 656, 1, 14, 7, 3, -11 },
  { 658, 5, 12, 5, -1, -10 },
  { 666, 6, 2, 7, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic14pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC14PT7B_H_
