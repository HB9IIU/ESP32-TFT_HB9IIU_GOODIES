#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC20PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x84, 0x21, 0x10, 0x84, 0x22, 0x00, 0x00, 0x60, 0x4A, 0xA5,
  0x29, 0x00, 0x04, 0x40, 0x88, 0x12, 0x04, 0x43, 0xFE, 0x12, 0x04, 0x40,
  0x88, 0x11, 0x1F, 0xD8, 0x88, 0x11, 0x02, 0x40, 0x88, 0x00, 0x04, 0x0E,
  0x35, 0x48, 0x48, 0x48, 0x28, 0x10, 0x1C, 0x12, 0x12, 0x12, 0x14, 0xF8,
  0x20, 0x20, 0x3C, 0x24, 0x44, 0x44, 0x84, 0x48, 0x89, 0x08, 0xA6, 0x8A,
  0x95, 0x51, 0x25, 0x10, 0x91, 0x12, 0x21, 0x22, 0x22, 0x24, 0x1C, 0x02,
  0x01, 0xA0, 0x22, 0x08, 0x41, 0x08, 0x22, 0x03, 0x80, 0x40, 0x34, 0x28,
  0x49, 0x09, 0x40, 0xC8, 0x10, 0x85, 0x1F, 0x30, 0x5A, 0x80, 0x08, 0x88,
  0x44, 0x22, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0xC0, 0x18, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x21, 0x10, 0x88, 0x80, 0x08, 0x08, 0xE8, 0x1F,
  0x28, 0x48, 0x44, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x00, 0x29, 0x28, 0xF0, 0xC0, 0x01, 0x80, 0x80, 0x80, 0x40,
  0x40, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x00, 0x04,
  0x1B, 0x21, 0x21, 0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x84,
  0x84, 0x78, 0x35, 0x91, 0x12, 0x22, 0x24, 0x44, 0x44, 0x1F, 0x00, 0x40,
  0x20, 0x10, 0x08, 0x08, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x07,
  0xF0, 0x1F, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x78, 0x04, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x27, 0xE0, 0x01, 0x80, 0xC0, 0xA0, 0xA0, 0x90, 0x88,
  0x44, 0x42, 0x42, 0x41, 0x1F, 0xE0, 0x40, 0x40, 0x20, 0x1F, 0x88, 0x04,
  0x02, 0x02, 0x01, 0xE0, 0x88, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x27,
  0xE0, 0x03, 0x86, 0x04, 0x04, 0x04, 0x02, 0x01, 0x71, 0x44, 0xC1, 0x40,
  0xA0, 0x50, 0x48, 0x24, 0x21, 0xE0, 0xFF, 0x02, 0x02, 0x04, 0x04, 0x08,
  0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0x80, 0x80, 0x0F, 0x88, 0x44, 0x22,
  0x11, 0x08, 0x58, 0x30, 0x64, 0x41, 0x20, 0xA0, 0x50, 0x24, 0x11, 0xF0,
  0x1E, 0x21, 0x41, 0x41, 0x41, 0x41, 0x43, 0x65, 0x1A, 0x02, 0x02, 0x04,
  0x08, 0xF0, 0x12, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x08, 0x80, 0x00, 0x00,
  0x00, 0x01, 0x10, 0x88, 0x40, 0x00, 0x81, 0x83, 0x06, 0x0C, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x18, 0x30, 0x60, 0xC0, 0x00, 0x7C, 0x04, 0x08, 0x20,
  0x41, 0x04, 0x10, 0x40, 0x80, 0x00, 0x00, 0x10, 0x00, 0x07, 0xE0, 0xC0,
  0x88, 0x02, 0x40, 0x14, 0x7C, 0xA4, 0x46, 0x22, 0x32, 0x11, 0x90, 0x8C,
  0x88, 0xA4, 0xA9, 0x19, 0x88, 0x00, 0x20, 0x00, 0x80, 0x03, 0xE0, 0x01,
  0x01, 0x80, 0xC0, 0x90, 0x48, 0x44, 0x22, 0x21, 0x1F, 0x90, 0x48, 0x28,
  0x14, 0x0C, 0x04, 0x3F, 0x10, 0x48, 0x24, 0x12, 0x0A, 0x09, 0xF8, 0x86,
  0x41, 0x40, 0xA0, 0x50, 0x28, 0x27, 0xE0, 0x0F, 0xC4, 0x02, 0x00, 0x80,
  0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x0F,
  0x80, 0x3F, 0x08, 0x22, 0x04, 0x81, 0x20, 0x50, 0x14, 0x05, 0x01, 0x40,
  0x60, 0x28, 0x0A, 0x04, 0x86, 0x3E, 0x00, 0x3F, 0x90, 0x08, 0x04, 0x02,
  0x02, 0x01, 0xF8, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x07, 0xE0, 0x3F,
  0x90, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0xFC, 0x40, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x00, 0x0F, 0xE2, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20,
  0x04, 0x1E, 0x80, 0x50, 0x12, 0x02, 0x20, 0x44, 0x08, 0x7E, 0x00, 0x20,
  0x24, 0x04, 0x80, 0x90, 0x22, 0x04, 0x80, 0x9F, 0xF2, 0x04, 0x40, 0x90,
  0x12, 0x02, 0x40, 0x48, 0x11, 0x02, 0x00, 0x1C, 0x41, 0x04, 0x10, 0x42,
  0x08, 0x20, 0x82, 0x10, 0x43, 0x80, 0x02, 0x04, 0x08, 0x10, 0x20, 0x81,
  0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x21, 0x80, 0x20, 0xC8,
  0x42, 0x20, 0x98, 0x2C, 0x12, 0x05, 0x01, 0xA0, 0x48, 0x21, 0x08, 0x42,
  0x10, 0x82, 0x20, 0x80, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x42, 0x08,
  0x20, 0x83, 0xF0, 0x30, 0x0C, 0xC0, 0x53, 0x01, 0x8C, 0x0A, 0x50, 0x29,
  0x21, 0x24, 0x85, 0x12, 0x24, 0x48, 0x92, 0x24, 0x48, 0x91, 0x22, 0x88,
  0x8C, 0x22, 0x10, 0x80, 0x30, 0x26, 0x04, 0xC0, 0x94, 0x22, 0x84, 0x90,
  0x91, 0x12, 0x22, 0x44, 0x90, 0x52, 0x0A, 0x41, 0x48, 0x11, 0x02, 0x00,
  0x03, 0x01, 0x90, 0x41, 0x10, 0x14, 0x02, 0x80, 0x50, 0x0C, 0x01, 0x80,
  0x30, 0x0A, 0x01, 0x40, 0x24, 0x08, 0x82, 0x0F, 0x80, 0x3F, 0x10, 0x48,
  0x24, 0x12, 0x0A, 0x09, 0x0C, 0xF8, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x00, 0x03, 0x01, 0x90, 0x41, 0x10, 0x14, 0x02, 0x80, 0x50, 0x0C, 0x01,
  0x80, 0x30, 0x0A, 0x01, 0x40, 0x24, 0x08, 0x82, 0x0F, 0x80, 0x20, 0x04,
  0x00, 0x40, 0x3F, 0x10, 0x48, 0x24, 0x12, 0x0A, 0x09, 0x08, 0xF8, 0x44,
  0x42, 0x21, 0x10, 0x88, 0x24, 0x10, 0x1F, 0x90, 0x08, 0x04, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x20, 0x27, 0xE0, 0xFF, 0x10,
  0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40,
  0x20, 0x24, 0x04, 0x80, 0x90, 0x24, 0x04, 0x80, 0x90, 0x12, 0x02, 0x40,
  0x90, 0x12, 0x02, 0x40, 0x84, 0x10, 0x7C, 0x00, 0x80, 0xC0, 0xA0, 0x50,
  0x48, 0x24, 0x22, 0x11, 0x10, 0x88, 0x28, 0x14, 0x0C, 0x06, 0x02, 0x00,
  0x81, 0x06, 0x0C, 0x18, 0x30, 0xA1, 0x42, 0x85, 0x12, 0x24, 0x48, 0x91,
  0x24, 0x48, 0x91, 0x22, 0x85, 0x0A, 0x14, 0x28, 0x60, 0xC1, 0x83, 0x04,
  0x00, 0x10, 0x21, 0x08, 0x22, 0x04, 0x80, 0x50, 0x0C, 0x01, 0x00, 0x50,
  0x0A, 0x02, 0x40, 0x88, 0x10, 0x84, 0x11, 0x02, 0x00, 0x81, 0x82, 0x84,
  0x44, 0x48, 0x48, 0x50, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x1F,
  0xC0, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x80, 0x3F, 0x80, 0x1E, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10,
  0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0xF0, 0x92, 0x44, 0x92, 0x48,
  0x92, 0x40, 0x1E, 0x04, 0x08, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20,
  0x41, 0x02, 0x04, 0x08, 0xE0, 0x0C, 0x0C, 0x12, 0x22, 0x22, 0x41, 0x81,
  0x81, 0xFE, 0x94, 0x1D, 0x23, 0x41, 0x41, 0x81, 0x82, 0x82, 0x82, 0x86,
  0x8A, 0x74, 0x10, 0x08, 0x04, 0x02, 0x01, 0x71, 0x44, 0xC2, 0x41, 0x20,
  0xA0, 0x50, 0x28, 0x14, 0x12, 0x12, 0xF0, 0x1E, 0x41, 0x02, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x01, 0xE0, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x1C, 0x88,
  0xC4, 0x11, 0x04, 0x81, 0x20, 0x48, 0x22, 0x08, 0x86, 0x21, 0x87, 0xA0,
  0x1C, 0x45, 0x0A, 0x18, 0x5F, 0x20, 0x40, 0x81, 0x01, 0xF0, 0x01, 0xE0,
  0x40, 0x08, 0x01, 0x00, 0xF8, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x70, 0x00, 0x0E, 0x44, 0x62, 0x08, 0x82, 0x40, 0x90, 0x24, 0x11, 0x04,
  0x43, 0x10, 0xC3, 0xD0, 0x08, 0x02, 0x00, 0x88, 0x41, 0xE0, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x71, 0x44, 0xC2, 0x41, 0x20, 0xA0, 0x90, 0x48, 0x24,
  0x12, 0x0A, 0x08, 0x10, 0x01, 0x22, 0x22, 0x44, 0x44, 0x48, 0x02, 0x00,
  0x00, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08,
  0x10, 0x43, 0x00, 0x10, 0x08, 0x04, 0x02, 0x01, 0x09, 0x08, 0x88, 0x48,
  0x28, 0x2C, 0x1A, 0x08, 0x84, 0x42, 0x22, 0x08, 0x11, 0x11, 0x12, 0x22,
  0x24, 0x44, 0x44, 0x80, 0x26, 0x38, 0xA5, 0x13, 0x08, 0x48, 0x41, 0x21,
  0x05, 0x04, 0x24, 0x10, 0x90, 0x42, 0x42, 0x09, 0x08, 0x28, 0x21, 0x00,
  0x27, 0x14, 0x4C, 0x24, 0x12, 0x0A, 0x09, 0x04, 0x82, 0x41, 0x20, 0xA0,
  0x80, 0x1C, 0x22, 0x41, 0x41, 0x81, 0x81, 0x81, 0x82, 0x82, 0x84, 0x78,
  0x13, 0x85, 0x11, 0x84, 0x41, 0x10, 0x48, 0x12, 0x04, 0x81, 0x20, 0x88,
  0x45, 0xE1, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x1C, 0x91, 0x90, 0x48,
  0x28, 0x14, 0x0A, 0x09, 0x04, 0x86, 0x43, 0x1E, 0x80, 0x80, 0x40, 0x20,
  0x10, 0x10, 0x26, 0x50, 0xC1, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x00,
  0x1C, 0x45, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x0B, 0xE0, 0x21, 0x3E,
  0x84, 0x21, 0x10, 0x84, 0x21, 0x0E, 0x00, 0x41, 0x41, 0x41, 0x41, 0x41,
  0x82, 0x82, 0x82, 0x86, 0x8C, 0xF4, 0x83, 0x06, 0x14, 0x28, 0x91, 0x24,
  0x28, 0x60, 0xC1, 0x00, 0x84, 0x18, 0x42, 0x8A, 0x28, 0xA4, 0x92, 0x49,
  0x24, 0x92, 0x8A, 0x28, 0xA3, 0x0C, 0x30, 0xC2, 0x00, 0x10, 0x88, 0x44,
  0x41, 0x40, 0xC0, 0x40, 0x30, 0x28, 0x22, 0x21, 0x30, 0x80, 0x10, 0x22,
  0x08, 0x41, 0x08, 0x41, 0x08, 0x12, 0x02, 0x40, 0x50, 0x0C, 0x01, 0x80,
  0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x06, 0x00, 0x3F, 0x02, 0x04, 0x04,
  0x08, 0x10, 0x20, 0x20, 0x40, 0x80, 0xFC, 0x0E, 0x20, 0x40, 0x82, 0x04,
  0x08, 0x20, 0x80, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x60, 0xFF, 0xFF,
  0xF0, 0x1C, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x06, 0x10, 0x20, 0x81,
  0x02, 0x04, 0x10, 0xC0, 0x78, 0xC3, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 14, 4, 0, -14 },
  { 10, 5, 5, 6, 2, -14 },
  { 14, 11, 14, 11, 0, -14 },
  { 34, 8, 16, 10, 1, -15 },
  { 50, 12, 14, 14, 1, -14 },
  { 71, 11, 15, 11, 0, -15 },
  { 92, 2, 5, 3, 2, -14 },
  { 94, 5, 17, 5, 1, -14 },
  { 105, 5, 17, 5, -1, -14 },
  { 116, 8, 7, 9, 2, -15 },
  { 123, 9, 10, 10, 1, -12 },
  { 135, 3, 5, 4, -1, -2 },
  { 137, 4, 1, 6, 1, -6 },
  { 138, 2, 1, 4, 0, -1 },
  { 139, 9, 14, 6, -1, -14 },
  { 155, 8, 15, 10, 1, -15 },
  { 170, 4, 14, 10, 3, -14 },
  { 177, 9, 14, 10, 0, -14 },
  { 193, 9, 14, 10, 0, -14 },
  { 209, 9, 14, 10, 0, -14 },
  { 225, 9, 14, 10, 0, -14 },
  { 241, 9, 15, 10, 1, -15 },
  { 258, 8, 14, 10, 2, -14 },
  { 272, 9, 14, 10, 0, -14 },
  { 288, 8, 14, 10, 1, -14 },
  { 302, 4, 11, 4, 0, -11 },
  { 308, 5, 14, 4, -1, -11 },
  { 317, 9, 9, 10, 1, -12 },
  { 328, 9, 4, 10, 1, -9 },
  { 333, 9, 9, 10, 1, -12 },
  { 344, 7, 14, 7, 1, -14 },
  { 357, 13, 16, 14, 1, -14 },
  { 383, 9, 14, 9, -1, -14 },
  { 399, 9, 14, 10, 1, -14 },
  { 415, 10, 14, 10, 1, -14 },
  { 433, 10, 14, 12, 1, -14 },
  { 451, 9, 14, 9, 1, -14 },
  { 467, 9, 14, 8, 1, -14 },
  { 483, 11, 14, 12, 1, -14 },
  { 503, 11, 14, 12, 1, -14 },
  { 523, 6, 14, 5, 0, -14 },
  { 534, 7, 18, 4, -3, -14 },
  { 550, 10, 14, 10, 1, -14 },
  { 568, 6, 14, 8, 1, -14 },
  { 579, 14, 14, 15, 1, -14 },
  { 604, 11, 14, 12, 1, -14 },
  { 624, 11, 15, 12, 1, -15 },
  { 645, 9, 14, 10, 1, -14 },
  { 661, 11, 18, 12, 1, -15 },
  { 686, 9, 14, 10, 1, -14 },
  { 702, 9, 14, 9, 0, -14 },
  { 718, 8, 14, 8, 2, -14 },
  { 732, 11, 14, 12, 1, -14 },
  { 752, 9, 14, 9, 2, -14 },
  { 768, 14, 14, 15, 2, -14 },
  { 793, 11, 14, 9, -1, -14 },
  { 813, 8, 14, 8, 2, -14 },
  { 827, 10, 14, 9, 0, -14 },
  { 845, 7, 17, 6, 0, -14 },
  { 860, 3, 14, 6, 2, -14 },
  { 866, 7, 17, 6, -1, -14 },
  { 881, 8, 8, 10, 1, -14 },
  { 889, 7, 1, 7, -2, 2 },
  { 890, 2, 3, 5, 3, -15 },
  { 891, 8, 11, 10, 1, -11 },
  { 902, 9, 15, 10, 0, -15 },
  { 919, 7, 11, 8, 1, -11 },
  { 929, 10, 15, 10, 1, -15 },
  { 948, 7, 11, 9, 1, -11 },
  { 958, 11, 20, 5, -3, -15 },
  { 986, 10, 16, 10, 0, -11 },
  { 1006, 9, 15, 10, 0, -15 },
  { 1023, 4, 14, 4, 0, -14 },
  { 1030, 7, 19, 4, -3, -14 },
  { 1047, 9, 15, 8, 0, -15 },
  { 1064, 4, 15, 4, 0, -15 },
  { 1072, 14, 11, 15, 0, -11 },
  { 1092, 9, 11, 10, 0, -11 },
  { 1105, 8, 11, 10, 1, -11 },
  { 1116, 10, 16, 10, -1, -11 },
  { 1136, 9, 16, 10, 1, -11 },
  { 1154, 7, 11, 7, 0, -11 },
  { 1164, 7, 11, 7, 0, -11 },
  { 1174, 5, 13, 5, 1, -13 },
  { 1183, 8, 11, 10, 1, -11 },
  { 1194, 7, 11, 7, 1, -11 },
  { 1204, 12, 11, 12, 1, -11 },
  { 1221, 9, 11, 8, -1, -11 },
  { 1234, 11, 16, 8, -2, -11 },
  { 1256, 8, 11, 7, 0, -11 },
  { 1267, 7, 17, 7, 1, -14 },
  { 1282, 1, 20, 9, 4, -15 },
  { 1285, 7, 17, 6, -1, -14 },
  { 1300, 9, 2, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic20pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC20PT7B_H_
