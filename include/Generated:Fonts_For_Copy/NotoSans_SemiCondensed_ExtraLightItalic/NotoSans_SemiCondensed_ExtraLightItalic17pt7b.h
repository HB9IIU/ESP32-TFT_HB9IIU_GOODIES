#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC17PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x22, 0x22, 0x24, 0x40, 0x0C, 0x9A, 0xAA, 0x09, 0x04, 0x82,
  0x47, 0xB5, 0x20, 0x90, 0x49, 0xFE, 0x24, 0x12, 0x11, 0x09, 0x00, 0x04,
  0x0E, 0x15, 0x24, 0x28, 0x28, 0x18, 0x0C, 0x12, 0x12, 0x12, 0xFC, 0x10,
  0x20, 0x78, 0x92, 0x48, 0x92, 0x28, 0x94, 0xA5, 0x5A, 0xA5, 0x29, 0x14,
  0x49, 0x12, 0x49, 0x0C, 0x0E, 0x08, 0x84, 0x42, 0x41, 0x40, 0xC0, 0xA0,
  0x89, 0x85, 0x41, 0x21, 0x8F, 0x20, 0xF0, 0x12, 0x44, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x80, 0x10, 0x82, 0x10, 0x84, 0x21, 0x10, 0x84, 0x44, 0x22,
  0x00, 0x10, 0x4D, 0x0F, 0x52, 0x60, 0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04,
  0x08, 0x29, 0x40, 0xE0, 0xC0, 0x03, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10,
  0x10, 0x20, 0x40, 0x40, 0x80, 0x3C, 0x45, 0x0A, 0x18, 0x30, 0x60, 0xC2,
  0x85, 0x0A, 0x23, 0x80, 0x17, 0x91, 0x22, 0x22, 0x24, 0x44, 0x3E, 0x01,
  0x01, 0x01, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFC, 0x3E, 0x01,
  0x01, 0x01, 0x02, 0x1C, 0x04, 0x02, 0x02, 0x02, 0x04, 0xF8, 0x03, 0x05,
  0x06, 0x0A, 0x12, 0x22, 0x44, 0x44, 0xFF, 0x04, 0x04, 0x08, 0x1F, 0x10,
  0x20, 0x20, 0x20, 0x3C, 0x02, 0x02, 0x02, 0x02, 0x04, 0xF8, 0x1E, 0x41,
  0x02, 0x09, 0x9C, 0xA1, 0x42, 0x85, 0x0A, 0x23, 0x80, 0x7E, 0x04, 0x10,
  0x20, 0x81, 0x04, 0x08, 0x20, 0x41, 0x06, 0x00, 0x1E, 0x21, 0x21, 0x21,
  0x12, 0x0C, 0x34, 0x42, 0x82, 0x82, 0x82, 0x7C, 0x1E, 0x21, 0x21, 0x41,
  0x41, 0x43, 0x26, 0x1A, 0x02, 0x04, 0x08, 0xF0, 0x20, 0x00, 0x00, 0x80,
  0x10, 0x00, 0x00, 0x02, 0x44, 0x80, 0x02, 0x18, 0xC6, 0x04, 0x06, 0x03,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x80, 0xC0, 0x60, 0x30, 0x43, 0x18, 0x40,
  0x78, 0x42, 0x10, 0x99, 0x08, 0x80, 0x01, 0x00, 0x0F, 0x82, 0x08, 0x80,
  0xA3, 0x98, 0x93, 0x22, 0x64, 0x4D, 0x11, 0xA2, 0x53, 0xF2, 0x00, 0x40,
  0x06, 0x20, 0x38, 0x00, 0x02, 0x06, 0x06, 0x09, 0x09, 0x11, 0x11, 0x3F,
  0x21, 0x41, 0x41, 0x81, 0x3E, 0x21, 0x41, 0x41, 0x42, 0x7C, 0x44, 0x82,
  0x82, 0x82, 0x84, 0xF8, 0x1F, 0x20, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x40, 0x3C, 0x3E, 0x21, 0x41, 0x41, 0x41, 0x41, 0x41, 0x81,
  0x81, 0x82, 0x84, 0xF8, 0x3E, 0x41, 0x02, 0x04, 0x0F, 0x90, 0x40, 0x81,
  0x02, 0x07, 0xC0, 0x3E, 0x41, 0x02, 0x04, 0x08, 0x1F, 0x40, 0x81, 0x02,
  0x04, 0x00, 0x1F, 0x90, 0x10, 0x08, 0x08, 0x04, 0x02, 0x1D, 0x02, 0x81,
  0x40, 0x90, 0x87, 0xC0, 0x20, 0x90, 0x50, 0x28, 0x14, 0x13, 0xF9, 0x05,
  0x02, 0x81, 0x41, 0x20, 0x90, 0x40, 0x38, 0x84, 0x42, 0x10, 0x84, 0x42,
  0x11, 0xC0, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20,
  0x81, 0x02, 0x38, 0x00, 0x21, 0x91, 0x11, 0x09, 0x05, 0x03, 0x81, 0x41,
  0x20, 0x88, 0x44, 0x21, 0x10, 0x80, 0x21, 0x10, 0x84, 0x21, 0x10, 0x84,
  0x21, 0xF0, 0x20, 0x32, 0x06, 0x50, 0x65, 0x0A, 0x50, 0xA5, 0x12, 0x51,
  0x49, 0x24, 0x92, 0x49, 0x44, 0x88, 0x88, 0x88, 0x20, 0x90, 0x54, 0x2A,
  0x15, 0x0A, 0x49, 0x25, 0x12, 0x85, 0x43, 0x20, 0x90, 0x40, 0x1F, 0x10,
  0x50, 0x28, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x40, 0x90, 0x8F, 0x80,
  0x3C, 0x45, 0x0A, 0x14, 0x28, 0xDE, 0x40, 0x81, 0x02, 0x04, 0x00, 0x1F,
  0x10, 0x50, 0x28, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x40, 0x90, 0x8F,
  0x80, 0x80, 0x40, 0x10, 0x3E, 0x45, 0x0A, 0x14, 0x28, 0x9E, 0x44, 0x89,
  0x12, 0x14, 0x20, 0x1F, 0x20, 0x20, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x02, 0x04, 0xF8, 0xFE, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82,
  0x04, 0x00, 0x20, 0xA0, 0x50, 0x28, 0x14, 0x12, 0x0A, 0x05, 0x02, 0x81,
  0x41, 0x20, 0x8F, 0x80, 0x83, 0x06, 0x14, 0x28, 0x91, 0x24, 0x48, 0xA1,
  0x43, 0x02, 0x00, 0x84, 0x18, 0x42, 0x8A, 0x28, 0xA2, 0x92, 0x49, 0x24,
  0xA2, 0x8A, 0x28, 0xA3, 0x0C, 0x30, 0x82, 0x08, 0x20, 0x10, 0xC4, 0x20,
  0x90, 0x28, 0x0C, 0x01, 0x00, 0xC0, 0x50, 0x24, 0x08, 0x84, 0x22, 0x08,
  0x87, 0x0A, 0x24, 0x89, 0x0C, 0x10, 0x20, 0x40, 0x82, 0x04, 0x00, 0x3F,
  0x01, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0x80, 0xFC, 0x1C,
  0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x08, 0x20, 0x82, 0x0E, 0x00, 0xAA,
  0xA5, 0x55, 0x1C, 0x10, 0x41, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10,
  0x8E, 0x00, 0x08, 0x30, 0x91, 0x24, 0x50, 0x60, 0x80, 0xF8, 0xD4, 0x3A,
  0x8E, 0x0C, 0x28, 0x50, 0xA1, 0x44, 0xF8, 0x10, 0x10, 0x20, 0x20, 0x2E,
  0x31, 0x21, 0x41, 0x41, 0x41, 0x42, 0x42, 0xBC, 0x3D, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x70, 0x01, 0x01, 0x01, 0x02, 0x3E, 0x42, 0x82, 0x82, 0x84,
  0x84, 0x84, 0x8C, 0xF4, 0x3D, 0x18, 0x62, 0xF2, 0x08, 0x20, 0x78, 0x03,
  0x04, 0x04, 0x08, 0x1E, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20,
  0x20, 0x20, 0x20, 0xC0, 0x1F, 0x21, 0x41, 0x41, 0x42, 0x42, 0x42, 0x46,
  0x7A, 0x04, 0x04, 0x04, 0xF8, 0x10, 0x20, 0x81, 0x03, 0xE4, 0x48, 0xA1,
  0x42, 0x85, 0x0A, 0x18, 0x40, 0x10, 0x02, 0x22, 0x44, 0x44, 0x88, 0x04,
  0x00, 0x02, 0x08, 0x21, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x30, 0x10,
  0x20, 0x81, 0x02, 0x24, 0x8A, 0x28, 0x70, 0x91, 0x24, 0x48, 0x40, 0x11,
  0x22, 0x22, 0x24, 0x44, 0x48, 0x80, 0x3E, 0xE2, 0x31, 0x22, 0x14, 0x21,
  0x42, 0x24, 0x22, 0x44, 0x28, 0x42, 0x84, 0x20, 0x3E, 0x21, 0x21, 0x42,
  0x42, 0x42, 0x42, 0x82, 0x84, 0x3C, 0x86, 0x0C, 0x18, 0x30, 0xA1, 0x44,
  0x70, 0x2E, 0x31, 0x21, 0x41, 0x41, 0x41, 0x42, 0x42, 0xBC, 0x80, 0x80,
  0x80, 0x80, 0x3E, 0x86, 0x0C, 0x18, 0x50, 0xA1, 0x46, 0xF4, 0x10, 0x20,
  0x40, 0x80, 0x3C, 0x82, 0x10, 0x41, 0x04, 0x20, 0x80, 0x3D, 0x04, 0x08,
  0x10, 0x20, 0x82, 0xF0, 0x44, 0xF4, 0x88, 0x88, 0x88, 0xE0, 0x42, 0x86,
  0x0C, 0x28, 0x50, 0xA1, 0x44, 0xF8, 0x86, 0x18, 0xA4, 0x92, 0x8A, 0x30,
  0x40, 0x88, 0x62, 0x29, 0x4A, 0x54, 0xA5, 0x29, 0x8C, 0x63, 0x10, 0x84,
  0x00, 0x21, 0x12, 0x14, 0x14, 0x08, 0x18, 0x24, 0x44, 0xC4, 0x10, 0x88,
  0x44, 0x42, 0x21, 0x20, 0x90, 0x30, 0x10, 0x08, 0x04, 0x04, 0x04, 0x0E,
  0x00, 0x3C, 0x10, 0x84, 0x10, 0x84, 0x20, 0xF8, 0x0E, 0x20, 0x40, 0x81,
  0x04, 0x08, 0x60, 0x20, 0x41, 0x02, 0x04, 0x08, 0x0C, 0x00, 0xFF, 0xFF,
  0x80, 0x18, 0x10, 0x82, 0x08, 0x20, 0x83, 0x10, 0x41, 0x04, 0x20, 0x8C,
  0x00, 0x73, 0x18,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 12, 4, 0, -12 },
  { 7, 4, 4, 5, 2, -12 },
  { 9, 9, 12, 9, 0, -12 },
  { 23, 8, 14, 8, 0, -13 },
  { 37, 10, 12, 12, 1, -12 },
  { 52, 9, 12, 9, 0, -12 },
  { 66, 1, 4, 3, 2, -12 },
  { 67, 4, 15, 4, 1, -12 },
  { 75, 5, 15, 4, -1, -12 },
  { 85, 6, 6, 8, 2, -13 },
  { 90, 7, 8, 9, 1, -10 },
  { 97, 3, 4, 3, -1, -2 },
  { 99, 3, 1, 5, 1, -5 },
  { 100, 2, 1, 3, 0, -1 },
  { 101, 8, 12, 5, -1, -12 },
  { 113, 7, 12, 8, 1, -12 },
  { 124, 4, 12, 8, 2, -12 },
  { 130, 8, 12, 8, 0, -12 },
  { 142, 8, 12, 8, 0, -12 },
  { 154, 8, 12, 8, 0, -12 },
  { 166, 8, 12, 8, 0, -12 },
  { 178, 7, 12, 8, 1, -12 },
  { 189, 7, 12, 8, 1, -12 },
  { 200, 8, 12, 8, 0, -12 },
  { 212, 8, 12, 8, 0, -12 },
  { 224, 3, 9, 3, 0, -9 },
  { 228, 4, 11, 3, -1, -9 },
  { 234, 7, 8, 9, 1, -10 },
  { 241, 7, 4, 9, 1, -8 },
  { 245, 7, 8, 9, 1, -10 },
  { 252, 5, 12, 6, 1, -12 },
  { 260, 11, 14, 12, 1, -12 },
  { 280, 8, 12, 8, -1, -12 },
  { 292, 8, 12, 9, 1, -12 },
  { 304, 8, 12, 9, 1, -12 },
  { 316, 8, 12, 10, 1, -12 },
  { 328, 7, 12, 8, 1, -12 },
  { 339, 7, 12, 7, 1, -12 },
  { 350, 9, 12, 10, 1, -12 },
  { 364, 9, 12, 10, 1, -12 },
  { 378, 5, 12, 4, 0, -12 },
  { 386, 7, 15, 4, -3, -12 },
  { 400, 9, 12, 8, 1, -12 },
  { 414, 5, 12, 7, 1, -12 },
  { 422, 12, 12, 13, 1, -12 },
  { 440, 9, 12, 10, 1, -12 },
  { 454, 9, 12, 11, 1, -12 },
  { 468, 7, 12, 8, 1, -12 },
  { 479, 9, 15, 11, 1, -12 },
  { 496, 7, 12, 8, 1, -12 },
  { 507, 8, 12, 8, 0, -12 },
  { 519, 7, 12, 7, 2, -12 },
  { 530, 9, 12, 10, 1, -12 },
  { 544, 7, 12, 8, 2, -12 },
  { 555, 12, 12, 13, 2, -12 },
  { 573, 10, 12, 7, -1, -12 },
  { 588, 7, 12, 7, 2, -12 },
  { 599, 8, 12, 8, 0, -12 },
  { 611, 6, 15, 5, 0, -12 },
  { 623, 2, 12, 5, 2, -12 },
  { 626, 6, 15, 5, -1, -12 },
  { 638, 7, 7, 8, 1, -12 },
  { 645, 5, 1, 6, -1, 1 },
  { 646, 2, 3, 4, 2, -13 },
  { 647, 7, 9, 8, 1, -9 },
  { 655, 8, 13, 9, 0, -13 },
  { 668, 6, 9, 7, 1, -9 },
  { 675, 8, 13, 9, 1, -13 },
  { 688, 6, 9, 7, 1, -9 },
  { 695, 8, 17, 4, -2, -13 },
  { 712, 8, 13, 9, 0, -9 },
  { 725, 7, 13, 8, 0, -13 },
  { 737, 4, 12, 3, 0, -12 },
  { 743, 6, 16, 3, -2, -12 },
  { 755, 7, 13, 7, 0, -13 },
  { 767, 4, 13, 3, 0, -13 },
  { 774, 12, 9, 13, 0, -9 },
  { 788, 8, 9, 8, 0, -9 },
  { 797, 7, 9, 8, 1, -9 },
  { 805, 8, 13, 9, 0, -9 },
  { 818, 7, 13, 9, 1, -9 },
  { 830, 6, 9, 6, 0, -9 },
  { 837, 6, 9, 6, 0, -9 },
  { 844, 4, 11, 5, 1, -11 },
  { 850, 7, 9, 8, 1, -9 },
  { 858, 6, 9, 6, 1, -9 },
  { 865, 10, 9, 10, 1, -9 },
  { 877, 8, 9, 7, -1, -9 },
  { 886, 9, 13, 6, -2, -9 },
  { 901, 6, 9, 6, 0, -9 },
  { 908, 7, 15, 6, 0, -12 },
  { 922, 1, 17, 8, 4, -13 },
  { 925, 6, 15, 6, -1, -12 },
  { 937, 7, 2, 9, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic17pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC17PT7B_H_
