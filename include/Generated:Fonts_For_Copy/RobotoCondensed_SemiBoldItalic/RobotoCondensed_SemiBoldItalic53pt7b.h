#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC53PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x3E, 0x00, 0x40, 0x00, 0x3E, 0x3C, 0xF1, 0xF7, 0xC7, 0xDF, 0x1F,
  0x7C, 0x7D, 0xF1, 0xE7, 0x87, 0x9E, 0x3E, 0xF8, 0xFB, 0xE3, 0xCF, 0x0F,
  0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0x80, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF0,
  0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0xF8, 0xF0, 0x00,
  0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x1E, 0x1E,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF8, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x03, 0xC3, 0xC0,
  0x00, 0xF8, 0xF8, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF8,
  0xF8, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF8, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF0, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x1F, 0x1F, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x78, 0x78, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F,
  0x8F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0x87, 0xE0,
  0x3F, 0x0F, 0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0xFC,
  0x03, 0xF9, 0xF8, 0x07, 0xF3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xE0,
  0x7F, 0x1F, 0xC0, 0xFE, 0x1F, 0xC7, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x78, 0x78, 0x0C, 0xF8, 0x78, 0x1E,
  0xF8, 0x7C, 0x3E, 0xF0, 0x7C, 0x3C, 0xF0, 0x78, 0x7C, 0xF0, 0x78, 0xF8,
  0xF0, 0x78, 0xF0, 0xF0, 0xF9, 0xF0, 0xF8, 0xFB, 0xE0, 0xFF, 0xF3, 0xC0,
  0x7F, 0xF7, 0x80, 0x7F, 0xEF, 0x80, 0x1F, 0xCF, 0x00, 0x04, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF9, 0xFC,
  0x01, 0xF7, 0xFE, 0x01, 0xE7, 0xFE, 0x03, 0xEF, 0xFF, 0x07, 0xDF, 0x0F,
  0x07, 0x9F, 0x0F, 0x0F, 0x9E, 0x0F, 0x1F, 0x1E, 0x0F, 0x1E, 0x1E, 0x0F,
  0x3E, 0x1E, 0x0F, 0x7C, 0x1E, 0x0F, 0x78, 0x1E, 0x1F, 0x78, 0x1E, 0x1E,
  0x10, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x00,
  0x3E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xE1, 0xF8, 0x00, 0xFC, 0xFE,
  0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0xC3, 0xF1, 0xFF, 0xF0, 0xFC, 0xFE, 0xFE, 0x3F, 0x3F, 0x3F, 0x8F,
  0x9F, 0xC7, 0xF7, 0xE7, 0xE1, 0xFD, 0xFB, 0xF8, 0x3F, 0xFC, 0xFE, 0x0F,
  0xFF, 0x3F, 0x81, 0xFF, 0x8F, 0xE0, 0x3F, 0xE3, 0xF8, 0x0F, 0xF0, 0xFE,
  0x01, 0xFC, 0x1F, 0xC1, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xDF, 0xC0, 0x7F, 0xC3, 0xF8, 0x03, 0x00,
  0x00, 0x1F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x78, 0x78, 0x78, 0x00, 0x02, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0x40, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x02, 0x07, 0xC0, 0x9E, 0x1E,
  0x1E, 0x7E, 0x79, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8,
  0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xBE, 0x00, 0x7C, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x83, 0xE0, 0x7C, 0x0F,
  0x80, 0x60, 0x1C, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x87, 0xE0,
  0xFC, 0x3F, 0x0F, 0xC0, 0xF0, 0x04, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x7E,
  0x10, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFC, 0x7F, 0x07, 0xF0, 0x7E, 0x0F, 0xC0,
  0xFC, 0x3F, 0x81, 0xFC, 0x7E, 0x03, 0xF8, 0xFC, 0x07, 0xF3, 0xF8, 0x0F,
  0xE7, 0xE0, 0x1F, 0xCF, 0xC0, 0x3F, 0x9F, 0x80, 0x7F, 0x3F, 0x00, 0xFC,
  0xFE, 0x01, 0xF9, 0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xE7, 0xF0, 0x1F, 0xCF,
  0xC0, 0x3F, 0x9F, 0x80, 0x7F, 0x3F, 0x00, 0xFC, 0xFE, 0x01, 0xF9, 0xFC,
  0x03, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0x1F, 0xC0,
  0x7E, 0x3F, 0x81, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0xFE, 0x3F,
  0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x03, 0xF8,
  0x1F, 0xF1, 0xFF, 0xEF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0xFF, 0xFD, 0xF3,
  0xFB, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xE1, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xE0, 0x3F, 0x87, 0xF0,
  0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0x7F,
  0x0F, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7D, 0xFC, 0x00,
  0xFD, 0xF8, 0x01, 0xF9, 0xF8, 0x01, 0xF1, 0xF8, 0x03, 0xF3, 0xF8, 0x07,
  0xE3, 0xF8, 0x07, 0xE3, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x83, 0xF0, 0x1F,
  0x87, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x9F, 0x00, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xCF, 0xF0, 0x0F,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0xFE,
  0x07, 0xF0, 0x7F, 0x1F, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x7E, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x9F, 0xE0, 0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x07, 0xE7,
  0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0xFE, 0x01, 0xFB, 0xF8, 0x07, 0xEF, 0xE0,
  0x1F, 0xBF, 0x80, 0x7E, 0x7E, 0x03, 0xF9, 0xF8, 0x0F, 0xE7, 0xE0, 0x7F,
  0x1F, 0xC1, 0xFC, 0x7F, 0x0F, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03,
  0xF8, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7F, 0x0F,
  0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7E, 0x07,
  0xE0, 0xFE, 0x07, 0xE0, 0xFC, 0x03, 0xFB, 0xFC, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xC7, 0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x7F,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E,
  0x03, 0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x8F, 0xF0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFF,
  0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0x8F, 0xE7, 0xF0,
  0x7F, 0x7F, 0x03, 0xF7, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x3F, 0xE7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x7C, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x03, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x7F,
  0xC0, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F, 0xE0,
  0xFF, 0x0F, 0xE0, 0xFE, 0x07, 0xC0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07,
  0xE0, 0x7E, 0x01, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0xFF, 0x03,
  0xFC, 0x07, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0,
  0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x80, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x07,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFF, 0xFF,
  0x9F, 0xC7, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x01, 0xE0, 0x1F, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x7C,
  0x03, 0xF0, 0x0F, 0x07, 0xC0, 0x7F, 0xC0, 0xF0, 0xF8, 0x1F, 0xFF, 0x0F,
  0x0F, 0x83, 0xFF, 0xF0, 0xF1, 0xF0, 0x3F, 0x1F, 0x0F, 0x1F, 0x07, 0xC1,
  0xE0, 0xF1, 0xE0, 0xFC, 0x1E, 0x0F, 0x3E, 0x0F, 0x83, 0xE0, 0xF3, 0xE0,
  0xF0, 0x3E, 0x0F, 0x3C, 0x1F, 0x03, 0xE0, 0xF7, 0xC1, 0xF0, 0x3C, 0x0F,
  0x7C, 0x3F, 0x07, 0xC0, 0xF7, 0x83, 0xE0, 0x7C, 0x0F, 0x78, 0x3E, 0x07,
  0xC0, 0xF7, 0x83, 0xE0, 0x78, 0x1E, 0xF8, 0x3E, 0x0F, 0x81, 0xEF, 0x87,
  0xE0, 0xF8, 0x1E, 0xF8, 0x7C, 0x0F, 0x81, 0xEF, 0x87, 0xC0, 0xF0, 0x3C,
  0xF8, 0x7C, 0x1F, 0x03, 0xCF, 0x87, 0xE1, 0xF0, 0x78, 0xF0, 0x3E, 0x3F,
  0x0F, 0x8F, 0x83, 0xFF, 0xF9, 0xF0, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0x81,
  0xFE, 0x7F, 0xC0, 0xF8, 0x0F, 0xC3, 0xF8, 0x07, 0x80, 0x20, 0x04, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x80, 0x00, 0x0F, 0xF0, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFC,
  0xFC, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xF0,
  0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x3F, 0xC0,
  0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF,
  0x03, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F,
  0x00, 0x7E, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x1F,
  0xC0, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0x81,
  0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80,
  0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x83, 0xF0, 0x0F, 0xF0,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0x0F, 0xF0, 0x3F, 0x80, 0xFE,
  0x0F, 0xE0, 0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0,
  0x03, 0xF3, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF0, 0xFC,
  0x00, 0xFE, 0x1F, 0x80, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE,
  0x07, 0xF8, 0x7F, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xF8, 0x1F,
  0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x07,
  0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7E, 0x00,
  0x7F, 0x07, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0,
  0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x1F, 0xC0,
  0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFC,
  0x1F, 0xC0, 0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8,
  0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0xFF,
  0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0x0F, 0xF0, 0x3F,
  0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x1F,
  0x8F, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x3F, 0xFC, 0xFE, 0x07,
  0xFF, 0x9F, 0xC1, 0xFF, 0xF3, 0xF0, 0x3F, 0xFE, 0xFE, 0x07, 0xFF, 0xDF,
  0xC0, 0x03, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x03,
  0xF8, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0x7F,
  0x80, 0x7F, 0x07, 0xFC, 0x7F, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF8,
  0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x07, 0xE0,
  0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0,
  0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x80,
  0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x3F, 0x80,
  0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80,
  0xFE, 0x07, 0xE0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x9F, 0xE0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x01,
  0xFC, 0x03, 0xFE, 0x01, 0xF8, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x03,
  0xF8, 0x0F, 0xF8, 0x03, 0xF8, 0x1F, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x03,
  0xF8, 0x3F, 0xC0, 0x03, 0xF0, 0x7F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x07,
  0xF0, 0xFF, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x07,
  0xE7, 0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7E,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x80,
  0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xEF, 0x80, 0x7F, 0xF8, 0x07, 0xEF,
  0x80, 0xFD, 0xF8, 0x0F, 0xEF, 0x80, 0xFD, 0xF8, 0x0F, 0xEF, 0x81, 0xFB,
  0xF8, 0x0F, 0xCF, 0x81, 0xFB, 0xF8, 0x0F, 0xCF, 0x81, 0xF3, 0xF0, 0x0F,
  0xCF, 0xC3, 0xF3, 0xF0, 0x1F, 0xCF, 0xC3, 0xE3, 0xF0, 0x1F, 0xC7, 0xC7,
  0xE7, 0xF0, 0x1F, 0xC7, 0xC7, 0xC7, 0xF0, 0x1F, 0xC7, 0xCF, 0xC7, 0xF0,
  0x1F, 0x87, 0xCF, 0x87, 0xE0, 0x1F, 0x87, 0xCF, 0x87, 0xE0, 0x3F, 0x87,
  0xDF, 0x8F, 0xE0, 0x3F, 0x87, 0xDF, 0x0F, 0xE0, 0x3F, 0x87, 0xFF, 0x0F,
  0xE0, 0x3F, 0x83, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xFE, 0x0F, 0xC0, 0x3F,
  0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF0, 0x1F, 0x80,
  0x7F, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xE0, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x03, 0xFE,
  0x00, 0x7F, 0x03, 0xFE, 0x00, 0x7E, 0x03, 0xFE, 0x00, 0x7E, 0x03, 0xFE,
  0x00, 0xFE, 0x03, 0xFF, 0x00, 0xFE, 0x03, 0xFF, 0x00, 0xFE, 0x07, 0xFF,
  0x00, 0xFE, 0x07, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0x81, 0xFC, 0x07, 0xFF,
  0x81, 0xFC, 0x07, 0xEF, 0x81, 0xFC, 0x07, 0xE7, 0xC1, 0xFC, 0x0F, 0xE7,
  0xC1, 0xFC, 0x0F, 0xE7, 0xC1, 0xF8, 0x0F, 0xE7, 0xE3, 0xF8, 0x0F, 0xE3,
  0xE3, 0xF8, 0x0F, 0xC3, 0xE3, 0xF8, 0x1F, 0xC3, 0xE3, 0xF8, 0x1F, 0xC3,
  0xF3, 0xF8, 0x1F, 0xC1, 0xF3, 0xF0, 0x1F, 0xC1, 0xF7, 0xF0, 0x1F, 0xC1,
  0xF7, 0xF0, 0x1F, 0x80, 0xFF, 0xF0, 0x3F, 0x80, 0xFF, 0xF0, 0x3F, 0x80,
  0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xE0, 0x3F, 0x80, 0x7F, 0xE0, 0x3F, 0x80,
  0x7F, 0xE0, 0x3F, 0x00, 0x7F, 0xE0, 0x7F, 0x00, 0x3F, 0xE0, 0x7F, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0x01, 0xFE, 0x0F, 0xE0,
  0x0F, 0xE0, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0x7F,
  0x1F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF8,
  0x00, 0x7F, 0x3F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7E,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xCF, 0xE0, 0x01,
  0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0x87,
  0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x80,
  0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFF, 0x03, 0xF0, 0x03, 0xF8, 0x3F,
  0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00,
  0x3F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0x01, 0xFE,
  0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xE1, 0xFC,
  0x00, 0x7E, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07,
  0xF3, 0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x7F,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0xFE, 0x7E, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xCF,
  0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xF8, 0xFE, 0x00,
  0x3F, 0x87, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0,
  0x7F, 0x80, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x02,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFC, 0x07,
  0xF0, 0x3F, 0x80, 0x7F, 0x07, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F,
  0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0x80, 0x1F,
  0xC3, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8,
  0x0F, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0x87,
  0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07,
  0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF0, 0x0F,
  0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F,
  0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x87,
  0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1,
  0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x01,
  0xFE, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x7F,
  0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFC,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F,
  0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x1F,
  0x80, 0x0F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01,
  0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x87,
  0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00,
  0x3F, 0x87, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xF0,
  0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0,
  0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0xC7, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFE,
  0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0xC7, 0xF0,
  0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x87, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x7F,
  0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x81, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F,
  0x80, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0x87, 0xE0, 0x01,
  0xF8, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x9F,
  0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xFC, 0x03, 0xF8, 0x07,
  0xEF, 0xC0, 0x3F, 0x80, 0xFE, 0xFC, 0x07, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F,
  0x80, 0xFC, 0xFC, 0x07, 0xF8, 0x1F, 0xCF, 0xC0, 0xFF, 0x81, 0xFC, 0xFC,
  0x0F, 0xF8, 0x1F, 0x8F, 0xC0, 0xFF, 0x83, 0xF8, 0xFC, 0x1F, 0xF8, 0x3F,
  0x8F, 0xC1, 0xFF, 0x83, 0xF0, 0xFC, 0x1F, 0xF8, 0x7F, 0x0F, 0xC3, 0xFF,
  0x87, 0xF0, 0xFC, 0x3F, 0xF8, 0x7E, 0x0F, 0xC3, 0xEF, 0x87, 0xE0, 0xFC,
  0x7E, 0xF8, 0xFE, 0x0F, 0xC7, 0xEF, 0x8F, 0xC0, 0xFC, 0x7C, 0xF8, 0xFC,
  0x0F, 0xCF, 0xCF, 0x9F, 0xC0, 0xFC, 0xF8, 0xF9, 0xF8, 0x0F, 0xCF, 0x8F,
  0x9F, 0x80, 0xFD, 0xF8, 0xFB, 0xF8, 0x0F, 0xDF, 0x0F, 0xBF, 0x00, 0xFD,
  0xF0, 0xFB, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE0,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFC, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x03,
  0xF8, 0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x3F, 0x0F, 0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x0F, 0xE7, 0xF8, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0xC7,
  0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8,
  0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xF9, 0xFC, 0x00,
  0xFF, 0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0xFE, 0x0F,
  0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x3F,
  0x80, 0x7E, 0x0F, 0xE0, 0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x1F,
  0x8F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xDF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xBC, 0x07, 0xDE, 0x03, 0xEF, 0x83, 0xE7,
  0xC1, 0xF3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0xF8, 0x3C, 0x7C, 0x1E, 0x7C,
  0x0F, 0xBE, 0x07, 0xFE, 0x03, 0xE0, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F,
  0xC1, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x7F, 0x0F,
  0xE3, 0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE,
  0x7F, 0xC7, 0xF3, 0xF8, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xC0,
  0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x3F, 0x9F, 0xC3, 0xFC, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFC, 0xFE, 0x01, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x80, 0x07, 0xE7, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0,
  0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0x80,
  0x7F, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x80,
  0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0x00,
  0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0xC7, 0xF8, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0x7E, 0xFF, 0xF0, 0xFC, 0xFF, 0xE0, 0xFC, 0x7F,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFE,
  0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFC, 0x3F, 0x8F,
  0xE0, 0x7E, 0x3F, 0x81, 0xFC, 0xFC, 0x07, 0xF7, 0xF0, 0x0F, 0xDF, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFC, 0xFE,
  0x03, 0xF1, 0xF8, 0x1F, 0xC7, 0xE0, 0x7E, 0x1F, 0xC3, 0xF8, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x41, 0xFC, 0x01, 0xFE, 0x7F, 0x01, 0xFF, 0xDF,
  0xC0, 0xFF, 0xF7, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xF8,
  0xFF, 0x83, 0xF8, 0x1F, 0xE0, 0xFE, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F,
  0xC0, 0x3F, 0x07, 0xF0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xFC,
  0x1F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0x83, 0xF8, 0x07, 0xE0, 0xFE, 0x03,
  0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xC0, 0xFE,
  0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x07, 0xF0, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0x9F,
  0x80, 0x01, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFE, 0x1F,
  0x87, 0xE0, 0x7F, 0x3F, 0x80, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xDF,
  0xC0, 0x3F, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFB, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x0C, 0x1F, 0xE0, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x03,
  0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0xFF, 0x87,
  0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x80, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x8F, 0xC0, 0x7F, 0xE7, 0xE0, 0x7F,
  0xFB, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F,
  0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7,
  0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF8,
  0x7E, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F,
  0x0F, 0xE0, 0x1F, 0x87, 0xF0, 0x1F, 0xC1, 0xF8, 0x0F, 0xE0, 0xFE, 0x07,
  0xF0, 0x7F, 0x8F, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xBF, 0x00, 0x04, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x20, 0x07, 0xF0, 0x18, 0x07, 0xF0, 0x1F,
  0x8F, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0x83,
  0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xE0, 0x3F,
  0x8F, 0xC0, 0x7F, 0x1F, 0x80, 0xFC, 0x7F, 0x01, 0xF8, 0xFE, 0x03, 0xF1,
  0xFC, 0x0F, 0xE3, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0x8F, 0xC0, 0x7E, 0x3F,
  0x80, 0xFC, 0x7F, 0x01, 0xF8, 0xFE, 0x07, 0xF1, 0xF8, 0x0F, 0xE3, 0xF0,
  0x1F, 0xC7, 0xE0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x7F, 0x03,
  0xF8, 0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x7E, 0x03, 0xF0,
  0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xE0, 0x3F, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x7F, 0x81, 0xF8,
  0x3F, 0xE0, 0xFE, 0x0F, 0xF0, 0x3F, 0x87, 0xF8, 0x0F, 0xE3, 0xFC, 0x03,
  0xF1, 0xFE, 0x00, 0xFC, 0xFF, 0x00, 0x3F, 0x3F, 0x80, 0x1F, 0xDF, 0xC0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xF7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFC, 0x3F, 0x00,
  0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x1F,
  0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x83, 0xF8,
  0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x7F, 0x07, 0xF8, 0x07, 0xFF, 0xF8,
  0xFF, 0xC0, 0x7F, 0xFF, 0xDF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xF1, 0xFF, 0x8F, 0xF0, 0xFE, 0x0F, 0xF0, 0x7F,
  0x0F, 0xC0, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE,
  0x07, 0xF1, 0xFC, 0x0F, 0xE0, 0x7F, 0x1F, 0x80, 0xFC, 0x07, 0xF1, 0xF8,
  0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x07, 0xE3, 0xF8, 0x1F, 0xC0, 0xFE,
  0x3F, 0x81, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC0, 0xFE, 0x3F, 0x01, 0xF8,
  0x0F, 0xE3, 0xF0, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x0F, 0xC7, 0xF0,
  0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x81, 0xFC,
  0x7E, 0x03, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0,
  0x1F, 0x8F, 0xE0, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F, 0x87, 0xF0, 0x7F, 0x1F, 0xC0,
  0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFC, 0x07, 0xF1, 0xF8, 0x0F,
  0xE3, 0xF0, 0x1F, 0x8F, 0xE0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x81, 0xFC,
  0x7E, 0x03, 0xF8, 0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0x8F,
  0xE0, 0x3F, 0x1F, 0xC0, 0xFE, 0x3F, 0x01, 0xFC, 0x7E, 0x03, 0xF8, 0xFC,
  0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0x8F, 0xE0, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x3F, 0x80,
  0xFC, 0x7E, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F,
  0xEF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0xFE, 0x00, 0xFD,
  0xFC, 0x01, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xE7, 0xE0, 0x1F, 0x8F,
  0xC0, 0x7F, 0x1F, 0xC0, 0xFC, 0x3F, 0xC7, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x7E, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xC3,
  0xF8, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F,
  0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xE0,
  0x7E, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0x83, 0xF8, 0x0F,
  0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x07, 0xF0,
  0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x87, 0xF8, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFE, 0xFF, 0xC0, 0x3F, 0x9F, 0xE0,
  0x0F, 0xC0, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x01, 0xFE, 0x3F, 0x07, 0xFF, 0x3F, 0x0F, 0xFF, 0x7E,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xC3, 0xFE, 0x3F, 0x81, 0xFE,
  0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7F, 0x01, 0xFC,
  0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xF8,
  0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8,
  0xFE, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0x0F, 0xF0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xE7, 0xE0, 0x01, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xFB, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFE,
  0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC0, 0xFC, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0xFE, 0x03, 0xF3, 0xF8, 0x0F, 0xC7, 0xE0, 0x7F, 0x1F, 0x81, 0xFC,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x01, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x00, 0x80, 0x1F, 0x80, 0xFE, 0x3F,
  0x01, 0xF8, 0xFE, 0x03, 0xF1, 0xFC, 0x07, 0xE3, 0xF8, 0x1F, 0xC7, 0xE0,
  0x3F, 0x8F, 0xC0, 0x7F, 0x1F, 0x80, 0xFC, 0x7F, 0x01, 0xF8, 0xFE, 0x07,
  0xF1, 0xFC, 0x0F, 0xE3, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0x8F, 0xC0, 0x7E,
  0x3F, 0x80, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xF8, 0x0F, 0xE3,
  0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x81, 0xFC, 0x3F,
  0x87, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x01, 0xFE, 0x7E, 0x00, 0x20, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xE0,
  0x1F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0xFE, 0x7F, 0x07, 0xF1,
  0xF8, 0x3F, 0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x8F,
  0xE0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x07,
  0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x07,
  0xC0, 0xFF, 0xF8, 0x1F, 0x81, 0xFB, 0xF0, 0x3F, 0x03, 0xF7, 0xE0, 0x7E,
  0x0F, 0xEF, 0xC1, 0xFC, 0x1F, 0x9F, 0x83, 0xF8, 0x3F, 0x3F, 0x0F, 0xF0,
  0xFE, 0x7E, 0x1F, 0xE1, 0xF8, 0x7C, 0x3F, 0xC3, 0xF0, 0xF8, 0xFF, 0x8F,
  0xC1, 0xF1, 0xFF, 0x1F, 0x83, 0xE7, 0xDF, 0x3F, 0x07, 0xCF, 0xBE, 0xFC,
  0x0F, 0x9F, 0x7D, 0xF8, 0x1F, 0x7C, 0xFB, 0xE0, 0x3E, 0xF9, 0xFF, 0xC0,
  0x7F, 0xE3, 0xFF, 0x80, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x03,
  0xFE, 0x1F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F,
  0xE0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE,
  0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x3F, 0x87, 0xF8, 0x0F, 0xE1, 0xFC,
  0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0xDF, 0xC0, 0x03, 0xF7,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xDF, 0x80, 0x07, 0xF7, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0xFE,
  0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x07,
  0xF0, 0x1F, 0x81, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07,
  0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x01, 0xFC,
  0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0xFC, 0x00,
  0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xCF, 0xE0, 0x03, 0xF3, 0xF8,
  0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07,
  0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0,
  0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x78,
  0x0F, 0x00, 0x00, 0x80, 0x00, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x03, 0xF8,
  0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x70, 0x00, 0x40, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x07,
  0xC7, 0xFE, 0x03, 0xE7, 0xFF, 0x83, 0xF3, 0xFF, 0xE1, 0xF3, 0xFF, 0xFF,
  0xF9, 0xF0, 0xFF, 0xF9, 0xF8, 0x3F, 0xFC, 0xF8, 0x0F, 0xFC, 0x7C, 0x03,
  0xFC, 0x00, 0x00, 0xFC, 0x00,
};

const GFXglyph RobotoCondensed_SemiBoldItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 13, 39, 13, 1, -38 },
  { 65, 14, 14, 16, 4, -40 },
  { 90, 27, 38, 27, 1, -38 },
  { 219, 23, 50, 26, 2, -44 },
  { 363, 24, 40, 33, 5, -39 },
  { 483, 26, 40, 29, 1, -39 },
  { 613, 8, 14, 8, 3, -40 },
  { 627, 16, 54, 16, 3, -42 },
  { 735, 16, 54, 17, -2, -42 },
  { 843, 22, 23, 23, 3, -38 },
  { 907, 22, 27, 25, 2, -31 },
  { 982, 11, 15, 12, -3, -6 },
  { 1003, 13, 6, 17, 2, -19 },
  { 1013, 8, 8, 15, 1, -7 },
  { 1021, 23, 41, 18, -3, -38 },
  { 1139, 23, 40, 26, 2, -39 },
  { 1254, 15, 38, 26, 6, -38 },
  { 1326, 25, 39, 26, 0, -39 },
  { 1448, 24, 40, 26, 1, -39 },
  { 1568, 24, 38, 26, 1, -38 },
  { 1682, 24, 39, 26, 2, -38 },
  { 1799, 22, 39, 26, 2, -38 },
  { 1907, 24, 38, 26, 3, -38 },
  { 2021, 24, 40, 26, 1, -39 },
  { 2141, 20, 39, 26, 4, -39 },
  { 2239, 12, 30, 14, 1, -29 },
  { 2284, 14, 38, 13, -2, -29 },
  { 2351, 21, 25, 23, 1, -29 },
  { 2417, 22, 18, 26, 2, -26 },
  { 2467, 21, 24, 23, 1, -28 },
  { 2530, 19, 40, 23, 4, -39 },
  { 2625, 36, 49, 39, 1, -37 },
  { 2846, 29, 38, 30, -2, -38 },
  { 2984, 28, 38, 29, 0, -38 },
  { 3117, 27, 40, 29, 2, -39 },
  { 3252, 28, 38, 29, 0, -38 },
  { 3385, 28, 38, 25, 0, -38 },
  { 3518, 27, 38, 25, 0, -38 },
  { 3647, 27, 40, 30, 2, -39 },
  { 3782, 32, 38, 32, 0, -38 },
  { 3934, 13, 38, 14, 1, -38 },
  { 3996, 26, 39, 25, 0, -38 },
  { 4123, 32, 38, 28, 0, -38 },
  { 4275, 22, 38, 25, 0, -38 },
  { 4380, 40, 38, 39, 0, -38 },
  { 4570, 32, 38, 32, 0, -38 },
  { 4722, 28, 40, 31, 2, -39 },
  { 4862, 29, 38, 29, 0, -38 },
  { 5000, 28, 46, 31, 2, -39 },
  { 5161, 27, 38, 28, 1, -38 },
  { 5290, 27, 40, 28, 1, -39 },
  { 5425, 26, 38, 28, 4, -38 },
  { 5549, 28, 39, 29, 2, -38 },
  { 5686, 28, 38, 30, 4, -38 },
  { 5819, 36, 38, 39, 5, -38 },
  { 5990, 33, 38, 29, -2, -38 },
  { 6147, 27, 38, 28, 4, -38 },
  { 6276, 30, 38, 27, -1, -38 },
  { 6419, 18, 53, 13, -1, -44 },
  { 6539, 12, 41, 19, 4, -38 },
  { 6601, 18, 53, 13, -3, -44 },
  { 6721, 17, 19, 20, 2, -38 },
  { 6762, 20, 5, 21, -3, 0 },
  { 6775, 11, 8, 17, 5, -40 },
  { 6786, 21, 30, 24, 1, -29 },
  { 6865, 24, 41, 25, 0, -40 },
  { 6988, 22, 30, 24, 1, -29 },
  { 7071, 26, 41, 25, 1, -40 },
  { 7205, 22, 30, 25, 1, -29 },
  { 7288, 18, 41, 17, 2, -41 },
  { 7381, 25, 40, 26, 0, -29 },
  { 7506, 23, 40, 25, 0, -40 },
  { 7621, 13, 39, 13, 0, -39 },
  { 7685, 19, 50, 12, -6, -39 },
  { 7804, 26, 40, 24, 0, -40 },
  { 7934, 14, 40, 13, 0, -40 },
  { 8004, 36, 29, 38, 0, -29 },
  { 8135, 23, 29, 25, 0, -29 },
  { 8219, 23, 30, 26, 1, -29 },
  { 8306, 26, 40, 25, -2, -29 },
  { 8436, 24, 40, 26, 1, -29 },
  { 8556, 18, 29, 17, 0, -29 },
  { 8622, 22, 30, 23, 0, -29 },
  { 8705, 14, 36, 16, 2, -35 },
  { 8768, 23, 29, 25, 2, -28 },
  { 8852, 21, 28, 23, 3, -28 },
  { 8926, 31, 28, 33, 3, -28 },
  { 9035, 26, 28, 23, -2, -28 },
  { 9126, 26, 39, 23, -2, -28 },
  { 9253, 24, 28, 23, -1, -28 },
  { 9337, 17, 50, 15, 1, -41 },
  { 9444, 11, 45, 13, 1, -38 },
  { 9506, 16, 50, 15, -2, -41 },
  { 9606, 25, 11, 29, 2, -21 },
};

const GFXfont RobotoCondensed_SemiBoldItalic53pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic53pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic53pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC53PT7B_H_
