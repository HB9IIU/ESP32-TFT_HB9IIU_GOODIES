#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC62PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x03, 0xE0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x01, 0xFC, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0x87, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7E, 0x1F, 0x1F, 0x0F,
  0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F, 0x8F, 0x83, 0xC3,
  0xE0, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x1F, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xC3,
  0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xE0, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x7C,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x3E, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFC, 0x7F, 0x81, 0xFF,
  0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC,
  0x1F, 0xC0, 0x3F, 0x87, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0xFE, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xC7, 0xF8,
  0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC,
  0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0x9F, 0x80,
  0x40, 0xF8, 0x7C, 0x03, 0x0F, 0xC3, 0xF0, 0x3E, 0x7C, 0x0F, 0x83, 0xF3,
  0xE0, 0x7C, 0x1F, 0x1F, 0x03, 0xE1, 0xF0, 0xF8, 0x3F, 0x1F, 0x87, 0xC1,
  0xF0, 0xF8, 0x3E, 0x0F, 0x8F, 0x81, 0xF0, 0x7C, 0xFC, 0x0F, 0x87, 0xE7,
  0xC0, 0x7E, 0x7E, 0x7C, 0x01, 0xFF, 0xF7, 0xE0, 0x0F, 0xFF, 0x7E, 0x00,
  0x3F, 0xF3, 0xE0, 0x00, 0xFF, 0x3E, 0x00, 0x00, 0x83, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF9,
  0xFE, 0x00, 0x0F, 0x9F, 0xF8, 0x00, 0xFD, 0xFF, 0xE0, 0x07, 0xDF, 0xFF,
  0x00, 0x7C, 0xFC, 0xFC, 0x07, 0xEF, 0xC3, 0xE0, 0x3E, 0x7C, 0x1F, 0x03,
  0xE3, 0xE0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xF1, 0xF8, 0x3E, 0x1F, 0x0F,
  0x81, 0xF1, 0xF0, 0x7C, 0x0F, 0x9F, 0x83, 0xE0, 0x7C, 0xF8, 0x1F, 0x87,
  0xE7, 0x80, 0x7C, 0x3E, 0x1C, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x01, 0xFE, 0x1F, 0xC0,
  0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01,
  0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7F,
  0x1F, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0xFC,
  0x3F, 0xFF, 0x83, 0xF1, 0xFF, 0xFE, 0x0F, 0xC7, 0xFB, 0xFC, 0x7F, 0x3F,
  0xCF, 0xF9, 0xFD, 0xFE, 0x1F, 0xE7, 0xE7, 0xF8, 0x3F, 0xFF, 0x9F, 0xE0,
  0xFF, 0xFE, 0xFF, 0x01, 0xFF, 0xF3, 0xFC, 0x07, 0xFF, 0xCF, 0xF0, 0x0F,
  0xFE, 0x3F, 0xC0, 0x3F, 0xF8, 0xFF, 0x00, 0x7F, 0xC1, 0xFE, 0x01, 0xFE,
  0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFB, 0xFE, 0x03,
  0xFF, 0x87, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3E, 0x3E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xFC, 0xF8, 0xF8, 0x00,
  0x00, 0x40, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0xC0, 0x3C, 0x02, 0x3C, 0x1F, 0x07,
  0x9F, 0xC7, 0xC7, 0xE7, 0xFD, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0x9F, 0x00,
  0x0F, 0xC7, 0xE0, 0x07, 0xE0, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x0F,
  0xC0, 0x1E, 0x01, 0xF0, 0x03, 0x00, 0x70, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0x3C, 0x00, 0x40,
  0x00, 0x7F, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF,
  0x80, 0x3F, 0x3F, 0xDF, 0xFF, 0xFF, 0xFB, 0xFD, 0xFE, 0x7E, 0x08, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xE1, 0xFE, 0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xF1, 0xFE, 0x03, 0xFC,
  0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xCF, 0xF0, 0x07, 0xF3, 0xF8, 0x01,
  0xFC, 0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8,
  0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7,
  0xF0, 0x07, 0xF9, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F,
  0xEF, 0xF0, 0x07, 0xF3, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80,
  0x3F, 0xCF, 0xE0, 0x0F, 0xF3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F,
  0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0xE3, 0xF8, 0x07, 0xF0, 0xFE, 0x03, 0xFC,
  0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xF0, 0x01,
  0xF8, 0x03, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE,
  0x7F, 0xFF, 0x3F, 0xFF, 0xCF, 0xE7, 0xF3, 0xC3, 0xFC, 0xC0, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xC1, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x01,
  0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x83, 0xF8, 0x03, 0xFC,
  0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F,
  0xF0, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF,
  0x00, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFB, 0xFC, 0x00,
  0x3F, 0xBF, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7E, 0x7F, 0x80, 0x0F, 0xE7,
  0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00,
  0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0x1F,
  0xF0, 0x0F, 0xC0, 0xFF, 0x80, 0x08, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x8F, 0xC0,
  0x3F, 0xDF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xBF, 0xF9, 0xFF, 0x07, 0xFD, 0xFF, 0x01,
  0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xBF, 0xC0, 0x1F, 0xDF, 0xE0,
  0x0F, 0xEF, 0xF0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC,
  0x01, 0xFE, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0xBF, 0xC0, 0x7F, 0x9F,
  0xE0, 0x3F, 0xC7, 0xF0, 0x3F, 0xC3, 0xFC, 0x3F, 0xE1, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F,
  0xE1, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xC0, 0x7F,
  0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC,
  0x07, 0xF8, 0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8,
  0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0x87, 0xF8, 0x1F, 0xE0, 0x7F, 0x07, 0xF8, 0x0F,
  0xF0, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xC7, 0xF8, 0x03, 0xF8, 0xFF,
  0x00, 0x7F, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F,
  0x8F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x1F, 0xE1, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0xE3, 0xFC,
  0x3F, 0xE0, 0xFF, 0x1F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F, 0xCF, 0xF0, 0x0F,
  0xE7, 0xF8, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFD, 0xFE, 0x00,
  0xFE, 0xFF, 0x00, 0x7F, 0x7F, 0x80, 0x3F, 0xBF, 0xC0, 0x1F, 0xDF, 0xE0,
  0x1F, 0xE7, 0xF0, 0x0F, 0xF3, 0xF8, 0x0F, 0xF9, 0xFE, 0x07, 0xFC, 0xFF,
  0x8F, 0xFC, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC0, 0xFF, 0xDF, 0xC0, 0x1F, 0x8F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xE0,
  0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x83, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x00, 0x20, 0x00, 0x00, 0x3E, 0x00, 0x3F,
  0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x0F, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xF1, 0xFE, 0x7F, 0x81,
  0xFE, 0xFF, 0x03, 0xFD, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0x80, 0xFC, 0x03, 0xFF, 0x00, 0xF0, 0x3F, 0x00, 0xFF,
  0xF8, 0x1E, 0x07, 0xC0, 0x3F, 0xFF, 0x83, 0xE1, 0xF8, 0x0F, 0xFF, 0xF0,
  0x7C, 0x3E, 0x03, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xFE, 0x0F, 0x81, 0xF1,
  0xF8, 0x1F, 0x81, 0xF0, 0x3E, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xC7, 0xC0,
  0xFC, 0x0F, 0xC0, 0xF9, 0xF8, 0x3F, 0x01, 0xF0, 0x1F, 0x3E, 0x07, 0xE0,
  0x3E, 0x03, 0xE7, 0xC0, 0xFC, 0x0F, 0xC0, 0x79, 0xF8, 0x3F, 0x01, 0xF8,
  0x0F, 0x3F, 0x07, 0xE0, 0x3E, 0x03, 0xE7, 0xC0, 0xFC, 0x07, 0xC0, 0x7C,
  0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x9F, 0x07, 0xE0, 0x3F, 0x01, 0xE3, 0xE0,
  0xFC, 0x07, 0xC0, 0x3C, 0xFC, 0x1F, 0x80, 0xF8, 0x0F, 0x9F, 0x83, 0xF0,
  0x3F, 0x01, 0xF3, 0xF0, 0x7E, 0x07, 0xE0, 0x3C, 0x7C, 0x0F, 0xC0, 0xFC,
  0x0F, 0x8F, 0x81, 0xF8, 0x3F, 0x81, 0xE1, 0xF0, 0x3F, 0x8F, 0xF0, 0x7C,
  0x3E, 0x07, 0xFB, 0xFE, 0x1F, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFC,
  0x0F, 0xFE, 0xFF, 0xF8, 0x0F, 0x80, 0xFF, 0x8F, 0xFE, 0x01, 0xF0, 0x0F,
  0xE0, 0xFF, 0x00, 0x3E, 0x00, 0x70, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x02, 0x00, 0x00, 0x07, 0xFC,
  0x03, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x01,
  0xFD, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x00,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x0F, 0xF0,
  0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x07, 0xF0,
  0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00,
  0x7F, 0x9F, 0xE0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x01, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFC,
  0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8,
  0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8,
  0x01, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xFC, 0x0F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x07, 0xF0, 0x3F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0,
  0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x3F, 0x80,
  0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0x80,
  0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0x87, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x03,
  0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x1F,
  0xE3, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x7F, 0x80,
  0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFE, 0x0F, 0xF0, 0x0F,
  0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x01,
  0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01,
  0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x01,
  0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01,
  0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x03,
  0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07,
  0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F,
  0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0x80, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0x87, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x1F, 0xF0,
  0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF1, 0xFE, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x3F, 0x9F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x3F, 0xFF, 0x3F, 0xC0, 0xFF, 0xFE, 0xFF, 0x01, 0xFF, 0xFD,
  0xFE, 0x03, 0xFF, 0xFB, 0xFC, 0x07, 0xFF, 0xE7, 0xF8, 0x0F, 0xFF, 0xCF,
  0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0x7F,
  0x80, 0x07, 0xFC, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF8,
  0x07, 0xFE, 0x1F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFC, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x3F, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F,
  0x83, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x81, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x3F, 0xF0, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xF8,
  0x03, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF8, 0x01, 0xFE, 0x01,
  0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x03,
  0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0xC0, 0x01, 0xFE, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x03, 0xFC,
  0x7F, 0xE0, 0x00, 0x1F, 0xE7, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0xE0, 0x00,
  0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xF3, 0xFC, 0x00, 0x03, 0xFF, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0xFF, 0x80, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x1F, 0xBF, 0x80, 0xFE,
  0xFC, 0x01, 0xFF, 0xFC, 0x0F, 0xF7, 0xE0, 0x0F, 0xDF, 0xC0, 0x7F, 0xBF,
  0x00, 0xFE, 0xFE, 0x03, 0xF9, 0xF8, 0x07, 0xE7, 0xF0, 0x1F, 0xCF, 0xC0,
  0x7F, 0x7F, 0x80, 0xFE, 0x7E, 0x03, 0xF3, 0xFC, 0x0F, 0xF3, 0xF0, 0x3F,
  0x9F, 0xE0, 0x7F, 0x9F, 0x81, 0xFC, 0xFE, 0x03, 0xFC, 0x7E, 0x0F, 0xC7,
  0xF0, 0x1F, 0xE3, 0xF0, 0xFE, 0x7F, 0x80, 0xFE, 0x1F, 0x87, 0xE3, 0xFC,
  0x07, 0xF0, 0xFC, 0x7F, 0x1F, 0xE0, 0x7F, 0x87, 0xE3, 0xF0, 0xFF, 0x03,
  0xFC, 0x3F, 0x3F, 0x87, 0xF0, 0x1F, 0xE1, 0xF9, 0xF8, 0x7F, 0x80, 0xFF,
  0x0F, 0xDF, 0xC3, 0xFC, 0x07, 0xF8, 0x7E, 0xFC, 0x1F, 0xE0, 0x3F, 0x81,
  0xF7, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x7F,
  0xF0, 0x7F, 0x80, 0xFF, 0x03, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF8,
  0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xFC, 0x07,
  0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0x80, 0xFF, 0x00, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x00, 0xFF, 0x01,
  0xFE, 0x01, 0xF8, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xFE,
  0x00, 0x3F, 0xC0, 0x7F, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xE0,
  0x1F, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xF8, 0x0F, 0xFF, 0x80,
  0x3F, 0xC0, 0x7F, 0xFC, 0x01, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xE0, 0x1F,
  0xFF, 0x80, 0xFF, 0x00, 0xFE, 0xFC, 0x07, 0xF8, 0x0F, 0xF3, 0xF0, 0x3F,
  0xC0, 0x7F, 0x9F, 0x81, 0xFE, 0x03, 0xFC, 0xFC, 0x0F, 0xE0, 0x1F, 0xE7,
  0xE0, 0xFF, 0x00, 0xFF, 0x1F, 0x87, 0xF8, 0x0F, 0xF0, 0xFC, 0x3F, 0xC0,
  0x7F, 0x87, 0xE1, 0xFE, 0x03, 0xFC, 0x1F, 0x8F, 0xF0, 0x1F, 0xE0, 0xFC,
  0x7F, 0x00, 0xFF, 0x07, 0xE7, 0xF8, 0x07, 0xF8, 0x3F, 0x3F, 0xC0, 0x7F,
  0x80, 0xFD, 0xFE, 0x03, 0xFC, 0x07, 0xEF, 0xF0, 0x1F, 0xE0, 0x3F, 0x7F,
  0x80, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xC0,
  0x3F, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xE0, 0x07, 0xFF, 0x80,
  0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xC0, 0x07,
  0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0xFF,
  0x00, 0x0F, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF0,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0,
  0x00, 0xFF, 0x3F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80,
  0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0xC0,
  0x3F, 0xE0, 0x7F, 0xF1, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x01,
  0xFC, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE,
  0x0F, 0xE0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x7F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x1F, 0xFC, 0x07, 0xFC, 0x03, 0xFC,
  0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x80, 0x01, 0xFE,
  0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xF0,
  0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF1, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x0D, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFE,
  0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xFC,
  0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x80,
  0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0,
  0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x3F, 0xE0,
  0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xC3, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F,
  0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x07,
  0xF8, 0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07,
  0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC,
  0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x7F,
  0xDF, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x1F,
  0xF1, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x07,
  0xF8, 0x3F, 0xC0, 0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x03,
  0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFC,
  0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x07,
  0xF8, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x7F, 0x7F, 0x80, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xC0, 0x0F,
  0xFF, 0xE0, 0x07, 0xF0, 0x07, 0xFB, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0xC0, 0x3F, 0xCF, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF3, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0xFE, 0x03, 0xFF, 0x01,
  0xFE, 0x3F, 0x80, 0xFF, 0xC0, 0x7F, 0x8F, 0xE0, 0x3F, 0xF0, 0x1F, 0xE3,
  0xF8, 0x1F, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xFF, 0x03, 0xFC, 0x3F, 0x81,
  0xFF, 0xC0, 0xFF, 0x0F, 0xE0, 0xFF, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0xFE,
  0x1F, 0xE0, 0xFE, 0x0F, 0xFF, 0x87, 0xF8, 0x3F, 0x87, 0xFF, 0xE1, 0xFC,
  0x0F, 0xE1, 0xF9, 0xF8, 0xFF, 0x03, 0xF8, 0x7E, 0x7E, 0x3F, 0xC0, 0xFE,
  0x3F, 0x9F, 0x8F, 0xE0, 0x3F, 0x8F, 0xC7, 0xE7, 0xF8, 0x0F, 0xE3, 0xF1,
  0xF9, 0xFE, 0x03, 0xF9, 0xFC, 0x7E, 0x7F, 0x00, 0xFE, 0x7E, 0x1F, 0x9F,
  0xC0, 0x3F, 0x9F, 0x87, 0xEF, 0xF0, 0x0F, 0xEF, 0xE1, 0xFB, 0xF8, 0x03,
  0xFB, 0xF0, 0x7E, 0xFE, 0x00, 0xFE, 0xFC, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x01,
  0xFF, 0x7F, 0x80, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x3F, 0xE7, 0xF8,
  0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x3F,
  0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x03, 0xFE, 0x7F, 0x80, 0x03, 0xFE, 0x7F, 0x80, 0x07, 0xFC, 0x7F, 0x80,
  0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0,
  0x1F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0,
  0xFF, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x0F, 0xE3,
  0xFC, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x07, 0xF7,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xF7,
  0xC0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC3, 0xE1, 0xF8,
  0x3E, 0x1F, 0x83, 0xE3, 0xF8, 0x3F, 0x3F, 0x03, 0xF7, 0xF0, 0x3F, 0x7E,
  0x03, 0xFF, 0xE0, 0x3F, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x83,
  0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03,
  0xF8, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F,
  0xE0, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC7, 0xFC, 0x1F, 0xE7, 0xFC, 0x0F, 0xE3, 0xFC, 0x07, 0xF3, 0xFC, 0x07,
  0xF9, 0xFE, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x3F, 0xC0,
  0xFF, 0x1F, 0xE0, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xF9, 0xFC, 0x07, 0xF8, 0xFE, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0,
  0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00, 0xFE,
  0x1F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xE3, 0xFC,
  0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x1F,
  0xC3, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC7, 0xFC, 0x07, 0xF8, 0x7F,
  0xE0, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xF7, 0xFF,
  0xE0, 0x7F, 0x7F, 0xFC, 0x0F, 0xF3, 0xFF, 0x80, 0xFE, 0x1F, 0xF0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xE3,
  0xFC, 0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE,
  0x1F, 0xC0, 0x3F, 0x87, 0xF8, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x10,
  0x3F, 0xC0, 0x0F, 0xF8, 0xFF, 0x00, 0x7F, 0xF3, 0xFC, 0x03, 0xFF, 0xEF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0x80, 0xFF, 0x83, 0xFC, 0x03, 0xFE, 0x0F,
  0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFF, 0x07, 0xF8,
  0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00,
  0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F,
  0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0,
  0xFF, 0x00, 0x7F, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFB,
  0xF8, 0x00, 0x7F, 0x8F, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x3F, 0xE1, 0xFE, 0x1F, 0xC0,
  0x7F, 0x1F, 0xE0, 0x3F, 0xCF, 0xE0, 0x0F, 0xEF, 0xF0, 0x07, 0xF7, 0xF0,
  0x03, 0xFB, 0xF8, 0x03, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x08, 0x3F, 0xC0, 0x1C, 0x0F, 0xF8, 0x3F,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0xFF, 0x1F, 0xC0, 0x3F, 0xFC, 0xFE, 0x03, 0xFF,
  0xF7, 0xF0, 0x3F, 0xFF, 0xBF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0x87,
  0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFC, 0x00, 0xFF, 0x0F, 0xE0,
  0x07, 0xF0, 0xFF, 0x00, 0x3F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F,
  0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x3F, 0x83,
  0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF0,
  0x07, 0xF8, 0x3F, 0x80, 0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x1F,
  0xE0, 0x7F, 0xC3, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0x00, 0x1F,
  0xF7, 0xF8, 0x00, 0x08, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0xC0, 0x07, 0xF8, 0x07, 0x00, 0x7F, 0x80,
  0x7F, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x20, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xC3,
  0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F,
  0xE0, 0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F,
  0xE1, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF0, 0x0F, 0xF0, 0xFE,
  0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0xFE,
  0x1F, 0xE0, 0x3F, 0xC3, 0xF8, 0x07, 0xF8, 0x7F, 0x00, 0xFF, 0x1F, 0xE0,
  0x1F, 0xE3, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1,
  0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01,
  0xFC, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x10, 0x00, 0x7C, 0x00, 0xFE, 0x01,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0xFF, 0xC1, 0xFE, 0x07, 0xFE, 0x07, 0xF8, 0x1F, 0xF0,
  0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0x87, 0xFC, 0x01, 0xFC, 0x3F, 0xE0, 0x07,
  0xF0, 0xFF, 0x80, 0x3F, 0xC7, 0xFC, 0x00, 0xFF, 0x3F, 0xE0, 0x03, 0xFD,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0,
  0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC,
  0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x80,
  0xFF, 0x80, 0x3F, 0xBF, 0xF8, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x7F, 0xFC,
  0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0xFF, 0xE1, 0xFF, 0x07, 0xF8, 0x1F,
  0xF0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC3,
  0xF8, 0x07, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x7F, 0x80,
  0x7F, 0x00, 0xFE, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x87, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x7F, 0x00, 0xFE, 0x01, 0xFE,
  0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC3, 0xFC,
  0x07, 0xF8, 0x07, 0xF0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0x7F,
  0x80, 0xFF, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF0, 0x0F,
  0xF1, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x1F,
  0xC0, 0x3F, 0xC0, 0x7F, 0x87, 0xF0, 0x0F, 0xF0, 0x1F, 0xE1, 0xFC, 0x03,
  0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xEF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x7F, 0xE1, 0xFF, 0x0F, 0xF8, 0x1F, 0xE1, 0xFE, 0x03, 0xFC,
  0x3F, 0xC0, 0x7F, 0x87, 0xF0, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x3F, 0xC0,
  0x3F, 0xC7, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3,
  0xF8, 0x07, 0xF8, 0x7F, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03,
  0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x3F,
  0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x3F,
  0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0xC7, 0xF8,
  0x07, 0xF8, 0xFF, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xC3, 0xFE, 0x3F,
  0xE0, 0x7F, 0x8F, 0xF0, 0x0F, 0xE7, 0xF8, 0x03, 0xF9, 0xFE, 0x00, 0xFF,
  0x7F, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8,
  0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x1F, 0xEF, 0xE0, 0x07, 0xFB,
  0xF8, 0x01, 0xFC, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0x8F, 0xF0, 0x1F,
  0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x07,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF,
  0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1,
  0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F,
  0x00, 0x3F, 0x81, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0,
  0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x0F,
  0xF0, 0x3F, 0x80, 0x3F, 0xC1, 0xFF, 0x01, 0xFE, 0x07, 0xFE, 0x0F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xF7, 0xFF, 0xC0, 0x3F, 0xCF, 0xFE, 0x00, 0xFF, 0x1F, 0xF0, 0x03, 0xFC,
  0x0C, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0x01, 0xFF, 0xC7, 0xF0, 0x3F,
  0xFE, 0x7F, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE1, 0xFF, 0x07, 0xFE, 0x1F, 0xE0, 0x3F, 0xE3, 0xFC, 0x01, 0xFE, 0x3F,
  0xC0, 0x1F, 0xC3, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0xC7, 0xF8, 0x03,
  0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0x87,
  0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x87, 0xF0, 0x07, 0xF8, 0x7F, 0x00,
  0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0,
  0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xFC,
  0x3F, 0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x00,
  0xC1, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xCF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0x10, 0x7F, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F,
  0xEF, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xF8, 0x0F, 0xF0,
  0xFE, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0xFE,
  0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0xEF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0,
  0x00, 0xC0, 0x00, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80,
  0x7F, 0x0F, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x8F,
  0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0x87, 0xF8, 0x07,
  0xF0, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x07, 0xF8, 0xFF,
  0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFF,
  0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0,
  0x0F, 0xE1, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0,
  0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xDF, 0xC0, 0x0F, 0xF3, 0xF8, 0x00, 0x30, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0x9F, 0xC0, 0x3F, 0xCF, 0xE0, 0x1F, 0xE7, 0xF0,
  0x1F, 0xE3, 0xF8, 0x0F, 0xF1, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0x7F,
  0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xE1, 0xFE, 0x07, 0xF0, 0xFE, 0x03,
  0xF8, 0xFF, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x3F, 0xC0,
  0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xEF, 0xE0, 0x03, 0xF7, 0xF0,
  0x01, 0xFB, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x01, 0xF0, 0x0F, 0xFF, 0xE0,
  0x3F, 0x00, 0xFE, 0xFE, 0x03, 0xF8, 0x1F, 0xEF, 0xE0, 0x7F, 0x81, 0xFC,
  0xFE, 0x07, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x83, 0xFC, 0xFE, 0x0F, 0xF8,
  0x3F, 0x8F, 0xE0, 0xFF, 0x83, 0xF8, 0xFE, 0x1F, 0xF8, 0x7F, 0x8F, 0xE1,
  0xFF, 0x87, 0xF0, 0xFE, 0x3F, 0xF8, 0x7F, 0x0F, 0xE3, 0xFF, 0x8F, 0xE0,
  0xFE, 0x3F, 0xF8, 0xFE, 0x0F, 0xE7, 0xEF, 0x8F, 0xE0, 0xFE, 0x7E, 0xF9,
  0xFC, 0x0F, 0xEF, 0xCF, 0x9F, 0xC0, 0xFE, 0xFC, 0xF9, 0xFC, 0x0F, 0xEF,
  0xCF, 0xBF, 0x80, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0x00,
  0xFF, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0xFF,
  0xE0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFC,
  0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0xFF, 0x80, 0x7F,
  0x83, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xE3,
  0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xFC, 0x3F, 0x80, 0x1F, 0xE0, 0xFF, 0x00,
  0xFF, 0x83, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF,
  0x80, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F,
  0x80, 0x7F, 0x80, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x3F, 0x81, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F,
  0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0,
  0x01, 0xFC, 0x7F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xCF, 0xF0, 0x00,
  0x7F, 0x3F, 0x80, 0x01, 0xFD, 0xFE, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x40, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x40, 0x00,
  0x0E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x1E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x03, 0xE0, 0xFF, 0xE0, 0x0F, 0x87, 0xFF, 0xC0, 0x7E, 0x1F, 0xFF, 0x81,
  0xF8, 0xFF, 0xFF, 0x0F, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xC3, 0xFF, 0xFC,
  0x7E, 0x07, 0xFF, 0xE1, 0xF8, 0x0F, 0xFF, 0x87, 0xC0, 0x1F, 0xFC, 0x3F,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
};

const GFXglyph RobotoCondensed_SemiBoldItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 15, 45, 15, 1, -44 },
  { 86, 18, 16, 19, 4, -47 },
  { 122, 30, 44, 32, 2, -44 },
  { 287, 27, 58, 30, 2, -51 },
  { 483, 29, 46, 38, 5, -45 },
  { 650, 30, 46, 34, 1, -45 },
  { 823, 8, 16, 10, 4, -47 },
  { 839, 19, 63, 19, 3, -49 },
  { 989, 20, 63, 19, -3, -49 },
  { 1147, 26, 27, 27, 3, -44 },
  { 1235, 26, 32, 29, 2, -36 },
  { 1339, 13, 18, 14, -4, -7 },
  { 1369, 15, 6, 20, 3, -22 },
  { 1381, 9, 9, 17, 1, -8 },
  { 1392, 28, 48, 21, -4, -44 },
  { 1560, 26, 46, 30, 3, -45 },
  { 1710, 18, 44, 30, 7, -44 },
  { 1809, 29, 45, 30, 0, -45 },
  { 1973, 28, 46, 30, 1, -45 },
  { 2134, 28, 44, 30, 1, -44 },
  { 2288, 28, 45, 30, 2, -44 },
  { 2446, 25, 45, 30, 3, -44 },
  { 2587, 29, 44, 30, 3, -44 },
  { 2747, 27, 46, 30, 2, -45 },
  { 2903, 25, 45, 30, 4, -45 },
  { 3044, 14, 34, 16, 1, -33 },
  { 3104, 17, 44, 15, -3, -33 },
  { 3198, 25, 29, 27, 1, -34 },
  { 3289, 25, 20, 30, 3, -30 },
  { 3352, 25, 29, 27, 1, -33 },
  { 3443, 23, 46, 27, 4, -45 },
  { 3576, 43, 57, 46, 1, -43 },
  { 3883, 34, 44, 36, -2, -44 },
  { 4070, 32, 44, 34, 1, -44 },
  { 4246, 31, 46, 34, 3, -45 },
  { 4425, 32, 44, 34, 1, -44 },
  { 4601, 31, 44, 30, 1, -44 },
  { 4772, 31, 44, 29, 1, -44 },
  { 4943, 31, 46, 35, 3, -45 },
  { 5122, 37, 44, 37, 1, -44 },
  { 5326, 15, 44, 16, 1, -44 },
  { 5409, 30, 45, 29, 0, -44 },
  { 5578, 37, 44, 33, 1, -44 },
  { 5782, 24, 44, 29, 1, -44 },
  { 5914, 45, 44, 46, 1, -44 },
  { 6162, 37, 44, 37, 1, -44 },
  { 6366, 32, 46, 36, 3, -45 },
  { 6550, 33, 44, 34, 1, -44 },
  { 6732, 32, 53, 36, 3, -45 },
  { 6944, 32, 44, 33, 1, -44 },
  { 7120, 31, 46, 32, 1, -45 },
  { 7299, 30, 44, 32, 5, -44 },
  { 7464, 34, 45, 34, 2, -44 },
  { 7656, 33, 44, 35, 5, -44 },
  { 7838, 42, 44, 45, 6, -44 },
  { 8069, 38, 44, 34, -2, -44 },
  { 8278, 32, 44, 32, 5, -44 },
  { 8454, 35, 44, 32, -1, -44 },
  { 8647, 21, 61, 16, -1, -51 },
  { 8808, 14, 48, 23, 5, -44 },
  { 8892, 20, 61, 16, -3, -51 },
  { 9045, 20, 22, 23, 2, -44 },
  { 9100, 24, 6, 24, -4, 0 },
  { 9118, 13, 9, 20, 6, -46 },
  { 9133, 25, 35, 28, 1, -34 },
  { 9243, 28, 48, 30, 0, -47 },
  { 9411, 26, 35, 28, 1, -34 },
  { 9525, 30, 48, 30, 1, -47 },
  { 9705, 25, 35, 29, 2, -34 },
  { 9815, 22, 48, 20, 2, -48 },
  { 9947, 29, 47, 30, 0, -34 },
  { 10118, 27, 47, 29, 0, -47 },
  { 10277, 16, 46, 15, 0, -46 },
  { 10369, 22, 59, 14, -7, -46 },
  { 10532, 30, 47, 28, 0, -47 },
  { 10709, 16, 47, 15, 0, -47 },
  { 10803, 42, 34, 45, 0, -34 },
  { 10982, 27, 34, 29, 0, -34 },
  { 11097, 26, 35, 30, 2, -34 },
  { 11211, 30, 47, 30, -2, -34 },
  { 11388, 28, 47, 30, 1, -34 },
  { 11553, 21, 34, 20, 0, -34 },
  { 11643, 26, 35, 27, 0, -34 },
  { 11757, 17, 42, 18, 2, -41 },
  { 11847, 27, 34, 29, 2, -33 },
  { 11962, 25, 33, 27, 3, -33 },
  { 12066, 36, 33, 38, 4, -33 },
  { 12215, 30, 33, 27, -2, -33 },
  { 12339, 30, 46, 26, -2, -33 },
  { 12512, 28, 33, 27, -1, -33 },
  { 12628, 20, 59, 18, 1, -48 },
  { 12776, 13, 52, 15, 1, -44 },
  { 12861, 19, 59, 18, -2, -48 },
  { 13002, 30, 13, 34, 2, -25 },
};

const GFXfont RobotoCondensed_SemiBoldItalic62pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic62pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic62pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC62PT7B_H_
