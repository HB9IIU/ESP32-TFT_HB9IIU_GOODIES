#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC23PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xC6, 0x38, 0xE3, 0x8E, 0x30, 0xC3, 0x0C, 0x00, 0x06,
  0x3C, 0x60, 0xEF, 0x3C, 0xF6, 0xDA, 0x60, 0x06, 0x60, 0xD8, 0x13, 0x06,
  0x60, 0xD8, 0xFF, 0xDF, 0xF8, 0xD8, 0x1B, 0x06, 0x63, 0xFE, 0x7F, 0xC2,
  0x60, 0xC8, 0x1B, 0x02, 0x60, 0xCC, 0x00, 0x03, 0x00, 0x80, 0xF0, 0x7E,
  0x3B, 0xCC, 0x77, 0x1D, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80,
  0xEE, 0x3B, 0x8E, 0xFF, 0x1F, 0x83, 0xC0, 0x40, 0x10, 0x00, 0x38, 0x0F,
  0x83, 0x33, 0x66, 0x6C, 0xD9, 0x9E, 0x3E, 0xC3, 0xB0, 0x0C, 0x01, 0xF8,
  0x6F, 0x1B, 0x33, 0x66, 0xCC, 0xF1, 0x90, 0x3E, 0x03, 0x80, 0x07, 0x80,
  0xFC, 0x1D, 0xC1, 0xCC, 0x18, 0xC1, 0x9C, 0x1F, 0x81, 0xF0, 0x1E, 0x03,
  0xE7, 0x77, 0x67, 0x76, 0xE3, 0xE6, 0x3C, 0x73, 0xC7, 0xFC, 0x3E, 0xE0,
  0x76, 0x66, 0x64, 0x02, 0x0C, 0x30, 0xE3, 0x86, 0x0C, 0x38, 0x60, 0xC3,
  0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC1, 0x81, 0x83, 0x06, 0x06, 0x04, 0x00,
  0x08, 0x30, 0x30, 0x60, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x38, 0x70, 0xE1,
  0xC3, 0x0E, 0x1C, 0x30, 0xE1, 0x86, 0x1C, 0x20, 0x00, 0x06, 0x01, 0x00,
  0xC1, 0xB6, 0xFF, 0xC7, 0x83, 0xC0, 0xD8, 0x67, 0x00, 0x80, 0x0E, 0x07,
  0x03, 0x01, 0x8F, 0xFF, 0xFF, 0xFE, 0x38, 0x18, 0x0C, 0x0E, 0x07, 0x00,
  0x33, 0x77, 0x6E, 0xC0, 0xFB, 0xE0, 0x77, 0x60, 0x01, 0xC0, 0x60, 0x18,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x30,
  0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x00, 0x0F, 0x07, 0xE3, 0xB9, 0xC7,
  0x71, 0xDC, 0x76, 0x1F, 0x87, 0xE1, 0xB8, 0xEE, 0x3B, 0x8E, 0xE3, 0xB8,
  0xCE, 0x71, 0xF8, 0x3C, 0x00, 0x04, 0xFF, 0xFF, 0x98, 0x63, 0x8E, 0x38,
  0xE3, 0x8C, 0x71, 0xC7, 0x1C, 0x70, 0x07, 0x83, 0xF8, 0xF7, 0x9C, 0x73,
  0x8E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0,
  0x70, 0x1C, 0x07, 0xFE, 0xFF, 0x80, 0x0F, 0x83, 0xF8, 0xF7, 0x1C, 0x70,
  0x0E, 0x01, 0xC0, 0x70, 0x1E, 0x0F, 0x81, 0xF0, 0x06, 0x00, 0xEE, 0x1C,
  0xC3, 0x1D, 0xE3, 0xF8, 0x1E, 0x00, 0x01, 0xE0, 0x38, 0x0F, 0x03, 0xE0,
  0x7C, 0x1F, 0x87, 0x70, 0xCC, 0x3B, 0x8E, 0x71, 0x8E, 0x7F, 0xEF, 0xFC,
  0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x1F, 0xCF, 0xF3, 0xFC, 0xC0, 0x30,
  0x1C, 0x07, 0xE1, 0xFC, 0x73, 0x80, 0xE0, 0x38, 0x0E, 0xE3, 0xB8, 0xEF,
  0x71, 0xF8, 0x3C, 0x00, 0x03, 0x87, 0xC7, 0xC7, 0x03, 0x83, 0x81, 0xFC,
  0xFF, 0xF7, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1D, 0xDC, 0xFC, 0x3C, 0x00,
  0x7F, 0xEF, 0xFC, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E,
  0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x00,
  0x0F, 0x07, 0xE3, 0xBD, 0xC7, 0x71, 0xDC, 0x73, 0xB8, 0xFC, 0x7F, 0x18,
  0xCE, 0x3B, 0x8E, 0xE3, 0xB9, 0xCE, 0x71, 0xF8, 0x3C, 0x00, 0x1E, 0x3F,
  0x9D, 0xDC, 0x6E, 0x3E, 0x1F, 0x0F, 0xCE, 0xE7, 0x7F, 0x9F, 0xC0, 0xC0,
  0xE0, 0xE1, 0xF1, 0xF0, 0xE0, 0x00, 0x39, 0xC6, 0x00, 0x00, 0x00, 0x03,
  0x9C, 0xC0, 0x1C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x0C, 0x71,
  0x8E, 0x10, 0x01, 0x03, 0x87, 0xCF, 0x8F, 0x07, 0x03, 0xE0, 0x7C, 0x0E,
  0x01, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x20, 0x0E,
  0x03, 0xE0, 0x3E, 0x03, 0xC1, 0xE1, 0xF1, 0xF0, 0x70, 0x10, 0x00, 0x3C,
  0x7E, 0xFF, 0xE7, 0x07, 0x07, 0x0E, 0x1E, 0x3C, 0x38, 0x70, 0x70, 0x00,
  0x00, 0xE0, 0xE0, 0x60, 0x00, 0xF8, 0x03, 0xFC, 0x06, 0x06, 0x0C, 0x03,
  0x18, 0x03, 0x38, 0xF3, 0x31, 0xF9, 0x33, 0x31, 0x67, 0x33, 0x66, 0x33,
  0x66, 0x33, 0x66, 0x63, 0x4E, 0x62, 0xC6, 0xE6, 0x47, 0xFC, 0x67, 0x38,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x40, 0x3F, 0xC0, 0x0F, 0x80, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x36, 0x03, 0xB0, 0x1D, 0x81, 0xCE, 0x0E,
  0x70, 0x63, 0x87, 0xFC, 0x3F, 0xE3, 0xFF, 0x1C, 0x39, 0xC0, 0xCE, 0x07,
  0xE0, 0x38, 0x1F, 0xC1, 0xFE, 0x1F, 0xF3, 0x87, 0x38, 0x73, 0x87, 0x38,
  0xE3, 0xFC, 0x3F, 0xC7, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x1E, 0x73,
  0xCF, 0xF8, 0xFF, 0x00, 0x07, 0x81, 0xFC, 0x3F, 0xE3, 0x86, 0x70, 0x77,
  0x07, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x0E, 0xE1, 0xCE,
  0x1C, 0x77, 0x87, 0xF8, 0x3E, 0x00, 0x1F, 0x81, 0xFE, 0x1F, 0xE3, 0x87,
  0x38, 0x73, 0x87, 0x38, 0x73, 0x87, 0x38, 0x77, 0x07, 0x70, 0x67, 0x0E,
  0x70, 0xE7, 0x1C, 0x77, 0xCF, 0xF8, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x1F,
  0xF3, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3F, 0xC7, 0xFC, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x7F, 0xCF, 0xF8, 0xFF, 0x80, 0x1F, 0xF1,
  0xFE, 0x1F, 0xE3, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xFC, 0x3F, 0xC7,
  0xF8, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x00,
  0x07, 0xC1, 0xFE, 0x3F, 0xE3, 0x87, 0x70, 0x77, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x0E, 0x3E, 0xE3, 0xEE, 0x0E, 0xE0, 0xEE, 0x1C, 0x7F, 0xC7, 0xFC,
  0x1F, 0x00, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xCE, 0x0E, 0x38, 0x38, 0xE0,
  0xE3, 0x83, 0x8F, 0xFE, 0x3F, 0xF9, 0xFF, 0xC7, 0x07, 0x1C, 0x1C, 0x70,
  0x71, 0xC1, 0xC7, 0x07, 0x38, 0x38, 0xE0, 0xE0, 0x1C, 0x71, 0xC7, 0x38,
  0xE3, 0x8E, 0x38, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0xE0, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x01, 0xCE, 0x39, 0xC7, 0x3D, 0xC3, 0xF8, 0x3C, 0x00, 0x1C, 0x3C, 0x71,
  0xE1, 0xCF, 0x0E, 0x38, 0x39, 0xC0, 0xEF, 0x03, 0xF8, 0x0F, 0xC0, 0x3F,
  0x01, 0xFE, 0x07, 0xB8, 0x1C, 0xE0, 0x73, 0xC1, 0xC7, 0x07, 0x1C, 0x38,
  0x78, 0xE0, 0xE0, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0x1E,
  0x07, 0x8F, 0x03, 0xC7, 0x83, 0xE7, 0xC1, 0xF3, 0xE1, 0xF1, 0xF0, 0xD8,
  0xF8, 0x7C, 0x7C, 0x7E, 0x37, 0x37, 0x3B, 0xBB, 0x9C, 0xD9, 0x8E, 0x7D,
  0xC7, 0x3C, 0xE3, 0x9E, 0x71, 0xCE, 0x39, 0xC7, 0x1C, 0xE3, 0x9C, 0x00,
  0x1C, 0x1C, 0x70, 0x71, 0xE1, 0xCF, 0x8E, 0x3E, 0x38, 0xF8, 0xE3, 0xF3,
  0x8E, 0xCE, 0x3B, 0x39, 0xCD, 0xC7, 0x1F, 0x1C, 0x7C, 0x71, 0xF1, 0xC7,
  0xC7, 0x0F, 0x38, 0x38, 0xE0, 0xE0, 0x07, 0x81, 0xFE, 0x3F, 0xE3, 0x87,
  0x70, 0x77, 0x07, 0x70, 0x7E, 0x07, 0xE0, 0x7E, 0x06, 0xE0, 0xEE, 0x0E,
  0xE0, 0xEE, 0x1C, 0x7F, 0xC7, 0xF8, 0x1E, 0x00, 0x1F, 0xC0, 0xFF, 0x07,
  0xFC, 0x70, 0xE3, 0x83, 0x9C, 0x1C, 0xE1, 0xC7, 0x0E, 0x3F, 0xF3, 0xFF,
  0x1F, 0xE0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x00,
  0x07, 0x81, 0xFE, 0x3F, 0xE3, 0x87, 0x70, 0x77, 0x07, 0x70, 0x7E, 0x07,
  0xE0, 0x7E, 0x06, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x1C, 0x7F, 0xC7, 0xF8,
  0x1F, 0x80, 0x38, 0x01, 0xC0, 0x08, 0x1F, 0xC1, 0xFE, 0x1F, 0xF3, 0x87,
  0x38, 0x73, 0x87, 0x38, 0x73, 0x8F, 0x39, 0xE7, 0xFC, 0x7F, 0x87, 0x38,
  0x71, 0xC7, 0x1C, 0x71, 0xCE, 0x1C, 0xE1, 0xE0, 0x07, 0xC0, 0xFE, 0x1E,
  0xF3, 0x87, 0x38, 0x73, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01,
  0xC0, 0x0E, 0xE0, 0xE7, 0x1C, 0x7B, 0xC3, 0xF8, 0x1F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x87, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x73,
  0x87, 0x70, 0x77, 0x07, 0x70, 0x67, 0x0E, 0x70, 0xE7, 0x0E, 0xE0, 0xEE,
  0x0E, 0xE0, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0xFF, 0x87, 0xF0, 0x3E, 0x00,
  0xE0, 0x7E, 0x0E, 0xE0, 0xEE, 0x1E, 0xE1, 0xC6, 0x1C, 0x63, 0x87, 0x38,
  0x73, 0x07, 0x70, 0x77, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x00, 0xE1, 0x87, 0xE3, 0x8E, 0xE3, 0x8E, 0xE3, 0x8E, 0xE7, 0x8C,
  0xE7, 0x9C, 0xE7, 0x9C, 0xEF, 0x98, 0xED, 0xB8, 0xED, 0xB8, 0xFD, 0xB0,
  0xF9, 0xF0, 0xF9, 0xF0, 0xF9, 0xE0, 0xF1, 0xE0, 0xF1, 0xE0, 0xE1, 0xE0,
  0x1C, 0x1C, 0x38, 0xF0, 0xE3, 0x83, 0x9C, 0x0E, 0x70, 0x1F, 0x80, 0x7E,
  0x01, 0xF0, 0x03, 0x80, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x1C, 0xE0, 0xF3,
  0x83, 0x8E, 0x1E, 0x38, 0x70, 0xF0, 0xE0, 0xEE, 0x1E, 0x61, 0xC7, 0x3C,
  0x73, 0x87, 0x70, 0x77, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x00, 0x3F, 0xF1, 0xFF, 0x8F,
  0xFC, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0xFF, 0x1F, 0xF8, 0xFF, 0xC0,
  0x1E, 0x3C, 0x70, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x61, 0xC3, 0x87, 0x0E, 0x1E, 0x3C, 0x00, 0xE7, 0x39, 0xC6,
  0x31, 0xCE, 0x73, 0x9C, 0x63, 0x1C, 0xE7, 0x39, 0xC0, 0x1E, 0x3C, 0x38,
  0x70, 0xE1, 0xC3, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0x87, 0x1E, 0x3C, 0x00, 0x0C, 0x38, 0x71, 0xB3, 0x6C, 0xD9,
  0xE3, 0xFF, 0x7F, 0x80, 0x71, 0x8E, 0x0F, 0x0F, 0xE3, 0xBC, 0xC7, 0x01,
  0x87, 0xE7, 0xF9, 0xCE, 0xE3, 0xBD, 0xE7, 0xF8, 0xEE, 0x1C, 0x07, 0x01,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0xF8, 0xFF, 0x39, 0xDC, 0x77, 0x1D, 0xC7,
  0x71, 0xDC, 0x76, 0x1F, 0xCE, 0xFF, 0xBB, 0xC0, 0x1E, 0x3F, 0x9D, 0xFC,
  0x7E, 0x3F, 0x03, 0x01, 0x80, 0xC7, 0x77, 0xBF, 0x8F, 0x80, 0x00, 0xE0,
  0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x8F, 0x73, 0xFC, 0x77, 0x9C, 0x73,
  0x8E, 0x71, 0xCC, 0x39, 0x86, 0x31, 0xC7, 0x78, 0xFF, 0x0F, 0xE0, 0x1E,
  0x1F, 0x9C, 0xFC, 0x7E, 0x3F, 0xFF, 0xFF, 0x80, 0xE0, 0x7B, 0x9F, 0xC7,
  0x80, 0x0F, 0x1F, 0x1C, 0x38, 0x38, 0x38, 0xFC, 0xFC, 0x70, 0x70, 0x70,
  0x70, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0x1E, 0xE7, 0xFC, 0xE7, 0x38,
  0xE7, 0x1C, 0xE3, 0x98, 0x73, 0x0E, 0x71, 0x8E, 0xF1, 0xFE, 0x1F, 0xC0,
  0x38, 0x07, 0x11, 0xC7, 0xF0, 0x7C, 0x00, 0x1C, 0x07, 0x01, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0xF8, 0xFF, 0x3B, 0xDC, 0x77, 0x1D, 0xC7, 0x71, 0xDC,
  0x66, 0x3B, 0x8E, 0xE3, 0xB8, 0xE0, 0x1C, 0x71, 0x80, 0x00, 0xE3, 0x8E,
  0x31, 0xC7, 0x1C, 0x71, 0xC6, 0x38, 0xE0, 0x06, 0x07, 0x06, 0x00, 0x00,
  0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38,
  0x38, 0x38, 0x70, 0xF0, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x79, 0xDE, 0x33, 0x8E, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xEE,
  0x19, 0xC7, 0x38, 0xE3, 0x9C, 0x70, 0x1C, 0x71, 0xC6, 0x38, 0xE3, 0x8E,
  0x38, 0xC7, 0x1C, 0x71, 0xC7, 0x18, 0xE3, 0x80, 0x3F, 0x9C, 0x3F, 0xFE,
  0x3B, 0xEF, 0x31, 0xC7, 0x71, 0xC7, 0x71, 0xC6, 0x71, 0x8E, 0x71, 0x8E,
  0x63, 0x8E, 0xE3, 0x8E, 0xE3, 0x8C, 0xE3, 0x9C, 0x3F, 0x8F, 0xF3, 0x9D,
  0xC7, 0x71, 0xDC, 0x77, 0x1D, 0xC6, 0x63, 0xB8, 0xEE, 0x3B, 0x8E, 0x1E,
  0x1F, 0x9C, 0xFC, 0x7E, 0x3F, 0x1F, 0x0F, 0x87, 0xE3, 0xF3, 0xBF, 0x87,
  0x80, 0x1F, 0xC3, 0xFC, 0x73, 0x8C, 0x73, 0x8E, 0x71, 0xCE, 0x39, 0xC7,
  0x30, 0xE7, 0x39, 0xFF, 0x3B, 0xC7, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0,
  0x00, 0x3D, 0xDF, 0xF7, 0x3B, 0x8E, 0xE3, 0xB8, 0xEC, 0x3B, 0x0C, 0xC7,
  0x3B, 0xCF, 0xF1, 0xFC, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x3F,
  0x3F, 0x3E, 0x38, 0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0x0F,
  0x0F, 0xE3, 0xB9, 0xC7, 0x38, 0x0F, 0x81, 0xF0, 0x1E, 0xE3, 0xB9, 0xC7,
  0xF0, 0xF8, 0x38, 0xE3, 0xBF, 0xFD, 0xC7, 0x1C, 0x71, 0x8E, 0x38, 0xE3,
  0xC7, 0x00, 0x71, 0xDC, 0x66, 0x3B, 0x8E, 0xE3, 0xB8, 0xEE, 0x3B, 0x8C,
  0xE7, 0x3B, 0xCF, 0xF1, 0xDC, 0xE3, 0xF1, 0xD8, 0xCC, 0xE6, 0x63, 0x71,
  0xB8, 0xD8, 0x7C, 0x3C, 0x1E, 0x06, 0x00, 0xE3, 0x1F, 0x9C, 0xEE, 0x73,
  0x99, 0xCC, 0x6F, 0x71, 0xBD, 0xC7, 0xB6, 0x1E, 0xF8, 0x79, 0xC1, 0xC7,
  0x07, 0x1C, 0x18, 0x60, 0x18, 0xE3, 0xBC, 0x77, 0x07, 0xC0, 0xF8, 0x1E,
  0x03, 0xC0, 0xF8, 0x1B, 0x07, 0x71, 0xCE, 0x38, 0xC0, 0x38, 0xE3, 0x8E,
  0x39, 0xC1, 0x9C, 0x19, 0xC1, 0xB8, 0x1B, 0x81, 0xF0, 0x1F, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x00, 0x3F,
  0xCF, 0xF0, 0x38, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3C, 0x0F,
  0xF3, 0xFC, 0x04, 0x1C, 0x70, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0xE3, 0x86,
  0x0E, 0x0C, 0x18, 0x30, 0xE1, 0xC3, 0x83, 0x07, 0x04, 0x00, 0x18, 0xC6,
  0x31, 0x88, 0xC6, 0x31, 0x8C, 0x66, 0x31, 0x8C, 0x63, 0x11, 0x80, 0x18,
  0x38, 0x30, 0x60, 0xC1, 0x83, 0x0E, 0x0C, 0x18, 0x38, 0x71, 0xC3, 0x0E,
  0x1C, 0x38, 0x60, 0xC3, 0x8E, 0x18, 0x00, 0x38, 0x6F, 0x9B, 0xBF, 0x63,
  0xEC, 0x38,
};

const GFXglyph RobotoCondensed_SemiBoldItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 17, 6, 0, -17 },
  { 14, 6, 6, 7, 2, -17 },
  { 19, 11, 17, 12, 1, -17 },
  { 43, 10, 21, 11, 1, -19 },
  { 70, 11, 17, 14, 2, -17 },
  { 94, 12, 17, 13, 0, -17 },
  { 120, 4, 6, 4, 1, -17 },
  { 123, 7, 23, 7, 1, -18 },
  { 144, 7, 23, 7, -1, -18 },
  { 165, 10, 10, 10, 1, -17 },
  { 178, 9, 12, 11, 1, -13 },
  { 192, 4, 7, 5, -1, -3 },
  { 196, 6, 2, 7, 1, -8 },
  { 198, 4, 3, 6, 0, -3 },
  { 200, 10, 18, 8, -1, -17 },
  { 223, 10, 17, 11, 1, -17 },
  { 245, 6, 17, 11, 3, -17 },
  { 258, 11, 17, 11, 0, -17 },
  { 282, 11, 17, 11, 0, -17 },
  { 306, 11, 17, 11, 0, -17 },
  { 330, 10, 17, 11, 1, -17 },
  { 352, 9, 17, 11, 1, -17 },
  { 372, 11, 17, 11, 1, -17 },
  { 396, 10, 17, 11, 1, -17 },
  { 418, 9, 17, 11, 2, -17 },
  { 438, 5, 12, 6, 0, -12 },
  { 446, 6, 16, 6, -1, -12 },
  { 458, 9, 10, 10, 1, -12 },
  { 470, 9, 7, 11, 1, -11 },
  { 478, 10, 10, 10, 0, -12 },
  { 491, 8, 17, 10, 2, -17 },
  { 508, 16, 21, 17, 0, -16 },
  { 550, 13, 17, 13, -1, -17 },
  { 578, 12, 17, 12, 0, -17 },
  { 604, 12, 17, 13, 1, -17 },
  { 630, 12, 17, 13, 0, -17 },
  { 656, 12, 17, 11, 0, -17 },
  { 682, 12, 17, 11, 0, -17 },
  { 708, 12, 17, 13, 1, -17 },
  { 734, 14, 17, 14, 0, -17 },
  { 764, 6, 17, 6, 0, -17 },
  { 777, 11, 17, 11, 0, -17 },
  { 801, 14, 17, 12, 0, -17 },
  { 831, 9, 17, 11, 0, -17 },
  { 851, 17, 17, 17, 0, -17 },
  { 888, 14, 17, 14, 0, -17 },
  { 918, 12, 17, 13, 1, -17 },
  { 944, 13, 17, 13, 0, -17 },
  { 972, 12, 20, 13, 1, -17 },
  { 1002, 12, 17, 12, 0, -17 },
  { 1028, 12, 17, 12, 0, -17 },
  { 1054, 11, 17, 12, 2, -17 },
  { 1078, 12, 17, 13, 1, -17 },
  { 1104, 12, 17, 13, 2, -17 },
  { 1130, 16, 17, 17, 2, -17 },
  { 1164, 14, 17, 12, -1, -17 },
  { 1194, 12, 17, 12, 2, -17 },
  { 1220, 13, 17, 12, 0, -17 },
  { 1248, 7, 23, 6, 0, -19 },
  { 1269, 5, 18, 8, 2, -17 },
  { 1281, 7, 23, 6, -1, -19 },
  { 1302, 7, 8, 9, 1, -17 },
  { 1309, 9, 2, 9, -1, 0 },
  { 1312, 5, 3, 7, 2, -17 },
  { 1314, 10, 12, 11, 0, -12 },
  { 1329, 10, 18, 11, 0, -18 },
  { 1352, 9, 12, 10, 1, -12 },
  { 1366, 11, 18, 11, 1, -18 },
  { 1391, 9, 12, 11, 1, -12 },
  { 1405, 8, 18, 7, 1, -18 },
  { 1423, 11, 17, 11, 0, -12 },
  { 1447, 10, 18, 11, 0, -18 },
  { 1470, 6, 17, 6, 0, -17 },
  { 1483, 8, 22, 5, -2, -17 },
  { 1505, 11, 18, 11, 0, -18 },
  { 1530, 6, 18, 6, 0, -18 },
  { 1544, 16, 12, 17, 0, -12 },
  { 1568, 10, 12, 11, 0, -12 },
  { 1583, 9, 12, 11, 1, -12 },
  { 1597, 11, 17, 11, -1, -12 },
  { 1621, 10, 17, 11, 1, -12 },
  { 1643, 8, 12, 7, 0, -12 },
  { 1655, 10, 12, 10, 0, -12 },
  { 1670, 6, 15, 7, 1, -15 },
  { 1682, 10, 12, 11, 1, -12 },
  { 1697, 9, 12, 10, 1, -12 },
  { 1711, 14, 12, 14, 1, -12 },
  { 1732, 11, 12, 10, -1, -12 },
  { 1749, 12, 17, 10, -1, -12 },
  { 1775, 10, 12, 10, 0, -12 },
  { 1790, 7, 22, 7, 1, -18 },
  { 1810, 5, 20, 6, 0, -17 },
  { 1823, 7, 22, 7, -1, -18 },
  { 1843, 11, 5, 13, 1, -9 },
};

const GFXfont RobotoCondensed_SemiBoldItalic23pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic23pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic23pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC23PT7B_H_
