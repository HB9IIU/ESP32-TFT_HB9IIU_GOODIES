#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC28PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x73, 0xCF, 0x3C, 0xE3, 0x8E, 0x39, 0xE7, 0x1C, 0x71, 0xC0,
  0x00, 0xE3, 0x8E, 0x38, 0x77, 0x67, 0x66, 0xE6, 0xEE, 0xCE, 0xCC, 0x01,
  0x98, 0x0E, 0xE0, 0x33, 0x00, 0xCC, 0x07, 0x70, 0x19, 0x83, 0xFF, 0xCF,
  0xFE, 0x0C, 0xE0, 0x33, 0x01, 0xCC, 0x06, 0x70, 0xFF, 0xF3, 0xFF, 0x83,
  0x38, 0x0C, 0xC0, 0x73, 0x01, 0x9C, 0x06, 0x60, 0x19, 0x80, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x7C, 0x0F, 0xE1, 0xFF, 0x3C, 0xF3, 0xC7, 0x38, 0x73,
  0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xC0, 0x1E, 0x01, 0xEE,
  0x0E, 0xE1, 0xEF, 0x1C, 0x7F, 0xC7, 0xF8, 0x1E, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x1C, 0x00, 0xF8, 0x07, 0x71, 0x19, 0xCE, 0x67, 0x31, 0x9D, 0x86,
  0x6E, 0x1F, 0xB0, 0x3D, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xBC, 0x0F, 0xF8,
  0x76, 0x61, 0xB9, 0xCC, 0xE6, 0x73, 0x99, 0x8E, 0xE0, 0x1F, 0x80, 0x38,
  0x03, 0xC0, 0x1F, 0x80, 0xFF, 0x03, 0x9C, 0x0E, 0x70, 0x71, 0xC1, 0xEF,
  0x03, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF9, 0xCF, 0xE7, 0x7B, 0xDD, 0xC7,
  0xE7, 0x1F, 0x9C, 0x3C, 0x78, 0xF1, 0xFF, 0xC3, 0xFF, 0x87, 0xCE, 0x76,
  0x6E, 0xEC, 0xC0, 0x01, 0x01, 0xC1, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x70,
  0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x1C, 0x06, 0x01, 0x00, 0x08,
  0x0C, 0x0E, 0x06, 0x07, 0x07, 0x07, 0x03, 0x03, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x3C, 0x38, 0x70,
  0xE0, 0xC0, 0x80, 0x03, 0x00, 0x30, 0x03, 0x04, 0x31, 0x7E, 0xF7, 0xFF,
  0x0F, 0x81, 0xF0, 0x1B, 0x03, 0xB8, 0x71, 0xC2, 0x10, 0x07, 0x80, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0x0E, 0x00, 0xE0,
  0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x71, 0xCE, 0x39, 0xE7, 0x18,
  0x7F, 0xFF, 0xF8, 0xEF, 0xFE, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x00, 0x07, 0xC0, 0xFE, 0x1F, 0xE3, 0xCF, 0x38,
  0x77, 0x87, 0x78, 0x77, 0x07, 0x70, 0xF7, 0x0F, 0x70, 0xFF, 0x0E, 0xF0,
  0xEF, 0x0E, 0xF1, 0xEF, 0x1C, 0x73, 0xC7, 0xF8, 0x7F, 0x81, 0xE0, 0x01,
  0x0F, 0x7F, 0x7F, 0xFE, 0x8E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C,
  0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x03, 0xE0, 0x7F, 0x87, 0xFE,
  0x38, 0xF3, 0xC7, 0x9E, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0xFF,
  0xBF, 0xFD, 0xFF, 0xC0, 0x07, 0xC0, 0x7F, 0x87, 0xFC, 0x38, 0xF3, 0xC7,
  0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x07, 0xF0, 0x3E, 0x01, 0xF8, 0x01, 0xC0,
  0x0F, 0x00, 0x79, 0xC3, 0xCE, 0x1E, 0x79, 0xE3, 0xFF, 0x0F, 0xF0, 0x3E,
  0x00, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x1F,
  0xC0, 0xFE, 0x0E, 0xF0, 0xE7, 0x07, 0x38, 0x71, 0xC7, 0x9E, 0x3F, 0xFF,
  0xFF, 0xDF, 0xFE, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0xF8,
  0xFF, 0xC7, 0xFC, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0xF0, 0x7F,
  0xC3, 0xFF, 0x0C, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x73, 0x83, 0x9E, 0x3C,
  0xF1, 0xC3, 0xFE, 0x1F, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0xFC, 0x3F, 0x8F,
  0x81, 0xC0, 0x78, 0x0E, 0x03, 0xFC, 0x7F, 0xCF, 0xFD, 0xE7, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x8F, 0x71, 0xCF, 0xF8, 0xFE, 0x0F, 0x80, 0x3F,
  0xF9, 0xFF, 0xDF, 0xFE, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0xFE, 0x1F,
  0xF3, 0xCF, 0x38, 0x73, 0x87, 0x38, 0xF3, 0xCE, 0x1F, 0xE1, 0xF8, 0x3F,
  0xC7, 0x1C, 0xF1, 0xEE, 0x1E, 0xE1, 0xEE, 0x1E, 0xF3, 0xCF, 0xFC, 0x7F,
  0x83, 0xE0, 0x0F, 0x07, 0xF0, 0xFF, 0x3C, 0xE7, 0x1F, 0xE3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFE, 0x7F, 0xFF, 0x3F, 0xE3, 0xDC, 0x07, 0x80, 0xE0, 0x3C,
  0x1F, 0x0F, 0xC1, 0xF0, 0x78, 0x00, 0x38, 0xF3, 0xCE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0xF3, 0xCE, 0x00, 0x0E, 0x3C, 0x78, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x87, 0x0E, 0x1C, 0x70, 0xE3, 0x82, 0x00,
  0x00, 0x20, 0x38, 0x1F, 0x0F, 0xE7, 0xF1, 0xF8, 0x3C, 0x07, 0xC0, 0x7E,
  0x07, 0xF0, 0x3E, 0x01, 0xC0, 0x10, 0x3F, 0xF7, 0xFE, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0xFF, 0xCF, 0xFC, 0x20, 0x07, 0x01, 0xF0, 0x3F, 0x80,
  0xFC, 0x07, 0xC0, 0x70, 0x7E, 0x3F, 0x9F, 0xC3, 0xE0, 0x70, 0x08, 0x00,
  0x1F, 0x0F, 0xE7, 0xFF, 0xCF, 0xF1, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1E, 0x1E, 0x07, 0x00, 0xE1, 0xC0,
  0x0C, 0x30, 0x01, 0x8E, 0x1E, 0x19, 0x8F, 0xE3, 0x71, 0xCC, 0x6C, 0x73,
  0x8F, 0x9C, 0x71, 0xF3, 0x8C, 0x7C, 0x71, 0x8D, 0x8C, 0x71, 0xB3, 0x8E,
  0x36, 0x71, 0x8C, 0xC7, 0x73, 0x98, 0xFF, 0xE3, 0x0E, 0x78, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x18, 0x01, 0xFF, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0xFE, 0x01, 0xDE, 0x07, 0x9C, 0x0E, 0x38, 0x3C, 0x70, 0x70, 0xE1,
  0xE1, 0xC3, 0xFF, 0x8F, 0xFF, 0x9F, 0xFF, 0x38, 0x1E, 0xF0, 0x3D, 0xC0,
  0x3F, 0x80, 0x70, 0x0F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0xF1, 0xE1, 0xE1,
  0xE3, 0x83, 0xC7, 0x07, 0x1E, 0x1E, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1,
  0xC3, 0xC3, 0x83, 0x8F, 0x07, 0x1E, 0x0E, 0x3C, 0x3C, 0x70, 0xF8, 0xFF,
  0xE1, 0xFF, 0x87, 0xFE, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x87, 0x8F,
  0x3C, 0x1C, 0xE0, 0x77, 0x81, 0xDE, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0xEF, 0x07, 0xBC, 0x1C, 0x78, 0xF1, 0xFF,
  0x83, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0xF1, 0xE1,
  0xE1, 0xC3, 0x83, 0xC7, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x38, 0xE0,
  0x71, 0xC0, 0xE3, 0x83, 0xCF, 0x07, 0x9E, 0x0E, 0x3C, 0x3C, 0x70, 0xF0,
  0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x7F, 0xF0,
  0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xFF, 0xE1, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xF1,
  0xFF, 0xC7, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x7F,
  0xF0, 0xF1, 0xE3, 0xC1, 0xC7, 0x03, 0x9E, 0x07, 0xBC, 0x00, 0x70, 0x00,
  0xE3, 0xF9, 0xC7, 0xF7, 0x8F, 0xEF, 0x03, 0x9E, 0x07, 0x3C, 0x1E, 0x38,
  0x3C, 0x78, 0xF8, 0xFF, 0xF0, 0xFF, 0x80, 0x7C, 0x00, 0x0E, 0x07, 0x8F,
  0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xE1, 0xE0, 0x70, 0xE0, 0x38, 0x70, 0x3C,
  0x78, 0x1E, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0x01, 0xC3, 0x81,
  0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x38, 0x70, 0x1C, 0x38, 0x1E, 0x1C,
  0x0F, 0x1E, 0x07, 0x80, 0x0E, 0x1C, 0x78, 0xF1, 0xE3, 0x87, 0x0E, 0x3C,
  0x78, 0xF1, 0xC3, 0x87, 0x1E, 0x3C, 0x78, 0xE1, 0xC7, 0x80, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x8F, 0x0E,
  0x3C, 0x78, 0xF1, 0xC1, 0xFF, 0x07, 0xF8, 0x07, 0xC0, 0x0E, 0x0F, 0x8F,
  0x0F, 0x87, 0x87, 0x83, 0xC7, 0x81, 0xE7, 0x80, 0xE7, 0xC0, 0x77, 0xC0,
  0x7B, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xDE,
  0x03, 0xCF, 0x01, 0xE3, 0xC0, 0xF1, 0xE0, 0x70, 0xF0, 0x38, 0x3C, 0x1C,
  0x1E, 0x1E, 0x0F, 0x00, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38,
  0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x70, 0x0F, 0xFD, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF8, 0xF8,
  0x07, 0xC7, 0xE0, 0x7C, 0x3F, 0x03, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8,
  0x7E, 0x1D, 0xC7, 0xF0, 0xFE, 0x3F, 0x8E, 0xE1, 0xDC, 0x77, 0x0E, 0x63,
  0xB8, 0x73, 0x3B, 0xC3, 0x99, 0xDE, 0x3C, 0xFC, 0xF1, 0xE7, 0xE7, 0x0F,
  0x3E, 0x38, 0x71, 0xF3, 0xC3, 0x8F, 0x1E, 0x1C, 0x78, 0xF1, 0xE1, 0x87,
  0x80, 0x0E, 0x07, 0x8F, 0x83, 0xC7, 0xC1, 0xE3, 0xE0, 0xE1, 0xF0, 0x70,
  0xFC, 0x38, 0x7E, 0x3C, 0x7B, 0x1E, 0x3D, 0xCF, 0x1E, 0xE7, 0x0E, 0x73,
  0x87, 0x1B, 0xC3, 0x8F, 0xE3, 0xC7, 0xF1, 0xE1, 0xF8, 0xF0, 0xF8, 0x70,
  0x7C, 0x38, 0x3E, 0x1C, 0x0F, 0x1E, 0x07, 0x80, 0x03, 0xE0, 0x1F, 0xF0,
  0x7F, 0xF0, 0xF1, 0xE3, 0xC1, 0xC7, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x70,
  0x1E, 0xE0, 0x39, 0xC0, 0x77, 0x80, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0E,
  0x38, 0x3C, 0x78, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0x0F, 0xF0,
  0x3F, 0xF8, 0x7F, 0xF0, 0xF0, 0xF1, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x9E,
  0x0F, 0x3C, 0x1E, 0x78, 0x78, 0xFF, 0xF1, 0xFF, 0xC3, 0xFE, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF0, 0xF1, 0xE3, 0xC1, 0xC7, 0x03, 0xDE,
  0x07, 0xBC, 0x0F, 0x70, 0x1E, 0xE0, 0x3B, 0xC0, 0x77, 0x80, 0xEF, 0x03,
  0xDE, 0x07, 0xBC, 0x0E, 0x78, 0x3C, 0x78, 0xF0, 0xFF, 0xE0, 0xFF, 0x80,
  0xFF, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x10, 0x0F, 0xF0, 0x3F,
  0xF0, 0x7F, 0xF0, 0xF0, 0xF1, 0xE1, 0xE3, 0x83, 0xC7, 0x07, 0x9E, 0x0E,
  0x3C, 0x3C, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x03, 0x8E, 0x0F, 0x1C, 0x1E,
  0x3C, 0x3C, 0x78, 0x70, 0xF0, 0xE0, 0xE1, 0xC1, 0xE7, 0x83, 0xC0, 0x07,
  0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x1E, 0x38, 0x38, 0xE0, 0xF3, 0x80, 0x0F,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0xF0, 0x03, 0xCE,
  0x0F, 0x38, 0x3C, 0xF1, 0xE3, 0xFF, 0x87, 0xFC, 0x07, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x1E, 0x78,
  0x3C, 0xF0, 0x79, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x9E, 0x0F, 0x3C, 0x1E,
  0x78, 0x3C, 0xE0, 0x71, 0xC0, 0xE3, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C,
  0x1E, 0x78, 0x38, 0xF0, 0xF0, 0xFF, 0xC1, 0xFF, 0x00, 0xFC, 0x00, 0xF0,
  0x1F, 0xE0, 0x79, 0xC0, 0xF3, 0x81, 0xE7, 0x07, 0x8F, 0x0F, 0x1E, 0x1C,
  0x3C, 0x78, 0x78, 0xE0, 0xF3, 0xC0, 0xE7, 0x81, 0xCE, 0x03, 0xBC, 0x07,
  0x70, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xE1, 0xE1, 0xFC, 0x3C, 0x3B, 0x87, 0x8F, 0x71, 0xF1, 0xEE, 0x3E,
  0x39, 0xC7, 0xCF, 0x39, 0xF9, 0xE7, 0x3F, 0x38, 0xE7, 0xEF, 0x1D, 0xDD,
  0xE3, 0xBB, 0xB8, 0x77, 0x77, 0x0F, 0xCF, 0xE1, 0xF9, 0xF8, 0x3E, 0x3F,
  0x07, 0xC7, 0xE0, 0xF8, 0xF8, 0x1E, 0x1F, 0x03, 0xC3, 0xE0, 0x78, 0x38,
  0x00, 0x0F, 0x07, 0x87, 0x87, 0xC3, 0xC3, 0xC0, 0xE3, 0xC0, 0x79, 0xE0,
  0x3D, 0xE0, 0x0E, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7B, 0x80, 0x3D, 0xE0, 0x3C, 0xF0, 0x3C,
  0x78, 0x1E, 0x1C, 0x1E, 0x0F, 0x1F, 0x07, 0x80, 0xF0, 0x3D, 0xC0, 0xF7,
  0x87, 0x9E, 0x1C, 0x78, 0xF0, 0xE3, 0x83, 0x9E, 0x0E, 0x70, 0x3F, 0xC0,
  0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F,
  0xF8, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x01, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x80, 0x0F, 0x87, 0xC7,
  0xC3, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0x81,
  0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0,
  0xF0, 0x7C, 0x3E, 0x1F, 0x00, 0xF0, 0xE1, 0xC3, 0x87, 0x0E, 0x1E, 0x3C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x8F, 0x1E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0xC0, 0x07, 0xC1, 0xF0, 0xF8, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x1F, 0x07, 0xC1, 0xF0,
  0x07, 0x07, 0x83, 0xC3, 0xE1, 0xB1, 0xD8, 0xCE, 0xE7, 0x73, 0xF1, 0xC0,
  0x7F, 0xEF, 0xFF, 0xFF, 0x80, 0xF1, 0xC3, 0x8E, 0x07, 0xC1, 0xFE, 0x3F,
  0xE3, 0xCF, 0x38, 0xF0, 0x0F, 0x0F, 0xE3, 0xFE, 0x7C, 0xE7, 0x1E, 0xF1,
  0xEF, 0x1E, 0x7F, 0xC7, 0xFC, 0x3D, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x77, 0x87, 0xFE, 0x3F, 0xF1, 0xE3, 0x8E,
  0x1C, 0x70, 0xE3, 0x87, 0x3C, 0x39, 0xE1, 0xCE, 0x0E, 0x70, 0xF3, 0xC7,
  0x3F, 0xF9, 0xFF, 0x8E, 0x78, 0x00, 0x0F, 0x87, 0xF9, 0xFF, 0x3C, 0xFF,
  0x0F, 0xE1, 0xF8, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x87, 0x71, 0xEF, 0xF8,
  0xFE, 0x0F, 0x80, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00,
  0x38, 0x79, 0xC7, 0xFE, 0x7F, 0xF3, 0xCF, 0xBC, 0x39, 0xE1, 0xCE, 0x0E,
  0x70, 0xF3, 0x87, 0x9C, 0x3C, 0xE1, 0xC7, 0x9E, 0x3F, 0xF0, 0xFF, 0x83,
  0xFC, 0x00, 0x0F, 0x83, 0xF8, 0xFF, 0xBC, 0x77, 0x0F, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x78, 0xCF, 0xFC, 0xFF, 0x0F, 0xC0, 0x03,
  0xC3, 0xF0, 0xF8, 0x78, 0x1C, 0x07, 0x07, 0xF3, 0xFC, 0xFF, 0x0E, 0x03,
  0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0,
  0xE0, 0x00, 0x0F, 0x38, 0xFD, 0xCF, 0xFE, 0x78, 0xF7, 0x87, 0xBC, 0x39,
  0xC1, 0xCE, 0x0E, 0x70, 0xF3, 0x87, 0x9C, 0x3C, 0xF1, 0xC7, 0xFE, 0x1F,
  0xF0, 0x7F, 0x80, 0x3C, 0x01, 0xC2, 0x1E, 0x3F, 0xF1, 0xFF, 0x03, 0xE0,
  0x00, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3D, 0xE3,
  0xFE, 0x3F, 0xF3, 0xCF, 0x38, 0x73, 0x87, 0x78, 0xF7, 0x8F, 0x78, 0xF7,
  0x0E, 0x70, 0xE7, 0x0E, 0xF1, 0xEF, 0x1E, 0xE1, 0xE0, 0x0C, 0x3C, 0x78,
  0x60, 0x00, 0x07, 0x0E, 0x3C, 0x78, 0xE1, 0xC3, 0x8F, 0x1E, 0x3C, 0x70,
  0xE1, 0xC7, 0x8F, 0x00, 0x01, 0x80, 0xF0, 0x3C, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C,
  0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0xFC, 0x3E,
  0x0F, 0x00, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x01, 0xC7, 0x8F, 0x3C, 0x3D, 0xE0, 0xE7, 0x83, 0xBC, 0x0F, 0xE0, 0x7F,
  0x01, 0xFE, 0x07, 0xF8, 0x1E, 0xE0, 0x73, 0xC1, 0xCF, 0x0F, 0x1C, 0x3C,
  0x78, 0xF1, 0xE0, 0x0E, 0x1C, 0x78, 0xF1, 0xE3, 0x87, 0x0E, 0x3C, 0x78,
  0xE1, 0xC3, 0x87, 0x1E, 0x3C, 0x70, 0xE1, 0xC7, 0x8F, 0x00, 0x1D, 0xE3,
  0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x9E, 0x7C, 0xF3, 0x87, 0x1E, 0x70, 0xE3,
  0xDE, 0x3C, 0x7B, 0xC7, 0x8F, 0x78, 0xE1, 0xCE, 0x1C, 0x39, 0xC3, 0x87,
  0x38, 0x71, 0xEF, 0x1E, 0x3D, 0xE3, 0xC7, 0xBC, 0x70, 0xE0, 0x3D, 0xE3,
  0xFF, 0x3F, 0xF3, 0xCF, 0x38, 0x73, 0x87, 0x78, 0xF7, 0x8F, 0x78, 0xF7,
  0x0E, 0x70, 0xE7, 0x0E, 0xF1, 0xEF, 0x1E, 0xF1, 0xE0, 0x0F, 0x83, 0xFC,
  0x3F, 0xE7, 0x8E, 0x70, 0xEF, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E,
  0xE1, 0xEF, 0x1C, 0xFF, 0xC7, 0xF8, 0x3E, 0x00, 0x0E, 0xF0, 0x7F, 0xE1,
  0xFF, 0x87, 0x8E, 0x1C, 0x38, 0x70, 0xE3, 0xC3, 0x8F, 0x0E, 0x3C, 0x38,
  0xE0, 0xE3, 0x87, 0x8F, 0x1C, 0x7F, 0xF1, 0xFF, 0x87, 0xBC, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x73, 0xF7,
  0x7F, 0xF7, 0x8F, 0xF0, 0xEF, 0x0E, 0xE0, 0xEE, 0x1E, 0xE1, 0xEE, 0x1E,
  0xE1, 0xCF, 0x3C, 0xFF, 0xC7, 0xFC, 0x3F, 0xC0, 0x3C, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x78, 0x07, 0x80, 0x3D, 0x9F, 0xCF, 0xE7, 0xF3, 0xC1, 0xC1,
  0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC0, 0x07, 0x81,
  0xFE, 0x3F, 0xE3, 0x8F, 0x38, 0xF3, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xC0,
  0x1E, 0xF1, 0xEF, 0x1C, 0x7F, 0xC7, 0xF8, 0x1F, 0x00, 0x1C, 0x1C, 0x3C,
  0xFF, 0xFE, 0xFE, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0x70, 0x70, 0xF0,
  0x7C, 0x78, 0x38, 0x78, 0xF7, 0x8F, 0x78, 0xF7, 0x0E, 0x70, 0xE7, 0x0E,
  0xF1, 0xEF, 0x1E, 0xF1, 0xEE, 0x1C, 0xE1, 0xCF, 0x3C, 0xFF, 0xC7, 0xFC,
  0x7B, 0xC0, 0x70, 0xE7, 0x1E, 0x71, 0xE7, 0x1C, 0x73, 0xC7, 0x38, 0x73,
  0x87, 0x78, 0x77, 0x03, 0x70, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x00, 0xE3, 0x8F, 0xE3, 0x8E, 0xE7, 0x8E, 0xE7, 0x9E, 0xE7, 0x9C, 0xEF,
  0x9C, 0xEF, 0xBC, 0xFD, 0xB8, 0xFD, 0xF8, 0xF9, 0xF0, 0xF9, 0xF0, 0xF9,
  0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0xE1, 0xE0, 0x1C, 0x38, 0x79, 0xE1, 0xE7,
  0x03, 0xBC, 0x0F, 0xE0, 0x3F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3F,
  0x01, 0xDC, 0x0F, 0x70, 0x39, 0xE1, 0xE7, 0x8F, 0x0E, 0x00, 0x1C, 0x3C,
  0x71, 0xE1, 0xC7, 0x87, 0x1C, 0x1C, 0xF0, 0x73, 0x81, 0xDE, 0x07, 0x78,
  0x1D, 0xC0, 0x7F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x0F, 0xC0, 0x3E, 0x00, 0xF0, 0x00, 0x3F,
  0xF3, 0xFF, 0x3F, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0xFF, 0xCF, 0xFC, 0xFF, 0xC0, 0x01, 0x07,
  0x0F, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0xF0, 0xE0,
  0xE0, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x38,
  0x10, 0x0C, 0x30, 0xC3, 0x1C, 0x71, 0x86, 0x18, 0x63, 0x8E, 0x30, 0xC3,
  0x0C, 0x31, 0xC7, 0x18, 0x61, 0x86, 0x18, 0x08, 0x06, 0x03, 0x81, 0xC0,
  0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x78, 0x18, 0x3C,
  0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x70,
  0x30, 0x00, 0x3C, 0x1B, 0xF1, 0xDF, 0xCF, 0xCF, 0xEE, 0x3F, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_SemiBoldItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 20, 7, 1, -20 },
  { 16, 8, 7, 9, 2, -21 },
  { 23, 14, 20, 14, 1, -20 },
  { 58, 12, 26, 14, 1, -23 },
  { 97, 14, 20, 17, 2, -20 },
  { 132, 14, 20, 15, 0, -20 },
  { 167, 4, 7, 4, 2, -21 },
  { 171, 9, 28, 9, 1, -22 },
  { 203, 8, 28, 9, -1, -22 },
  { 231, 12, 12, 12, 1, -20 },
  { 249, 12, 14, 13, 1, -16 },
  { 270, 6, 8, 6, -2, -3 },
  { 276, 7, 3, 9, 1, -10 },
  { 279, 4, 4, 8, 1, -4 },
  { 281, 13, 22, 9, -2, -20 },
  { 317, 12, 20, 14, 1, -20 },
  { 347, 8, 20, 14, 3, -20 },
  { 367, 13, 20, 14, 0, -20 },
  { 400, 13, 20, 14, 0, -20 },
  { 433, 13, 20, 14, 0, -20 },
  { 466, 13, 20, 14, 1, -20 },
  { 499, 11, 20, 14, 1, -20 },
  { 527, 13, 20, 14, 1, -20 },
  { 560, 12, 20, 14, 1, -20 },
  { 590, 11, 20, 14, 2, -20 },
  { 618, 6, 15, 7, 1, -15 },
  { 630, 7, 20, 7, -1, -15 },
  { 648, 11, 13, 12, 1, -15 },
  { 666, 12, 8, 14, 1, -13 },
  { 678, 11, 13, 12, 1, -15 },
  { 696, 10, 20, 12, 2, -20 },
  { 721, 19, 25, 21, 1, -19 },
  { 781, 15, 20, 16, -1, -20 },
  { 819, 15, 20, 15, 0, -20 },
  { 857, 14, 20, 15, 1, -20 },
  { 892, 15, 20, 15, 0, -20 },
  { 930, 15, 20, 13, 0, -20 },
  { 968, 14, 20, 13, 0, -20 },
  { 1003, 15, 20, 16, 1, -20 },
  { 1041, 17, 20, 17, 0, -20 },
  { 1084, 7, 20, 7, 0, -20 },
  { 1102, 14, 20, 13, 0, -20 },
  { 1137, 17, 20, 15, 0, -20 },
  { 1180, 11, 20, 13, 0, -20 },
  { 1208, 21, 20, 21, 0, -20 },
  { 1261, 17, 20, 17, 0, -20 },
  { 1304, 15, 20, 16, 1, -20 },
  { 1342, 15, 20, 15, 0, -20 },
  { 1380, 15, 24, 16, 1, -20 },
  { 1425, 15, 20, 15, 0, -20 },
  { 1463, 14, 20, 15, 1, -20 },
  { 1498, 14, 20, 15, 2, -20 },
  { 1533, 15, 20, 15, 1, -20 },
  { 1571, 15, 20, 16, 2, -20 },
  { 1609, 19, 20, 20, 3, -20 },
  { 1657, 17, 20, 15, -1, -20 },
  { 1700, 14, 20, 15, 2, -20 },
  { 1735, 15, 20, 14, 0, -20 },
  { 1773, 9, 28, 7, 0, -23 },
  { 1805, 7, 22, 10, 2, -20 },
  { 1825, 10, 28, 7, -2, -23 },
  { 1860, 9, 10, 10, 1, -20 },
  { 1872, 11, 3, 11, -2, 0 },
  { 1877, 6, 4, 9, 3, -21 },
  { 1880, 12, 15, 13, 0, -15 },
  { 1903, 13, 21, 13, 0, -21 },
  { 1938, 11, 15, 13, 1, -15 },
  { 1959, 13, 21, 13, 1, -21 },
  { 1994, 11, 15, 13, 1, -15 },
  { 2015, 10, 21, 9, 1, -21 },
  { 2042, 13, 21, 14, 0, -15 },
  { 2077, 12, 21, 13, 0, -21 },
  { 2109, 7, 21, 7, 0, -21 },
  { 2128, 10, 27, 7, -3, -21 },
  { 2162, 14, 21, 13, 0, -21 },
  { 2199, 7, 21, 7, 0, -21 },
  { 2218, 19, 15, 20, 0, -15 },
  { 2254, 12, 15, 13, 0, -15 },
  { 2277, 12, 15, 14, 1, -15 },
  { 2300, 14, 21, 13, -1, -15 },
  { 2337, 12, 21, 14, 1, -15 },
  { 2369, 9, 15, 9, 0, -15 },
  { 2386, 12, 15, 12, 0, -15 },
  { 2409, 8, 18, 8, 1, -18 },
  { 2427, 12, 15, 13, 1, -15 },
  { 2450, 12, 15, 12, 1, -15 },
  { 2473, 16, 15, 17, 2, -15 },
  { 2503, 14, 15, 12, -1, -15 },
  { 2530, 14, 21, 12, -1, -15 },
  { 2567, 12, 15, 12, 0, -15 },
  { 2590, 8, 27, 8, 1, -22 },
  { 2617, 6, 24, 7, 0, -20 },
  { 2635, 9, 27, 8, -1, -22 },
  { 2666, 13, 6, 15, 1, -11 },
};

const GFXfont RobotoCondensed_SemiBoldItalic28pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic28pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic28pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC28PT7B_H_
