#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC71PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x03,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x01, 0xC0, 0x00, 0x1F, 0x87, 0xF1, 0xF8,
  0x7E, 0x3F, 0x87, 0xE3, 0xF8, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0xFE, 0x3F,
  0x0F, 0xE3, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7,
  0xE0, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF8, 0x7C, 0x1F, 0x8F, 0xC1, 0xF0,
  0xFC, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x07,
  0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x0F, 0xF0, 0xFF,
  0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x60, 0xFE, 0x0F, 0xC0, 0x3C, 0x7E, 0x07, 0xE0, 0x3F,
  0x3F, 0x03, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x1F,
  0x8F, 0xC0, 0x7E, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC3, 0xF0, 0x1F, 0x0F,
  0xC1, 0xF8, 0x1F, 0x8F, 0xC0, 0x7C, 0x0F, 0xCF, 0xE0, 0x3F, 0x0F, 0xE7,
  0xE0, 0x1F, 0xCF, 0xE7, 0xE0, 0x0F, 0xFF, 0xF7, 0xE0, 0x03, 0xFF, 0xF3,
  0xF0, 0x00, 0xFF, 0xF3, 0xF0, 0x00, 0x3F, 0xF3, 0xF0, 0x00, 0x0F, 0xE1,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0x80, 0x00,
  0xFE, 0x7F, 0xE0, 0x00, 0x7E, 0x7F, 0xF8, 0x00, 0x7E, 0x7F, 0xFE, 0x00,
  0x7F, 0x7F, 0xFF, 0x00, 0x3F, 0x7F, 0x9F, 0xC0, 0x3F, 0x3F, 0x07, 0xE0,
  0x3F, 0x1F, 0x83, 0xF0, 0x1F, 0x9F, 0xC1, 0xF8, 0x1F, 0x8F, 0xC0, 0x7C,
  0x1F, 0x87, 0xE0, 0x3E, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC1, 0xF8, 0x1F,
  0x8F, 0xC0, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x07, 0xE7, 0xE0, 0x3F, 0x03,
  0xF7, 0xE0, 0x1F, 0x83, 0xF0, 0xF0, 0x0F, 0xE1, 0xF8, 0x30, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xC3,
  0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x07,
  0xF0, 0x7F, 0xFF, 0xC1, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xC7, 0xFE, 0xFF,
  0x87, 0xF0, 0xFF, 0x9F, 0xF0, 0xFE, 0x3F, 0xE1, 0xFF, 0x3F, 0xC7, 0xFC,
  0x3F, 0xE7, 0xF9, 0xFF, 0x03, 0xFE, 0xFE, 0x3F, 0xE0, 0x7F, 0xFF, 0xC7,
  0xFC, 0x07, 0xFF, 0xF8, 0xFF, 0x80, 0xFF, 0xFE, 0x3F, 0xE0, 0x0F, 0xFF,
  0xC7, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xC0, 0x1F, 0xFE, 0x0F, 0xF8, 0x03,
  0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x1F,
  0xF0, 0x07, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x9F,
  0xCF, 0xE7, 0xF3, 0xF9, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x30, 0x07, 0xC0, 0x31, 0xE0, 0x3E, 0x07, 0x9F, 0xE3, 0xF1, 0xFC,
  0xFF, 0xDF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xBF, 0x00,
  0x03, 0xF9, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xFC, 0x3F, 0x00, 0x3F,
  0xC1, 0xFC, 0x03, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x3C, 0x00,
  0xF8, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x03,
  0xC0, 0x02, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xEF,
  0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0x3F, 0x1F, 0xEF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x1F,
  0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x0F, 0xF0,
  0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF1, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF3, 0xFE, 0x00, 0x7F,
  0xCF, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0x00, 0x1F, 0xF3,
  0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x01, 0xFE, 0x7F, 0xC0, 0x07, 0xF9, 0xFF,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x7F, 0x80,
  0x0F, 0xF9, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0x3F, 0xE0, 0x03,
  0xFC, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF,
  0x3F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x8F,
  0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0xC1, 0xFE,
  0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0x80, 0x01, 0xFC,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0x7F, 0xCF,
  0xC3, 0xFC, 0x78, 0x1F, 0xE2, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0,
  0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xE0,
  0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07,
  0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF,
  0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xF7, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F, 0xEF, 0xF8, 0x00,
  0x1F, 0xEF, 0xF8, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x3F, 0x8F, 0xF8, 0x00,
  0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFE, 0x1F, 0xF0, 0x01,
  0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x07,
  0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x7E,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xF8, 0x0F, 0xF8, 0x00, 0x18,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x81,
  0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x8F, 0xE0, 0x07,
  0xFD, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0xFF,
  0xF3, 0xFF, 0x81, 0xFF, 0x9F, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xE7,
  0xFC, 0x01, 0xFF, 0x3F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xDF, 0xF0,
  0x01, 0xFE, 0xFF, 0x80, 0x0F, 0xF7, 0xFC, 0x00, 0x7F, 0xBF, 0xE0, 0x03,
  0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xF9,
  0xFE, 0x00, 0xFF, 0x8F, 0xF0, 0x07, 0xFC, 0x7F, 0x80, 0x3F, 0xE3, 0xFE,
  0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x87,
  0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF,
  0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80,
  0x3F, 0xE7, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x0F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80,
  0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x01,
  0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F,
  0xF8, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x01, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xF8, 0x7F, 0xC3, 0xFF, 0x03, 0xFE, 0x3F,
  0xE0, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x7F, 0xC0, 0x1F, 0xE7, 0xFC, 0x01,
  0xFE, 0x7F, 0x80, 0x1F, 0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFE, 0xFF, 0x80,
  0x1F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE,
  0xFF, 0x80, 0x7F, 0xE7, 0xFC, 0x0F, 0xFE, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x7F, 0x80, 0x1F, 0x8F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF,
  0x03, 0xFE, 0x03, 0xF8, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xE0, 0x07, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x04, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x7F, 0xE0, 0xFF, 0x9F, 0xF0, 0x3F,
  0xE7, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xC7, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x3E, 0x01, 0xF8, 0x01, 0xFF, 0xC0,
  0x1F, 0x81, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xC0, 0xFC, 0x01, 0xFF, 0xFE,
  0x03, 0xE0, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xF0, 0x7E, 0x01, 0xFF, 0xFF,
  0x80, 0xF8, 0x3F, 0x01, 0xFE, 0x0F, 0xC0, 0x7C, 0x3F, 0x00, 0xFE, 0x07,
  0xE0, 0x3E, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x1F, 0xC0, 0x7E, 0x03,
  0xF8, 0x0F, 0x8F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xC7, 0xE0, 0x3F, 0x00,
  0xFC, 0x03, 0xE7, 0xF0, 0x3F, 0x80, 0x7E, 0x01, 0xF3, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xF9, 0xF8, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0xFC, 0x0F, 0xE0,
  0x1F, 0x80, 0x7E, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x3E, 0x7E, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0x3F, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0x9F, 0x81, 0xFC,
  0x03, 0xF0, 0x0F, 0xCF, 0xC0, 0xFE, 0x01, 0xF8, 0x07, 0xC7, 0xE0, 0x7F,
  0x01, 0xFC, 0x03, 0xE3, 0xF0, 0x3F, 0x80, 0xFC, 0x01, 0xF1, 0xF8, 0x1F,
  0xC0, 0x7E, 0x01, 0xF1, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xF8, 0xFC, 0x07,
  0xF0, 0x3F, 0x80, 0xFC, 0x7E, 0x03, 0xF8, 0x3F, 0xC0, 0x7C, 0x3F, 0x01,
  0xFC, 0x1F, 0xE0, 0x7E, 0x1F, 0x80, 0xFF, 0x1F, 0xF0, 0x7E, 0x07, 0xC0,
  0x7F, 0xFF, 0xFE, 0xFE, 0x03, 0xE0, 0x1F, 0xFF, 0x7F, 0xFF, 0x01, 0xF8,
  0x0F, 0xFF, 0x3F, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0x0F, 0xFF, 0x00, 0x7E,
  0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x04, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFD, 0xFC, 0x00,
  0x00, 0x07, 0xFB, 0xF8, 0x00, 0x00, 0x1F, 0xF7, 0xF0, 0x00, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x01, 0xFE, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x3F,
  0xE1, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x7F, 0xC7,
  0xFE, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00,
  0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x7F, 0xC0, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF8,
  0x1F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x7F, 0xC0, 0x07, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00,
  0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF,
  0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFE, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01,
  0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x0F, 0xFE, 0x07, 0xFC, 0x03, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xFE, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0xFF,
  0x1F, 0xF0, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xFE, 0x7F, 0xC0, 0x3F,
  0xFF, 0xE7, 0xFC, 0x03, 0xFF, 0xFC, 0x7F, 0xC0, 0x3F, 0xFF, 0xC7, 0xFC,
  0x03, 0xFF, 0xFC, 0xFF, 0xC0, 0x7F, 0xFF, 0xCF, 0xF8, 0x07, 0xFF, 0xFC,
  0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF8,
  0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x03,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x07, 0xFC, 0x0F,
  0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xFC, 0x0F,
  0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x0F,
  0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x00, 0x1F,
  0xF0, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x3F, 0xE1, 0xFF, 0xC0,
  0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xCF, 0xFE, 0x00, 0x00, 0x1F, 0xF7,
  0xFF, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF7, 0xFC, 0x00,
  0x00, 0x7F, 0xF9, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x07, 0xFE,
  0x00, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF8, 0x07, 0xFD, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0x9F, 0xC0, 0x1F, 0xEF, 0xF8, 0x07, 0xF9,
  0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0x9F, 0xC0, 0x1F, 0xCF, 0xF0, 0x0F,
  0xF9, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x9F, 0xC0, 0x3F, 0x9F, 0xF0,
  0x0F, 0xF9, 0xFC, 0x07, 0xF9, 0xFF, 0x00, 0xFF, 0x9F, 0xC0, 0x7F, 0x1F,
  0xF0, 0x0F, 0xF0, 0xFE, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0xFE,
  0x3F, 0xE0, 0x1F, 0xF0, 0xFE, 0x1F, 0xE3, 0xFE, 0x01, 0xFF, 0x0F, 0xE1,
  0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFE, 0x1F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F,
  0xE3, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0xFE, 0x3F, 0x87, 0xFC, 0x01, 0xFF,
  0x0F, 0xE7, 0xF8, 0x7F, 0xC0, 0x3F, 0xE0, 0x7E, 0x7F, 0x07, 0xFC, 0x03,
  0xFE, 0x07, 0xEF, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xFE, 0x07, 0xFC,
  0x03, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xFC, 0x0F,
  0xF8, 0x07, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xF8,
  0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0x80, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x1F, 0xF0,
  0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x00,
  0x0F, 0xF8, 0x07, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xF0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F,
  0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x7F, 0x00, 0xFF, 0x80,
  0x7F, 0xCF, 0xE0, 0x3F, 0xE0, 0x1F, 0xF3, 0xF8, 0x0F, 0xF8, 0x07, 0xFC,
  0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x3F, 0x81, 0xFF, 0x00, 0xFF, 0xC7, 0xF0,
  0x7F, 0xC0, 0x3F, 0xE1, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0x07, 0xFC,
  0x03, 0xFE, 0x0F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xF8, 0xFF, 0xC0, 0x3F,
  0xE0, 0xFE, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0x8F, 0xF8, 0x07, 0xFC, 0x07,
  0xF3, 0xFE, 0x01, 0xFF, 0x01, 0xFC, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xDF, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0xFC, 0x03,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xE0,
  0x07, 0xFF, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x7F,
  0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFF, 0xE0,
  0x1F, 0xF0, 0x00, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00,
  0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0xFF,
  0x9F, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0x9F,
  0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x01,
  0xFF, 0x3F, 0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x07, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF8,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0xFF,
  0x9F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00,
  0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0x9F,
  0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x03,
  0xFE, 0x3F, 0xE0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0x9F, 0xF0,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x03, 0xFE,
  0x3F, 0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00,
  0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x80,
  0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x07, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x07, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03,
  0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x03, 0xFF, 0x07,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x07,
  0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x80,
  0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x01,
  0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0xC3, 0xFE,
  0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x1F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F,
  0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0xFF, 0x80, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xE0,
  0x00, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00,
  0x3F, 0xC7, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xF3, 0xFE,
  0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x1F,
  0xEF, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE7, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF3, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF1, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0xF8, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFC, 0x7F, 0x80,
  0x3F, 0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xFC, 0x03, 0xFE, 0x1F, 0xE0,
  0x1F, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0x07, 0xF8,
  0x0F, 0xFF, 0x80, 0xFF, 0x83, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0x81, 0xFE,
  0x03, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F,
  0x81, 0xFF, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0xFC, 0x1F, 0xF0, 0x1F,
  0xE0, 0xFF, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0x7F, 0x07, 0xF8, 0x07,
  0xF8, 0x3F, 0xBF, 0x83, 0xFC, 0x03, 0xFC, 0x3F, 0xDF, 0xC3, 0xFE, 0x01,
  0xFE, 0x1F, 0xCF, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xE7, 0xF0, 0xFF, 0x00,
  0x7F, 0x8F, 0xF3, 0xF8, 0xFF, 0x80, 0x3F, 0xC7, 0xF1, 0xFC, 0x7F, 0x80,
  0x1F, 0xE3, 0xF8, 0xFE, 0x3F, 0xC0, 0x0F, 0xF3, 0xFC, 0x7F, 0x3F, 0xE0,
  0x07, 0xF9, 0xFC, 0x3F, 0x9F, 0xE0, 0x03, 0xFD, 0xFE, 0x1F, 0xCF, 0xF0,
  0x01, 0xFE, 0xFE, 0x0F, 0xEF, 0xF8, 0x00, 0xFF, 0x7F, 0x03, 0xF7, 0xF8,
  0x00, 0x7F, 0xFF, 0x81, 0xFB, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xF3, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xE3, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x81,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFE,
  0x7F, 0xC0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x01,
  0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x1F,
  0xF0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF,
  0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00,
  0x07, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x07, 0xF9, 0xFF,
  0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xFD, 0xF8, 0x01, 0xF9, 0xF8, 0x03,
  0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x0F,
  0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F,
  0x80, 0xFE, 0x3F, 0x80, 0x7E, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE,
  0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xE7,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE,
  0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x8F, 0xFC, 0x07, 0xFC, 0x7F,
  0xC0, 0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xF1, 0xFF, 0x00,
  0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xE3, 0xFE, 0x03, 0xFF,
  0x1F, 0xF0, 0x3F, 0xF8, 0xFF, 0xEF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0x3F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0x00, 0x01, 0xFE, 0x7F,
  0xE0, 0x03, 0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x01,
  0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x01,
  0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x01,
  0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01,
  0xFE, 0x1F, 0xF0, 0x01, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x03,
  0xFE, 0x1F, 0xE0, 0x03, 0xFE, 0x1F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x03,
  0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07,
  0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xF8, 0x3F,
  0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xBF, 0xFF,
  0xE0, 0x7F, 0xBF, 0xFF, 0xC0, 0x7F, 0x9F, 0xFF, 0x80, 0xFF, 0x8F, 0xFF,
  0x00, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFE, 0x1F, 0xF8, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xF3,
  0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF7, 0xFC, 0x00, 0xFF, 0x7F, 0xC0,
  0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF,
  0x00, 0x7F, 0xCF, 0xF8, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x1F,
  0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0x87,
  0xF8, 0x01, 0xFF, 0xF3, 0xFE, 0x00, 0xFF, 0xFE, 0xFF, 0x80, 0x7F, 0xFF,
  0xBF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F,
  0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0x81,
  0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x03, 0xFE,
  0x07, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x0F,
  0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFD, 0xFE, 0x00, 0x07, 0xFC,
  0x7F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x7F,
  0xC0, 0x1F, 0xF3, 0xFC, 0x00, 0xFF, 0x9F, 0xE0, 0x07, 0xFD, 0xFF, 0x00,
  0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFB, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0x01, 0xFF, 0x00, 0x38, 0x0F,
  0xFC, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x0F, 0xF0, 0x03, 0xFF, 0xE7, 0xF8, 0x03, 0xFF,
  0xF9, 0xFE, 0x01, 0xFF, 0xFF, 0x7F, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC,
  0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F,
  0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x03, 0xFE, 0x07, 0xF8, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0,
  0x03, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xF7, 0xF8, 0x00, 0x1F, 0xF9, 0xFE, 0x00, 0x00, 0xF0, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0x00, 0x07, 0xFC, 0x00,
  0x60, 0x03, 0xFF, 0x00, 0x3C, 0x01, 0xFF, 0xC0, 0x1F, 0xC1, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x83, 0xC0, 0x01, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xFC,
  0x1F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1,
  0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFE, 0x1F,
  0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF,
  0x80, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFF, 0x0F, 0xF8,
  0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0,
  0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x01,
  0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F,
  0xF0, 0x7F, 0x80, 0x1F, 0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF,
  0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x1C, 0x00,
  0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x80, 0x7F,
  0xC0, 0x7F, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0x07, 0xFF, 0x00,
  0x3F, 0xC1, 0xFF, 0xC0, 0x07, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x0F, 0xFC,
  0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xBF,
  0xF8, 0x00, 0x1F, 0xE7, 0xFE, 0x00, 0x03, 0xFD, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x7F, 0x80, 0x01, 0xFF,
  0xCF, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x03, 0xFC, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xFE, 0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFE, 0xFF, 0xF0, 0x7F, 0xF8, 0x03,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF9, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0x07,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x0F,
  0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x0F,
  0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x0F,
  0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x1F,
  0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x1F,
  0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x1F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x3F,
  0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x3F,
  0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x3F,
  0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x7F,
  0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x7F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0xFF,
  0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x0F, 0xF3, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xF8,
  0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80,
  0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x01,
  0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F,
  0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF,
  0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8,
  0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F,
  0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xC1, 0xFE,
  0x00, 0x7F, 0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0,
  0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF,
  0x8F, 0xF8, 0x01, 0xFE, 0x3F, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x01, 0xFF, 0x7F, 0x80, 0x07, 0xFD, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFE, 0xFF, 0x80,
  0x07, 0xFB, 0xFE, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x03,
  0xFE, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0xFF,
  0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xE3, 0xFE, 0x00, 0xFF, 0x87,
  0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xE7, 0xFE, 0x00, 0x0F, 0xF7,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8,
  0x07, 0xF8, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F,
  0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xF0,
  0x01, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC,
  0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xBF, 0xFF, 0xC0, 0x3F, 0xE7,
  0xFF, 0xE0, 0x0F, 0xF9, 0xFF, 0xF0, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0xFF,
  0x81, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFF, 0xC3, 0xFC, 0x07, 0xFF, 0xC7, 0xF8, 0x1F,
  0xFF, 0xCF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xF8, 0x1F, 0xFC, 0x7F, 0xE0,
  0x1F, 0xF8, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0x00, 0x3F, 0xC7, 0xFC, 0x00,
  0x7F, 0x8F, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x3F, 0xC0, 0x07,
  0xFC, 0x7F, 0x80, 0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x7F,
  0xC7, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFE,
  0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xE1,
  0xFE, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0xFF, 0x87, 0xF8, 0x01, 0xFF, 0x0F,
  0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xF8, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x01, 0xFE, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xC2, 0x07, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xC7, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFC,
  0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x07, 0xFC, 0x7F, 0x80, 0x3F, 0xE3, 0xFC,
  0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0x00, 0x0F,
  0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F,
  0xC0, 0x1F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xFC,
  0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0,
  0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07,
  0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFC,
  0x1F, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1,
  0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFE, 0x0F,
  0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF7, 0xF8, 0x01, 0xFF,
  0x9F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x7F,
  0xCF, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0x7F, 0x87, 0xF8, 0x0F, 0xF8, 0x7F,
  0x80, 0xFF, 0x87, 0xF8, 0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x83, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x03,
  0xF8, 0x7F, 0xC0, 0x3F, 0x87, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xCF,
  0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFD, 0xFE, 0x00,
  0x3F, 0xDF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x7F, 0xBF, 0xC0, 0x1F, 0xC0, 0x3F, 0xEF, 0xF0, 0x07, 0xF0, 0x0F, 0xFB,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x3F, 0xC0,
  0x7F, 0xC0, 0x7F, 0x87, 0xF0, 0x1F, 0xF0, 0x1F, 0xE1, 0xFC, 0x0F, 0xFC,
  0x0F, 0xF8, 0x7F, 0x03, 0xFF, 0x03, 0xFC, 0x1F, 0xC0, 0xFF, 0xC0, 0xFF,
  0x07, 0xF0, 0x7F, 0xF8, 0x7F, 0xC1, 0xFC, 0x1F, 0xFE, 0x1F, 0xE0, 0x7F,
  0x0F, 0xFF, 0x87, 0xF8, 0x1F, 0xC3, 0xFF, 0xE3, 0xFC, 0x07, 0xF0, 0xFF,
  0xF8, 0xFF, 0x01, 0xFC, 0x7F, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xFF, 0x9F,
  0xE0, 0x1F, 0xCF, 0xE7, 0xE7, 0xF8, 0x07, 0xF3, 0xF9, 0xF9, 0xFE, 0x01,
  0xFC, 0xFC, 0x7E, 0xFF, 0x00, 0x7F, 0x7F, 0x1F, 0xBF, 0xC0, 0x1F, 0xDF,
  0xC7, 0xEF, 0xE0, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x7F,
  0xFE, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x7F,
  0xF8, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xF8,
  0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x03,
  0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFE,
  0x3F, 0xF0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x03,
  0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x0F,
  0xF9, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x01, 0xFF, 0x1F, 0xF0, 0x00,
  0xFF, 0xC3, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xE0,
  0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xF0, 0x1F, 0xF0, 0x01, 0xFE, 0x07,
  0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0xFF,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xE0, 0x00,
  0x7F, 0x87, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xE0,
  0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xBF,
  0xE0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xC3, 0xFF, 0xE0, 0x0F, 0xE3,
  0xFF, 0xF8, 0x07, 0xF1, 0xFF, 0xFC, 0x03, 0xF9, 0xFF, 0xFF, 0x03, 0xF8,
  0xFF, 0xFF, 0xC1, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x07, 0xFF, 0xFE,
  0x3F, 0x81, 0xFF, 0xFF, 0x3F, 0x80, 0x7F, 0xFF, 0x1F, 0xC0, 0x3F, 0xFF,
  0x0F, 0xE0, 0x0F, 0xFF, 0x87, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x00,
};

const GFXglyph RobotoCondensed_SemiBoldItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 18, 51, 18, 1, -50 },
  { 116, 20, 19, 22, 5, -53 },
  { 164, 35, 50, 37, 2, -50 },
  { 383, 32, 66, 35, 2, -58 },
  { 647, 33, 52, 44, 6, -51 },
  { 862, 35, 52, 39, 1, -51 },
  { 1090, 9, 19, 11, 5, -53 },
  { 1112, 22, 72, 22, 3, -56 },
  { 1310, 22, 72, 22, -3, -56 },
  { 1508, 29, 30, 31, 4, -50 },
  { 1617, 30, 37, 33, 2, -42 },
  { 1756, 14, 20, 16, -4, -8 },
  { 1791, 17, 7, 23, 3, -25 },
  { 1806, 10, 10, 20, 2, -9 },
  { 1819, 31, 54, 23, -4, -50 },
  { 2029, 30, 52, 35, 3, -51 },
  { 2224, 21, 50, 35, 8, -50 },
  { 2356, 33, 51, 35, 0, -51 },
  { 2567, 32, 52, 35, 1, -51 },
  { 2775, 32, 50, 35, 1, -50 },
  { 2975, 33, 51, 35, 2, -50 },
  { 3186, 29, 51, 35, 3, -50 },
  { 3371, 33, 50, 35, 3, -50 },
  { 3578, 31, 52, 35, 2, -51 },
  { 3780, 28, 51, 35, 5, -51 },
  { 3959, 15, 39, 19, 2, -38 },
  { 4033, 19, 50, 17, -3, -38 },
  { 4152, 27, 33, 31, 2, -38 },
  { 4264, 29, 23, 34, 3, -34 },
  { 4348, 29, 33, 31, 1, -38 },
  { 4468, 26, 52, 30, 5, -51 },
  { 4637, 49, 65, 53, 1, -49 },
  { 5036, 39, 50, 41, -3, -50 },
  { 5280, 36, 50, 38, 1, -50 },
  { 5505, 36, 52, 39, 3, -51 },
  { 5739, 36, 50, 39, 1, -50 },
  { 5964, 36, 50, 34, 1, -50 },
  { 6189, 35, 50, 33, 1, -50 },
  { 6408, 36, 52, 40, 3, -51 },
  { 6642, 42, 50, 42, 1, -50 },
  { 6905, 18, 50, 18, 1, -50 },
  { 7018, 35, 51, 34, 0, -50 },
  { 7242, 42, 50, 38, 1, -50 },
  { 7505, 28, 50, 33, 1, -50 },
  { 7680, 52, 50, 52, 1, -50 },
  { 8005, 42, 50, 42, 1, -50 },
  { 8268, 37, 52, 42, 3, -51 },
  { 8509, 38, 50, 39, 1, -50 },
  { 8747, 37, 60, 42, 3, -51 },
  { 9025, 37, 50, 38, 1, -50 },
  { 9257, 36, 52, 37, 1, -51 },
  { 9491, 34, 50, 37, 6, -50 },
  { 9704, 39, 51, 39, 2, -50 },
  { 9953, 37, 50, 40, 6, -50 },
  { 10185, 49, 50, 52, 6, -50 },
  { 10492, 44, 50, 38, -2, -50 },
  { 10767, 36, 50, 37, 6, -50 },
  { 10992, 40, 50, 36, -1, -50 },
  { 11242, 23, 71, 18, -1, -59 },
  { 11447, 16, 54, 26, 6, -50 },
  { 11555, 24, 71, 18, -4, -59 },
  { 11768, 24, 25, 27, 2, -50 },
  { 11843, 27, 7, 28, -4, 0 },
  { 11867, 15, 11, 22, 7, -54 },
  { 11888, 29, 40, 33, 1, -39 },
  { 12033, 32, 54, 34, 0, -53 },
  { 12249, 28, 40, 32, 2, -39 },
  { 12389, 34, 54, 34, 2, -53 },
  { 12619, 29, 40, 33, 2, -39 },
  { 12764, 25, 54, 22, 2, -54 },
  { 12933, 34, 53, 35, 0, -39 },
  { 13159, 31, 53, 34, 0, -53 },
  { 13365, 17, 53, 17, 1, -53 },
  { 13478, 25, 67, 17, -7, -53 },
  { 13688, 35, 53, 32, 0, -53 },
  { 13920, 17, 53, 17, 1, -53 },
  { 14033, 48, 39, 51, 0, -39 },
  { 14267, 31, 39, 34, 0, -39 },
  { 14419, 30, 40, 34, 2, -39 },
  { 14569, 34, 53, 34, -2, -39 },
  { 14795, 31, 53, 34, 2, -39 },
  { 15001, 24, 39, 22, 0, -39 },
  { 15118, 29, 40, 31, 1, -39 },
  { 15263, 20, 48, 21, 2, -47 },
  { 15383, 31, 39, 34, 2, -38 },
  { 15535, 28, 38, 31, 4, -38 },
  { 15668, 42, 38, 44, 4, -38 },
  { 15868, 34, 38, 31, -2, -38 },
  { 16030, 35, 52, 30, -2, -38 },
  { 16258, 32, 38, 31, -1, -38 },
  { 16410, 22, 68, 21, 2, -55 },
  { 16597, 15, 59, 17, 1, -50 },
  { 16708, 22, 68, 21, -3, -55 },
  { 16895, 33, 15, 39, 3, -28 },
};

const GFXfont RobotoCondensed_SemiBoldItalic71pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic71pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic71pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC71PT7B_H_
