#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC49PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x07, 0xC0, 0xFC, 0x0F,
  0xE0, 0xFC, 0x07, 0xC0, 0x78, 0x00, 0x3E, 0x3C, 0xF9, 0xF3, 0xC7, 0xCF,
  0x1F, 0x3C, 0x78, 0xF1, 0xE7, 0xC7, 0x9E, 0x3E, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1C, 0x3C, 0xF0, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x8F, 0x00,
  0x03, 0xC7, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0,
  0x00, 0xF0, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1C, 0x3C,
  0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF1,
  0xE0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x78, 0x03, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x07,
  0x87, 0x80, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x01, 0xE1, 0xE0, 0x00,
  0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x7C, 0x00,
  0x1E, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03,
  0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xF8, 0xFE,
  0x1F, 0x83, 0xF1, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0,
  0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x7E,
  0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E,
  0x3F, 0x8F, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xC7, 0x81, 0x8F, 0x0F, 0x07, 0x9E,
  0x1E, 0x1F, 0x3C, 0x3C, 0x3C, 0xF8, 0x78, 0xF1, 0xE0, 0xF3, 0xE3, 0xE3,
  0xE7, 0x83, 0xC7, 0x9E, 0x07, 0xFF, 0x78, 0x0F, 0xFC, 0xF0, 0x0F, 0xF3,
  0xC0, 0x07, 0xCF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xCF, 0x80, 0x0F, 0x7F, 0x80, 0x3D, 0xFF, 0x80, 0xF3, 0xFF,
  0x81, 0xEF, 0x8F, 0x07, 0x9E, 0x1E, 0x1E, 0x3C, 0x3C, 0x7C, 0x78, 0x78,
  0xF1, 0xF0, 0xF3, 0xC3, 0xC1, 0xEF, 0x07, 0xC3, 0xCE, 0x07, 0x8F, 0x08,
  0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x03, 0xF1, 0xF0, 0x03, 0xE1, 0xF8, 0x07, 0xE1, 0xF8, 0x07,
  0xC1, 0xF8, 0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xE3, 0xE0, 0x07,
  0xEF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0x1F, 0xFE, 0x3F, 0x3F,
  0xFE, 0x3E, 0x3F, 0x7F, 0x3E, 0x7E, 0x3F, 0x3E, 0x7E, 0x3F, 0xFE, 0xFC,
  0x1F, 0xFC, 0xFC, 0x1F, 0xFC, 0xFC, 0x0F, 0xF8, 0xFC, 0x07, 0xF8, 0xFE,
  0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFE, 0xFC, 0x0F, 0xF8, 0xFE, 0x00, 0x80, 0x00, 0x3E,
  0x7C, 0xF1, 0xE7, 0xCF, 0x9F, 0x3C, 0x78, 0xF1, 0xE7, 0xCF, 0x00, 0x00,
  0x04, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x04, 0x00, 0x00, 0x80, 0x03,
  0x80, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0x78, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0xE1,
  0xE1, 0xCF, 0xCF, 0x3E, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC3, 0xFF, 0xF8,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xF3,
  0xC0, 0x1F, 0x1E, 0x01, 0xF0, 0xF8, 0x0F, 0x03, 0xE0, 0x38, 0x1C, 0x00,
  0x80, 0x40, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F,
  0x87, 0xE1, 0xF0, 0x78, 0x04, 0x00, 0x7F, 0xF7, 0xFF, 0xFF, 0xEF, 0xFE,
  0xFF, 0xE0, 0x3C, 0xFF, 0xFF, 0xFF, 0xEF, 0xCF, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xF1, 0xF8, 0x3F, 0x07,
  0xC3, 0xF0, 0x3F, 0x1F, 0x81, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E,
  0x03, 0xF3, 0xF0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x7E,
  0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xEF, 0xC0,
  0x3F, 0x7E, 0x01, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7,
  0xE0, 0x3F, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x87, 0xC1, 0xF8, 0x3F, 0x1F,
  0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x01,
  0xFC, 0x00, 0x00, 0x06, 0x00, 0x78, 0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF,
  0xFF, 0x9F, 0xFF, 0x3F, 0xFC, 0x7D, 0xF8, 0xC3, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFE,
  0x3F, 0x81, 0xF8, 0x3F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80,
  0xFC, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0x8F, 0xE0, 0xFC, 0x1F, 0xC7, 0xF0, 0x3F, 0x1F,
  0x80, 0xFC, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x0F,
  0xCF, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x7F, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xBF, 0x00, 0x3E, 0xFC, 0x01,
  0xF3, 0xF0, 0x0F, 0xDF, 0x80, 0x3E, 0x7E, 0x01, 0xF1, 0xF8, 0x0F, 0xC7,
  0xE0, 0x3E, 0x1F, 0x81, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0x3E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x3E, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0xFC, 0x3F, 0x80, 0x60, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE3,
  0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF8,
  0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x3E,
  0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xF8,
  0xFE, 0x7F, 0x07, 0xE7, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xE7,
  0xC0, 0xFE, 0x7E, 0x0F, 0xC7, 0xF3, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0,
  0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x1F, 0xC7, 0xE0, 0x7E, 0x1F, 0xC3, 0xF8, 0x3F, 0x0F,
  0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x3F, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0x87, 0xE0, 0xFC,
  0x1F, 0x87, 0xE0, 0x3E, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F,
  0xCF, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x0F, 0xE1, 0xFC, 0x7F, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC1, 0xFC, 0xFE, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x7E, 0x03,
  0xE7, 0xE0, 0x3E, 0x7E, 0x03, 0xE7, 0xE0, 0x3E, 0xFE, 0x03, 0xEF, 0xC0,
  0x7E, 0xFC, 0x07, 0xEF, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0xFE, 0x7F,
  0x1F, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0,
  0x7D, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x81, 0xF8, 0x3F, 0x0F, 0xF0,
  0xFC, 0x1F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0x80,
  0xFC, 0x07, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F,
  0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x80,
  0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xC0, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x0F,
  0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F,
  0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0xDF,
  0xE7, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x00,
  0xF0, 0x07, 0xC0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x01, 0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x3E, 0x07, 0xFC, 0x0E, 0x0F, 0x03,
  0xFF, 0xC3, 0x87, 0xC1, 0xFF, 0xF0, 0xF1, 0xE0, 0xFC, 0x78, 0x3C, 0x78,
  0x3E, 0x1E, 0x0F, 0x3C, 0x1F, 0x07, 0x83, 0xCF, 0x07, 0x83, 0xE0, 0xF3,
  0xC3, 0xE0, 0xF0, 0x3D, 0xE0, 0xF8, 0x3C, 0x0E, 0x78, 0x3C, 0x0F, 0x03,
  0x9E, 0x1F, 0x07, 0xC1, 0xE7, 0x87, 0xC1, 0xF0, 0x7B, 0xE1, 0xF0, 0x78,
  0x1E, 0xF0, 0x78, 0x1E, 0x07, 0x3C, 0x1E, 0x07, 0x81, 0xCF, 0x07, 0x83,
  0xE0, 0xF3, 0xC1, 0xE0, 0xF0, 0x38, 0xF0, 0x78, 0x7C, 0x1E, 0x3C, 0x1F,
  0x1F, 0x07, 0x8F, 0x07, 0xFF, 0xE3, 0xC3, 0xC1, 0xFF, 0x7F, 0xE0, 0xF0,
  0x3F, 0x9F, 0xF0, 0x3C, 0x0F, 0xC3, 0xF8, 0x07, 0x80, 0x40, 0x10, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x40, 0x00, 0x1F, 0xC0, 0x70,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xDF, 0x80,
  0x01, 0xF9, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x03, 0xF0,
  0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00,
  0xFE, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x07, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x8F, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFC,
  0x1F, 0xE0, 0x7F, 0x01, 0xF8, 0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x1F, 0xC1,
  0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x3F,
  0x83, 0xF0, 0x1F, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7E, 0x03, 0xF8, 0x1F,
  0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0xFE, 0x01, 0xF8,
  0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x03,
  0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0xC1, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xC7, 0xF8, 0x3F, 0x80, 0xFC, 0x3F, 0x80,
  0x7F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0,
  0x03, 0xF3, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x3F, 0x83, 0xFC, 0x7F, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFC, 0x7F, 0xC0, 0x7F, 0x03,
  0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E,
  0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x07, 0xF0,
  0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x87, 0xF0, 0x07,
  0xE1, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x87, 0xE0,
  0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x7F, 0x0F,
  0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x03, 0xFC,
  0x1F, 0xC3, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xC7, 0xF8, 0x3F,
  0x80, 0xFE, 0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xCF,
  0xE0, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xFF,
  0x9F, 0x81, 0xFF, 0xCF, 0xC1, 0xFF, 0xEF, 0xE0, 0xFF, 0xF7, 0xF0, 0x7F,
  0xF3, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7F, 0x00,
  0x7F, 0x1F, 0x80, 0x3F, 0x8F, 0xC0, 0x1F, 0x87, 0xF0, 0x1F, 0xC3, 0xFE,
  0x3F, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x0F, 0xC0,
  0x07, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01,
  0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFE,
  0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x7E, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x0F,
  0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF0,
  0x3F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F,
  0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x7E, 0x07, 0xE0,
  0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF8,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0xFE,
  0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0x7E,
  0x0F, 0xE0, 0x7F, 0x9F, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x07, 0xF8,
  0x0F, 0xC0, 0x1F, 0xE0, 0x3F, 0x00, 0xFF, 0x00, 0xFC, 0x07, 0xF8, 0x03,
  0xF0, 0x3F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xF8,
  0x3F, 0xC0, 0x07, 0xE1, 0xFE, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7E, 0x3F,
  0x80, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0x7F, 0x80,
  0x00, 0xFD, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFE, 0x7E, 0x00, 0x0F, 0xF1,
  0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F,
  0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xF0,
  0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x01,
  0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x80,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFF, 0x01,
  0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x0F,
  0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0x01, 0xF7,
  0x80, 0x3F, 0xF8, 0x1F, 0xBE, 0x03, 0xFF, 0xC0, 0xFD, 0xF0, 0x1F, 0x7C,
  0x07, 0xEF, 0x81, 0xFF, 0xE0, 0x3F, 0x7C, 0x0F, 0xBF, 0x01, 0xFB, 0xE0,
  0x7D, 0xF8, 0x0F, 0xDF, 0x07, 0xCF, 0xC0, 0xFC, 0xF8, 0x3E, 0x7E, 0x07,
  0xE7, 0xC3, 0xE7, 0xE0, 0x3F, 0x1E, 0x1F, 0x3F, 0x01, 0xF8, 0xF1, 0xF9,
  0xF8, 0x0F, 0xC7, 0xCF, 0x8F, 0xC0, 0x7E, 0x3E, 0xFC, 0x7E, 0x07, 0xF1,
  0xF7, 0xC7, 0xF0, 0x3F, 0x8F, 0xBE, 0x3F, 0x01, 0xF8, 0x7F, 0xE1, 0xF8,
  0x0F, 0xC3, 0xFF, 0x0F, 0xC0, 0x7E, 0x0F, 0xF0, 0x7E, 0x03, 0xF0, 0x7F,
  0x87, 0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0xC1, 0xF8, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3E, 0x03,
  0xF0, 0x1F, 0x81, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0,
  0x07, 0xF0, 0x3F, 0x80, 0x1F, 0x80, 0xFF, 0x00, 0x7E, 0x03, 0xFC, 0x01,
  0xF8, 0x0F, 0xF0, 0x07, 0xE0, 0x7F, 0xC0, 0x3F, 0x81, 0xFF, 0x80, 0xFC,
  0x07, 0xFE, 0x03, 0xF0, 0x1F, 0xF8, 0x0F, 0xC0, 0x7F, 0xF0, 0x3F, 0x03,
  0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x07, 0xF0, 0x3F, 0x3C, 0x1F, 0x80, 0xFC,
  0xF8, 0x7E, 0x03, 0xF3, 0xE1, 0xF8, 0x0F, 0xCF, 0x87, 0xE0, 0x7F, 0x1E,
  0x1F, 0x81, 0xFC, 0x7C, 0xFE, 0x07, 0xE1, 0xF3, 0xF0, 0x1F, 0x83, 0xCF,
  0xC0, 0x7E, 0x0F, 0xBF, 0x01, 0xF8, 0x3E, 0xFC, 0x0F, 0xE0, 0xFF, 0xF0,
  0x3F, 0x81, 0xFF, 0xC0, 0xFC, 0x07, 0xFE, 0x03, 0xF0, 0x1F, 0xF8, 0x0F,
  0xC0, 0x3F, 0xE0, 0x3F, 0x00, 0xFF, 0x81, 0xFC, 0x03, 0xFE, 0x07, 0xE0,
  0x0F, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0x01, 0xF8, 0x01,
  0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFE,
  0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87,
  0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F,
  0x9F, 0xC0, 0x07, 0xE7, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00,
  0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x03, 0xF9, 0xF8, 0x00, 0xFE, 0xFE,
  0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC,
  0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x03,
  0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xF1, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xE0, 0x7F, 0x81, 0xFC, 0x03, 0xF0,
  0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0x80,
  0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83,
  0xF0, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x7F, 0x00,
  0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC,
  0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x9F, 0xC0, 0x07, 0xE7, 0xE0, 0x01, 0xF9,
  0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x03,
  0xFB, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0,
  0x03, 0xF3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F,
  0xE0, 0x0F, 0xE1, 0xF8, 0x07, 0xF0, 0x7F, 0x03, 0xFC, 0x1F, 0xF3, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFC, 0x1F, 0xE0, 0x7F, 0x01, 0xFC,
  0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00,
  0xFC, 0x1F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC,
  0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x0F, 0xC1, 0xFF, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x01, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x83, 0xF0, 0x0F, 0xC0,
  0xFC, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x1F,
  0xC0, 0x7E, 0x07, 0xF0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0x7E, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F,
  0xC7, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x07,
  0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0xFC, 0x7E, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x1F, 0xC0, 0x3F, 0x07, 0xE0,
  0x3F, 0x83, 0xFC, 0x7F, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03,
  0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0x87, 0xE0,
  0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x87,
  0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xF8, 0x7F, 0x00,
  0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E,
  0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0,
  0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x07,
  0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0xE3, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00,
  0xFC, 0xFE, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xC7, 0xE0, 0x0F, 0xE1, 0xF8,
  0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x1F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7F,
  0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xCF, 0xE0, 0x01,
  0xF3, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xFF, 0x80,
  0xFC, 0x07, 0xEF, 0xE0, 0x3F, 0x01, 0xFB, 0xF8, 0x1F, 0xC0, 0x7E, 0x7E,
  0x07, 0xF0, 0x3F, 0x1F, 0x81, 0xFC, 0x0F, 0xC7, 0xE0, 0xFF, 0x03, 0xF1,
  0xF8, 0x3F, 0xC1, 0xF8, 0x7E, 0x0F, 0xF0, 0x7E, 0x1F, 0x87, 0xFC, 0x1F,
  0x87, 0xE1, 0xFF, 0x0F, 0xC1, 0xF8, 0x7F, 0xC3, 0xF0, 0x7E, 0x3F, 0xF0,
  0xFC, 0x1F, 0x8F, 0xFC, 0x3F, 0x07, 0xE7, 0xFF, 0x1F, 0x81, 0xF1, 0xF7,
  0xC7, 0xE0, 0x7C, 0x7D, 0xF1, 0xF8, 0x1F, 0x3F, 0x3C, 0xFC, 0x07, 0xCF,
  0x8F, 0x3F, 0x01, 0xF3, 0xE3, 0xCF, 0xC0, 0x7D, 0xF0, 0xF7, 0xE0, 0x1F,
  0x7C, 0x3D, 0xF8, 0x07, 0xDF, 0x0F, 0x7E, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0x3F,
  0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0x7E,
  0x03, 0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x7F, 0x03, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F,
  0x00, 0x7E, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0x9F, 0x80, 0x3F, 0x8F, 0xC0, 0x1F, 0xC7,
  0xE0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xE0,
  0x3F, 0x07, 0xF0, 0x1F, 0x83, 0xF0, 0x07, 0xC3, 0xF8, 0x03, 0xF1, 0xF8,
  0x01, 0xF9, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7E,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFC, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xBC, 0x0F, 0xBC, 0x0F, 0x3C, 0x1F,
  0x3E, 0x1E, 0x3E, 0x3E, 0x3E, 0x7C, 0x1E, 0x7C, 0x1E, 0xF8, 0x1E, 0xF8,
  0x1F, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFC, 0xFE, 0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x00, 0x7E,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFC,
  0x7E, 0x3F, 0x87, 0xE3, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x01,
  0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0x0F, 0xCF,
  0xE0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC1, 0xFC,
  0xFC, 0x3F, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xDF,
  0x80, 0xF9, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF3, 0xF0,
  0x0F, 0xDF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F,
  0xE3, 0xFC, 0x7F, 0x07, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80,
  0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC,
  0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF9, 0xF8,
  0x0F, 0xC7, 0xF0, 0x3F, 0x1F, 0xE3, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x87, 0xDF, 0xFC, 0x3F, 0x3F, 0xE0, 0xFC, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFC, 0x7E,
  0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7C, 0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E,
  0x1F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x01,
  0xF8, 0xFC, 0x07, 0xFC, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x3F, 0xC7, 0xF8, 0x3F, 0x03, 0xF8, 0x3F, 0x01, 0xF8, 0x7E,
  0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xFE,
  0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC,
  0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F,
  0x1F, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xEF, 0xC0, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF,
  0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFC, 0x7F, 0x3F, 0x83, 0xF3, 0xF0,
  0x3F, 0x3F, 0x01, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x30, 0x7F, 0x0F, 0x87, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x07,
  0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x3E, 0x03, 0xFE,
  0xFC, 0x1F, 0xFD, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFC, 0x7F,
  0x87, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8,
  0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F,
  0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8,
  0x0F, 0xC3, 0xF8, 0x1F, 0x83, 0xF8, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xCF, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x04, 0x03, 0xF8, 0x1E, 0x0F, 0xE0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0xFD,
  0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xE3, 0xF8,
  0xFE, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0,
  0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F,
  0xC0, 0xFC, 0x7E, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x1F,
  0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8,
  0x0F, 0xCF, 0xC0, 0xFC, 0x00, 0x00, 0xC0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x00,
  0x06, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x1F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0xFE, 0x0F, 0xC1, 0xFE, 0x0F, 0xC3, 0xFC, 0x0F, 0xC3, 0xF8, 0x0F, 0xC7,
  0xF0, 0x0F, 0xCF, 0xE0, 0x1F, 0x9F, 0xC0, 0x1F, 0xBF, 0x80, 0x1F, 0xBF,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xBF,
  0x00, 0x3F, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F,
  0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07,
  0xE0, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC7, 0xC0, 0xFC, 0x07, 0xEF, 0xF0,
  0xFF, 0x03, 0xFF, 0xFC, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0x1F, 0xF1, 0xFC, 0x7F, 0x07, 0xF0, 0x7E, 0x3F, 0x03,
  0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x0F, 0xC7, 0xE0,
  0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x01, 0xF9, 0xF8,
  0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC0, 0xFC, 0x7E, 0x07, 0xE0, 0x7E, 0x3F,
  0x03, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0x1F, 0x9F, 0x81, 0xF8, 0x0F, 0xCF,
  0xC0, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x03, 0xF1,
  0xF8, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC0, 0xFC, 0xFC, 0x0F, 0xC0, 0x7E,
  0x7E, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC7, 0xC0, 0x7E, 0xFF, 0x03, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xF1, 0xFC, 0x7F, 0x07, 0xE3,
  0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x7E, 0x03,
  0xF3, 0xF0, 0x1F, 0x9F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F,
  0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E,
  0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x0F, 0xE3, 0xF8, 0xFE, 0x0F, 0xC7, 0xE0, 0x3F, 0x7F,
  0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0,
  0x1F, 0x9F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xF1, 0xFC, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF3, 0xF0, 0x03, 0xF7, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x03, 0xF8, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3F, 0x07,
  0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F,
  0xE3, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0x7F, 0xF0, 0x3F,
  0x3F, 0xE0, 0x3F, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0xFC, 0x1F, 0xF3, 0xF0, 0xFF, 0xEF, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0xFF, 0x1F, 0xE3, 0xF0, 0x3F, 0x8F, 0xC0, 0x7E, 0x7E, 0x03, 0xF9,
  0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0xFE, 0x03, 0xF3, 0xF0,
  0x0F, 0xCF, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F,
  0x8F, 0xC0, 0x7E, 0x3F, 0x83, 0xF8, 0x7F, 0x1F, 0xC1, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xEF, 0xC0, 0x3F, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x0F, 0xCF, 0x0F, 0xDF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFF, 0x1F, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07,
  0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF1, 0xFC, 0x3F, 0x1F, 0x83, 0xF1,
  0xF8, 0x3F, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0xFC, 0x07, 0xE7, 0xC0, 0xFC, 0x7E, 0x0F, 0xC7, 0xFF,
  0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x1F, 0x80, 0xFF, 0x07, 0xF8, 0x3F, 0xC0,
  0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0x87,
  0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0xFE, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0,
  0xFE, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x1F, 0xC0, 0xFC,
  0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E,
  0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0xFE, 0x1F, 0x83, 0xF0, 0x7F, 0x1F,
  0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xEF, 0x80,
  0x3F, 0x00, 0x00, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0x7E, 0x07,
  0xEF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7C, 0x3F,
  0x0F, 0x8F, 0xC1, 0xF1, 0xF8, 0x3E, 0x3E, 0x07, 0xCF, 0xC0, 0xF9, 0xF0,
  0x1F, 0x3E, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x03, 0xFF, 0xC1, 0xF0, 0x3F,
  0xFC, 0x1F, 0x03, 0xFF, 0xC3, 0xF0, 0x7E, 0xFC, 0x3F, 0x87, 0xEF, 0xC3,
  0xF8, 0x7C, 0xFC, 0x7F, 0x8F, 0xCF, 0xC7, 0xF8, 0xFC, 0xFC, 0xFF, 0x8F,
  0x8F, 0xCF, 0xF9, 0xF8, 0xFC, 0xFF, 0x9F, 0x0F, 0xDF, 0x79, 0xF0, 0xFD,
  0xE7, 0xBF, 0x0F, 0xFE, 0x7B, 0xE0, 0xFF, 0xE7, 0xBE, 0x07, 0xFC, 0x7F,
  0xE0, 0x7F, 0xC7, 0xFC, 0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0x87, 0xF8, 0x07,
  0xF8, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x07,
  0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x00,
  0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7E, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFC,
  0x03, 0xF1, 0xFC, 0x01, 0xF9, 0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xEF, 0xC0, 0x07, 0xEF, 0xC0,
  0x0F, 0xC7, 0xE0, 0x1F, 0xC7, 0xE0, 0x1F, 0x87, 0xE0, 0x3F, 0x87, 0xE0,
  0x7F, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x1F, 0x81, 0xFC,
  0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03,
  0xF0, 0xFE, 0x07, 0xE1, 0xF8, 0x0F, 0xC7, 0xF0, 0x0F, 0x8F, 0xC0, 0x1F,
  0x1F, 0x80, 0x3E, 0x7E, 0x00, 0x7C, 0xFC, 0x00, 0xFB, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7E, 0x00, 0xFC,
  0x01, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xE0, 0x00, 0x40, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x01,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0xFE, 0x03, 0xFC,
  0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x0E,
  0x00, 0x10, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x7C, 0xFF, 0xC0,
  0xF9, 0xFF, 0xC1, 0xF7, 0xFF, 0xC7, 0xCF, 0x9F, 0x9F, 0x9E, 0x1F, 0xFF,
  0x7C, 0x1F, 0xFC, 0xF8, 0x1F, 0xF1, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0x00,
};

const GFXglyph RobotoCondensed_SemiBoldItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 12, 35, 12, 1, -35 },
  { 54, 14, 13, 15, 3, -37 },
  { 77, 25, 35, 25, 1, -35 },
  { 187, 21, 45, 24, 2, -40 },
  { 306, 23, 35, 30, 4, -35 },
  { 407, 24, 36, 27, 1, -35 },
  { 515, 7, 13, 8, 3, -37 },
  { 527, 15, 50, 15, 2, -39 },
  { 621, 15, 50, 15, -2, -39 },
  { 715, 21, 21, 21, 2, -35 },
  { 771, 21, 26, 23, 1, -30 },
  { 840, 10, 14, 11, -3, -6 },
  { 858, 12, 5, 16, 2, -17 },
  { 866, 7, 7, 14, 1, -7 },
  { 873, 22, 38, 16, -3, -35 },
  { 978, 21, 35, 24, 2, -35 },
  { 1070, 15, 35, 24, 5, -35 },
  { 1136, 23, 35, 24, 0, -35 },
  { 1237, 22, 35, 24, 1, -35 },
  { 1334, 22, 35, 24, 1, -35 },
  { 1431, 22, 35, 24, 2, -35 },
  { 1528, 20, 35, 24, 2, -35 },
  { 1616, 23, 35, 24, 2, -35 },
  { 1717, 22, 35, 24, 1, -35 },
  { 1814, 20, 35, 24, 3, -35 },
  { 1902, 11, 27, 13, 1, -27 },
  { 1940, 13, 35, 12, -2, -27 },
  { 1997, 19, 23, 21, 1, -27 },
  { 2052, 20, 15, 24, 2, -23 },
  { 2090, 20, 23, 22, 1, -26 },
  { 2148, 18, 35, 21, 3, -35 },
  { 2227, 34, 45, 36, 1, -34 },
  { 2419, 27, 35, 28, -2, -35 },
  { 2538, 26, 35, 27, 0, -35 },
  { 2652, 25, 35, 27, 2, -35 },
  { 2762, 26, 35, 27, 0, -35 },
  { 2876, 26, 35, 23, 0, -35 },
  { 2990, 25, 35, 23, 0, -35 },
  { 3100, 25, 35, 28, 2, -35 },
  { 3210, 30, 35, 29, 0, -35 },
  { 3342, 12, 35, 13, 1, -35 },
  { 3395, 24, 35, 23, 0, -35 },
  { 3500, 30, 35, 26, 0, -35 },
  { 3632, 20, 35, 23, 0, -35 },
  { 3720, 37, 35, 36, 0, -35 },
  { 3882, 30, 35, 29, 0, -35 },
  { 4014, 26, 35, 29, 2, -35 },
  { 4128, 27, 35, 27, 0, -35 },
  { 4247, 26, 41, 29, 2, -35 },
  { 4381, 26, 35, 26, 0, -35 },
  { 4495, 25, 35, 25, 1, -35 },
  { 4605, 24, 35, 26, 4, -35 },
  { 4710, 26, 35, 27, 2, -35 },
  { 4824, 26, 35, 27, 4, -35 },
  { 4938, 34, 35, 36, 4, -35 },
  { 5087, 30, 35, 27, -1, -35 },
  { 5219, 25, 35, 26, 4, -35 },
  { 5329, 28, 35, 25, -1, -35 },
  { 5452, 16, 48, 12, -1, -40 },
  { 5548, 11, 38, 18, 4, -35 },
  { 5601, 17, 48, 12, -3, -40 },
  { 5703, 16, 17, 18, 2, -35 },
  { 5737, 19, 5, 19, -3, 0 },
  { 5749, 10, 7, 16, 5, -36 },
  { 5758, 20, 26, 22, 1, -26 },
  { 5823, 22, 37, 24, 0, -37 },
  { 5925, 20, 26, 22, 1, -26 },
  { 5990, 24, 37, 24, 1, -37 },
  { 6101, 20, 26, 23, 1, -26 },
  { 6166, 17, 38, 15, 2, -38 },
  { 6247, 23, 36, 24, 0, -26 },
  { 6351, 21, 37, 23, 0, -37 },
  { 6449, 12, 36, 12, 0, -36 },
  { 6503, 17, 46, 11, -5, -36 },
  { 6601, 24, 37, 22, 0, -37 },
  { 6712, 13, 37, 12, 0, -37 },
  { 6773, 33, 26, 35, 0, -26 },
  { 6881, 21, 26, 23, 0, -26 },
  { 6950, 21, 26, 24, 1, -26 },
  { 7019, 24, 36, 24, -2, -26 },
  { 7127, 22, 36, 24, 1, -26 },
  { 7226, 16, 26, 15, 0, -26 },
  { 7278, 20, 26, 22, 0, -26 },
  { 7343, 13, 32, 14, 2, -32 },
  { 7395, 22, 26, 23, 1, -26 },
  { 7467, 19, 26, 21, 3, -26 },
  { 7529, 28, 26, 30, 3, -26 },
  { 7620, 24, 26, 21, -2, -26 },
  { 7698, 23, 36, 21, -1, -26 },
  { 7802, 22, 26, 21, -1, -26 },
  { 7874, 15, 47, 14, 1, -38 },
  { 7963, 10, 41, 12, 1, -35 },
  { 8015, 15, 47, 14, -2, -38 },
  { 8104, 23, 11, 27, 2, -20 },
};

const GFXfont RobotoCondensed_SemiBoldItalic49pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic49pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic49pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC49PT7B_H_
