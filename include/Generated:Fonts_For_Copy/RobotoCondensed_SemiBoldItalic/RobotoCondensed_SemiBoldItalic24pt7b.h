#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC24PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xC7, 0x18, 0xE3, 0x8E, 0x38, 0xC3, 0x0C, 0x00, 0x06,
  0x3C, 0x60, 0x6F, 0xBC, 0xF3, 0xDB, 0x60, 0x06, 0x60, 0x66, 0x06, 0xC0,
  0xCC, 0x0C, 0xC3, 0xFF, 0x7F, 0xE1, 0x98, 0x1B, 0x01, 0xB0, 0xFF, 0xCF,
  0xFC, 0x36, 0x06, 0x60, 0x66, 0x06, 0xC0, 0xCC, 0x00, 0x03, 0x00, 0xC0,
  0xF0, 0x7E, 0x3F, 0xCE, 0x73, 0x1D, 0xC7, 0x38, 0x0F, 0x01, 0xF0, 0x3E,
  0x03, 0xB8, 0xEE, 0x3B, 0x8E, 0xFF, 0x9F, 0xC3, 0xC0, 0x60, 0x10, 0x00,
  0x38, 0x0F, 0x83, 0xB1, 0x66, 0x6C, 0xCD, 0x9B, 0x1F, 0xC3, 0xF8, 0x06,
  0x01, 0xB8, 0x6F, 0x8F, 0x33, 0x66, 0xCC, 0xF9, 0x98, 0x3F, 0x03, 0xC0,
  0x07, 0x80, 0xFC, 0x1F, 0xC1, 0xCE, 0x1C, 0xC1, 0xDC, 0x1F, 0x80, 0xF0,
  0x1E, 0x03, 0xF3, 0x77, 0x77, 0x3F, 0xF3, 0xE7, 0x1E, 0x7B, 0xC7, 0xFE,
  0x3E, 0xE0, 0xFF, 0x6D, 0x80, 0x02, 0x0C, 0x38, 0xE1, 0x87, 0x0C, 0x38,
  0x70, 0xC1, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x83, 0x06, 0x0E,
  0x0C, 0x08, 0x08, 0x30, 0x30, 0x70, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x61, 0xC7, 0x0C, 0x38, 0x40, 0x06,
  0x01, 0x80, 0x61, 0x97, 0xFF, 0xC7, 0x81, 0xE0, 0xD8, 0x63, 0x08, 0x80,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x3F, 0xFF, 0xFF, 0xFE, 0x1C, 0x07,
  0x01, 0xC0, 0xE0, 0x38, 0x00, 0x33, 0x77, 0x6E, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0x80, 0x00, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30,
  0x00, 0x0F, 0x07, 0xE3, 0xFC, 0xC7, 0x71, 0xDC, 0x77, 0x1D, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x8E, 0xE3, 0xB8, 0xEF, 0xF1, 0xF8, 0x3C, 0x00, 0x06,
  0x7B, 0xF7, 0xE9, 0xC3, 0x87, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x8E, 0x1C,
  0x38, 0x70, 0x07, 0x81, 0xF8, 0x7F, 0x9C, 0x73, 0x8E, 0x71, 0xC0, 0x38,
  0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x70, 0x1F, 0xF7, 0xFE,
  0xFF, 0xC0, 0x07, 0x83, 0xF8, 0x7F, 0x9C, 0x73, 0x8E, 0x01, 0xC0, 0x38,
  0x1E, 0x0F, 0x81, 0xF0, 0x07, 0x00, 0xEE, 0x1C, 0xE3, 0x9F, 0xE3, 0xFC,
  0x1E, 0x00, 0x00, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x83, 0x70,
  0xEE, 0x39, 0xCE, 0x39, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0xE0, 0x18,
  0x07, 0x00, 0x1F, 0xE3, 0xFC, 0xFF, 0x1C, 0x03, 0x80, 0x60, 0x1F, 0xC3,
  0xFC, 0x7F, 0x80, 0x70, 0x06, 0x00, 0xCE, 0x39, 0xC7, 0x3F, 0xE3, 0xF8,
  0x3C, 0x00, 0x03, 0x83, 0xE1, 0xF8, 0xF0, 0x38, 0x1C, 0x07, 0xF1, 0xFE,
  0xFF, 0xBC, 0xFE, 0x1F, 0x87, 0xE3, 0xB8, 0xE7, 0xF9, 0xFC, 0x3C, 0x00,
  0x7F, 0xEF, 0xFD, 0xFF, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07,
  0x01, 0xC0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x00,
  0x0F, 0x07, 0xF3, 0xFC, 0xE7, 0x71, 0xDC, 0x73, 0xB8, 0x7C, 0x7F, 0x1C,
  0xEE, 0x3B, 0x8E, 0xE3, 0xB8, 0xEF, 0xF1, 0xFC, 0x3C, 0x00, 0x1E, 0x1F,
  0x9F, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xFF, 0xFF, 0x9F, 0xC0, 0xE0,
  0xE0, 0xF3, 0xF1, 0xF0, 0xE0, 0x00, 0x7B, 0xCC, 0x00, 0x00, 0x00, 0x00,
  0x39, 0xCE, 0x00, 0x1C, 0x38, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE1, 0x83, 0x0E, 0x1C, 0x70, 0x40, 0x00, 0x81, 0xC3, 0xE7, 0xEF, 0x87,
  0x03, 0xC0, 0xF8, 0x1E, 0x07, 0x00, 0x80, 0x7F, 0xDF, 0xF7, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFB, 0xFE, 0xFF, 0x80, 0x20, 0x0E, 0x03, 0xE0, 0x7E,
  0x07, 0xC0, 0x70, 0xFC, 0xFC, 0x7C, 0x1C, 0x04, 0x00, 0x3E, 0x7F, 0xFF,
  0xE7, 0xE7, 0x07, 0x0F, 0x1E, 0x3C, 0x38, 0x30, 0x70, 0x00, 0x00, 0xE0,
  0xF0, 0x60, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xC1, 0xC1, 0xC0, 0x61, 0xC0,
  0x18, 0xC7, 0x8C, 0xC7, 0xE6, 0x67, 0x33, 0x73, 0x19, 0xB3, 0x98, 0xD9,
  0x8C, 0x6C, 0xC6, 0x36, 0x63, 0x37, 0x33, 0x9B, 0x19, 0x88, 0xCF, 0x7C,
  0x63, 0xBC, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3F, 0x01, 0xB8, 0x1D,
  0xC0, 0xEE, 0x0E, 0x70, 0x73, 0x87, 0xFC, 0x3F, 0xE3, 0xFF, 0x9C, 0x1D,
  0xC0, 0xEE, 0x07, 0xF0, 0x38, 0x1F, 0xC0, 0xFF, 0x87, 0xFC, 0x38, 0xF3,
  0x87, 0x1C, 0x38, 0xE3, 0xC7, 0xF8, 0x3F, 0xE1, 0xC7, 0x1C, 0x38, 0xE1,
  0xC7, 0x0E, 0x38, 0x71, 0xFF, 0x9F, 0xF8, 0xFF, 0x00, 0x07, 0xC1, 0xFE,
  0x3F, 0xF3, 0x87, 0x70, 0x77, 0x07, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x0E, 0xE0, 0xEE, 0x1C, 0x7F, 0xC7, 0xF8, 0x1E, 0x00, 0x1F,
  0xC0, 0xFF, 0x07, 0xFC, 0x38, 0xE3, 0x87, 0x1C, 0x1C, 0xE1, 0xE7, 0x0E,
  0x38, 0x71, 0xC3, 0x9C, 0x1C, 0xE0, 0xE7, 0x0E, 0x38, 0xF1, 0xFF, 0x1F,
  0xF0, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x38, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xFF, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0xFC, 0x3F, 0xC3, 0xFC, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x00, 0x07, 0xC1, 0xFE,
  0x3F, 0xF3, 0x87, 0x70, 0x77, 0x07, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x3F,
  0xE3, 0xEE, 0x0E, 0xE0, 0xEF, 0x0E, 0x7F, 0xE7, 0xFC, 0x1F, 0x00, 0x1C,
  0x1E, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x0E,
  0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF1, 0xC0, 0xE3, 0x81, 0xC7, 0x07, 0x0E,
  0x0E, 0x1C, 0x1C, 0x78, 0x38, 0xE0, 0x70, 0x1C, 0x71, 0xC7, 0x1C, 0xE3,
  0x8E, 0x38, 0xE7, 0x9C, 0x71, 0xC7, 0x1C, 0xF0, 0x00, 0x70, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0xE3, 0xCE, 0x38, 0xFF, 0x87, 0xF0, 0x3E, 0x00, 0x1C, 0x3C,
  0x38, 0x70, 0x71, 0xE0, 0xE7, 0x83, 0x9E, 0x07, 0x78, 0x0E, 0xE0, 0x1F,
  0x80, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xDE, 0x07, 0x1C, 0x0E, 0x38,
  0x1C, 0x78, 0x78, 0x70, 0xE0, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x03, 0xC7, 0x81, 0xF1, 0xE0, 0x7C, 0x78,
  0x3E, 0x3F, 0x0F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x6E, 0x3B, 0x3B,
  0x0C, 0xCD, 0xC7, 0x37, 0x71, 0xCD, 0x9C, 0x73, 0xE7, 0x1C, 0xF1, 0xC7,
  0x3C, 0xE3, 0xCE, 0x38, 0xE1, 0x8E, 0x00, 0x1C, 0x1E, 0x3C, 0x38, 0x78,
  0x70, 0xF0, 0xE3, 0xE1, 0xC7, 0xE3, 0x8E, 0xCE, 0x1D, 0x9C, 0x3B, 0xB8,
  0x73, 0x71, 0xC6, 0xE3, 0x8D, 0xC7, 0x1F, 0x0E, 0x1E, 0x1C, 0x3C, 0x78,
  0x78, 0xE0, 0x70, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0x70, 0xE7, 0x07, 0x38,
  0x39, 0xC1, 0xCE, 0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xC0, 0xEE, 0x0E,
  0x78, 0xF1, 0xFF, 0x0F, 0xF0, 0x1F, 0x00, 0x1F, 0xE0, 0xFF, 0x87, 0xFE,
  0x38, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x0F, 0x3F, 0xF1, 0xFF, 0x1F,
  0xF0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x00, 0x07,
  0xC1, 0xFE, 0x3F, 0xF3, 0x87, 0x70, 0x77, 0x07, 0x70, 0x77, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xEF, 0x1E, 0x7F, 0xC7, 0xF8, 0x1F,
  0x80, 0x3C, 0x01, 0xC0, 0x08, 0x1F, 0xC0, 0xFF, 0x87, 0xFC, 0x38, 0xF3,
  0x83, 0x9C, 0x1C, 0xE1, 0xC7, 0x0E, 0x3F, 0xE1, 0xFF, 0x1F, 0xE0, 0xE3,
  0x87, 0x1C, 0x38, 0xE1, 0xC7, 0x9E, 0x1C, 0xE0, 0xE0, 0x07, 0xC0, 0x7F,
  0x07, 0xFC, 0x78, 0xE3, 0x87, 0x1C, 0x00, 0x70, 0x03, 0xE0, 0x0F, 0xC0,
  0x1E, 0x00, 0x78, 0xE1, 0xC7, 0x0E, 0x38, 0x71, 0xFF, 0x07, 0xF8, 0x1F,
  0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x00, 0x38, 0x39, 0xC3, 0xCE, 0x1C, 0xE0, 0xE7, 0x07, 0x38,
  0x39, 0xC1, 0xCE, 0x1C, 0x70, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCE, 0x1E,
  0x70, 0xE3, 0xFF, 0x0F, 0xF0, 0x3E, 0x00, 0xE0, 0x77, 0x03, 0xB8, 0x3D,
  0xC1, 0xCF, 0x1E, 0x38, 0xE1, 0xC7, 0x0E, 0x70, 0x73, 0x83, 0xBC, 0x1D,
  0xC0, 0xEE, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x00, 0xE1,
  0xC7, 0x70, 0xE3, 0xB8, 0xF1, 0xDC, 0x79, 0xCE, 0x7C, 0xE7, 0x3E, 0x73,
  0x9F, 0x31, 0xDD, 0xB8, 0xEE, 0xDC, 0x76, 0x6C, 0x3F, 0x3E, 0x1F, 0x9F,
  0x0F, 0x8F, 0x07, 0xC7, 0x81, 0xC3, 0xC0, 0xE1, 0xC0, 0x70, 0xE0, 0x00,
  0x1E, 0x1E, 0x1C, 0x38, 0x38, 0xF0, 0x73, 0xC0, 0x77, 0x00, 0xFE, 0x01,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x77, 0x01, 0xEE,
  0x03, 0x9C, 0x0E, 0x3C, 0x3C, 0x38, 0x70, 0x70, 0xE0, 0xFE, 0x0E, 0x71,
  0xE7, 0x1C, 0x73, 0x87, 0x38, 0x37, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x1C,
  0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x00, 0x1F, 0xF9,
  0xFF, 0xCF, 0xFC, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07,
  0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xFF, 0x9F, 0xFC,
  0xFF, 0xC0, 0x1F, 0x1E, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE0,
  0xF0, 0xF0, 0xE7, 0x38, 0xC7, 0x39, 0xCE, 0x73, 0x8C, 0x73, 0x9C, 0xE7,
  0x38, 0xC0, 0x1F, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70,
  0xF0, 0xF0, 0x0C, 0x1C, 0x1E, 0x3E, 0x36, 0x76, 0x66, 0x66, 0xE7, 0xFF,
  0xFF, 0xC0, 0x73, 0x8E, 0x30, 0x0F, 0x07, 0xE3, 0xFC, 0xE7, 0x01, 0xC7,
  0xF3, 0xFD, 0xC6, 0xF3, 0xB8, 0xEF, 0x79, 0xFE, 0x3B, 0x80, 0x1C, 0x03,
  0x80, 0x70, 0x0C, 0x03, 0x80, 0x77, 0x0F, 0xF1, 0xFE, 0x38, 0xE6, 0x1D,
  0xC3, 0xB8, 0x77, 0x0C, 0xE3, 0x9C, 0x77, 0xFE, 0xFF, 0x9D, 0xE0, 0x1E,
  0x1F, 0x9F, 0xFC, 0x7E, 0x3F, 0x03, 0x81, 0xC0, 0xE3, 0x73, 0xBF, 0xDF,
  0xC3, 0xC0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x7B, 0x9F, 0xF3,
  0xFE, 0xE1, 0xDC, 0x3B, 0x8E, 0x71, 0xCE, 0x39, 0xC7, 0x38, 0xE7, 0xF8,
  0xFF, 0x0F, 0xE0, 0x1F, 0x1F, 0xDF, 0xEE, 0x3E, 0x1F, 0xFF, 0xFF, 0xC0,
  0xE0, 0x70, 0x3F, 0xCF, 0xE3, 0xE0, 0x0F, 0x1F, 0x1F, 0x38, 0x38, 0xFE,
  0xFE, 0x38, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE0,
  0x0E, 0x67, 0xFC, 0xFF, 0xBC, 0x77, 0x0E, 0xE1, 0xDC, 0x73, 0x8E, 0x71,
  0xCE, 0x39, 0xFF, 0x3F, 0xC3, 0xF8, 0x07, 0x00, 0xE7, 0x78, 0xFF, 0x0F,
  0x80, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0xE3, 0xFC, 0xFF, 0x39,
  0xDC, 0x77, 0x1D, 0xC7, 0x71, 0xDC, 0x77, 0x1F, 0x8E, 0xE3, 0xB8, 0xE0,
  0x1C, 0x71, 0xC0, 0x00, 0xE3, 0x8E, 0x38, 0xE7, 0x1C, 0x71, 0xC7, 0x1C,
  0xE3, 0x80, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x03,
  0x87, 0xC3, 0xC3, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03,
  0x8E, 0x39, 0xC3, 0xBC, 0x3F, 0x87, 0xF0, 0x7E, 0x07, 0xE0, 0x7F, 0x07,
  0x70, 0x77, 0x0E, 0x38, 0xE3, 0x8E, 0x3C, 0x1C, 0x71, 0xC7, 0x18, 0xE3,
  0x8E, 0x38, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0xE3, 0x80, 0x3B, 0x9E, 0x3F,
  0xFF, 0x3F, 0xFF, 0x39, 0xE7, 0x71, 0xC7, 0x71, 0xC7, 0x71, 0xC7, 0x71,
  0xC7, 0x71, 0xC7, 0x71, 0xCE, 0xE3, 0x8E, 0xE3, 0x8E, 0xE3, 0x8E, 0x3B,
  0x8F, 0xF3, 0xFC, 0xE7, 0x71, 0xDC, 0x77, 0x1D, 0xC7, 0x71, 0xDC, 0x7E,
  0x3B, 0x8E, 0xE3, 0x80, 0x1F, 0x0F, 0xE7, 0xFB, 0xC7, 0xE1, 0xF8, 0x7E,
  0x1F, 0x86, 0xE3, 0xB8, 0xEF, 0xF1, 0xFC, 0x3C, 0x00, 0x1D, 0xC1, 0xFE,
  0x1F, 0xE1, 0xC7, 0x38, 0x73, 0x87, 0x38, 0x73, 0x8E, 0x38, 0xE3, 0x8E,
  0x7F, 0xE7, 0xFC, 0x77, 0x87, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00,
  0x3D, 0xDF, 0xF7, 0xFF, 0x87, 0xE1, 0xF8, 0xEE, 0x3B, 0x8E, 0xE3, 0xB8,
  0xEF, 0xF3, 0xFC, 0x7F, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0x3F,
  0x3F, 0x3F, 0x38, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0,
  0x0F, 0x0F, 0xE3, 0x9C, 0xC7, 0x38, 0x0F, 0x01, 0xF0, 0x3E, 0x03, 0xB8,
  0xEF, 0x79, 0xFC, 0x3E, 0x00, 0x38, 0xE3, 0xBF, 0xFD, 0xC7, 0x1C, 0x71,
  0xC6, 0x38, 0xE3, 0xEF, 0x9C, 0x71, 0xDC, 0x77, 0x1D, 0xC7, 0xE3, 0xB8,
  0xEE, 0x3B, 0x8E, 0xE3, 0xB8, 0xEF, 0xF3, 0xFC, 0x7F, 0x00, 0xE1, 0xF8,
  0xE6, 0x39, 0x8C, 0x67, 0x1D, 0xC7, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0xC0,
  0xE0, 0x38, 0x00, 0xE3, 0x1F, 0x8E, 0x76, 0x79, 0x99, 0xEE, 0x6F, 0xB9,
  0xB6, 0xC6, 0xDF, 0x1F, 0x7C, 0x79, 0xE1, 0xE7, 0x87, 0x1C, 0x1C, 0x70,
  0x71, 0xC0, 0x1C, 0xF1, 0xCE, 0x1D, 0xC0, 0xDC, 0x0F, 0x80, 0xF8, 0x0F,
  0x00, 0xF0, 0x1F, 0x83, 0xB8, 0x3B, 0x87, 0x18, 0x71, 0xC0, 0x38, 0x73,
  0x8E, 0x18, 0xE1, 0x9C, 0x1D, 0xC1, 0xDC, 0x1F, 0x81, 0xF8, 0x1F, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x07, 0x80, 0xF0, 0x0E,
  0x00, 0x3F, 0xCF, 0xF3, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x38,
  0x1C, 0x0F, 0xFB, 0xFE, 0xFF, 0x00, 0x06, 0x1C, 0x70, 0xC1, 0x87, 0x0E,
  0x1C, 0x38, 0x61, 0xC7, 0x0E, 0x0C, 0x18, 0x30, 0x61, 0xC3, 0x87, 0x06,
  0x0E, 0x08, 0x00, 0x18, 0xC6, 0x31, 0x8C, 0xC6, 0x31, 0x8C, 0x63, 0x31,
  0x8C, 0x63, 0x19, 0x80, 0x08, 0x38, 0x30, 0x70, 0xE1, 0xC3, 0x06, 0x0C,
  0x18, 0x38, 0x30, 0xE3, 0x86, 0x1C, 0x38, 0x70, 0xE1, 0x87, 0x1C, 0x30,
  0x00, 0x38, 0x6F, 0x8D, 0xFF, 0xF3, 0xEC, 0x38,
};

const GFXglyph RobotoCondensed_SemiBoldItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 17, 6, 0, -17 },
  { 14, 6, 6, 7, 2, -18 },
  { 19, 12, 17, 12, 1, -17 },
  { 45, 10, 21, 12, 1, -19 },
  { 72, 11, 17, 15, 2, -17 },
  { 96, 12, 17, 13, 0, -17 },
  { 122, 3, 6, 4, 2, -18 },
  { 125, 7, 24, 7, 1, -19 },
  { 146, 7, 24, 8, -1, -19 },
  { 167, 10, 10, 10, 1, -17 },
  { 180, 10, 13, 11, 1, -15 },
  { 197, 4, 7, 5, -1, -3 },
  { 201, 6, 3, 8, 1, -9 },
  { 204, 3, 3, 7, 1, -3 },
  { 206, 10, 18, 8, -1, -17 },
  { 229, 10, 17, 12, 1, -17 },
  { 251, 7, 17, 12, 3, -17 },
  { 266, 11, 17, 12, 0, -17 },
  { 290, 11, 17, 12, 0, -17 },
  { 314, 11, 17, 12, 0, -17 },
  { 338, 11, 17, 12, 1, -17 },
  { 362, 10, 17, 12, 1, -17 },
  { 384, 11, 17, 12, 1, -17 },
  { 408, 10, 17, 12, 1, -17 },
  { 430, 9, 17, 12, 2, -17 },
  { 450, 5, 13, 6, 1, -13 },
  { 459, 7, 17, 6, -1, -13 },
  { 474, 9, 11, 10, 1, -13 },
  { 487, 10, 9, 12, 1, -12 },
  { 499, 10, 11, 11, 0, -13 },
  { 513, 8, 17, 10, 2, -17 },
  { 530, 17, 22, 18, 0, -17 },
  { 577, 13, 17, 14, -1, -17 },
  { 605, 13, 17, 13, 0, -17 },
  { 633, 12, 17, 13, 1, -17 },
  { 659, 13, 17, 13, 0, -17 },
  { 687, 13, 17, 11, 0, -17 },
  { 715, 12, 17, 11, 0, -17 },
  { 741, 12, 17, 14, 1, -17 },
  { 767, 15, 17, 14, 0, -17 },
  { 799, 6, 17, 6, 0, -17 },
  { 812, 12, 17, 11, 0, -17 },
  { 838, 15, 17, 13, 0, -17 },
  { 870, 10, 17, 11, 0, -17 },
  { 892, 18, 17, 18, 0, -17 },
  { 931, 15, 17, 14, 0, -17 },
  { 963, 13, 17, 14, 1, -17 },
  { 991, 13, 17, 13, 0, -17 },
  { 1019, 12, 20, 14, 1, -17 },
  { 1049, 13, 17, 13, 0, -17 },
  { 1077, 13, 17, 12, 0, -17 },
  { 1105, 12, 17, 13, 2, -17 },
  { 1131, 13, 17, 13, 1, -17 },
  { 1159, 13, 17, 13, 2, -17 },
  { 1187, 17, 17, 18, 2, -17 },
  { 1224, 15, 17, 13, -1, -17 },
  { 1256, 12, 17, 13, 2, -17 },
  { 1282, 13, 17, 12, 0, -17 },
  { 1310, 8, 24, 6, 0, -20 },
  { 1334, 5, 18, 9, 2, -17 },
  { 1346, 8, 24, 6, -1, -20 },
  { 1370, 8, 9, 9, 1, -17 },
  { 1379, 9, 2, 9, -1, 0 },
  { 1382, 5, 4, 8, 2, -18 },
  { 1385, 10, 13, 11, 0, -13 },
  { 1402, 11, 18, 12, 0, -18 },
  { 1427, 9, 13, 11, 1, -13 },
  { 1442, 11, 18, 12, 1, -18 },
  { 1467, 9, 13, 11, 1, -13 },
  { 1482, 8, 18, 8, 1, -18 },
  { 1500, 11, 18, 12, 0, -13 },
  { 1525, 10, 18, 11, 0, -18 },
  { 1548, 6, 18, 6, 0, -18 },
  { 1562, 9, 23, 6, -3, -18 },
  { 1588, 12, 18, 11, 0, -18 },
  { 1615, 6, 18, 6, 0, -18 },
  { 1629, 16, 13, 17, 0, -13 },
  { 1655, 10, 13, 11, 0, -13 },
  { 1672, 10, 13, 12, 1, -13 },
  { 1689, 12, 18, 12, -1, -13 },
  { 1716, 10, 18, 12, 1, -13 },
  { 1739, 8, 13, 8, 0, -13 },
  { 1752, 10, 13, 11, 0, -13 },
  { 1769, 6, 16, 7, 1, -16 },
  { 1781, 10, 13, 11, 1, -13 },
  { 1798, 10, 13, 10, 1, -13 },
  { 1815, 14, 13, 15, 1, -13 },
  { 1838, 12, 13, 10, -1, -13 },
  { 1858, 12, 18, 10, -1, -13 },
  { 1885, 10, 13, 10, 0, -13 },
  { 1902, 7, 23, 7, 1, -19 },
  { 1923, 5, 20, 6, 0, -17 },
  { 1936, 7, 23, 7, -1, -19 },
  { 1957, 11, 5, 13, 1, -9 },
};

const GFXfont RobotoCondensed_SemiBoldItalic24pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic24pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic24pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC24PT7B_H_
