#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC11PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0x24, 0x36, 0xB7, 0x00, 0x18, 0x67, 0xCA, 0x33, 0xE5, 0x18,
  0x11, 0xDA, 0x96, 0x0B, 0x6B, 0x71, 0x00, 0x65, 0x6D, 0xC3, 0xB6, 0xA3,
  0x31, 0xA7, 0x8C, 0x7F, 0x6D, 0x9E, 0xE0, 0x2B, 0x49, 0x24, 0x92, 0x00,
  0x48, 0x92, 0x5A, 0x52, 0x00, 0x24, 0xFE, 0xA0, 0x31, 0x3E, 0x42, 0x00,
  0x4B, 0x00, 0x60, 0x30, 0x08, 0x44, 0x22, 0x11, 0x08, 0x40, 0x3B, 0x52,
  0x94, 0xED, 0x4E, 0x3C, 0x96, 0xD2, 0x3B, 0x52, 0x33, 0x31, 0x1F, 0x3A,
  0x42, 0x61, 0x8F, 0x4E, 0x18, 0xCE, 0xF5, 0x7C, 0x42, 0x3B, 0x10, 0xE1,
  0x8F, 0x6E, 0x19, 0x10, 0xE5, 0xAD, 0x6E, 0xF8, 0x8C, 0x46, 0x23, 0x10,
  0x3B, 0x52, 0xE5, 0xEF, 0x4E, 0x69, 0x9B, 0xF2, 0x6C, 0x4C, 0x01, 0x80,
  0x22, 0x00, 0x06, 0x44, 0x13, 0xB0, 0xE1, 0x00, 0x78, 0x1C, 0x43, 0x86,
  0xC8, 0x00, 0x6B, 0x32, 0x44, 0x08, 0x1E, 0x22, 0x5D, 0x55, 0xA5, 0xA9,
  0xAA, 0xB6, 0x40, 0x78, 0x18, 0x62, 0x8A, 0x69, 0xEC, 0xA3, 0x79, 0xB4,
  0xDC, 0x49, 0x2D, 0xBC, 0x39, 0xB4, 0x50, 0x43, 0x24, 0x9C, 0x79, 0xB4,
  0xD3, 0x4D, 0x2D, 0xBC, 0x7D, 0x84, 0x1E, 0x41, 0x0C, 0x3C, 0x7D, 0x84,
  0x10, 0x79, 0x0C, 0x30, 0x39, 0xB4, 0x50, 0x5D, 0x34, 0x9E, 0x66, 0xC9,
  0x12, 0x27, 0xC9, 0xB3, 0x64, 0x6D, 0x24, 0xB6, 0x08, 0x42, 0x31, 0x8B,
  0x4C, 0x64, 0xD1, 0x63, 0x87, 0x0A, 0x36, 0x64, 0x66, 0x44, 0x44, 0xCF,
  0x63, 0x63, 0x65, 0x77, 0x5E, 0x5A, 0xDA, 0xD2, 0x66, 0xC9, 0xD2, 0xA5,
  0x4B, 0xB3, 0x64, 0x39, 0xB4, 0x51, 0x45, 0x34, 0x9C, 0x79, 0xB4, 0x53,
  0x79, 0x0C, 0x30, 0x39, 0xB4, 0x51, 0x47, 0x34, 0x9C, 0x08, 0x79, 0xB4,
  0xD2, 0x79, 0x4D, 0xB2, 0x39, 0xB4, 0x1C, 0x1B, 0x2D, 0x9C, 0xF9, 0x08,
  0xC6, 0x21, 0x08, 0x65, 0x94, 0xD3, 0x4F, 0x24, 0x9C, 0x8E, 0x2D, 0xB4,
  0xF1, 0x86, 0x10, 0x92, 0x92, 0xB6, 0xB4, 0xB4, 0xDC, 0xD8, 0xC8, 0x65,
  0xB3, 0x8C, 0x31, 0xC5, 0xB2, 0x8E, 0xD4, 0xC6, 0x21, 0x08, 0x7C, 0x21,
  0x84, 0x21, 0x8C, 0x3E, 0x6D, 0x24, 0x96, 0xD3, 0x00, 0xAF, 0x55, 0x40,
  0x33, 0x33, 0x22, 0x22, 0x66, 0xC0, 0x23, 0x55, 0xF8, 0xD0, 0x72, 0xDD,
  0xAD, 0x38, 0x63, 0x10, 0xF5, 0xA7, 0x7B, 0xB0, 0x72, 0xF1, 0x8D, 0x38,
  0x08, 0x20, 0x9E, 0x5B, 0x6D, 0xB4, 0x70, 0x72, 0xFF, 0x8C, 0x38, 0x32,
  0x67, 0x44, 0x44, 0xC0, 0x7A, 0x77, 0xBD, 0x3A, 0x5C, 0x63, 0x10, 0xE5,
  0xAF, 0x7A, 0x90, 0x0C, 0x24, 0x96, 0xC0, 0x03, 0x02, 0x22, 0x66, 0x44,
  0xC0, 0x63, 0x10, 0xB5, 0x33, 0xDE, 0x90, 0x6D, 0x24, 0xB6, 0xC0, 0x76,
  0xB5, 0x6E, 0x9D, 0x32, 0x40, 0x72, 0xD7, 0xBD, 0x48, 0x72, 0xF3, 0xBD,
  0x38, 0x7A, 0xD3, 0xBD, 0xDA, 0x10, 0x7A, 0xF7, 0xBD, 0x38, 0x46, 0x76,
  0x4C, 0xC8, 0x72, 0xD8, 0x69, 0x38, 0x7D, 0x24, 0x98, 0x4A, 0x57, 0xBD,
  0x38, 0xBA, 0xAE, 0xCC, 0xA6, 0xBE, 0xB6, 0xD2, 0x40, 0x5A, 0x98, 0xC7,
  0x48, 0x5A, 0x94, 0xC6, 0x31, 0x10, 0x78, 0x88, 0xCC, 0x78, 0x12, 0x26,
  0x48, 0x44, 0x44, 0x40, 0x49, 0x24, 0x94, 0x80, 0x4D, 0xA4, 0x52, 0xD2,
  0x00, 0x6D, 0x60,
};

const GFXglyph RobotoCondensed_SemiBoldItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 8, 3, 0, -8 },
  { 4, 3, 3, 3, 1, -8 },
  { 6, 6, 8, 6, 0, -8 },
  { 12, 5, 10, 5, 0, -9 },
  { 19, 5, 8, 7, 1, -8 },
  { 24, 6, 8, 6, 0, -8 },
  { 30, 1, 3, 2, 1, -8 },
  { 31, 3, 11, 3, 1, -9 },
  { 36, 3, 11, 3, 0, -9 },
  { 41, 4, 5, 5, 1, -8 },
  { 44, 5, 5, 5, 0, -6 },
  { 48, 3, 3, 3, -1, -1 },
  { 50, 3, 1, 4, 0, -4 },
  { 51, 2, 2, 3, 0, -2 },
  { 52, 5, 9, 4, -1, -8 },
  { 58, 5, 8, 5, 0, -8 },
  { 63, 3, 8, 5, 1, -8 },
  { 66, 5, 8, 5, 0, -8 },
  { 71, 5, 8, 5, 0, -8 },
  { 76, 5, 8, 5, 0, -8 },
  { 81, 5, 8, 5, 0, -8 },
  { 86, 5, 8, 5, 0, -8 },
  { 91, 5, 8, 5, 1, -8 },
  { 96, 5, 8, 5, 0, -8 },
  { 101, 4, 8, 5, 1, -8 },
  { 105, 3, 6, 3, 0, -6 },
  { 108, 4, 8, 3, -1, -6 },
  { 112, 5, 5, 5, 0, -6 },
  { 116, 5, 3, 5, 0, -5 },
  { 118, 5, 5, 5, 0, -6 },
  { 122, 4, 8, 5, 1, -8 },
  { 126, 8, 10, 8, 0, -8 },
  { 136, 6, 8, 6, 0, -8 },
  { 142, 6, 8, 6, 0, -8 },
  { 148, 6, 8, 6, 0, -8 },
  { 154, 6, 8, 6, 0, -8 },
  { 160, 6, 8, 5, 0, -8 },
  { 166, 6, 8, 5, 0, -8 },
  { 172, 6, 8, 6, 0, -8 },
  { 178, 7, 8, 7, 0, -8 },
  { 185, 3, 8, 3, 0, -8 },
  { 188, 5, 8, 5, 0, -8 },
  { 193, 7, 8, 6, 0, -8 },
  { 200, 4, 8, 5, 0, -8 },
  { 204, 8, 8, 8, 0, -8 },
  { 212, 7, 8, 7, 0, -8 },
  { 219, 6, 8, 6, 0, -8 },
  { 225, 6, 8, 6, 0, -8 },
  { 231, 6, 9, 6, 0, -8 },
  { 238, 6, 8, 6, 0, -8 },
  { 244, 6, 8, 6, 0, -8 },
  { 250, 5, 8, 6, 1, -8 },
  { 255, 6, 8, 6, 0, -8 },
  { 261, 6, 8, 6, 1, -8 },
  { 267, 8, 8, 8, 1, -8 },
  { 275, 6, 8, 6, 0, -8 },
  { 281, 5, 8, 6, 1, -8 },
  { 286, 6, 8, 6, 0, -8 },
  { 292, 3, 11, 3, 0, -9 },
  { 297, 2, 9, 4, 1, -8 },
  { 300, 4, 11, 3, -1, -9 },
  { 306, 4, 4, 4, 0, -8 },
  { 308, 5, 1, 4, -1, 0 },
  { 309, 2, 2, 3, 1, -9 },
  { 310, 5, 6, 5, 0, -6 },
  { 314, 5, 9, 5, 0, -9 },
  { 320, 5, 6, 5, 0, -6 },
  { 324, 6, 9, 5, 0, -9 },
  { 331, 5, 6, 5, 0, -6 },
  { 335, 4, 9, 3, 0, -9 },
  { 340, 5, 8, 5, 0, -6 },
  { 345, 5, 9, 5, 0, -9 },
  { 351, 3, 9, 3, 0, -9 },
  { 355, 4, 11, 3, -1, -9 },
  { 361, 5, 9, 5, 0, -9 },
  { 367, 3, 9, 3, 0, -9 },
  { 371, 7, 6, 8, 0, -6 },
  { 377, 5, 6, 5, 0, -6 },
  { 381, 5, 6, 5, 0, -6 },
  { 385, 5, 8, 5, 0, -6 },
  { 390, 5, 8, 5, 0, -6 },
  { 395, 4, 6, 3, 0, -6 },
  { 398, 5, 6, 5, 0, -6 },
  { 402, 3, 7, 3, 0, -7 },
  { 405, 5, 6, 5, 0, -6 },
  { 409, 4, 6, 5, 1, -6 },
  { 412, 6, 6, 7, 1, -6 },
  { 417, 5, 6, 5, 0, -6 },
  { 421, 5, 8, 5, 0, -6 },
  { 426, 5, 6, 5, 0, -6 },
  { 430, 4, 11, 3, 0, -9 },
  { 436, 3, 9, 3, 0, -8 },
  { 440, 3, 11, 3, 0, -9 },
  { 445, 6, 2, 6, 0, -4 },
};

const GFXfont RobotoCondensed_SemiBoldItalic11pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic11pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic11pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC11PT7B_H_
