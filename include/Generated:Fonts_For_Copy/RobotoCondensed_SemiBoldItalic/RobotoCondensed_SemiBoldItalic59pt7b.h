#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC59PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x01, 0xF0, 0x07, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x1F,
  0x1F, 0x8F, 0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xE3, 0xF1, 0xF1, 0xF9, 0xF8,
  0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1E, 0x1F, 0x0F, 0x0F, 0x0F, 0x8F,
  0x87, 0xC7, 0xC3, 0xC3, 0xE1, 0xE0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07,
  0xC3, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1,
  0xE0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x07, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x03, 0xC3, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xF0,
  0x78, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3C,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1E, 0x00,
  0x01, 0xF0, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x00, 0x3C,
  0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1E, 0x1F,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x0F, 0x80,
  0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0x87, 0xC0, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x81, 0xFE, 0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFF,
  0x0F, 0xF0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F,
  0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0xFF,
  0x07, 0xF8, 0x7F, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xE3, 0xE0, 0x10, 0x7C, 0x1E, 0x03, 0x87, 0xC1,
  0xF0, 0x7E, 0x7C, 0x1F, 0x07, 0xC7, 0x81, 0xF0, 0xF8, 0xF8, 0x1F, 0x1F,
  0x8F, 0x81, 0xE1, 0xF0, 0xF8, 0x3E, 0x3E, 0x0F, 0x83, 0xE7, 0xC0, 0x78,
  0x3E, 0x7C, 0x07, 0xC7, 0xCF, 0x80, 0x7F, 0xFD, 0xF0, 0x03, 0xFF, 0x9F,
  0x00, 0x3F, 0xF3, 0xE0, 0x00, 0xFE, 0x7C, 0x00, 0x01, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x7F, 0x00, 0x07, 0xCF, 0xFC, 0x00, 0xFD, 0xFF, 0xC0, 0x0F, 0xBF, 0xFE,
  0x01, 0xF3, 0xE3, 0xE0, 0x3E, 0x7C, 0x1E, 0x03, 0xE7, 0xC1, 0xF0, 0x7C,
  0x7C, 0x1F, 0x0F, 0x87, 0x81, 0xF0, 0xF8, 0x78, 0x1F, 0x1F, 0x0F, 0x81,
  0xE3, 0xE0, 0xF8, 0x3E, 0x3E, 0x0F, 0x83, 0xE7, 0xC0, 0x7C, 0x3E, 0x18,
  0x07, 0xC7, 0xC0, 0x80, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0x87,
  0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x07, 0xE0,
  0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x0F,
  0xE1, 0xFC, 0x00, 0x3F, 0x3F, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x3F, 0x0F,
  0xFF, 0xC1, 0xF8, 0xFF, 0xFF, 0x1F, 0xCF, 0xF7, 0xF8, 0xFC, 0x7F, 0x1F,
  0xE7, 0xE7, 0xF8, 0x7F, 0x7F, 0x3F, 0x83, 0xFF, 0xFB, 0xFC, 0x0F, 0xFF,
  0x9F, 0xE0, 0x7F, 0xFC, 0xFF, 0x01, 0xFF, 0xC7, 0xF8, 0x0F, 0xFE, 0x3F,
  0xC0, 0x3F, 0xE1, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFE, 0xFF, 0x00, 0xFF, 0xC3, 0xFC, 0x00, 0x40, 0x00, 0x00,
  0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0xF8,
  0xF8, 0xF8, 0xF8, 0x00, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x38, 0x1E, 0x07, 0x7E, 0x1E, 0x3F, 0x7F, 0x9E, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xEF, 0x80, 0x0F,
  0xCF, 0x80, 0x1F, 0x87, 0xC0, 0x3F, 0x07, 0xE0, 0x7F, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x0C, 0x03, 0x80, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0,
  0x7E, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0x87, 0xF1, 0xFC, 0x3F, 0x03, 0xC0,
  0x10, 0x00, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF,
  0xFF, 0x80, 0x1E, 0x3F, 0x9F, 0xDF, 0xFF, 0xFF, 0xFD, 0xFC, 0x7C, 0x08,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F,
  0xE1, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3,
  0xF0, 0x07, 0xE3, 0xF8, 0x03, 0xF1, 0xFC, 0x01, 0xFC, 0xFE, 0x01, 0xFE,
  0xFF, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F,
  0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF7, 0xF8, 0x07, 0xFB, 0xFC, 0x03,
  0xFD, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80,
  0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x1F, 0xE7, 0xF0, 0x0F, 0xE3, 0xF8,
  0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x3F,
  0x80, 0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x07, 0x80,
  0x1F, 0xC0, 0x3F, 0xE0, 0xFF, 0xF1, 0xFF, 0xF9, 0xFF, 0xFD, 0xFF, 0xFC,
  0xFF, 0xFE, 0x7F, 0xFF, 0x3E, 0x3F, 0x98, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFE,
  0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0xFF, 0x1F,
  0xC0, 0x1F, 0xE3, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0x07, 0xF8, 0x3F,
  0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xDF, 0xC0, 0x07,
  0xE7, 0xF0, 0x01, 0xF9, 0xFC, 0x00, 0xFC, 0xFF, 0x00, 0x7F, 0x3F, 0x80,
  0x3F, 0x8F, 0xE0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x3F,
  0x80, 0xFC, 0x1F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x07, 0xF0, 0x1F, 0xC3, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x3F,
  0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x3F,
  0xC1, 0xFC, 0x0F, 0xF0, 0x3F, 0xC3, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE3, 0xF0, 0x1F, 0xDF, 0xF0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFC, 0x3F, 0xDF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x07, 0xFB, 0xFC, 0x0F,
  0xE3, 0xF8, 0x3F, 0xC7, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xE1, 0xFE,
  0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x0F, 0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0x80,
  0xFF, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F,
  0x81, 0xFE, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xC3, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8,
  0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F,
  0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x7F,
  0x0F, 0xE0, 0x1F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xE0, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F,
  0x01, 0xFD, 0xFE, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xCF, 0xE0, 0x7F,
  0x9F, 0xE1, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xDF, 0xC0, 0x3F, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xE0, 0x1F, 0x81, 0xFE, 0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x1F,
  0xC0, 0x7C, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xF8, 0x1F, 0xC1, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC1, 0xFC, 0x07, 0xC0, 0x08, 0x00, 0x00, 0x3C, 0x00, 0x7E, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x80, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x00, 0x04, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xE1, 0xFE, 0x7F, 0x83, 0xF9, 0xFC,
  0x0F, 0xEF, 0xF0, 0x3F, 0xFF, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFB, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x3F, 0x00, 0x7E, 0x00, 0xF0, 0x1F, 0x00, 0xFF, 0xC0, 0x78, 0x1F,
  0x00, 0xFF, 0xF0, 0x3C, 0x0F, 0x80, 0xFF, 0xFC, 0x1E, 0x0F, 0x80, 0xFF,
  0xFE, 0x0F, 0x87, 0xC0, 0xFC, 0x1F, 0x07, 0xC7, 0xE0, 0xFC, 0x1F, 0x83,
  0xE3, 0xE0, 0x7E, 0x0F, 0x81, 0xF1, 0xF0, 0x7E, 0x07, 0xC0, 0xF9, 0xF0,
  0x3E, 0x03, 0xE0, 0x7C, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x7C, 0x1F, 0x81,
  0xF0, 0x1E, 0x7E, 0x0F, 0x80, 0xF8, 0x0F, 0x3E, 0x07, 0xC0, 0x7C, 0x07,
  0x9F, 0x07, 0xE0, 0x3E, 0x03, 0xCF, 0x83, 0xF0, 0x3E, 0x03, 0xE7, 0xC1,
  0xF8, 0x1F, 0x01, 0xF3, 0xE0, 0xF8, 0x0F, 0x80, 0xF3, 0xE0, 0x7C, 0x07,
  0xC0, 0x79, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0xF8, 0x3F, 0x03, 0xE0, 0x3C,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x3E, 0x07, 0xC1, 0xF8, 0x1E, 0x1F, 0x03,
  0xF1, 0xFC, 0x1F, 0x0F, 0x81, 0xFD, 0xFE, 0x1F, 0x07, 0xC0, 0xFF, 0xEF,
  0xFF, 0x83, 0xE0, 0x3F, 0xF7, 0xFF, 0x80, 0xF0, 0x1F, 0xF1, 0xFF, 0x80,
  0x7C, 0x07, 0xF0, 0x7F, 0x00, 0x3E, 0x00, 0x40, 0x0C, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x02, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFB, 0xF0,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x7F, 0x81, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFC,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE,
  0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0x83, 0xFF, 0x80, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0,
  0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x03,
  0xFC, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x03, 0xFC,
  0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F,
  0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8,
  0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xFC, 0x1F,
  0xC0, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x03,
  0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x0F,
  0xE1, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x7F,
  0x8F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0,
  0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x0F,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0x87, 0xFF, 0x00, 0xFE, 0x03, 0xFE, 0x07,
  0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0x81, 0xFC,
  0x00, 0xFF, 0x07, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0xFF, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x0F,
  0xF0, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xF8,
  0x7F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFE, 0x1F,
  0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x0F, 0xF0,
  0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x01,
  0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x01, 0xFF,
  0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xC1, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x07,
  0xF0, 0x7F, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F,
  0xC7, 0xF0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xFF, 0x1F, 0xE0, 0x3F, 0xFE, 0x3F,
  0xC0, 0xFF, 0xFC, 0x7F, 0x81, 0xFF, 0xF8, 0xFE, 0x03, 0xFF, 0xF1, 0xFC,
  0x07, 0xFF, 0xE3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0,
  0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x03, 0xF8, 0x0F, 0xF0, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x01, 0xFC, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x03, 0xFC,
  0x1F, 0xE0, 0x1F, 0xC0, 0xFF, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F,
  0xC0, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0xC0, 0x3F, 0x80, 0x1F, 0xF8, 0x0F, 0xF0, 0x07, 0xFE, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x00, 0xFE,
  0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0xC0, 0x07, 0xF8, 0x1F, 0xF0, 0x00,
  0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x03, 0xF8, 0x7F, 0xC0,
  0x00, 0x7F, 0x0F, 0xF8, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x03, 0xFC, 0xFF,
  0x80, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x01, 0xFD,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x7F,
  0x80, 0x00, 0xFF, 0xCF, 0xF0, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x01, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x1F, 0xFE,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x00, 0xFF, 0xF8, 0x1F,
  0xDF, 0x80, 0x3F, 0xFF, 0x03, 0xFB, 0xF0, 0x07, 0xEF, 0xE0, 0x7F, 0x7E,
  0x01, 0xFF, 0xF8, 0x0F, 0xEF, 0xC0, 0x3F, 0x7F, 0x01, 0xFD, 0xF8, 0x0F,
  0xEF, 0xE0, 0x3F, 0xBF, 0x01, 0xF9, 0xFC, 0x0F, 0xF7, 0xE0, 0x3F, 0x3F,
  0x81, 0xFC, 0x7C, 0x0F, 0xCF, 0xF0, 0x3F, 0x8F, 0xC1, 0xF9, 0xFC, 0x07,
  0xF1, 0xF8, 0x7E, 0x3F, 0x80, 0xFE, 0x3F, 0x0F, 0xC7, 0xF0, 0x1F, 0xC7,
  0xE3, 0xF8, 0xFE, 0x07, 0xF8, 0xFC, 0x7E, 0x3F, 0xC0, 0xFF, 0x1F, 0x9F,
  0xC7, 0xF0, 0x1F, 0xC3, 0xF3, 0xF0, 0xFE, 0x03, 0xF8, 0x3E, 0x7E, 0x1F,
  0xC0, 0x7F, 0x07, 0xDF, 0x87, 0xF8, 0x0F, 0xE0, 0xFB, 0xF0, 0xFF, 0x03,
  0xFC, 0x1F, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFF, 0x83, 0xF8, 0x0F, 0xF0,
  0x7F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x7F,
  0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0xE0, 0x01, 0xFC, 0x07, 0xFE, 0x00,
  0x7F, 0x80, 0xFF, 0xC0, 0x0F, 0xF0, 0x1F, 0xF8, 0x01, 0xFE, 0x07, 0xFF,
  0x80, 0x3F, 0x80, 0xFF, 0xF0, 0x07, 0xF0, 0x1F, 0xFE, 0x00, 0xFE, 0x03,
  0xFF, 0xC0, 0x3F, 0xC0, 0x7F, 0xFC, 0x07, 0xF8, 0x1F, 0xFF, 0x80, 0xFF,
  0x03, 0xFD, 0xF0, 0x1F, 0xC0, 0x7F, 0xBF, 0x03, 0xF8, 0x0F, 0xF7, 0xE0,
  0xFF, 0x01, 0xFC, 0xFC, 0x1F, 0xE0, 0x3F, 0x8F, 0x83, 0xFC, 0x0F, 0xF1,
  0xF8, 0x7F, 0x01, 0xFE, 0x3F, 0x0F, 0xE0, 0x3F, 0xC7, 0xE1, 0xFC, 0x07,
  0xF0, 0x7C, 0x7F, 0x80, 0xFE, 0x0F, 0xCF, 0xF0, 0x1F, 0xC1, 0xF9, 0xFE,
  0x07, 0xF8, 0x1F, 0x3F, 0x80, 0xFF, 0x03, 0xF7, 0xF0, 0x1F, 0xE0, 0x7E,
  0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0x00, 0xFF, 0xF8, 0x0F, 0xE0,
  0x1F, 0xFF, 0x03, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xF8, 0x0F,
  0xF0, 0x07, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0x80, 0x1F, 0xFC,
  0x0F, 0xF0, 0x01, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x07,
  0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x00,
  0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x03,
  0xFC, 0xFE, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x1F,
  0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0xFE,
  0x7F, 0x80, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFF, 0x1F,
  0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x03, 0xFE,
  0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFE, 0x3F, 0xFF, 0x01, 0xFC, 0x01,
  0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x03,
  0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x1F,
  0xC3, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFE,
  0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xF0, 0xFF, 0x00, 0x7F, 0xC1,
  0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFC,
  0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x9F,
  0xE0, 0x00, 0x7F, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0xFE,
  0x00, 0x07, 0xF9, 0xFC, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xF0,
  0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0xFE, 0x7F, 0x80,
  0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x0F, 0xF3, 0xF8, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFF, 0x1F, 0xC0, 0x01,
  0xFE, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F,
  0xC1, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x0F, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x6F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0x81, 0xFF, 0x80, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x03,
  0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0x7F,
  0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0xE0, 0xFE,
  0x01, 0xFF, 0x07, 0xF8, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80,
  0x3F, 0x81, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0,
  0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x83, 0xFC, 0x01,
  0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x3F,
  0xC3, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x07,
  0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0xC1, 0xFC,
  0x00, 0xFF, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x01,
  0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0xFF,
  0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F,
  0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x0F,
  0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F,
  0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x1F,
  0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F,
  0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F,
  0x80, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F,
  0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x7F, 0x9F, 0xE0,
  0x01, 0xFF, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x83, 0xFC, 0x01,
  0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xC0,
  0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE3, 0xFC, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0xFE, 0x7F, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0xBF, 0xC0, 0x3F, 0xC0,
  0x3F, 0xDF, 0xE0, 0x1F, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF0, 0x0F, 0xE7,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF3, 0xFC, 0x07, 0xFC, 0x07, 0xF9, 0xFE, 0x03,
  0xFE, 0x03, 0xF8, 0x7F, 0x03, 0xFF, 0x01, 0xFC, 0x3F, 0x81, 0xFF, 0x81,
  0xFE, 0x1F, 0xC0, 0xFF, 0xC0, 0xFE, 0x0F, 0xE0, 0xFF, 0xE0, 0x7F, 0x07,
  0xF0, 0x7F, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xF8, 0x3F, 0x81, 0xFC, 0x3F,
  0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xFE, 0x1F, 0xE0, 0x7F, 0x0F, 0xFF, 0x0F,
  0xE0, 0x3F, 0x8F, 0xDF, 0x87, 0xF0, 0x1F, 0xC7, 0xEF, 0xC7, 0xF8, 0x0F,
  0xE3, 0xF7, 0xE3, 0xF8, 0x07, 0xF3, 0xF3, 0xF1, 0xFC, 0x03, 0xF9, 0xF8,
  0xF8, 0xFE, 0x01, 0xFD, 0xFC, 0x7C, 0xFE, 0x00, 0xFE, 0xFC, 0x3E, 0x7F,
  0x00, 0x7F, 0x7E, 0x1F, 0x3F, 0x80, 0x3F, 0xFF, 0x0F, 0xBF, 0x80, 0x1F,
  0xFF, 0x07, 0xDF, 0xC0, 0x0F, 0xFF, 0x83, 0xEF, 0xE0, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8,
  0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x07,
  0xF7, 0xF8, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01,
  0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xE7, 0xF0, 0x00, 0xFF,
  0x1F, 0xC0, 0x07, 0xFC, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x83,
  0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x80, 0xFE,
  0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xC1,
  0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF9, 0xFE,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7D,
  0xF0, 0x1F, 0xBE, 0x03, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x8F, 0x87, 0xE1,
  0xF0, 0xFC, 0x3E, 0x3F, 0x07, 0xC7, 0xE0, 0xFD, 0xF8, 0x1F, 0xBF, 0x03,
  0xFF, 0xC0, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF0, 0x3F,
  0x83, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xF9, 0xFE, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0,
  0xFF, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xC1, 0xFC, 0x7F, 0x81, 0xFC, 0xFF, 0x01,
  0xFC, 0xFF, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x03,
  0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0xBF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFB, 0xF8, 0x0F, 0xE3, 0xF8, 0x01, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x7F,
  0x7F, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x3F, 0xE0, 0xFF, 0x0F, 0xF0, 0x1F, 0xC3, 0xF8, 0x07,
  0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0xE0, 0x1F, 0xC7, 0xF8,
  0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7,
  0xF0, 0x07, 0xF3, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x3F,
  0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFE, 0x7F, 0x80,
  0x7F, 0x1F, 0xF0, 0x3F, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x1F, 0x9F, 0xFE, 0x0F, 0xE7, 0xFF, 0x03, 0xF8, 0x7F, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x1F, 0xE0, 0xFF, 0x1F, 0xC0, 0x7F, 0x3F, 0xC0, 0x7F, 0x3F, 0x80,
  0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x7F, 0x01,
  0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x83, 0xF8, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x0F, 0xFE,
  0x7F, 0x00, 0xFF, 0xFB, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xC1, 0xFF, 0x83, 0xFC, 0x07, 0xF8, 0x1F,
  0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x80,
  0x7F, 0x83, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE,
  0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x1F,
  0xE0, 0x1F, 0xC0, 0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x3F, 0xC0,
  0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x7E, 0x00, 0x1F, 0xF3, 0xF0, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x1F, 0x8F, 0xE0,
  0x0F, 0xC7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xFB, 0xFC, 0x03, 0xFD, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xCF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x30, 0x3F, 0xE0, 0x7C,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xFF,
  0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF,
  0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x7F, 0x00,
  0xFF, 0xE7, 0xF0, 0x1F, 0xFF, 0x7F, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x1F, 0xE1,
  0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x3F, 0xC0,
  0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0xC3, 0xF8, 0x03, 0xFC,
  0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8,
  0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x83, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F,
  0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFE, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x61, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x30, 0x07,
  0xF8, 0x07, 0xC0, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0xFF, 0x00,
  0x7F, 0x7F, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x3F, 0x83, 0xF8,
  0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xE0, 0x3F, 0x87,
  0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x7F,
  0x8F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F,
  0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8,
  0x7F, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07,
  0xF0, 0x00, 0x78, 0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x8F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x0F, 0xF8, 0x1F, 0xC0, 0xFF, 0x80, 0xFE, 0x07, 0xFC, 0x07, 0xF0, 0x7F,
  0xC0, 0x3F, 0x87, 0xFC, 0x01, 0xFC, 0x7F, 0xC0, 0x1F, 0xE7, 0xFC, 0x00,
  0xFE, 0x3F, 0xC0, 0x07, 0xF3, 0xFC, 0x00, 0x3F, 0xBF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xEF, 0xF0, 0x01, 0xFE,
  0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF8, 0x3F,
  0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x80,
  0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFC,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F,
  0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF3, 0xFC, 0x0F, 0xF8,
  0x07, 0xF7, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0x3F, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x0F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F,
  0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x1F, 0xE0, 0x3F, 0x80, 0xFF,
  0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x1F, 0xC0,
  0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x3F, 0xC0, 0x7F, 0x01,
  0xFE, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x3F,
  0x80, 0xFF, 0x01, 0xFC, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x3F, 0x80, 0xFE,
  0x01, 0xFC, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x7F, 0x00, 0xFE, 0x03, 0xFC,
  0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x7F, 0x01,
  0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0xFF, 0x01, 0xFC, 0x07,
  0xF8, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0xFF,
  0x00, 0x7F, 0x7F, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x3F, 0x83,
  0xF8, 0x0F, 0xF0, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFE, 0x1F, 0xE0, 0x3F,
  0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0,
  0x7F, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F,
  0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F, 0xF1, 0xFE, 0x03, 0xFC,
  0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03,
  0xF8, 0x7F, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xC1, 0xFE, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x0F, 0xE3, 0xF8,
  0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x9F, 0xE0, 0x0F, 0xE7,
  0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F,
  0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x1F, 0xC0,
  0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0x7F, 0x81, 0xFE, 0x1F,
  0xE0, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x01, 0xFD, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x3F, 0x80,
  0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x07, 0xF8, 0x07, 0xF0,
  0x7F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0,
  0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF,
  0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE,
  0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFD, 0xFF, 0xE0, 0x3F,
  0xDF, 0xFC, 0x03, 0xF8, 0xFF, 0x80, 0x3F, 0x80, 0x80, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE1, 0xFC, 0x0F, 0xFE, 0x3F, 0x03, 0xFF,
  0xEF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0,
  0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x07, 0xF0, 0xFE, 0x00,
  0xFE, 0x1F, 0xC0, 0x1F, 0xC7, 0xF8, 0x07, 0xF8, 0xFE, 0x00, 0xFE, 0x1F,
  0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x1F,
  0xE1, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x0F, 0xE1, 0xFE,
  0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xF0, 0x7F, 0x01, 0xFE,
  0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xDF, 0xC0,
  0x00, 0x83, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x40, 0x7F, 0x3F, 0x07, 0xF7,
  0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF,
  0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0xE3, 0xFC, 0x1F,
  0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0xC3, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x07,
  0xF0, 0xFC, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xE1,
  0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x01, 0x00, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1,
  0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F,
  0xE3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0,
  0x1F, 0xC3, 0xF8, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x00, 0xFE, 0x1F,
  0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xF8, 0x7F, 0x01, 0xFE,
  0x3F, 0xC0, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01,
  0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0x00, 0x0C, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0x7F, 0x01,
  0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x07,
  0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F,
  0xE0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x3F,
  0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x03,
  0xE0, 0x1F, 0xFF, 0x01, 0xF8, 0x0F, 0xEF, 0xC0, 0x7E, 0x03, 0xFB, 0xF0,
  0x3F, 0x80, 0xFE, 0xFC, 0x0F, 0xE0, 0x7F, 0x3F, 0x03, 0xFC, 0x1F, 0xCF,
  0xC1, 0xFF, 0x0F, 0xE3, 0xF0, 0x7F, 0xC3, 0xF8, 0xFC, 0x3F, 0xF0, 0xFE,
  0x3F, 0x0F, 0xFC, 0x7F, 0x0F, 0xC3, 0xFF, 0x1F, 0xC3, 0xF1, 0xFF, 0xC7,
  0xE0, 0xFC, 0x7D, 0xF3, 0xF8, 0x3F, 0x3F, 0x7C, 0xFE, 0x0F, 0xCF, 0xDF,
  0x3F, 0x03, 0xF7, 0xE7, 0xDF, 0xC0, 0xFD, 0xF9, 0xF7, 0xF0, 0x3F, 0x7C,
  0x7D, 0xF8, 0x0F, 0xFF, 0x1F, 0xFE, 0x03, 0xFF, 0xC7, 0xFF, 0x00, 0xFF,
  0xE1, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x03,
  0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x3F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x03, 0xF8, 0x3F,
  0xC0, 0x1F, 0xC3, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF9, 0xFE, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0x3F,
  0x80, 0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x80,
  0x7F, 0x81, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x03, 0xFE,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x81, 0xFE,
  0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x0F,
  0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0x80,
  0x1F, 0xC3, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF1, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F, 0x3F,
  0x80, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0,
  0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0x00, 0x40, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x40, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0x0F, 0xFC, 0x03, 0xF1,
  0xFF, 0xE0, 0x3F, 0x3F, 0xFF, 0x03, 0xE3, 0xFF, 0xF8, 0x7E, 0x7F, 0x3F,
  0xCF, 0xE7, 0xE1, 0xFF, 0xFC, 0x7E, 0x0F, 0xFF, 0xC7, 0xC0, 0x7F, 0xF8,
  0xFC, 0x03, 0xFF, 0x8F, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_SemiBoldItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 15, 43, 15, 1, -42 },
  { 82, 17, 15, 18, 4, -44 },
  { 114, 30, 42, 30, 1, -42 },
  { 272, 26, 56, 29, 2, -49 },
  { 454, 28, 44, 36, 5, -43 },
  { 608, 29, 44, 33, 1, -43 },
  { 768, 8, 15, 9, 4, -44 },
  { 783, 18, 60, 18, 3, -47 },
  { 918, 19, 60, 18, -3, -47 },
  { 1061, 24, 25, 26, 3, -42 },
  { 1136, 24, 30, 28, 2, -34 },
  { 1226, 11, 17, 13, -3, -7 },
  { 1250, 15, 6, 19, 2, -21 },
  { 1262, 9, 9, 16, 1, -8 },
  { 1273, 27, 46, 20, -4, -42 },
  { 1429, 25, 44, 29, 3, -43 },
  { 1567, 17, 42, 29, 7, -42 },
  { 1657, 28, 43, 29, 0, -43 },
  { 1808, 27, 44, 29, 1, -43 },
  { 1957, 26, 42, 29, 1, -42 },
  { 2094, 27, 43, 29, 2, -42 },
  { 2240, 23, 43, 29, 3, -42 },
  { 2364, 27, 42, 29, 3, -42 },
  { 2506, 26, 44, 29, 2, -43 },
  { 2649, 23, 43, 29, 4, -43 },
  { 2773, 13, 33, 15, 1, -32 },
  { 2827, 16, 42, 14, -3, -32 },
  { 2911, 23, 27, 26, 1, -32 },
  { 2989, 25, 18, 28, 2, -28 },
  { 3046, 24, 28, 26, 1, -32 },
  { 3130, 22, 44, 25, 4, -43 },
  { 3251, 41, 54, 44, 1, -41 },
  { 3528, 32, 42, 34, -2, -42 },
  { 3696, 30, 42, 32, 1, -42 },
  { 3854, 31, 44, 33, 2, -43 },
  { 4025, 30, 42, 32, 1, -42 },
  { 4183, 30, 42, 28, 1, -42 },
  { 4341, 29, 42, 27, 1, -42 },
  { 4494, 31, 44, 34, 2, -43 },
  { 4665, 35, 42, 35, 1, -42 },
  { 4849, 15, 42, 15, 1, -42 },
  { 4928, 29, 43, 28, 0, -42 },
  { 5084, 35, 42, 32, 1, -42 },
  { 5268, 23, 42, 27, 1, -42 },
  { 5389, 43, 42, 43, 1, -42 },
  { 5615, 35, 42, 35, 1, -42 },
  { 5799, 31, 44, 35, 2, -43 },
  { 5970, 31, 42, 32, 1, -42 },
  { 6133, 31, 50, 35, 2, -43 },
  { 6327, 30, 42, 31, 1, -42 },
  { 6485, 30, 44, 31, 1, -43 },
  { 6650, 29, 42, 31, 5, -42 },
  { 6803, 32, 43, 33, 2, -42 },
  { 6975, 31, 42, 33, 5, -42 },
  { 7138, 41, 42, 43, 5, -42 },
  { 7354, 37, 42, 32, -2, -42 },
  { 7549, 30, 42, 31, 5, -42 },
  { 7707, 33, 42, 30, -1, -42 },
  { 7881, 20, 59, 15, -1, -49 },
  { 8029, 13, 46, 22, 5, -42 },
  { 8104, 19, 59, 15, -3, -49 },
  { 8245, 19, 21, 22, 2, -42 },
  { 8295, 22, 6, 23, -3, 0 },
  { 8312, 12, 9, 19, 6, -44 },
  { 8326, 24, 33, 27, 1, -32 },
  { 8425, 26, 45, 28, 0, -44 },
  { 8572, 24, 33, 26, 1, -32 },
  { 8671, 29, 45, 28, 1, -44 },
  { 8835, 25, 33, 27, 1, -32 },
  { 8939, 20, 45, 19, 2, -45 },
  { 9052, 28, 44, 29, 0, -32 },
  { 9206, 26, 44, 28, 0, -44 },
  { 9349, 15, 43, 14, 0, -43 },
  { 9430, 21, 55, 14, -6, -43 },
  { 9575, 29, 44, 27, 0, -44 },
  { 9735, 15, 44, 14, 0, -44 },
  { 9818, 40, 32, 43, 0, -32 },
  { 9978, 26, 32, 28, 0, -32 },
  { 10082, 26, 33, 29, 1, -32 },
  { 10190, 28, 44, 28, -2, -32 },
  { 10344, 27, 44, 28, 1, -32 },
  { 10493, 20, 32, 19, 0, -32 },
  { 10573, 25, 33, 26, 0, -32 },
  { 10677, 16, 40, 17, 2, -39 },
  { 10757, 26, 32, 28, 2, -31 },
  { 10861, 24, 31, 25, 3, -31 },
  { 10954, 34, 31, 36, 4, -31 },
  { 11086, 29, 31, 26, -2, -31 },
  { 11199, 29, 43, 25, -2, -31 },
  { 11355, 27, 31, 26, -1, -31 },
  { 11460, 19, 56, 17, 1, -46 },
  { 11593, 12, 50, 14, 1, -42 },
  { 11668, 18, 57, 17, -2, -46 },
  { 11797, 28, 13, 32, 2, -24 },
};

const GFXfont RobotoCondensed_SemiBoldItalic59pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic59pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic59pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC59PT7B_H_
