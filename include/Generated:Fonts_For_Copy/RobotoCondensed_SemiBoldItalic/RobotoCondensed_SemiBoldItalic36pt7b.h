#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC36PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0x83, 0xC1, 0xF0, 0xF0, 0x38, 0x00, 0x39, 0xC7, 0x38, 0xE7, 0x3C,
  0xE7, 0x1C, 0xE7, 0x1C, 0xE3, 0x1C, 0x63, 0x80, 0x00, 0x73, 0x80, 0x38,
  0xE0, 0x0E, 0x30, 0x03, 0x9C, 0x00, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0xE0,
  0x7F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xE0, 0x39, 0xC0, 0x1C, 0x70, 0x07,
  0x38, 0x01, 0xCE, 0x00, 0xE3, 0x80, 0x39, 0xC0, 0xFF, 0xFE, 0x3F, 0xFF,
  0x8F, 0xFF, 0xE0, 0x73, 0x80, 0x38, 0xE0, 0x0E, 0x30, 0x03, 0x9C, 0x00,
  0xC7, 0x00, 0x71, 0xC0, 0x1C, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x1F,
  0x1F, 0x1F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3C, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0x78, 0x7C, 0x7F,
  0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0E, 0x70, 0x4F, 0x1C, 0x77,
  0x0E, 0x73, 0x8E, 0x39, 0xC7, 0x38, 0xE3, 0xB8, 0x3F, 0xDC, 0x1F, 0xDC,
  0x07, 0xDC, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x78, 0x0E, 0xFE, 0x07,
  0x7F, 0x07, 0x71, 0xC7, 0x38, 0xE3, 0x9C, 0x73, 0x8E, 0x3B, 0x87, 0x1D,
  0xC3, 0x9C, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x01,
  0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x78, 0x78,
  0x3C, 0x78, 0x1F, 0x3C, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0xFE, 0x3C, 0xFF, 0x9E, 0xFF, 0xCF, 0xF9, 0xF7, 0xFC, 0xFF, 0xBC,
  0x3F, 0xDE, 0x0F, 0xCF, 0x07, 0xE7, 0xC3, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC,
  0x3F, 0xFF, 0x0F, 0xC7, 0x80, 0x39, 0xDE, 0xF7, 0x39, 0xCE, 0xE0, 0x00,
  0x40, 0x18, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07,
  0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0C,
  0x00, 0x80, 0x02, 0x00, 0x30, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x1E,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x06, 0x00, 0x40, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x06, 0x38, 0x5F, 0x77, 0xBF, 0xFF, 0x9F,
  0xFC, 0x07, 0x80, 0x1F, 0x80, 0x77, 0x01, 0xEF, 0x07, 0x8E, 0x0E, 0x1C,
  0x00, 0x10, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0xF0, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x3C, 0x78, 0xF3, 0xC7, 0x9E, 0x3C, 0xF0, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE3, 0xE3, 0xC7,
  0x87, 0xDF, 0x07, 0xBC, 0x0F, 0x78, 0x3E, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xEF, 0x83, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x3E, 0xF0, 0x7D, 0xE0, 0xF3,
  0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x9E, 0x1E, 0x3F, 0xFC, 0x3F, 0xF0, 0x7F,
  0xC0, 0x3E, 0x00, 0x00, 0x40, 0xF0, 0xFD, 0xFF, 0x7F, 0xFF, 0xFE, 0x7A,
  0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x00,
  0x00, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xF0, 0xF8, 0xF8,
  0x7C, 0x78, 0x3E, 0x3C, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xFF,
  0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x00, 0x01, 0xF0, 0x07, 0xFC,
  0x0F, 0xFE, 0x1F, 0xFE, 0x3E, 0x1E, 0x3E, 0x1F, 0x3C, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0,
  0x07, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0xF0, 0x3C,
  0xF0, 0x7C, 0xF8, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xDE, 0x01, 0xEF, 0x01, 0xE7, 0x81,
  0xE7, 0xC0, 0xF3, 0xE0, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x7F, 0xFF,
  0x3F, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x07, 0xFF, 0x83, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xC0,
  0xE1, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x9F, 0x07, 0x8F, 0x87, 0xC3, 0xC3, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x07, 0xE0, 0x00, 0x00, 0x78, 0x07, 0xE0, 0x7F, 0x83, 0xFE, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xEF, 0x87, 0xFF, 0x3F,
  0xFE, 0xFF, 0xFB, 0xE1, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF,
  0x07, 0xFC, 0x1E, 0xF0, 0x7B, 0xE3, 0xE7, 0xFF, 0x1F, 0xF8, 0x3F, 0xC0,
  0x7E, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE,
  0x0F, 0xFE, 0x1F, 0x1F, 0x1E, 0x1F, 0x1E, 0x1F, 0x1E, 0x1F, 0x1E, 0x1E,
  0x1E, 0x3E, 0x1F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF8, 0x7C, 0x78,
  0x78, 0x3C, 0x78, 0x3C, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C,
  0xF8, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0x80, 0x03, 0xE0,
  0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE3, 0xE3, 0xCF, 0x87, 0x9E, 0x0F, 0x3C,
  0x1E, 0x78, 0x3E, 0xF0, 0x7D, 0xE0, 0xF3, 0xC1, 0xE7, 0x87, 0xCF, 0xFF,
  0x9F, 0xFF, 0x1F, 0xFC, 0x1F, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0x7E, 0x00, 0xF0, 0x00, 0x1E,
  0x3E, 0x3F, 0x3E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0xF8, 0xF8, 0xF8, 0x70, 0x03, 0x81, 0xF0, 0x7C, 0x1F,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC1,
  0xE0, 0xF0, 0x08, 0x00, 0x00, 0x04, 0x00, 0x70, 0x0F, 0x80, 0xFE, 0x0F,
  0xF8, 0xFF, 0x8F, 0xF8, 0x3F, 0x00, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF0, 0x0F, 0x80, 0x0E, 0x00, 0x08, 0x7F, 0xFD, 0xFF, 0xF7,
  0xFF, 0xDF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0xFF, 0xFB,
  0xFF, 0xEF, 0xFF, 0x00, 0x10, 0x00, 0xE0, 0x03, 0xE0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0xFC, 0x1F, 0xE1, 0xFF, 0x1F,
  0xF0, 0xFE, 0x03, 0xE0, 0x0E, 0x00, 0x20, 0x00, 0x0F, 0x81, 0xFF, 0x1F,
  0xFC, 0xFF, 0xEF, 0x8F, 0x78, 0x7F, 0xC3, 0xE0, 0x1E, 0x01, 0xF0, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x1F, 0x00, 0x78,
  0x03, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFC,
  0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x0E, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x07,
  0x0E, 0x00, 0x07, 0x1C, 0x0F, 0x03, 0x3C, 0x3F, 0xC3, 0x38, 0x7F, 0xE3,
  0x38, 0x71, 0xC3, 0x70, 0xE1, 0xC3, 0x71, 0xE1, 0xC3, 0x71, 0xE3, 0xC3,
  0xE1, 0xC3, 0x87, 0xE3, 0xC3, 0x87, 0xE3, 0xC3, 0x87, 0xE3, 0xC7, 0x86,
  0xE3, 0x87, 0x0E, 0xE3, 0x87, 0x0E, 0xE3, 0xCF, 0x1C, 0xE3, 0xFF, 0xF8,
  0xE1, 0xFB, 0xF0, 0xE0, 0xE1, 0xE0, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x04, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07,
  0xBC, 0x00, 0xF7, 0x80, 0x3E, 0xF0, 0x07, 0x9E, 0x01, 0xF3, 0xC0, 0x3C,
  0x7C, 0x0F, 0x87, 0x81, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xF3, 0xE0, 0x3E, 0x78, 0x07, 0xDF, 0x00,
  0xFB, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3C, 0x07, 0xFE, 0x01, 0xFF,
  0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xF8, 0x3E, 0x1E, 0x07, 0xC3, 0xC0,
  0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xC3, 0xE0, 0xF8, 0x7C, 0xFE, 0x0F, 0xFF,
  0x81, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0x83, 0xE1, 0xF0, 0x3C, 0x3E, 0x07,
  0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x3E,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xF8, 0x7C, 0x3E, 0x07,
  0xC7, 0x80, 0xF9, 0xF0, 0x1F, 0x3C, 0x03, 0xE7, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0xC7, 0x81, 0xF0,
  0xF8, 0x3E, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0xFC, 0x00,
  0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xF8, 0x7C,
  0x1E, 0x07, 0x83, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C,
  0x7C, 0x0F, 0x8F, 0x01, 0xF1, 0xE0, 0x3E, 0x7C, 0x07, 0x8F, 0x80, 0xF1,
  0xF0, 0x1E, 0x3E, 0x07, 0xC7, 0x80, 0xF8, 0xF0, 0x1E, 0x3E, 0x07, 0xC7,
  0xC1, 0xF0, 0xF8, 0x7E, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x81, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F,
  0xFE, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE,
  0x1F, 0x0F, 0x8F, 0x81, 0xF3, 0xC0, 0x7D, 0xF0, 0x0F, 0x7C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x7F, 0xBE, 0x1F, 0xEF, 0x0F,
  0xFB, 0xC3, 0xFE, 0xF0, 0x0F, 0xBC, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x7C,
  0xF8, 0x1F, 0x3F, 0x0F, 0xC7, 0xFF, 0xF1, 0xFF, 0xF8, 0x3F, 0xF8, 0x03,
  0xF8, 0x00, 0x07, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0,
  0x1E, 0x0F, 0x80, 0x78, 0x3C, 0x03, 0xE0, 0xF0, 0x0F, 0x87, 0xC0, 0x3E,
  0x1F, 0x00, 0xF0, 0x7C, 0x03, 0xC1, 0xF0, 0x0F, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0x80, 0x78, 0x3E, 0x01,
  0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xC1,
  0xF0, 0x0F, 0x07, 0xC0, 0x7C, 0x1E, 0x01, 0xF0, 0x78, 0x07, 0xC3, 0xE0,
  0x1F, 0x00, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xC1, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x8F, 0x83, 0xC3, 0xE0, 0xF0, 0xF8, 0x7C, 0x1E, 0x3E, 0x07, 0xFF, 0x81,
  0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xE0, 0x00, 0x07, 0x80, 0xF8, 0x3E, 0x07,
  0xE0, 0xF8, 0x3F, 0x03, 0xE1, 0xF8, 0x0F, 0x87, 0xC0, 0x3C, 0x3E, 0x00,
  0xF1, 0xF8, 0x07, 0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0x7D, 0xF0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x3F, 0x7C, 0x00, 0xF8, 0xF0, 0x03, 0xC3, 0xE0, 0x1F,
  0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1E, 0x07,
  0xE0, 0x78, 0x0F, 0x83, 0xE0, 0x3E, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0xFF, 0xBF, 0xFE, 0x7F, 0xFD, 0xFF, 0xF8, 0x07, 0xE0, 0x07, 0xE1,
  0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01,
  0xFC, 0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F,
  0xE0, 0x7F, 0x83, 0xDE, 0x0F, 0xF0, 0x7B, 0xC3, 0xDE, 0x0F, 0x78, 0x7B,
  0xC1, 0xEF, 0x1E, 0xF8, 0x7D, 0xE3, 0xDF, 0x0F, 0x9C, 0x73, 0xC1, 0xF3,
  0x9E, 0x78, 0x3C, 0x73, 0x8F, 0x07, 0x8E, 0xF3, 0xE0, 0xF1, 0xDE, 0x7C,
  0x3E, 0x3F, 0x8F, 0x87, 0xC7, 0xF1, 0xE0, 0xF8, 0xFC, 0x3C, 0x1F, 0x1F,
  0x8F, 0x83, 0xC1, 0xE1, 0xF0, 0x78, 0x3C, 0x3E, 0x1F, 0x07, 0x07, 0xC0,
  0x07, 0x80, 0x7C, 0x3F, 0x01, 0xF0, 0xFC, 0x07, 0x83, 0xF0, 0x1E, 0x0F,
  0xE0, 0x78, 0x3F, 0x83, 0xE0, 0xFE, 0x0F, 0x87, 0xF8, 0x3E, 0x1F, 0xF0,
  0xF0, 0x7F, 0xC3, 0xC1, 0xF7, 0x1F, 0x07, 0x9C, 0x7C, 0x1E, 0x79, 0xF0,
  0xF8, 0xE7, 0xC3, 0xE3, 0x9E, 0x0F, 0x8F, 0x78, 0x3E, 0x3F, 0xE0, 0xF0,
  0x7F, 0x83, 0xC1, 0xFE, 0x1F, 0x07, 0xF8, 0x7C, 0x1F, 0xC1, 0xF0, 0x3F,
  0x07, 0xC0, 0xFC, 0x1E, 0x03, 0xF0, 0x78, 0x07, 0xC3, 0xE0, 0x1F, 0x00,
  0x01, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0x0F, 0x8F,
  0x81, 0xF3, 0xC0, 0x7D, 0xF0, 0x0F, 0x7C, 0x03, 0xDE, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1E,
  0xF0, 0x07, 0xBC, 0x03, 0xEF, 0x00, 0xFB, 0xC0, 0x3C, 0xF8, 0x1F, 0x3F,
  0x0F, 0x87, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0x83, 0xE0,
  0xF0, 0x1E, 0x0F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1E,
  0x1F, 0x03, 0xE1, 0xE0, 0x3E, 0x1E, 0x07, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF,
  0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07,
  0xFF, 0xE0, 0xF8, 0x7C, 0x3E, 0x07, 0xC7, 0x80, 0xF9, 0xF0, 0x0F, 0x3C,
  0x01, 0xE7, 0x80, 0x3D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8,
  0x07, 0xDE, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0xF9, 0xE0,
  0x1E, 0x3C, 0x07, 0xC7, 0xC0, 0xF8, 0xFC, 0x3E, 0x0F, 0xFF, 0x81, 0xFF,
  0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x1C, 0x00, 0x01, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0xF8, 0x3E, 0x1E, 0x07, 0xC3, 0xC0, 0xF8, 0xF8,
  0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x0F, 0x07, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3E, 0x3C, 0x07, 0x87,
  0xC0, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x3E, 0x1F, 0x07,
  0xC3, 0xC0, 0xF8, 0x78, 0x0F, 0x1F, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xFF,
  0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0x0F, 0x87, 0xC1, 0xF3, 0xE0, 0x7C,
  0xF8, 0x1F, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xCF, 0x01, 0xF3, 0xC0, 0x7C, 0xF8, 0x1E, 0x3E, 0x0F, 0x87, 0xFF, 0xC1,
  0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF1, 0xF0, 0x1E, 0x1F,
  0x01, 0xE1, 0xF0, 0x3E, 0x1E, 0x03, 0xE1, 0xE0, 0x3E, 0x3E, 0x03, 0xE3,
  0xE0, 0x3C, 0x3E, 0x03, 0xC3, 0xE0, 0x7C, 0x3C, 0x07, 0xC3, 0xC0, 0x7C,
  0x7C, 0x07, 0xC7, 0xC0, 0x78, 0x7C, 0x07, 0x87, 0xC0, 0xF8, 0x78, 0x0F,
  0x87, 0x80, 0xF8, 0xF8, 0x0F, 0x0F, 0x80, 0xF0, 0x78, 0x1F, 0x07, 0xC3,
  0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0xF8,
  0x03, 0xFF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x07, 0xEF, 0x80, 0xF8, 0xF0,
  0x1F, 0x1E, 0x07, 0xC3, 0xC0, 0xF8, 0x78, 0x1E, 0x0F, 0x87, 0xC1, 0xF0,
  0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0x78, 0xF0, 0x0F, 0x3E, 0x01, 0xE7,
  0x80, 0x3D, 0xF0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x3C, 0x0F, 0xFC, 0x1E, 0x07, 0xBE, 0x0F, 0x83, 0xDF, 0x0F,
  0xC3, 0xEF, 0x87, 0xE1, 0xE7, 0xC3, 0xF0, 0xF3, 0xE3, 0xF8, 0xF9, 0xF1,
  0xFC, 0x78, 0xF8, 0xFE, 0x3C, 0x7C, 0xFF, 0x3E, 0x3E, 0x7F, 0x9E, 0x0F,
  0x3B, 0xCF, 0x07, 0xBD, 0xEF, 0x83, 0xDE, 0xF7, 0x81, 0xEE, 0x7B, 0xC0,
  0xFF, 0x3D, 0xE0, 0x7F, 0x9F, 0xF0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8,
  0x0F, 0xE1, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F,
  0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x81, 0xF0, 0x7C, 0x03, 0xC3,
  0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x7C, 0x00, 0x79, 0xE0, 0x01, 0xEF, 0x80,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0x78,
  0x00, 0x7D, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x8F, 0x00, 0x7C, 0x3E, 0x03,
  0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x7C, 0x07, 0xC3, 0xF0, 0x1F, 0x00, 0xF8,
  0x07, 0xFE, 0x03, 0xE7, 0x80, 0xF9, 0xE0, 0x7C, 0x7C, 0x1F, 0x1F, 0x0F,
  0x83, 0xC3, 0xC0, 0xF1, 0xF0, 0x3C, 0x78, 0x0F, 0x3E, 0x01, 0xEF, 0x00,
  0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xC0, 0x7C,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xF0, 0xF0, 0xF8,
  0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x0F, 0x0F,
  0x0F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x03, 0xC0, 0x3C, 0x07, 0xC0,
  0x7C, 0x0F, 0xE0, 0xEE, 0x1E, 0xE1, 0xCE, 0x3C, 0xE3, 0xCE, 0x78, 0xF7,
  0x8F, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0xF8, 0xF0,
  0xF1, 0xE1, 0xE0, 0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xF1, 0xE1,
  0xE7, 0xC3, 0xC0, 0x07, 0x83, 0xFF, 0x1F, 0xFE, 0x7F, 0xF9, 0xF8, 0xF3,
  0xE1, 0xE7, 0x83, 0xDF, 0x0F, 0x9E, 0x1F, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F,
  0xF0, 0x79, 0xF0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x78, 0x1F, 0xFE, 0x1F,
  0xFE, 0x1F, 0xFF, 0x1F, 0x1F, 0x3E, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C,
  0x0F, 0x3C, 0x1F, 0x3C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1E, 0x78, 0x1E, 0x7C,
  0x3E, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xF1, 0xE0, 0x03, 0xE0, 0x3F,
  0xE1, 0xFF, 0x8F, 0xFF, 0x7C, 0x3D, 0xE0, 0xF7, 0x83, 0xFE, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x7B, 0xC1, 0xEF, 0x8F, 0x9F,
  0xFC, 0x7F, 0xF0, 0xFF, 0x81, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x07, 0x9F, 0x0F, 0xEF, 0x8F, 0xFF, 0x87, 0xFF, 0xC7, 0xC3, 0xE3, 0xC1,
  0xF1, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3C, 0x7C, 0x1E, 0x3C, 0x0F, 0x1E,
  0x0F, 0x8F, 0x07, 0xC7, 0x83, 0xE3, 0xE3, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xBC, 0x0F, 0x9E, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF,
  0xE3, 0xC3, 0xCF, 0x87, 0x9E, 0x0F, 0xBC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xF7, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x0C, 0x3F, 0xFC, 0x7F,
  0xF8, 0x7F, 0xE0, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0,
  0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x7F, 0xE3, 0xFF, 0x1F, 0xF0, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E,
  0x00, 0x03, 0xE7, 0x87, 0xFB, 0xC7, 0xFF, 0xE3, 0xFF, 0xF3, 0xE1, 0xF1,
  0xF0, 0x78, 0xF0, 0x3C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x1E, 0x07,
  0x8F, 0x03, 0xC7, 0x83, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xFF, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFE, 0x03, 0xDF, 0x00, 0x0F, 0x80, 0x07, 0x83, 0x07, 0xC1,
  0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xC0, 0x00, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x1F, 0x78, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x3E, 0x1E, 0x3E,
  0x1F, 0x3E, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x7C, 0x3E, 0x7C,
  0x3E, 0x78, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0xF8, 0x7C, 0xF8,
  0x7C, 0xF0, 0x7C, 0x07, 0x07, 0xC3, 0xE1, 0xF0, 0x70, 0x00, 0x00, 0x00,
  0x1F, 0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F,
  0x07, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x3E, 0x00, 0x00, 0x70,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x81, 0xFC,
  0x1F, 0xC0, 0xFE, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x0F, 0x87, 0x87, 0xC1, 0xE3, 0xE0, 0x79, 0xF0, 0x1E, 0xFC, 0x0F,
  0xBE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x01, 0xFF, 0xC0, 0x7C, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x81, 0xE1, 0xE0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xC0, 0x07, 0x83, 0xC1, 0xE1, 0xF0,
  0xF8, 0x78, 0x3C, 0x1E, 0x1F, 0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1E, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C,
  0x3E, 0x00, 0x1E, 0x7C, 0x3C, 0x1F, 0xFE, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x1E, 0x1F, 0x0F, 0x3E, 0x1F, 0x0F, 0x3E, 0x1E, 0x0F, 0x3C,
  0x1E, 0x0F, 0x3C, 0x1E, 0x0F, 0x3C, 0x1E, 0x1F, 0x3C, 0x3E, 0x1F, 0x7C,
  0x3E, 0x1F, 0x7C, 0x3C, 0x1E, 0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x1E, 0x78,
  0x3C, 0x3E, 0x78, 0x7C, 0x3E, 0xF8, 0x7C, 0x3E, 0xF8, 0x78, 0x3C, 0x1E,
  0x78, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E,
  0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF0,
  0x7C, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE7, 0xC3, 0xEF, 0x87,
  0xDE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xDF, 0x0F, 0xBE, 0x1F, 0x3F, 0xFC, 0x7F, 0xF0, 0x7F, 0xC0, 0x3E,
  0x00, 0x0F, 0x3C, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xF0, 0xF0, 0xF8,
  0xF8, 0x3C, 0x7C, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x07, 0xC7, 0x83,
  0xE7, 0xC1, 0xF3, 0xE0, 0xF1, 0xE0, 0xF8, 0xF8, 0x7C, 0x7F, 0xFC, 0x7F,
  0xFE, 0x3F, 0xFE, 0x1F, 0x3C, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x07, 0x8F, 0x1F,
  0xFF, 0x3F, 0xFE, 0x3F, 0xFE, 0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3C, 0xF8, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0,
  0x78, 0xF8, 0x78, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x1E, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x1E, 0x71, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF3, 0xF0, 0x3E, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0,
  0xFF, 0xF3, 0xE3, 0xE7, 0x83, 0xCF, 0x80, 0x0F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x07, 0xDF, 0x0F, 0xBE, 0x1E, 0x3E, 0xFC,
  0x7F, 0xF0, 0x7F, 0xC0, 0x3F, 0x00, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1F,
  0x1F, 0xF7, 0xFF, 0xFF, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x7E, 0x1F, 0x83, 0xE0, 0x78,
  0x3E, 0x1F, 0x3C, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x7C, 0x1E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF8, 0x7C, 0xF8, 0x78, 0xF8, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8,
  0x3E, 0xF8, 0xF0, 0x7F, 0xC1, 0xFF, 0x87, 0xBE, 0x3E, 0xF8, 0xF1, 0xE3,
  0xC7, 0x9F, 0x1E, 0x78, 0x79, 0xE1, 0xEF, 0x07, 0xBC, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x00,
  0xF0, 0x70, 0x7F, 0x87, 0x87, 0xFC, 0x3C, 0x3D, 0xE3, 0xE1, 0xEF, 0x1F,
  0x1E, 0x78, 0xF8, 0xF3, 0xCF, 0xE7, 0x9E, 0x7F, 0x78, 0xF7, 0xFB, 0xC3,
  0xBB, 0xDC, 0x1D, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xE3, 0xF0, 0x3F, 0x1F,
  0x81, 0xF0, 0xFC, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xC1, 0xE0, 0x1E,
  0x0F, 0x00, 0x1F, 0x0F, 0x87, 0x87, 0x83, 0xC7, 0xC1, 0xF3, 0xC0, 0x7B,
  0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x79, 0xE0, 0x7C, 0xF0,
  0x7C, 0x7C, 0x3E, 0x3E, 0x3E, 0x0F, 0x00, 0x1F, 0x0F, 0x8F, 0x87, 0xC7,
  0xC3, 0xC3, 0xE3, 0xE1, 0xF1, 0xE0, 0x79, 0xF0, 0x3C, 0xF8, 0x1E, 0x78,
  0x0F, 0x7C, 0x07, 0xBC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xF8, 0xFF,
  0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x40, 0x3C, 0x0F, 0x81, 0xE0, 0x78,
  0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C,
  0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x01,
  0xE0, 0x1C, 0x01, 0x80, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x61, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x00, 0x04, 0x00, 0xE0, 0x3C,
  0x03, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x7C, 0x1F, 0x07, 0xC0,
  0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0,
  0x78, 0x1E, 0x07, 0x80, 0xE0, 0x18, 0x00, 0x0F, 0x00, 0x1F, 0xC1, 0xCF,
  0xF0, 0xEF, 0xFC, 0xF7, 0x9F, 0xF3, 0x87, 0xFB, 0xC1, 0xF8, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_SemiBoldItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 9, 26, 9, 1, -26 },
  { 31, 11, 9, 11, 2, -27 },
  { 44, 18, 26, 19, 1, -26 },
  { 103, 16, 33, 18, 1, -30 },
  { 169, 17, 26, 22, 3, -26 },
  { 225, 17, 26, 20, 1, -26 },
  { 281, 5, 9, 6, 2, -27 },
  { 287, 11, 37, 11, 2, -29 },
  { 338, 12, 37, 11, -2, -29 },
  { 394, 15, 15, 16, 2, -26 },
  { 423, 15, 18, 17, 1, -21 },
  { 457, 7, 10, 8, -2, -4 },
  { 466, 8, 4, 12, 2, -13 },
  { 470, 5, 5, 10, 1, -5 },
  { 474, 16, 28, 12, -2, -26 },
  { 530, 15, 26, 18, 2, -26 },
  { 579, 10, 26, 18, 4, -26 },
  { 612, 17, 26, 18, 0, -26 },
  { 668, 16, 26, 18, 1, -26 },
  { 720, 17, 26, 18, 0, -26 },
  { 776, 17, 26, 18, 1, -26 },
  { 832, 14, 26, 18, 2, -26 },
  { 878, 16, 26, 18, 2, -26 },
  { 930, 16, 26, 18, 1, -26 },
  { 982, 15, 26, 18, 2, -26 },
  { 1031, 8, 20, 9, 1, -20 },
  { 1051, 10, 26, 9, -2, -20 },
  { 1084, 14, 16, 16, 1, -19 },
  { 1112, 14, 11, 17, 2, -17 },
  { 1132, 14, 16, 16, 1, -19 },
  { 1160, 13, 26, 15, 3, -26 },
  { 1203, 24, 33, 27, 1, -25 },
  { 1302, 19, 26, 21, -1, -26 },
  { 1364, 19, 26, 19, 0, -26 },
  { 1426, 19, 26, 20, 1, -26 },
  { 1488, 19, 26, 20, 0, -26 },
  { 1550, 19, 26, 17, 0, -26 },
  { 1612, 18, 26, 17, 0, -26 },
  { 1671, 18, 26, 20, 2, -26 },
  { 1730, 22, 26, 22, 0, -26 },
  { 1802, 9, 26, 9, 1, -26 },
  { 1832, 18, 26, 17, 0, -26 },
  { 1891, 22, 26, 19, 0, -26 },
  { 1963, 15, 26, 17, 0, -26 },
  { 2012, 27, 26, 26, 0, -26 },
  { 2100, 22, 26, 21, 0, -26 },
  { 2172, 18, 26, 21, 2, -26 },
  { 2231, 20, 26, 20, 0, -26 },
  { 2296, 19, 31, 21, 1, -26 },
  { 2370, 19, 26, 19, 0, -26 },
  { 2432, 18, 26, 19, 1, -26 },
  { 2491, 18, 26, 19, 3, -26 },
  { 2550, 20, 26, 20, 1, -26 },
  { 2615, 19, 26, 20, 3, -26 },
  { 2677, 25, 26, 26, 3, -26 },
  { 2759, 22, 26, 19, -1, -26 },
  { 2831, 18, 26, 19, 3, -26 },
  { 2890, 20, 26, 18, 0, -26 },
  { 2955, 12, 36, 9, -1, -30 },
  { 3009, 8, 28, 13, 3, -26 },
  { 3037, 12, 36, 9, -2, -30 },
  { 3091, 12, 13, 13, 1, -26 },
  { 3111, 14, 4, 14, -2, 0 },
  { 3118, 7, 5, 11, 4, -27 },
  { 3123, 15, 19, 17, 0, -19 },
  { 3159, 16, 27, 17, 0, -27 },
  { 3213, 14, 19, 16, 1, -19 },
  { 3247, 17, 27, 17, 1, -27 },
  { 3305, 15, 19, 17, 1, -19 },
  { 3341, 13, 27, 11, 1, -27 },
  { 3385, 17, 26, 17, 0, -19 },
  { 3441, 16, 27, 17, 0, -27 },
  { 3495, 9, 27, 9, 0, -27 },
  { 3526, 13, 34, 8, -4, -27 },
  { 3582, 18, 27, 16, 0, -27 },
  { 3643, 9, 27, 9, 0, -27 },
  { 3674, 24, 19, 26, 0, -19 },
  { 3731, 16, 19, 17, 0, -19 },
  { 3769, 15, 19, 17, 1, -19 },
  { 3805, 17, 26, 17, -1, -19 },
  { 3861, 16, 26, 17, 1, -19 },
  { 3913, 12, 19, 11, 0, -19 },
  { 3942, 15, 19, 16, 0, -19 },
  { 3978, 10, 24, 11, 1, -24 },
  { 4008, 16, 19, 17, 1, -19 },
  { 4046, 14, 19, 16, 2, -19 },
  { 4080, 21, 19, 22, 2, -19 },
  { 4130, 17, 19, 16, -1, -19 },
  { 4171, 17, 26, 15, -1, -19 },
  { 4227, 16, 19, 16, 0, -19 },
  { 4265, 11, 34, 10, 1, -28 },
  { 4312, 7, 31, 9, 1, -26 },
  { 4340, 11, 34, 10, -1, -28 },
  { 4387, 17, 8, 20, 1, -15 },
};

const GFXfont RobotoCondensed_SemiBoldItalic36pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic36pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic36pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC36PT7B_H_
