#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC29PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x38, 0x71, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0x71, 0xE3, 0x87,
  0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x87, 0x0E, 0x00, 0x77, 0x77, 0x67, 0x66,
  0xE6, 0xE6, 0xCE, 0xCE, 0x01, 0x9C, 0x06, 0x60, 0x39, 0x80, 0xCE, 0x03,
  0x30, 0x1C, 0xC3, 0xFF, 0xCF, 0xFF, 0x0E, 0x60, 0x33, 0x80, 0xCC, 0x07,
  0x30, 0x19, 0xC3, 0xFF, 0xCF, 0xFF, 0x0E, 0xE0, 0x33, 0x80, 0xCC, 0x07,
  0x30, 0x19, 0xC0, 0x66, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x0F, 0x80,
  0xFE, 0x0F, 0xF8, 0x79, 0xC7, 0x8F, 0x3C, 0x79, 0xC3, 0xCF, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xE7, 0x87, 0x3C, 0x39,
  0xE3, 0xCF, 0x1E, 0x3F, 0xE0, 0xFE, 0x03, 0xE0, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x3C, 0x03, 0xE0, 0x3B, 0x81, 0x8C, 0x6C, 0x67, 0x63, 0x33, 0x3B,
  0x19, 0xF8, 0xFF, 0x83, 0xD8, 0x01, 0xC0, 0x1D, 0xC0, 0xDF, 0x0F, 0xDC,
  0xEC, 0x66, 0x63, 0x63, 0x1F, 0x19, 0xD0, 0xCC, 0x07, 0xE0, 0x1E, 0x00,
  0x07, 0xC0, 0x3F, 0x81, 0xFE, 0x07, 0x3C, 0x1C, 0x70, 0x71, 0xC1, 0xCE,
  0x07, 0x78, 0x1F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0xC7, 0x7F, 0xBB, 0xCE,
  0xEE, 0x3F, 0xB8, 0x7C, 0xE1, 0xF3, 0xC7, 0x8F, 0xFF, 0x1F, 0xFC, 0x3E,
  0x78, 0x77, 0x66, 0xEE, 0xEC, 0x00, 0x80, 0xC0, 0xE0, 0xE0, 0xE0, 0x70,
  0x70, 0x38, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x0C, 0x07,
  0x01, 0x80, 0x40, 0x08, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x0C, 0x06,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x81,
  0xC1, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x1C, 0x0C, 0x04,
  0x00, 0x03, 0x80, 0x30, 0x03, 0x06, 0x31, 0x7B, 0xF7, 0xFF, 0x0F, 0x80,
  0xF0, 0x1F, 0x83, 0x98, 0x71, 0xC2, 0x08, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x70, 0x07, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0E, 0x00,
  0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x00, 0x1C, 0x71, 0xCE, 0x39, 0xE7, 0x18,
  0x7F, 0xFF, 0xF8, 0xEF, 0xFE, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x7F, 0x07, 0xFC,
  0x78, 0xE3, 0x87, 0x1C, 0x39, 0xE1, 0xEF, 0x0E, 0x78, 0x73, 0x83, 0x9C,
  0x1C, 0xE1, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0x9E, 0x1C, 0xF1, 0xE3, 0x8E,
  0x1F, 0xF0, 0x7F, 0x01, 0xE0, 0x00, 0x01, 0x87, 0x8F, 0xCF, 0xEF, 0xF6,
  0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38,
  0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x80, 0x03, 0xE0, 0x1F, 0xC0, 0xFF, 0x87,
  0x9E, 0x1C, 0x3C, 0xF0, 0xF3, 0xC3, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xF0, 0x0F, 0xFF, 0x3F, 0xFC, 0xFF, 0xF0, 0x03, 0xE0, 0x3F, 0xC0, 0xFF,
  0x87, 0x9E, 0x1C, 0x38, 0xF0, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x1F,
  0xC0, 0x7C, 0x01, 0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x1C, 0x1C, 0x70,
  0xF1, 0xE7, 0xC7, 0xFE, 0x0F, 0xF0, 0x1F, 0x00, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x77, 0x01, 0xDC, 0x0E, 0xF0,
  0x7B, 0xC1, 0xCF, 0x0E, 0x3C, 0x78, 0xE1, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0xF8, 0xFF,
  0xC7, 0xFE, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0xF0, 0x3F, 0xE3,
  0xFF, 0x0E, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xDC, 0x1C, 0xF1,
  0xE7, 0x8F, 0x1F, 0xF0, 0x7F, 0x01, 0xF0, 0x00, 0x00, 0xE0, 0x3E, 0x0F,
  0xE0, 0xF8, 0x1E, 0x03, 0xC0, 0x38, 0x03, 0xBC, 0x7F, 0xE7, 0xFE, 0x78,
  0xF7, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0E, 0x70, 0xE7, 0x1E, 0x7F,
  0xC3, 0xF8, 0x1F, 0x00, 0x3F, 0xFC, 0xFF, 0xF7, 0xFF, 0x80, 0x1E, 0x00,
  0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x7F, 0x07, 0xFC, 0x78, 0xE3,
  0xC7, 0x9E, 0x3C, 0xE1, 0xC7, 0x0E, 0x3C, 0xF0, 0xFF, 0x07, 0xF0, 0x7F,
  0x87, 0x9E, 0x78, 0x73, 0xC3, 0x9C, 0x1C, 0xF1, 0xE7, 0x8F, 0x3F, 0xF0,
  0xFF, 0x01, 0xF0, 0x00, 0x0F, 0x83, 0xF8, 0xFF, 0x3C, 0xF7, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0xC7, 0xBF, 0xF7, 0xFC, 0x7B, 0x80,
  0xF0, 0x1C, 0x07, 0x83, 0xE1, 0xF8, 0x3E, 0x07, 0x00, 0x38, 0xF3, 0xCE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0xCF, 0x38, 0x0E, 0x1F, 0x1F,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x38,
  0x38, 0x38, 0x70, 0x70, 0xE0, 0x40, 0x00, 0x20, 0x1C, 0x0F, 0x87, 0xE3,
  0xF9, 0xFC, 0x3E, 0x07, 0x80, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xC0, 0x38,
  0x01, 0x00, 0x3F, 0xF3, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xEF, 0xFE, 0xFF, 0xE0, 0x20, 0x07, 0x00, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xC0, 0x78, 0x1F, 0x0F, 0xEF, 0xF3, 0xF8, 0x7C, 0x0E, 0x01, 0x00, 0x00,
  0x1F, 0x07, 0xF1, 0xFF, 0x3C, 0xEF, 0x1F, 0xE3, 0xC0, 0x70, 0x1E, 0x07,
  0x81, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x01, 0xE0, 0x3C, 0x07, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xC3,
  0xC0, 0xF0, 0x0C, 0x0E, 0x00, 0xE1, 0xC0, 0x06, 0x38, 0x78, 0x63, 0x0F,
  0xE6, 0x71, 0xCE, 0x66, 0x38, 0xC6, 0x63, 0x8C, 0x6E, 0x71, 0xC6, 0xE7,
  0x1C, 0x6C, 0x71, 0x86, 0xC7, 0x18, 0x6C, 0x63, 0x8C, 0xC6, 0x38, 0xCC,
  0x77, 0x98, 0xC7, 0xDF, 0x8C, 0x39, 0xE0, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xC6, 0x00, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xDC, 0x01, 0xDC,
  0x03, 0xDC, 0x03, 0x9C, 0x07, 0x9C, 0x07, 0x1C, 0x0F, 0x1E, 0x0E, 0x1E,
  0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0x3C, 0x0E, 0x78, 0x0E, 0x78, 0x0E,
  0x70, 0x0F, 0xF0, 0x0F, 0x0F, 0xF0, 0x1F, 0xF8, 0x7F, 0xF0, 0xF0, 0xF1,
  0xE1, 0xE3, 0xC3, 0xC7, 0x07, 0x8E, 0x0F, 0x3C, 0x3C, 0x7F, 0xF0, 0xFF,
  0xC1, 0xFF, 0xC3, 0x83, 0xC7, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x3C,
  0xF0, 0xF1, 0xFF, 0xE7, 0xFF, 0x8F, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xF0,
  0x3F, 0xF0, 0xF1, 0xE3, 0xC1, 0xE7, 0x03, 0xDE, 0x07, 0xBC, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x0F,
  0x78, 0x1C, 0x70, 0x78, 0xF1, 0xE1, 0xFF, 0xC1, 0xFF, 0x00, 0xF8, 0x00,
  0x0F, 0xE0, 0x1F, 0xF0, 0x7F, 0xF0, 0xF1, 0xE1, 0xE1, 0xE3, 0xC3, 0xC7,
  0x03, 0x8E, 0x07, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0x81,
  0xE7, 0x03, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x78, 0xF1, 0xF1, 0xFF, 0xC7,
  0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0xF8, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x00, 0x0F, 0xFE, 0x1F, 0xFC,
  0x7F, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0x80, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF1, 0xF3, 0xC1, 0xE7, 0x83, 0xDE,
  0x07, 0xBC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC3, 0xF3, 0x8F, 0xEF, 0x1F,
  0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0x70, 0x38, 0xF1, 0xF1, 0xFF, 0xE1,
  0xFF, 0x80, 0xFC, 0x00, 0x0E, 0x03, 0xC3, 0x80, 0xE1, 0xE0, 0x38, 0x78,
  0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xC0, 0x78, 0x70, 0x1C, 0x3C, 0x07,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x38, 0x0F, 0x0E, 0x03, 0x87,
  0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x01, 0xE3, 0xC0,
  0x70, 0xF0, 0x3C, 0x00, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C,
  0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x78, 0x78, 0x78, 0x70,
  0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x3C, 0x3C, 0xF1, 0xE3, 0xE7, 0x87, 0xFC, 0x1F, 0xE0,
  0x1F, 0x00, 0x0E, 0x07, 0x83, 0x83, 0xC1, 0xE1, 0xF0, 0x78, 0xF8, 0x1E,
  0x3C, 0x07, 0x9E, 0x01, 0xCF, 0x00, 0x77, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0x78, 0x07, 0x8F, 0x01,
  0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x1E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x3C, 0x00, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x7F, 0xFF, 0xFE, 0xFF, 0xE0, 0x0F, 0x80,
  0x7C, 0x3E, 0x03, 0xE1, 0xF8, 0x0F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8,
  0x7E, 0x0F, 0xE1, 0xF8, 0x3F, 0x87, 0xE0, 0xFC, 0x3F, 0x87, 0x70, 0xF6,
  0x1D, 0xC3, 0xDC, 0xEF, 0x0E, 0x73, 0xBC, 0x39, 0xDC, 0xF0, 0xE7, 0x73,
  0x87, 0x9D, 0x9E, 0x1E, 0x7E, 0x78, 0x79, 0xF9, 0xE1, 0xE3, 0xC7, 0x87,
  0x0F, 0x1E, 0x3C, 0x38, 0x70, 0xF0, 0xE3, 0xC0, 0x0F, 0x03, 0xC3, 0xC0,
  0xE1, 0xF0, 0x38, 0x7C, 0x1E, 0x1F, 0x87, 0x87, 0xE1, 0xE1, 0xF8, 0x78,
  0x77, 0x1C, 0x3D, 0xCF, 0x0F, 0x73, 0xC3, 0xCC, 0xF0, 0xF3, 0xBC, 0x38,
  0xEF, 0x0E, 0x3B, 0x87, 0x87, 0xE1, 0xE1, 0xF8, 0x78, 0x7E, 0x1E, 0x1F,
  0x87, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x00, 0x03, 0xF0, 0x0F, 0xF0,
  0x3F, 0xF0, 0xF9, 0xF3, 0xC1, 0xE7, 0x83, 0xDE, 0x03, 0xBC, 0x07, 0x78,
  0x1E, 0xF0, 0x3D, 0xC0, 0x7B, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xBC, 0x0F,
  0x78, 0x1E, 0x70, 0x78, 0xF1, 0xF1, 0xFF, 0xC1, 0xFF, 0x00, 0xF8, 0x00,
  0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x1E, 0x1E, 0x1E, 0x0F, 0x1E, 0x0F,
  0x1C, 0x0F, 0x1C, 0x0F, 0x3C, 0x1E, 0x3C, 0x3E, 0x3F, 0xFC, 0x3F, 0xF8,
  0x3F, 0xF0, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0,
  0xF1, 0xF3, 0xC1, 0xE7, 0x83, 0xDE, 0x03, 0xBC, 0x07, 0x78, 0x1E, 0xE0,
  0x3D, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xBC, 0x0F, 0x78, 0x1E,
  0x70, 0x78, 0xF1, 0xF1, 0xFF, 0xC1, 0xFF, 0x00, 0xFE, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x38, 0x00, 0x20, 0x0F, 0xF0, 0x1F, 0xF8, 0x7F, 0xF8, 0xF0,
  0xF1, 0xE1, 0xE3, 0xC1, 0xC7, 0x03, 0x8E, 0x0F, 0x3C, 0x1E, 0x78, 0x78,
  0xFF, 0xF1, 0xFF, 0x83, 0xFE, 0x07, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78,
  0x70, 0xF0, 0xF1, 0xC1, 0xE3, 0x83, 0xCF, 0x07, 0x80, 0x03, 0xE0, 0x3F,
  0xE1, 0xFF, 0x8F, 0x9F, 0x3C, 0x3C, 0xE0, 0xF3, 0x80, 0x0F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xCE, 0x07, 0x38,
  0x1C, 0xF0, 0xF3, 0xC7, 0xC7, 0xFE, 0x0F, 0xF0, 0x1F, 0x00, 0x7F, 0xFC,
  0xFF, 0xFB, 0xFF, 0xF0, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x1C, 0x0F, 0x3C, 0x0E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E,
  0x38, 0x1E, 0x38, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C,
  0x70, 0x3C, 0x70, 0x3C, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78,
  0xF8, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0xF0, 0x1F, 0xF0, 0x1E,
  0x70, 0x1E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x78, 0xF0, 0x78, 0xF0, 0x39, 0xE0, 0x39, 0xE0, 0x39, 0xC0, 0x3B, 0xC0,
  0x3B, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0xE0, 0xE0, 0xFC, 0x3C, 0x3F, 0x87, 0x87, 0xF0, 0xF0, 0xEE,
  0x3E, 0x3D, 0xC7, 0xC7, 0xB8, 0xF8, 0xE7, 0x3F, 0x3C, 0xE7, 0xE7, 0x9C,
  0xEC, 0xE3, 0xB9, 0x9C, 0x77, 0x37, 0x8E, 0xE6, 0xE1, 0xF8, 0xDC, 0x3F,
  0x1F, 0x87, 0xE3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xE0, 0x78,
  0x3C, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0xC3, 0xC1, 0xE0, 0xF0, 0xF0, 0x1E,
  0x3C, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x3B, 0xC0, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0xF7, 0x80, 0x3D, 0xE0, 0x1E, 0x38, 0x0F, 0x8F, 0x03, 0xC3, 0xC1, 0xE0,
  0xF0, 0xF8, 0x3E, 0x00, 0x70, 0x1E, 0xF0, 0x79, 0xE0, 0xF3, 0xC3, 0xC3,
  0x87, 0x07, 0x1E, 0x0E, 0x38, 0x1E, 0xF0, 0x3D, 0xC0, 0x3F, 0x80, 0x7E,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x1F, 0xFF, 0x1F, 0xFF,
  0x1F, 0xFE, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xFF, 0xF8, 0xFF, 0xF8,
  0xFF, 0xF8, 0x0F, 0x87, 0xC3, 0xE3, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C,
  0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x3E, 0x1F, 0x0F, 0x80, 0x70,
  0xE1, 0xC3, 0x87, 0x0F, 0x1E, 0x3C, 0x38, 0x70, 0xE1, 0xC3, 0xC7, 0x8F,
  0x0E, 0x1C, 0x38, 0x70, 0xF1, 0xE3, 0xC7, 0x80, 0x07, 0xC1, 0xF0, 0xFC,
  0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x70, 0x1C, 0x07, 0x07, 0xC1, 0xF0, 0xFC, 0x00, 0x07, 0x07, 0x83,
  0xC3, 0xE1, 0xF1, 0xDC, 0xEE, 0xE7, 0x71, 0xF0, 0xC0, 0x7F, 0xE7, 0xFE,
  0xFF, 0xE0, 0xF1, 0xE3, 0x87, 0x07, 0xC0, 0xFE, 0x1F, 0xF3, 0xCF, 0x38,
  0x70, 0x0F, 0x0F, 0xF3, 0xFF, 0x7C, 0xF7, 0x8E, 0xF0, 0xEF, 0x1E, 0xF1,
  0xE7, 0xFE, 0x7F, 0xE3, 0xDE, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0E, 0x00, 0x77, 0x83, 0xFE, 0x3F, 0xF9, 0xE3, 0xCF, 0x1E, 0x70,
  0xF3, 0x87, 0x9C, 0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0x73, 0x87, 0x9E, 0x3D,
  0xFF, 0xCF, 0xFE, 0x73, 0xC0, 0x0F, 0x83, 0xF8, 0xFF, 0xBC, 0x77, 0x0F,
  0xE1, 0xFC, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0xEF, 0x3D, 0xFF,
  0x9F, 0xE1, 0xF0, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78,
  0x01, 0xE1, 0xE7, 0x8F, 0xDC, 0x7F, 0xF1, 0xE3, 0xC7, 0x0F, 0x3C, 0x3C,
  0xF0, 0xF3, 0x83, 0x8E, 0x0E, 0x38, 0x78, 0xE1, 0xE3, 0x87, 0x8F, 0x3E,
  0x3F, 0xF0, 0x7F, 0xC0, 0xF7, 0x00, 0x0F, 0x81, 0xFC, 0x3F, 0xE7, 0x8E,
  0x70, 0xEF, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xEE, 0x00, 0xE0, 0x0F, 0x00,
  0xF1, 0xC7, 0xFC, 0x7F, 0xC1, 0xF0, 0x03, 0xC3, 0xF0, 0xFC, 0x78, 0x1E,
  0x07, 0x07, 0xF1, 0xFC, 0xFF, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07,
  0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x07, 0xBC,
  0x7F, 0xF1, 0xFF, 0x8F, 0x1E, 0x38, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x1E,
  0x70, 0x71, 0xC1, 0xC7, 0x0F, 0x1C, 0x3C, 0x78, 0xF1, 0xFF, 0xC3, 0xFE,
  0x07, 0xB8, 0x01, 0xE0, 0x07, 0x84, 0x3C, 0x3F, 0xF0, 0xFF, 0x80, 0xF8,
  0x00, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x77,
  0x87, 0xFE, 0x3F, 0xF1, 0xE3, 0x8F, 0x1E, 0x70, 0xF3, 0x87, 0x3C, 0x39,
  0xE3, 0xCF, 0x1E, 0x70, 0xF3, 0x87, 0x9C, 0x39, 0xE1, 0xCF, 0x0E, 0x78,
  0xF0, 0x0E, 0x3C, 0x78, 0x70, 0x00, 0x07, 0x0E, 0x3C, 0x78, 0xF1, 0xE3,
  0x87, 0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0x8F, 0x1E, 0x00, 0x01, 0xC0, 0xF0,
  0x3C, 0x07, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07,
  0x81, 0xE0, 0x70, 0x3C, 0x3F, 0x0F, 0x83, 0xC0, 0x0E, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC7, 0xC7, 0x1E, 0x3C, 0xF0,
  0xF7, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7B, 0xC1, 0xCF, 0x07, 0x1C, 0x3C, 0x78, 0xF1, 0xE3, 0xC3, 0xC0, 0x0E,
  0x0E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x38,
  0x38, 0x38, 0x78, 0x78, 0x78, 0x70, 0x70, 0xF0, 0xF0, 0x1D, 0xE3, 0xC3,
  0xFF, 0x7E, 0x3F, 0xFF, 0xE3, 0xC7, 0x8F, 0x3C, 0x78, 0xF3, 0x87, 0x0F,
  0x38, 0x70, 0xE7, 0x87, 0x0E, 0x78, 0xF0, 0xE7, 0x8F, 0x1E, 0x78, 0xF1,
  0xE7, 0x0F, 0x1E, 0x70, 0xE1, 0xEF, 0x0E, 0x1C, 0xF1, 0xE1, 0xCF, 0x1E,
  0x3C, 0x1D, 0xE1, 0xFF, 0x8F, 0xFC, 0x78, 0xE3, 0x87, 0x9C, 0x3C, 0xE1,
  0xCF, 0x0E, 0x78, 0xF3, 0xC7, 0x9C, 0x3C, 0xE1, 0xE7, 0x0E, 0x78, 0x73,
  0xC3, 0x9E, 0x3C, 0x0F, 0x81, 0xFC, 0x3F, 0xE7, 0x8F, 0x70, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xEF, 0x1E, 0xF1, 0xE7, 0xFC,
  0x7F, 0x83, 0xF0, 0x0E, 0xF0, 0x7F, 0xE1, 0xFF, 0x87, 0x8F, 0x1C, 0x3C,
  0x70, 0xF1, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0x83, 0x8E, 0x1E,
  0x3C, 0x79, 0xFF, 0xC7, 0xFE, 0x1E, 0xF0, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1F, 0x79, 0xFB, 0x9F, 0xFC, 0xF1,
  0xE7, 0x0F, 0x78, 0x7B, 0xC3, 0xDC, 0x1C, 0xE0, 0xE7, 0x0F, 0x38, 0x79,
  0xC3, 0xCF, 0x3E, 0x7F, 0xE1, 0xFF, 0x07, 0xF8, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1D, 0xCF, 0xF3, 0xF8, 0xFE, 0x3C,
  0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F,
  0x03, 0xC0, 0x07, 0xC1, 0xFE, 0x3F, 0xF3, 0xCF, 0x38, 0x73, 0x80, 0x3E,
  0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xEF, 0x0E, 0xF1, 0xE7, 0xFC, 0x7F,
  0xC1, 0xF0, 0x1C, 0x1C, 0x1C, 0xFF, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x78,
  0x78, 0x78, 0x70, 0x70, 0x70, 0xF0, 0x7C, 0x7C, 0x3C, 0x38, 0x73, 0xC3,
  0x9E, 0x1C, 0xF1, 0xE7, 0x0F, 0x38, 0x79, 0xC3, 0x9E, 0x1C, 0xF0, 0xE7,
  0x8F, 0x3C, 0x79, 0xC3, 0xCF, 0x3C, 0x7F, 0xE1, 0xFF, 0x07, 0xB8, 0xE1,
  0xFC, 0x3F, 0x8F, 0x71, 0xEE, 0x39, 0xCF, 0x39, 0xC7, 0xB8, 0xFF, 0x0F,
  0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xE1, 0x87, 0x71,
  0xC3, 0xB8, 0xF3, 0xDC, 0xF9, 0xCE, 0x7C, 0xE7, 0x3E, 0xF3, 0xBF, 0x71,
  0xDF, 0xB8, 0xFD, 0xF8, 0x7E, 0xFC, 0x3E, 0x7E, 0x1F, 0x3E, 0x0F, 0x8F,
  0x07, 0x87, 0x83, 0xC3, 0x81, 0xC1, 0xC0, 0x1E, 0x3C, 0x79, 0xE0, 0xE7,
  0x83, 0xBC, 0x0E, 0xF0, 0x3F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F,
  0x01, 0xFC, 0x07, 0xF0, 0x3D, 0xE0, 0xE3, 0x87, 0x8E, 0x3C, 0x3C, 0x1C,
  0x3C, 0x70, 0xF1, 0xC7, 0x87, 0x1E, 0x1C, 0x70, 0x73, 0xC1, 0xEE, 0x07,
  0xF8, 0x1F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x3F, 0x00, 0xF8, 0x03,
  0xC0, 0x00, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x7F,
  0xE3, 0xFF, 0x1F, 0xF8, 0x01, 0x03, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x0F, 0x87, 0x03, 0x80, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3C, 0x0E, 0x02, 0x00,
  0x0E, 0x18, 0x30, 0x60, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x87,
  0x0C, 0x18, 0x30, 0x61, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0x60, 0x08, 0x07,
  0x03, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xE0,
  0x78, 0x1C, 0x3E, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xC0, 0xE0,
  0x70, 0x78, 0x78, 0x38, 0x18, 0x00, 0x1C, 0x1D, 0xFC, 0x77, 0xF3, 0xBD,
  0xFE, 0xE3, 0xF0, 0x03, 0x80,
};

const GFXglyph RobotoCondensed_SemiBoldItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 21, 7, 1, -21 },
  { 20, 8, 8, 9, 2, -22 },
  { 28, 14, 21, 15, 1, -21 },
  { 65, 13, 27, 14, 1, -24 },
  { 109, 13, 21, 18, 3, -21 },
  { 144, 14, 21, 16, 1, -21 },
  { 181, 4, 8, 5, 2, -22 },
  { 185, 9, 30, 9, 1, -23 },
  { 219, 9, 30, 9, -1, -23 },
  { 253, 12, 12, 13, 1, -21 },
  { 271, 12, 15, 14, 1, -17 },
  { 294, 6, 8, 7, -2, -3 },
  { 300, 7, 3, 9, 1, -10 },
  { 303, 4, 4, 8, 1, -4 },
  { 305, 13, 23, 10, -2, -21 },
  { 343, 13, 21, 14, 1, -21 },
  { 378, 9, 21, 14, 3, -21 },
  { 402, 14, 21, 14, 0, -21 },
  { 439, 14, 21, 14, 0, -21 },
  { 476, 14, 21, 14, 0, -21 },
  { 513, 13, 21, 14, 1, -21 },
  { 548, 12, 21, 14, 1, -21 },
  { 580, 14, 21, 14, 1, -21 },
  { 617, 13, 21, 14, 1, -21 },
  { 652, 11, 21, 14, 2, -21 },
  { 681, 6, 16, 8, 1, -16 },
  { 693, 8, 21, 7, -1, -16 },
  { 714, 11, 14, 13, 1, -16 },
  { 734, 12, 9, 14, 1, -14 },
  { 748, 11, 14, 13, 1, -16 },
  { 768, 11, 21, 12, 2, -21 },
  { 797, 20, 26, 22, 1, -20 },
  { 862, 16, 21, 17, -1, -21 },
  { 904, 15, 21, 16, 0, -21 },
  { 944, 15, 21, 16, 1, -21 },
  { 984, 15, 21, 16, 0, -21 },
  { 1024, 15, 21, 14, 0, -21 },
  { 1064, 15, 21, 13, 0, -21 },
  { 1104, 15, 21, 17, 1, -21 },
  { 1144, 18, 21, 17, 0, -21 },
  { 1192, 8, 21, 7, 0, -21 },
  { 1213, 14, 21, 14, 0, -21 },
  { 1250, 18, 21, 16, 0, -21 },
  { 1298, 12, 21, 13, 0, -21 },
  { 1330, 22, 21, 21, 0, -21 },
  { 1388, 18, 21, 17, 0, -21 },
  { 1436, 15, 21, 17, 1, -21 },
  { 1476, 16, 21, 16, 0, -21 },
  { 1518, 15, 25, 17, 1, -21 },
  { 1565, 15, 21, 15, 0, -21 },
  { 1605, 14, 21, 15, 1, -21 },
  { 1642, 15, 21, 15, 2, -21 },
  { 1682, 16, 21, 16, 1, -21 },
  { 1724, 16, 21, 16, 2, -21 },
  { 1766, 19, 21, 21, 3, -21 },
  { 1816, 18, 21, 16, -1, -21 },
  { 1864, 15, 21, 15, 2, -21 },
  { 1904, 16, 21, 15, 0, -21 },
  { 1946, 9, 29, 7, 0, -24 },
  { 1979, 7, 23, 11, 2, -21 },
  { 2000, 10, 29, 7, -2, -24 },
  { 2037, 9, 10, 11, 1, -21 },
  { 2049, 12, 3, 11, -2, 0 },
  { 2054, 6, 4, 9, 3, -21 },
  { 2057, 12, 16, 13, 0, -16 },
  { 2081, 13, 22, 14, 0, -22 },
  { 2117, 11, 16, 13, 1, -16 },
  { 2139, 14, 22, 14, 1, -22 },
  { 2178, 12, 16, 13, 1, -16 },
  { 2202, 10, 22, 9, 1, -22 },
  { 2230, 14, 22, 14, 0, -16 },
  { 2269, 13, 22, 14, 0, -22 },
  { 2305, 7, 22, 7, 0, -22 },
  { 2325, 10, 28, 7, -3, -22 },
  { 2360, 14, 22, 13, 0, -22 },
  { 2399, 8, 22, 7, 0, -22 },
  { 2421, 20, 16, 21, 0, -16 },
  { 2461, 13, 16, 14, 0, -16 },
  { 2487, 12, 16, 14, 1, -16 },
  { 2511, 14, 22, 14, -1, -16 },
  { 2550, 13, 22, 14, 1, -16 },
  { 2586, 10, 16, 9, 0, -16 },
  { 2606, 12, 16, 13, 0, -16 },
  { 2630, 8, 19, 9, 1, -19 },
  { 2649, 13, 16, 14, 1, -16 },
  { 2675, 11, 16, 12, 2, -16 },
  { 2697, 17, 16, 18, 2, -16 },
  { 2731, 14, 16, 13, -1, -16 },
  { 2759, 14, 22, 12, -1, -16 },
  { 2798, 13, 16, 13, 0, -16 },
  { 2824, 9, 28, 8, 1, -23 },
  { 2856, 7, 25, 7, 0, -21 },
  { 2878, 9, 28, 8, -1, -23 },
  { 2910, 14, 6, 16, 1, -11 },
};

const GFXfont RobotoCondensed_SemiBoldItalic29pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic29pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic29pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC29PT7B_H_
