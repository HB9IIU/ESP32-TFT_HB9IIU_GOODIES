#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC39PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0x83, 0xC1, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0xF8, 0x7C, 0x3E, 0x0E, 0x00, 0x79, 0xCF, 0x39,
  0xC7, 0x39, 0xE7, 0x3D, 0xE7, 0x38, 0xE7, 0x1C, 0xE3, 0x9C, 0x60, 0x00,
  0x39, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x39, 0xE0, 0x0F, 0x38, 0x01,
  0xC7, 0x00, 0x38, 0xE0, 0x0F, 0x38, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F,
  0xFF, 0x81, 0xC7, 0x00, 0x38, 0xE0, 0x0F, 0x3C, 0x01, 0xC7, 0x00, 0x38,
  0xE0, 0x07, 0x3C, 0x1F, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x81, 0xC7,
  0x00, 0x38, 0xE0, 0x07, 0x3C, 0x01, 0xE7, 0x00, 0x38, 0xE0, 0x07, 0x1C,
  0x01, 0xE7, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE,
  0x0F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0x78, 0x7C, 0x1E, 0x1F, 0x07, 0x87,
  0xC0, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF3, 0xE0, 0x7C,
  0xF8, 0x1F, 0x3E, 0x07, 0x87, 0x83, 0xE1, 0xF1, 0xF8, 0x7F, 0xFC, 0x0F,
  0xFE, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x3C, 0xE0,
  0x87, 0x1E, 0x1C, 0xE3, 0xC7, 0x1C, 0x79, 0xE7, 0x8E, 0x78, 0x71, 0xCE,
  0x0E, 0x7B, 0x81, 0xFE, 0xF0, 0x1F, 0xDC, 0x01, 0xE7, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x78, 0x03, 0xFF, 0x80, 0xF7, 0xF8, 0x1D, 0xE7,
  0x07, 0x38, 0xF1, 0xE7, 0x1E, 0x38, 0xE3, 0xCE, 0x3C, 0x73, 0xC3, 0x8E,
  0x30, 0x73, 0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0xF8, 0xF0, 0x1F, 0x1E,
  0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x1F, 0x01, 0xE7, 0xC0, 0x3F, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x79, 0xFF, 0x9F,
  0x7F, 0xF3, 0xCF, 0x9F, 0x7B, 0xE3, 0xFF, 0x7C, 0x3F, 0xCF, 0x87, 0xF9,
  0xF0, 0x7E, 0x3E, 0x0F, 0xC7, 0xE3, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x07, 0xE3, 0xE0, 0x7B, 0xDC, 0xEF, 0x7B, 0xDC, 0xE7, 0x00,
  0x00, 0x20, 0x06, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0,
  0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x30, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1E,
  0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8,
  0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x60, 0x04, 0x00,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x41, 0xC0, 0x71, 0xC7,
  0x7D, 0xFF, 0xFF, 0xFF, 0x1F, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x1E, 0xE0,
  0x1E, 0xE0, 0x3C, 0xF0, 0x78, 0x78, 0x30, 0x70, 0x00, 0x20, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xEF,
  0xFF, 0xF0, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x3E,
  0x3C, 0x3C, 0x7C, 0xF8, 0xF0, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x23,
  0xEF, 0xBE, 0xF9, 0xC0, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xFC,
  0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x1F, 0x3E, 0x1F, 0x3C, 0x0F, 0x3C, 0x0F,
  0x7C, 0x0F, 0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF0, 0x3E, 0xF0, 0x3E,
  0xF0, 0x3C, 0xF0, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0,
  0x3F, 0xE0, 0x1F, 0x80, 0x00, 0x30, 0x1E, 0x07, 0xE3, 0xFE, 0x7F, 0xE7,
  0xFE, 0x7B, 0xEE, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0x0F, 0xCF, 0xC3, 0xE1, 0xF1,
  0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF,
  0xFC, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE1, 0xF9, 0xF8,
  0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xCF, 0x01, 0xE7, 0xC1, 0xF3,
  0xE0, 0xF9, 0xF8, 0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xFC, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7B, 0xE0,
  0x3C, 0xF0, 0x0F, 0x7C, 0x07, 0x9F, 0x03, 0xE7, 0xC0, 0xF1, 0xF0, 0x78,
  0x7C, 0x3E, 0x1E, 0x0F, 0x0F, 0x87, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF,
  0xBF, 0xFF, 0xE0, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F,
  0xFF, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xBE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0x8F, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0xF8, 0x1F, 0x3E, 0x0F, 0x87, 0x83, 0xE1, 0xF1, 0xF8, 0x7F, 0xFC,
  0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x01, 0xF8, 0x0F,
  0xF0, 0x3F, 0xE0, 0xFE, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0x7B, 0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0x07,
  0xFE, 0x1F, 0x7E, 0x7E, 0x7F, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0x7C, 0x00,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFE, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF0,
  0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x87,
  0xC7, 0xC3, 0xE1, 0xE3, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F,
  0xF8, 0x3E, 0x3E, 0x3E, 0x0F, 0x1E, 0x07, 0x9F, 0x03, 0xCF, 0x81, 0xE7,
  0xC1, 0xF3, 0xE0, 0xF8, 0xF8, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xFC,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE7, 0xE7,
  0xCF, 0x87, 0x9E, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x0F, 0xBE, 0x3F, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F,
  0xF8, 0x7D, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x0F, 0xE0,
  0x7F, 0xC0, 0xFE, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x04, 0x1F, 0x1F, 0x1F,
  0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0xF8, 0xF8, 0xF8, 0xF8, 0x70, 0x00, 0x00, 0x78, 0x1F, 0x83, 0xF0,
  0x3E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C,
  0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0,
  0xFE, 0x01, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00,
  0xFE, 0x00, 0x78, 0x00, 0x70, 0x00, 0x20, 0x3F, 0xFF, 0x7F, 0xFE, 0x7F,
  0xFE, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x10, 0x00, 0x38, 0x00, 0x78,
  0x01, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x3E,
  0x00, 0xFC, 0x0F, 0xF8, 0x7F, 0xE3, 0xFF, 0x0F, 0xF0, 0x3F, 0x80, 0x7C,
  0x00, 0xE0, 0x01, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE,
  0x7C, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x07,
  0x80, 0x07, 0x01, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x0E, 0x07, 0xC1,
  0xC3, 0xC3, 0xFE, 0x38, 0x70, 0xFF, 0xC3, 0x1E, 0x1E, 0x38, 0x73, 0x87,
  0x8F, 0x0E, 0xF1, 0xE1, 0xE1, 0xDE, 0x3C, 0x38, 0x33, 0x87, 0x07, 0x0E,
  0x71, 0xE1, 0xE1, 0xDE, 0x3C, 0x3C, 0x3B, 0xC7, 0x87, 0x07, 0x70, 0xF0,
  0xE0, 0xEE, 0x1C, 0x3C, 0x39, 0xC3, 0x87, 0x87, 0x38, 0x71, 0xF1, 0xC7,
  0x0F, 0x3E, 0x38, 0xE1, 0xFD, 0xFE, 0x1C, 0x1F, 0xBF, 0x83, 0x83, 0xC3,
  0xE0, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x07, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3D, 0xE0, 0x01, 0xF7, 0x80,
  0x07, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x07, 0xC7, 0xC0, 0x1F,
  0x0F, 0x00, 0xF8, 0x3C, 0x03, 0xE0, 0xF0, 0x1F, 0x03, 0xC0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xF0, 0x0F, 0x87,
  0xC0, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00,
  0x1F, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F,
  0x83, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0,
  0xF8, 0x1F, 0x1F, 0x03, 0xF1, 0xF0, 0x7E, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x1F, 0xFF, 0x03, 0xFF, 0xFC, 0x3E, 0x07, 0xC3, 0xE0, 0x3C, 0x3E, 0x03,
  0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC1,
  0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0xC7, 0xE1,
  0xF0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x1E, 0x7C, 0x01, 0xE7, 0xC0, 0x1F,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xCF, 0x80,
  0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x07, 0xC3, 0xF0, 0x7F,
  0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xF8, 0x7E, 0x07, 0xC0,
  0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x80, 0xF0, 0x7C, 0x07, 0x87,
  0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07,
  0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C,
  0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x3E, 0x0F, 0x87, 0xF0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF,
  0x03, 0xFF, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF,
  0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xC7, 0xE1, 0xF0, 0x3E, 0x3E, 0x01,
  0xE3, 0xE0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x83, 0xFE, 0xF8, 0x7F, 0xEF, 0x87, 0xFC, 0xF8,
  0x7F, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF,
  0x80, 0xFC, 0xFC, 0x0F, 0x87, 0xE3, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF0,
  0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1E, 0x07,
  0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x1F,
  0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E,
  0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C,
  0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x7C,
  0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x8F, 0x81, 0xF1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xE3, 0xE0, 0x7F, 0xFC,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x7E, 0x07,
  0xC0, 0xFC, 0x07, 0xC1, 0xFC, 0x07, 0xC1, 0xF8, 0x0F, 0x83, 0xF0, 0x0F,
  0x87, 0xE0, 0x0F, 0x8F, 0xC0, 0x0F, 0x8F, 0xC0, 0x0F, 0x9F, 0x80, 0x0F,
  0xBF, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xBE, 0x00, 0x3F, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7C,
  0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0x7C,
  0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFE, 0xFF, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1,
  0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x07, 0xF8,
  0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x1F,
  0xF0, 0x7F, 0x81, 0xFF, 0x87, 0xDE, 0x0F, 0x78, 0x3E, 0xF0, 0x7F, 0xC1,
  0xF7, 0x87, 0xBE, 0x0F, 0xBC, 0x3D, 0xF0, 0x79, 0xE3, 0xCF, 0x87, 0xCF,
  0x1E, 0x78, 0x3E, 0x79, 0xE7, 0xC1, 0xF3, 0xCF, 0x3E, 0x0F, 0x8E, 0xF9,
  0xF0, 0x7C, 0x77, 0x8F, 0x83, 0xE3, 0xBC, 0x7C, 0x3E, 0x1F, 0xC7, 0xC1,
  0xF0, 0xFE, 0x3E, 0x0F, 0x87, 0xE1, 0xF0, 0x7C, 0x3F, 0x0F, 0x83, 0xE1,
  0xF0, 0x7C, 0x1F, 0x07, 0x83, 0xE1, 0xF0, 0x38, 0x3E, 0x00, 0x07, 0xC0,
  0x1F, 0x07, 0xC0, 0x3E, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x0F, 0xE0,
  0x3E, 0x0F, 0xF0, 0x3E, 0x0F, 0xF0, 0x3E, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0,
  0x7C, 0x0F, 0xF8, 0x7C, 0x1F, 0x78, 0x7C, 0x1F, 0x78, 0x7C, 0x1F, 0x3C,
  0x7C, 0x1F, 0x3C, 0xF8, 0x1F, 0x3C, 0xF8, 0x3F, 0x1C, 0xF8, 0x3E, 0x1E,
  0xF8, 0x3E, 0x1E, 0xF8, 0x3E, 0x1E, 0xF8, 0x3E, 0x0F, 0xF0, 0x3E, 0x0F,
  0xF0, 0x7C, 0x0F, 0xF0, 0x7C, 0x07, 0xF0, 0x7C, 0x07, 0xF0, 0x7C, 0x07,
  0xE0, 0x7C, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x00, 0xFE,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xC7, 0xE1, 0xF0,
  0x3E, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C,
  0x01, 0xF7, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7C,
  0xF8, 0x07, 0xCF, 0x80, 0xF8, 0xFC, 0x0F, 0x87, 0xE3, 0xF0, 0x7F, 0xFF,
  0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x3F,
  0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xF8, 0x1F, 0x87, 0xC0, 0x7C,
  0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC7, 0xC0,
  0x3E, 0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x0F, 0x83, 0xF8, 0x7F, 0xFF, 0x87,
  0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xC7, 0xE1, 0xF0,
  0x3E, 0x3E, 0x01, 0xE3, 0xE0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C,
  0x01, 0xF7, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xCF, 0x80, 0x7C,
  0xF8, 0x07, 0xCF, 0x80, 0xF8, 0xFC, 0x1F, 0x87, 0xE3, 0xF0, 0x7F, 0xFF,
  0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xF8, 0x3F, 0x07, 0xC0,
  0xF8, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF0, 0x7C, 0x0F, 0x87,
  0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xF0, 0x7E, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C,
  0x3E, 0x03, 0xE1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0,
  0x7C, 0x0F, 0x83, 0xE0, 0x7E, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xFC, 0x7E, 0x3F,
  0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x7C, 0x07, 0xCF, 0x80,
  0xF9, 0xF0, 0x1F, 0x3E, 0x07, 0xE3, 0xF1, 0xF8, 0x7F, 0xFF, 0x07, 0xFF,
  0xC0, 0x7F, 0xE0, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1,
  0xF0, 0x0F, 0x8F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x3E, 0x01,
  0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F,
  0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x3E,
  0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xF0,
  0x3E, 0x0F, 0xC7, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xBF, 0x00, 0xFC, 0xF8,
  0x07, 0xC7, 0xC0, 0x7E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x81, 0xF8,
  0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0x78, 0x3E, 0x03, 0xC3,
  0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01,
  0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x3D, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x1E, 0x07, 0xFC, 0x0F, 0x81, 0xFF,
  0x03, 0xE0, 0xFB, 0xC0, 0xF8, 0x3E, 0xF0, 0x7E, 0x0F, 0xBC, 0x1F, 0x83,
  0xCF, 0x0F, 0xE1, 0xF3, 0xC3, 0xF8, 0x7C, 0xF0, 0xFE, 0x1E, 0x3C, 0x7F,
  0x8F, 0x8F, 0x1F, 0xE3, 0xE3, 0xC7, 0xF8, 0xF0, 0xF3, 0xFE, 0x7C, 0x3C,
  0xF3, 0x9F, 0x0F, 0x3C, 0xE7, 0x83, 0xDE, 0x3B, 0xE0, 0xF7, 0x8E, 0xF8,
  0x3D, 0xE3, 0xBC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F,
  0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x00, 0xFC,
  0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0x3E, 0x00,
  0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0xFC,
  0x03, 0xE1, 0xF8, 0x03, 0xE1, 0xF0, 0x01, 0xF3, 0xF0, 0x01, 0xF3, 0xE0,
  0x01, 0xF7, 0xE0, 0x00, 0xF7, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xEF, 0x00, 0x07, 0xEF, 0x80,
  0x07, 0xCF, 0x80, 0x0F, 0x8F, 0x80, 0x1F, 0x87, 0xC0, 0x1F, 0x07, 0xC0,
  0x3F, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0xFC, 0x03, 0xE0,
  0xFC, 0x03, 0xF7, 0xC0, 0x3E, 0x7C, 0x07, 0xE7, 0xC0, 0x7C, 0x7C, 0x0F,
  0x83, 0xC1, 0xF8, 0x3E, 0x1F, 0x03, 0xE3, 0xF0, 0x3E, 0x3E, 0x01, 0xE7,
  0xC0, 0x1E, 0x7C, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3C, 0x01,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x7F, 0x00, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x1E,
  0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0,
  0x7E, 0x03, 0xF8, 0x3D, 0xC1, 0xCE, 0x1E, 0x70, 0xE3, 0x8F, 0x1C, 0x70,
  0xF7, 0x87, 0xBC, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xE0,
  0xF8, 0x7C, 0x3C, 0x3E, 0x1E, 0x0F, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFE,
  0x1F, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x03, 0xFF,
  0x0F, 0xFF, 0x3F, 0xFF, 0x3F, 0x1E, 0x7C, 0x1E, 0x7C, 0x3E, 0x7C, 0x3E,
  0x78, 0x3E, 0x7C, 0x7E, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xBC, 0x1F, 0x3E,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x3C, 0x0F, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xF1, 0xF8, 0xF8, 0xF8, 0x7C, 0x78, 0x1E, 0x7C, 0x0F, 0x3E, 0x07,
  0x9F, 0x07, 0xCF, 0x83, 0xE7, 0x81, 0xF3, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0,
  0x3C, 0xF8, 0x3E, 0x7E, 0x3F, 0x3F, 0xFF, 0x3F, 0xFF, 0x9F, 0x7F, 0x8F,
  0x9F, 0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFE, 0x3E, 0x3E,
  0x7C, 0x1E, 0x7C, 0x1F, 0x78, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x3C, 0xF8, 0x7C, 0xFC, 0x7C,
  0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x07, 0xCF, 0x81, 0xFD, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF,
  0xC3, 0xE3, 0xF8, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xC0, 0xF8, 0xF8, 0x1F,
  0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C,
  0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xFC, 0x7C, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x1F, 0xFE, 0x01, 0xF7, 0xC0, 0x03, 0xF0, 0x07, 0xFC, 0x1F, 0xFE, 0x1F,
  0xFE, 0x3E, 0x1F, 0x3C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x08, 0x7C, 0x38, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0x00,
  0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x7F, 0xF1, 0xFF, 0xC7, 0xFE, 0x1F, 0xF8, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF8, 0x00, 0x03, 0xE3, 0xC0, 0xFF, 0x78, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1,
  0xF8, 0xFC, 0x7C, 0x0F, 0x8F, 0x81, 0xE1, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F,
  0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF0, 0xF8, 0x3E, 0x1F,
  0x07, 0xC3, 0xE0, 0xF8, 0x7E, 0x3F, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0xFB, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x70,
  0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x3C, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF,
  0xF1, 0xF9, 0xF8, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F,
  0x07, 0xCF, 0x83, 0xC7, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C,
  0xF8, 0x3E, 0x7C, 0x1E, 0x3C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83,
  0xE0, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x83, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0,
  0xF8, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x03,
  0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x07, 0xE3, 0xE1, 0xF8, 0x7C, 0x7E, 0x0F, 0x9F, 0x81,
  0xF7, 0xE0, 0x3E, 0xF8, 0x07, 0xBE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0xFD, 0xF0, 0x1F,
  0x1E, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x0F, 0x83, 0xE0, 0xF8, 0x7C,
  0x1F, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xE0, 0xF8, 0x00, 0x0F, 0x3E, 0x1F, 0x07, 0xFF, 0xCF, 0xE1,
  0xFF, 0xF7, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0x9F, 0xC7, 0xC7, 0xC3, 0xE1,
  0xF1, 0xE0, 0xF8, 0x3C, 0xF8, 0x3E, 0x0F, 0x3E, 0x0F, 0x87, 0xCF, 0x83,
  0xC1, 0xF3, 0xE1, 0xF0, 0x7C, 0xF0, 0x7C, 0x1F, 0x3C, 0x1F, 0x07, 0xDF,
  0x07, 0xC1, 0xE7, 0xC1, 0xF0, 0xF9, 0xF0, 0x78, 0x3E, 0x7C, 0x3E, 0x0F,
  0x9E, 0x0F, 0x83, 0xEF, 0x83, 0xE0, 0xFB, 0xE0, 0xF8, 0x3C, 0xF8, 0x3E,
  0x1F, 0x00, 0x1F, 0x3E, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xF1, 0xF9,
  0xF8, 0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF,
  0x83, 0xC7, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E,
  0x7C, 0x1E, 0x3C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE0, 0x03,
  0xF0, 0x03, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xF3, 0xF3, 0xF0, 0xF9,
  0xF0, 0x3C, 0xF8, 0x1E, 0xF8, 0x0F, 0x7C, 0x07, 0xBE, 0x07, 0xDF, 0x03,
  0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x79, 0xF0, 0x7C, 0x7C, 0x7C, 0x3F,
  0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0x9E, 0x03, 0xFF,
  0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xC7, 0xC3, 0xE1, 0xF0, 0xF0, 0x3C,
  0x7C, 0x0F, 0x1F, 0x03, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x78, 0x1F, 0x3E,
  0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x78, 0xF8, 0x3E, 0x3F, 0x1F, 0x8F, 0xFF,
  0xC7, 0xFF, 0xF1, 0xF7, 0xF8, 0x7C, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC7, 0x87, 0xF3, 0xC7, 0xFF, 0xE7, 0xFF, 0xF3, 0xE3,
  0xFB, 0xE0, 0xF9, 0xF0, 0x7C, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE,
  0x07, 0xDF, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C,
  0xFC, 0x7C, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xF7, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x78, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF,
  0x8F, 0xC0, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x1F,
  0x1F, 0x3E, 0x1F, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0xF8, 0x3E, 0xF8, 0x3E, 0x78,
  0x7C, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xC0, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF0, 0xFF, 0xDF, 0xFB, 0xFF, 0xFF, 0xC3, 0xE0, 0x78,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0xC3, 0xF8, 0x3F, 0x03, 0xE0, 0x3E, 0x0F, 0x9F,
  0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF1, 0xE0, 0xF9, 0xF0, 0x7C,
  0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0x8F, 0x07, 0xCF, 0x83,
  0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0xFC, 0xFC, 0xFC, 0x3F, 0xFE, 0x1F,
  0xFF, 0x0F, 0xFF, 0x81, 0xF7, 0xC0, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E,
  0xF8, 0x7C, 0x78, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0x78, 0xF8, 0x78, 0xF0,
  0x79, 0xF0, 0x79, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0xF8, 0x38, 0x3F, 0xF0, 0xF0, 0x7B, 0xE1, 0xE1, 0xF7, 0xC7, 0xE3, 0xE7,
  0x8F, 0xC7, 0x8F, 0x1F, 0x9F, 0x1E, 0x7F, 0x3E, 0x3C, 0xFE, 0x78, 0x7B,
  0xFD, 0xF0, 0xF7, 0xFB, 0xC1, 0xEE, 0xF7, 0x83, 0xFC, 0xFF, 0x07, 0xF9,
  0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F,
  0x80, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0x81, 0xE0,
  0x00, 0x0F, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x3E, 0x07, 0xCF, 0xC0, 0x79,
  0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFF,
  0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x07, 0xC7, 0x81, 0xF8, 0xF8, 0x3E, 0x1F,
  0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xE3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x87,
  0xC0, 0xF0, 0xF8, 0x1E, 0x3E, 0x03, 0xC7, 0xC0, 0x78, 0xF8, 0x0F, 0x3E,
  0x01, 0xE7, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xE0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC0, 0x00, 0x20, 0x0F,
  0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x03, 0xE0, 0xFE, 0x0F, 0x80,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x04, 0x00, 0x07, 0x07, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07,
  0xC0, 0x3C, 0x03, 0xF0, 0x1E, 0x01, 0xE0, 0x7E, 0x0F, 0x80, 0xF8, 0x0F,
  0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E,
  0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xF0, 0x0E, 0x00, 0x80, 0x00, 0x1F, 0x00,
  0x0F, 0xE0, 0xF7, 0xFC, 0x3F, 0xFF, 0x9E, 0xFB, 0xFF, 0xBC, 0x7F, 0xCE,
  0x0F, 0xF0, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_SemiBoldItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 28, 10, 1, -28 },
  { 33, 11, 10, 12, 3, -29 },
  { 47, 19, 28, 20, 1, -28 },
  { 114, 18, 36, 19, 1, -32 },
  { 195, 19, 28, 24, 3, -28 },
  { 262, 19, 28, 22, 1, -28 },
  { 329, 5, 10, 6, 3, -29 },
  { 336, 12, 40, 12, 2, -31 },
  { 396, 12, 40, 12, -2, -31 },
  { 456, 16, 17, 17, 2, -28 },
  { 490, 17, 21, 18, 1, -24 },
  { 535, 8, 11, 9, -2, -5 },
  { 546, 9, 4, 13, 2, -14 },
  { 551, 6, 6, 11, 1, -6 },
  { 556, 17, 30, 13, -2, -28 },
  { 620, 16, 28, 19, 2, -28 },
  { 676, 12, 28, 19, 4, -28 },
  { 718, 18, 28, 19, 0, -28 },
  { 781, 17, 28, 19, 1, -28 },
  { 841, 18, 28, 19, 0, -28 },
  { 904, 18, 28, 19, 1, -28 },
  { 967, 15, 28, 19, 2, -28 },
  { 1020, 18, 28, 19, 2, -28 },
  { 1083, 17, 28, 19, 1, -28 },
  { 1143, 15, 28, 19, 3, -28 },
  { 1196, 8, 22, 10, 1, -22 },
  { 1218, 11, 28, 9, -2, -22 },
  { 1257, 15, 18, 17, 1, -21 },
  { 1291, 16, 12, 19, 2, -19 },
  { 1315, 15, 18, 17, 1, -21 },
  { 1349, 14, 28, 17, 3, -28 },
  { 1398, 27, 36, 29, 1, -27 },
  { 1520, 22, 28, 22, -2, -28 },
  { 1597, 20, 28, 21, 0, -28 },
  { 1667, 20, 28, 22, 2, -28 },
  { 1737, 21, 28, 21, 0, -28 },
  { 1811, 20, 28, 19, 0, -28 },
  { 1881, 20, 28, 18, 0, -28 },
  { 1951, 20, 28, 22, 2, -28 },
  { 2021, 24, 28, 23, 0, -28 },
  { 2105, 9, 28, 10, 1, -28 },
  { 2137, 19, 28, 18, 0, -28 },
  { 2204, 24, 28, 21, 0, -28 },
  { 2288, 16, 28, 18, 0, -28 },
  { 2344, 29, 28, 29, 0, -28 },
  { 2446, 24, 28, 23, 0, -28 },
  { 2530, 20, 28, 23, 2, -28 },
  { 2600, 21, 28, 21, 0, -28 },
  { 2674, 20, 33, 23, 2, -28 },
  { 2757, 21, 28, 21, 0, -28 },
  { 2831, 19, 28, 20, 1, -28 },
  { 2898, 19, 28, 20, 3, -28 },
  { 2965, 21, 28, 22, 1, -28 },
  { 3039, 21, 28, 22, 3, -28 },
  { 3113, 26, 28, 28, 4, -28 },
  { 3204, 24, 28, 21, -1, -28 },
  { 3288, 20, 28, 20, 3, -28 },
  { 3358, 22, 28, 20, -1, -28 },
  { 3435, 13, 38, 10, -1, -32 },
  { 3497, 9, 30, 14, 3, -28 },
  { 3531, 13, 38, 10, -2, -32 },
  { 3593, 13, 14, 15, 1, -28 },
  { 3616, 15, 4, 15, -2, 0 },
  { 3624, 8, 6, 12, 4, -29 },
  { 3630, 16, 21, 18, 0, -21 },
  { 3672, 17, 29, 19, 0, -29 },
  { 3734, 16, 21, 17, 1, -21 },
  { 3776, 19, 29, 19, 1, -29 },
  { 3845, 16, 21, 18, 1, -21 },
  { 3887, 14, 29, 12, 1, -29 },
  { 3938, 19, 29, 19, 0, -21 },
  { 4007, 17, 29, 19, 0, -29 },
  { 4069, 10, 29, 9, 0, -29 },
  { 4106, 14, 37, 9, -4, -29 },
  { 4171, 19, 29, 18, 0, -29 },
  { 4240, 10, 29, 9, 0, -29 },
  { 4277, 26, 21, 28, 0, -21 },
  { 4346, 17, 21, 19, 0, -21 },
  { 4391, 17, 21, 19, 1, -21 },
  { 4436, 18, 29, 19, -1, -21 },
  { 4502, 17, 29, 19, 1, -21 },
  { 4564, 13, 21, 12, 0, -21 },
  { 4599, 16, 21, 17, 0, -21 },
  { 4641, 11, 26, 12, 1, -26 },
  { 4677, 17, 21, 19, 1, -21 },
  { 4722, 16, 21, 17, 2, -21 },
  { 4764, 23, 21, 24, 2, -21 },
  { 4825, 19, 21, 17, -1, -21 },
  { 4875, 19, 29, 17, -1, -21 },
  { 4944, 17, 21, 17, 0, -21 },
  { 4989, 12, 37, 11, 1, -30 },
  { 5045, 8, 33, 10, 1, -28 },
  { 5078, 12, 37, 11, -1, -30 },
  { 5134, 18, 8, 21, 2, -15 },
};

const GFXfont RobotoCondensed_SemiBoldItalic39pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic39pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic39pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC39PT7B_H_
