#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC60PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x03, 0xE0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0,
  0xF8, 0xF8, 0xFC, 0xFC, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F,
  0x87, 0x87, 0x83, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF0, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8,
  0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x78, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0,
  0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x07, 0xF0, 0x0F, 0xE0,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x01, 0xFC,
  0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xE0,
  0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x3F, 0xC3, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xE3,
  0xF0, 0x10, 0x7E, 0x1F, 0x01, 0xC7, 0xC1, 0xF0, 0x3E, 0x7C, 0x1F, 0x07,
  0xE7, 0xC1, 0xF0, 0x7C, 0x7C, 0x1F, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0xF8,
  0x1F, 0x1F, 0x0F, 0x83, 0xE3, 0xE0, 0x7C, 0x3E, 0x7C, 0x07, 0xC7, 0xE7,
  0xC0, 0x7F, 0xFC, 0xF8, 0x03, 0xFF, 0xDF, 0x00, 0x1F, 0xF9, 0xF0, 0x00,
  0xFE, 0x3E, 0x00, 0x01, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x04, 0x00, 0x03, 0xE7, 0xF8,
  0x00, 0x7C, 0xFF, 0xC0, 0x0F, 0xDF, 0xFE, 0x00, 0xFB, 0xFF, 0xE0, 0x1F,
  0x3F, 0x3F, 0x03, 0xF7, 0xE1, 0xF0, 0x3E, 0x7C, 0x1F, 0x07, 0xC7, 0xC1,
  0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0x87, 0xC1, 0xF1, 0xF0, 0x7C, 0x1F, 0x3E,
  0x07, 0xC1, 0xF3, 0xE0, 0x7C, 0x1F, 0x7C, 0x07, 0xC3, 0xE1, 0x80, 0x7E,
  0x7E, 0x08, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xC7, 0xF0,
  0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x07,
  0xF0, 0x3F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE1,
  0xFC, 0x00, 0x3F, 0x1F, 0xE0, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x3F, 0x0F, 0xFF,
  0xC1, 0xF8, 0xFF, 0xFF, 0x0F, 0xC7, 0xFF, 0xF8, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF7, 0xF8, 0xFF, 0x3F, 0x3F, 0xC3, 0xFF, 0xF9, 0xFC, 0x1F, 0xFF, 0xDF,
  0xE0, 0x7F, 0xFC, 0xFF, 0x03, 0xFF, 0xE7, 0xF8, 0x0F, 0xFE, 0x3F, 0xC0,
  0x3F, 0xF1, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF3, 0xFC, 0x07, 0xFE, 0x1F, 0xE0, 0x03,
  0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7E, 0x7C,
  0x7C, 0x7C, 0x7C, 0xFC, 0xF8, 0xF8, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x60, 0x3E, 0x06, 0x3C, 0x1E, 0x0F, 0x3F, 0x8F, 0x3F,
  0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFB, 0xE0, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0x7C, 0x01, 0xF8,
  0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x0C, 0x01, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x0F,
  0xE0, 0xFC, 0x07, 0x80, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFB, 0xFF, 0xE0, 0x1E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFC, 0x7C, 0x08, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F,
  0xF0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF3, 0xF8, 0x03, 0xF9,
  0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x7F, 0x80, 0x3F,
  0xBF, 0xC0, 0x3F, 0xDF, 0xC0, 0x1F, 0xEF, 0xE0, 0x0F, 0xF7, 0xF0, 0x07,
  0xF3, 0xF8, 0x03, 0xFB, 0xFC, 0x01, 0xFD, 0xFE, 0x00, 0xFE, 0xFF, 0x00,
  0xFF, 0x7F, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0,
  0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x03, 0xF8, 0xFE,
  0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFF, 0x1F, 0xC0, 0x7F, 0x0F,
  0xE0, 0x7F, 0x87, 0xF8, 0x7F, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x3F,
  0xF0, 0x7F, 0xF1, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F,
  0xFF, 0xBF, 0x3F, 0x9C, 0x1F, 0xC8, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07,
  0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xE1,
  0xFE, 0x07, 0xF8, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x87,
  0xF0, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x07,
  0xF0, 0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xDF, 0xC0, 0x03, 0xF3, 0xF8,
  0x00, 0xFE, 0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x07, 0xF3, 0xFC, 0x01, 0xFC,
  0x7F, 0x80, 0x3F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0x80,
  0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x3E, 0x00, 0x0F, 0xDF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xC3, 0xFE, 0x01, 0xE0,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x07, 0xF8, 0xFE, 0x00, 0xFF, 0x1F,
  0xE0, 0x1F, 0xC3, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0xFF, 0x07, 0xF8, 0x3F,
  0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x8F,
  0xC0, 0x3F, 0xBF, 0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xE3, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x80,
  0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0x7F, 0x03,
  0xFC, 0x7F, 0x07, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x60,
  0x00, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xF0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFC, 0x0F, 0xF0, 0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x0F,
  0xE0, 0x1F, 0xC3, 0xF8, 0x0F, 0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0xFE,
  0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0x7F, 0x8F, 0xF0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xF8, 0xFF, 0x03, 0xF8, 0x1F, 0xC1,
  0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x3F, 0xC0, 0x3F, 0x8F, 0xF0, 0x0F,
  0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0,
  0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x3F, 0xE1, 0xFF, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xE1, 0xFC, 0x3F,
  0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0x7F,
  0x00, 0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF,
  0x00, 0xFE, 0xFF, 0x01, 0xFE, 0x7F, 0x03, 0xFE, 0x7F, 0x87, 0xFC, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x03, 0xF3, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xE0, 0x1F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7E,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x03, 0xF8, 0x1F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC1,
  0xFC, 0x07, 0xC0, 0x08, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01,
  0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x1F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0x04, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFE, 0x03, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xF1, 0xFF,
  0x7F, 0x83, 0xFD, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x7F, 0xE0, 0x1E, 0x0F,
  0x80, 0x7F, 0xFC, 0x0F, 0x0F, 0xC0, 0x7F, 0xFF, 0x07, 0x87, 0xC0, 0x7F,
  0xFF, 0x83, 0xC3, 0xE0, 0x7F, 0x0F, 0x81, 0xE3, 0xE0, 0x3F, 0x07, 0xC0,
  0xF1, 0xF0, 0x3F, 0x03, 0xE0, 0x79, 0xF8, 0x1F, 0x03, 0xF0, 0x3C, 0xF8,
  0x1F, 0x81, 0xF0, 0x1E, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x3E, 0x0F, 0xC0,
  0x7C, 0x07, 0xBF, 0x07, 0xE0, 0x7E, 0x07, 0xDF, 0x03, 0xF0, 0x3E, 0x03,
  0xEF, 0x83, 0xF0, 0x1F, 0x01, 0xF7, 0xC1, 0xF8, 0x0F, 0x80, 0xF3, 0xE0,
  0xFC, 0x0F, 0xC0, 0x7B, 0xF0, 0x7E, 0x07, 0xE0, 0x7D, 0xF0, 0x3F, 0x03,
  0xE0, 0x3E, 0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x7C, 0x0F, 0x81, 0xF8, 0x1F,
  0x3E, 0x07, 0xC0, 0xFC, 0x0F, 0x1F, 0x03, 0xF0, 0xFE, 0x0F, 0x8F, 0x81,
  0xF8, 0x7F, 0x07, 0x87, 0xC0, 0xFE, 0xFF, 0x87, 0xC3, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC1, 0xF0, 0x1F, 0xFB, 0xFF, 0xC0, 0x7C, 0x0F, 0xF8, 0xFF, 0xC0,
  0x3E, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0x00, 0x20, 0x07, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x03, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x03,
  0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFE, 0x07, 0xF0, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0x7F, 0x7F, 0xC0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x01, 0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07,
  0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC,
  0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F,
  0x80, 0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0,
  0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0xFF, 0x83, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xF8,
  0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x07,
  0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x1F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x07, 0xFC, 0x07,
  0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F,
  0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xE0,
  0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01,
  0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFE,
  0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xE0,
  0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x01, 0xFF, 0x03, 0xF8, 0x07, 0xFC, 0x07,
  0xFC, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x07,
  0xFC, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F,
  0x1F, 0xC0, 0x01, 0xFC, 0xFF, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x1F, 0xFF, 0xBF, 0xC0, 0x7F, 0xFE, 0xFF, 0x01, 0xFF,
  0xFB, 0xFC, 0x0F, 0xFF, 0xCF, 0xF0, 0x3F, 0xFF, 0x3F, 0xC0, 0xFF, 0xFC,
  0xFE, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFF, 0x3F,
  0x80, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0,
  0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xE1, 0xFF, 0x83,
  0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x83, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF,
  0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x03,
  0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xE0,
  0x3F, 0x80, 0x0F, 0xF8, 0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0xC0, 0x3F, 0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0xFE, 0x01,
  0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0xC0, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0xFF,
  0x07, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xE0, 0x00,
  0x7F, 0x0F, 0xF8, 0x00, 0x0F, 0xE3, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0xC0,
  0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xEF, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x03, 0xFE, 0x1F,
  0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0xC0, 0x01, 0xFC,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x07, 0xF0, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC, 0x03, 0xF8,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x3F,
  0xF8, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x7F, 0xFC,
  0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF,
  0xFC, 0x0F, 0xEF, 0xC0, 0x1F, 0xFF, 0x80, 0xFE, 0xFC, 0x01, 0xFB, 0xF8,
  0x0F, 0xEF, 0xC0, 0x1F, 0xBF, 0x80, 0xFE, 0xFC, 0x03, 0xFB, 0xF8, 0x0F,
  0xE7, 0xC0, 0x3F, 0x7F, 0x80, 0xFE, 0x7E, 0x07, 0xF7, 0xF0, 0x1F, 0xE7,
  0xE0, 0x7E, 0x7F, 0x01, 0xFE, 0x7E, 0x0F, 0xE7, 0xF0, 0x1F, 0xC7, 0xE0,
  0xFC, 0x7F, 0x01, 0xFC, 0x7E, 0x1F, 0xCF, 0xF0, 0x1F, 0xC7, 0xE1, 0xF8,
  0xFF, 0x01, 0xFC, 0x7E, 0x1F, 0x8F, 0xE0, 0x3F, 0xC7, 0xE3, 0xF0, 0xFE,
  0x03, 0xFC, 0x3E, 0x3F, 0x0F, 0xE0, 0x3F, 0xC3, 0xE7, 0xE1, 0xFE, 0x03,
  0xF8, 0x3F, 0x7E, 0x1F, 0xE0, 0x3F, 0x83, 0xFF, 0xE1, 0xFE, 0x03, 0xF8,
  0x3F, 0xFC, 0x1F, 0xC0, 0x7F, 0x83, 0xFF, 0xC1, 0xFC, 0x07, 0xF8, 0x3F,
  0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xFF, 0x83, 0xFC, 0x07, 0xF0, 0x1F, 0xF0,
  0x3F, 0xC0, 0x7F, 0x01, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x80, 0xFE,
  0x01, 0xF8, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0xC0,
  0x01, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x0F, 0xF0, 0x3F,
  0xF0, 0x01, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0xC0, 0x07, 0xF0,
  0x1F, 0xFC, 0x00, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xF0, 0x07,
  0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0xFC,
  0x03, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0x03, 0xFD, 0xF0, 0x1F, 0xE0, 0x7F,
  0xBF, 0x03, 0xFC, 0x0F, 0xF7, 0xE0, 0x7F, 0x81, 0xFE, 0xFC, 0x0F, 0xE0,
  0x3F, 0x8F, 0xC1, 0xFC, 0x07, 0xF1, 0xF8, 0x7F, 0x81, 0xFE, 0x3F, 0x0F,
  0xF0, 0x3F, 0xC3, 0xE1, 0xFE, 0x07, 0xF8, 0x7E, 0x3F, 0xC0, 0xFF, 0x0F,
  0xC7, 0xF0, 0x1F, 0xC1, 0xF8, 0xFE, 0x03, 0xF8, 0x1F, 0xBF, 0xC0, 0xFF,
  0x03, 0xF7, 0xF8, 0x1F, 0xE0, 0x7E, 0xFF, 0x03, 0xFC, 0x07, 0xDF, 0xE0,
  0x7F, 0x80, 0xFF, 0xF8, 0x0F, 0xE0, 0x1F, 0xFF, 0x01, 0xFC, 0x03, 0xFF,
  0xE0, 0x7F, 0x80, 0x3F, 0xFC, 0x0F, 0xF0, 0x07, 0xFF, 0x81, 0xFE, 0x00,
  0xFF, 0xF0, 0x3F, 0xC0, 0x0F, 0xFC, 0x07, 0xF0, 0x01, 0xFF, 0x81, 0xFE,
  0x00, 0x3F, 0xF0, 0x3F, 0xC0, 0x07, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x07,
  0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x7F,
  0x9F, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0xFF,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0xFF, 0x3F, 0x80,
  0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x01,
  0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x03,
  0xFC, 0x0F, 0xE0, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x03,
  0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00,
  0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x00,
  0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x01,
  0xFE, 0x3F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01,
  0xFE, 0x7F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x03,
  0xFC, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x1F,
  0xE0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0D, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x01, 0xFE,
  0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8,
  0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F,
  0xE0, 0x0F, 0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x00, 0xFF, 0xC1, 0xFF,
  0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x1F,
  0xC0, 0x0F, 0xE0, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC,
  0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0,
  0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0xC3,
  0xF8, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xC3, 0xFE, 0x03, 0xFC,
  0x07, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFC, 0x00,
  0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x87,
  0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0xC1, 0xFF,
  0x83, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0xFF, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x01,
  0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x01,
  0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xE0, 0x03,
  0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x03,
  0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x07,
  0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x07,
  0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x0F,
  0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x3F,
  0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x03,
  0xFE, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F,
  0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x1F,
  0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x7F,
  0x80, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0xFF,
  0x00, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xBF, 0xC0,
  0x1F, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xF0, 0x07, 0xFB, 0xFC, 0x03, 0xFC,
  0x01, 0xFC, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC7, 0xF0, 0x1F, 0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xFC, 0x03, 0xF8, 0x7F,
  0x01, 0xFF, 0x01, 0xFE, 0x1F, 0xC0, 0xFF, 0xC0, 0x7F, 0x07, 0xF0, 0x3F,
  0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xFC, 0x0F, 0xF0, 0x7F, 0x07, 0xFF, 0x03,
  0xF8, 0x1F, 0xC1, 0xFF, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0xF8, 0x7F, 0x81,
  0xFC, 0x3F, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xDF, 0x87, 0xF0, 0x1F, 0xC3,
  0xF7, 0xE3, 0xFC, 0x07, 0xF1, 0xFD, 0xF8, 0xFE, 0x01, 0xFC, 0x7E, 0x7E,
  0x3F, 0x80, 0x7F, 0x1F, 0x9F, 0x8F, 0xE0, 0x1F, 0xCF, 0xC7, 0xE7, 0xF0,
  0x07, 0xF3, 0xF1, 0xF9, 0xFC, 0x01, 0xFC, 0xFC, 0x7E, 0x7F, 0x00, 0x7F,
  0x7E, 0x1F, 0xBF, 0x80, 0x1F, 0xDF, 0x87, 0xEF, 0xE0, 0x07, 0xF7, 0xE1,
  0xFB, 0xF8, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x1F, 0xFC,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x01,
  0xFE, 0x7F, 0x80, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x03, 0xFC,
  0x7F, 0x00, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x9F, 0xE0, 0x03,
  0xFC, 0x7F, 0x80, 0x1F, 0xF1, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x03, 0xFE,
  0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x01,
  0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xC1, 0xFE, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE7,
  0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x01, 0xFB, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF,
  0xC0, 0x3F, 0x7C, 0x07, 0xE7, 0xC0, 0x7E, 0x7C, 0x0F, 0xC7, 0xC0, 0xFC,
  0x7C, 0x1F, 0x87, 0xC1, 0xF8, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x3E, 0x7E,
  0x03, 0xE7, 0xE0, 0x3E, 0xFC, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0xFF, 0x07, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xE0,
  0x7F, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xE1, 0xFE,
  0x7F, 0x81, 0xFE, 0x7F, 0x01, 0xFC, 0xFF, 0x01, 0xFC, 0xFF, 0x01, 0xFC,
  0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFF, 0x07, 0xFC,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFB, 0xF8, 0x0F, 0xF3, 0xFC, 0x01, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF7, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0xC3,
  0xF8, 0x07, 0xF8, 0x7F, 0x00, 0xFF, 0x0F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03,
  0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xE0, 0x0F, 0xF1, 0xFC, 0x01, 0xFC, 0x3F,
  0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF1, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x1F,
  0xC7, 0xF0, 0x07, 0xF8, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8,
  0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x1F, 0xF8, 0x3F, 0xC3, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFD, 0xFF, 0xF0, 0x7F, 0x1F,
  0xFC, 0x0F, 0xE1, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xC0,
  0x7F, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8,
  0x03, 0xFB, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC,
  0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x80, 0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x07,
  0xFF, 0x3F, 0x80, 0x7F, 0xFB, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x07, 0xFC,
  0x1F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x7F,
  0x80, 0x3F, 0x83, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00,
  0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC,
  0x1F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F,
  0xC0, 0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80,
  0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFB, 0xF8, 0x00,
  0x7F, 0x9F, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xE0, 0xFE, 0x3F, 0xC0, 0x7F, 0x3F, 0x80,
  0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x20, 0xFF, 0x00,
  0x60, 0xFF, 0x81, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0x80, 0x3F, 0xF9,
  0xFC, 0x03, 0xFF, 0xEF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF,
  0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0xC1, 0xFC, 0x01,
  0xFE, 0x1F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8,
  0x3F, 0x80, 0x3F, 0xC1, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F,
  0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x01,
  0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xF8,
  0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFC,
  0xFE, 0x00, 0x03, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x02, 0x00, 0x3F, 0xC0, 0x1C, 0x03, 0xFE, 0x01, 0xF8, 0x3F, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x3F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xF8, 0x0F, 0xF0, 0xFE, 0x01,
  0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF1, 0xFC,
  0x03, 0xFC, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE3,
  0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x8F, 0xE0, 0x1F,
  0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0,
  0x3F, 0xC7, 0xF0, 0x0F, 0xF1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F,
  0xC0, 0x3F, 0x8F, 0xF0, 0x0F, 0xE3, 0xFC, 0x07, 0xF8, 0xFE, 0x01, 0xFE,
  0x00, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x04, 0xFF, 0xC0, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x07,
  0xFC, 0x07, 0xF0, 0x7F, 0xC0, 0x3F, 0x87, 0xFC, 0x01, 0xFC, 0x3F, 0xC0,
  0x1F, 0xE3, 0xFE, 0x00, 0xFF, 0x3F, 0xE0, 0x07, 0xFB, 0xFE, 0x00, 0x3F,
  0x9F, 0xE0, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0x3F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0x0F,
  0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0xC1, 0xFC, 0x01, 0xFE, 0x0F, 0xF0,
  0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F,
  0xC0, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0xF9,
  0xFF, 0x03, 0xFC, 0x01, 0xFD, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xFF, 0xF7,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFB, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0xFF, 0xE1, 0xFE, 0x0F, 0xF0,
  0x3F, 0xE0, 0x7F, 0x87, 0xF0, 0x1F, 0xE0, 0x3F, 0xC3, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE1, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x87, 0xF0, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF0, 0x1F, 0xC3,
  0xFC, 0x07, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0xFE, 0x01,
  0xFC, 0x07, 0xF8, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x01,
  0xFE, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x07,
  0xF0, 0x1F, 0xE1, 0xFC, 0x07, 0xF8, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x07,
  0xF0, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0xFF, 0x80, 0x7F, 0x7F, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F,
  0xC3, 0xF8, 0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0xE0,
  0x3F, 0xC7, 0xF8, 0x0F, 0xF1, 0xFC, 0x03, 0xFC, 0x7F, 0x00, 0xFE, 0x1F,
  0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFE,
  0x3F, 0x80, 0x7F, 0x8F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01,
  0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF0, 0x0F, 0xF1, 0xFC,
  0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xF0, 0x0F, 0xE3,
  0xFC, 0x07, 0xF8, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0x3F,
  0x87, 0xF0, 0x0F, 0xE3, 0xFC, 0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x3F, 0x80,
  0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFC, 0x00, 0xFF, 0x7F,
  0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE,
  0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x1F, 0xE7, 0xF0, 0x07, 0xF1, 0xFC, 0x01,
  0xFC, 0x7F, 0x00, 0xFF, 0x1F, 0xE0, 0x3F, 0x87, 0xFC, 0x1F, 0xE0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE7, 0xFC, 0x00, 0x7F, 0x7F, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xC1, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE,
  0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x83, 0xFC, 0x03,
  0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF0,
  0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0xFF,
  0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01,
  0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x0F, 0xF0,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0x7F, 0xFC, 0x07, 0xF9, 0xFF, 0xC0, 0x3F, 0x87, 0xF8, 0x01, 0xFC, 0x04,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xF1,
  0xFC, 0x07, 0xFF, 0x3F, 0x81, 0xFF, 0xF7, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xE0, 0x3F,
  0xC7, 0xF8, 0x07, 0xF8, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC7, 0xF8,
  0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xE3, 0xF8, 0x03, 0xFC,
  0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x7F, 0x80,
  0x3F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0x87,
  0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0x10, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x3F, 0x07, 0xF7, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xF3, 0xFC, 0x1F,
  0xE0, 0xFF, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF9, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x1F, 0xC0,
  0xFF, 0x0F, 0xF8, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xDF,
  0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F,
  0xE0, 0x01, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF1, 0xFC,
  0x03, 0xFC, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xF0, 0x0F, 0xE3,
  0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x8F, 0xE0, 0x1F,
  0xC3, 0xF8, 0x07, 0xF1, 0xFE, 0x01, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0,
  0x3F, 0xC7, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x3F,
  0xC0, 0x3F, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFE, 0x01, 0xFC,
  0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFF, 0x03,
  0xFC, 0x3F, 0xC1, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xBF, 0x80, 0x7F, 0xCF, 0xE0,
  0x01, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01,
  0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x03,
  0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F,
  0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0xBF, 0x80, 0x3F, 0xBF, 0x80, 0x3F, 0xBF,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0xDF, 0xC0, 0x7E, 0x03,
  0xFB, 0xF8, 0x1F, 0xC0, 0xFF, 0x7F, 0x03, 0xF8, 0x1F, 0xCF, 0xE0, 0xFF,
  0x03, 0xF9, 0xFC, 0x1F, 0xE0, 0xFE, 0x3F, 0x83, 0xFC, 0x1F, 0xC7, 0xF0,
  0xFF, 0x83, 0xF8, 0xFE, 0x1F, 0xF0, 0xFE, 0x1F, 0xC7, 0xFE, 0x1F, 0xC3,
  0xF8, 0xFF, 0xC3, 0xF8, 0x7F, 0x3F, 0xF8, 0xFE, 0x0F, 0xE7, 0xFF, 0x1F,
  0xC1, 0xFC, 0xFF, 0xE3, 0xF0, 0x3F, 0xBF, 0x7C, 0xFE, 0x07, 0xF7, 0xEF,
  0xDF, 0xC0, 0xFF, 0xF9, 0xFB, 0xF0, 0x1F, 0xFF, 0x3F, 0xFE, 0x03, 0xFF,
  0xC7, 0xFF, 0x80, 0x7F, 0xF8, 0xFF, 0xF0, 0x0F, 0xFF, 0x1F, 0xFE, 0x01,
  0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x03, 0xF0, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x03,
  0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xF9,
  0xFE, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xF7, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0x3F, 0x80, 0x07, 0xF9, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xF8,
  0x7F, 0x80, 0x3F, 0xC1, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xE0, 0x07, 0xF8, 0x07, 0xF8,
  0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F,
  0x80, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x07,
  0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x1F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0x1F, 0x8F, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x07,
  0xE7, 0xF8, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x40, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x40, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x07,
  0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xF0,
  0x00, 0x10, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0x83,
  0xFF, 0x80, 0x7C, 0x3F, 0xFE, 0x03, 0xE3, 0xFF, 0xF0, 0x3F, 0x1F, 0xFF,
  0xC1, 0xF8, 0xFE, 0xFF, 0xBF, 0x8F, 0xC1, 0xFF, 0xFC, 0x7E, 0x0F, 0xFF,
  0xC3, 0xE0, 0x3F, 0xFE, 0x3F, 0x00, 0xFF, 0xE1, 0xF8, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xC0, 0x00,
};

const GFXglyph RobotoCondensed_SemiBoldItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 15, 44, 15, 1, -43 },
  { 84, 17, 16, 19, 4, -45 },
  { 118, 30, 43, 31, 1, -43 },
  { 280, 27, 57, 29, 2, -50 },
  { 473, 28, 45, 37, 5, -44 },
  { 631, 29, 45, 33, 1, -44 },
  { 795, 8, 16, 10, 4, -45 },
  { 811, 18, 61, 19, 3, -48 },
  { 949, 19, 62, 19, -3, -48 },
  { 1097, 25, 26, 26, 3, -43 },
  { 1179, 25, 31, 28, 2, -36 },
  { 1276, 12, 17, 14, -3, -7 },
  { 1302, 14, 6, 19, 3, -21 },
  { 1313, 9, 9, 17, 1, -8 },
  { 1324, 27, 47, 20, -4, -43 },
  { 1483, 25, 45, 29, 3, -44 },
  { 1624, 17, 43, 29, 7, -43 },
  { 1716, 28, 44, 29, 0, -44 },
  { 1870, 27, 45, 29, 1, -44 },
  { 2022, 27, 43, 29, 1, -43 },
  { 2168, 27, 44, 29, 2, -43 },
  { 2317, 24, 44, 29, 3, -43 },
  { 2449, 28, 43, 29, 3, -43 },
  { 2600, 26, 45, 29, 2, -44 },
  { 2747, 24, 44, 29, 4, -44 },
  { 2879, 13, 33, 16, 1, -32 },
  { 2933, 17, 42, 14, -3, -32 },
  { 3023, 24, 27, 26, 1, -32 },
  { 3104, 24, 18, 29, 3, -28 },
  { 3158, 24, 28, 27, 1, -32 },
  { 3242, 22, 45, 26, 4, -44 },
  { 3366, 41, 55, 45, 1, -42 },
  { 3648, 33, 43, 34, -2, -43 },
  { 3826, 31, 43, 32, 1, -43 },
  { 3993, 31, 45, 33, 2, -44 },
  { 4168, 31, 43, 33, 1, -43 },
  { 4335, 30, 43, 29, 1, -43 },
  { 4497, 30, 43, 28, 1, -43 },
  { 4659, 30, 45, 34, 3, -44 },
  { 4828, 36, 43, 36, 1, -43 },
  { 5022, 15, 43, 15, 1, -43 },
  { 5103, 29, 44, 28, 0, -43 },
  { 5263, 35, 43, 32, 1, -43 },
  { 5452, 23, 43, 28, 1, -43 },
  { 5576, 44, 43, 44, 1, -43 },
  { 5813, 35, 43, 36, 1, -43 },
  { 6002, 31, 45, 35, 3, -44 },
  { 6177, 32, 43, 33, 1, -43 },
  { 6349, 32, 52, 35, 2, -44 },
  { 6557, 31, 43, 32, 1, -43 },
  { 6724, 30, 45, 31, 1, -44 },
  { 6893, 29, 43, 31, 5, -43 },
  { 7049, 32, 44, 33, 2, -43 },
  { 7225, 32, 43, 33, 5, -43 },
  { 7397, 42, 43, 44, 5, -43 },
  { 7623, 37, 43, 32, -2, -43 },
  { 7822, 30, 43, 31, 5, -43 },
  { 7984, 34, 43, 31, -1, -43 },
  { 8167, 20, 59, 15, -1, -49 },
  { 8315, 14, 47, 22, 5, -43 },
  { 8398, 20, 59, 15, -3, -49 },
  { 8546, 20, 21, 22, 2, -43 },
  { 8599, 24, 6, 23, -4, 0 },
  { 8617, 12, 9, 19, 6, -45 },
  { 8631, 24, 34, 28, 1, -33 },
  { 8733, 27, 46, 29, 0, -45 },
  { 8889, 25, 34, 27, 1, -33 },
  { 8996, 29, 46, 29, 1, -45 },
  { 9163, 24, 34, 28, 2, -33 },
  { 9265, 21, 46, 19, 2, -46 },
  { 9386, 29, 45, 29, 0, -33 },
  { 9550, 26, 45, 29, 0, -45 },
  { 9697, 15, 44, 14, 0, -44 },
  { 9780, 21, 56, 14, -6, -44 },
  { 9927, 29, 45, 27, 0, -45 },
  { 10091, 16, 45, 14, 0, -45 },
  { 10181, 41, 33, 43, 0, -33 },
  { 10351, 26, 33, 29, 0, -33 },
  { 10459, 26, 34, 29, 1, -33 },
  { 10570, 29, 45, 29, -2, -33 },
  { 10734, 27, 45, 29, 1, -33 },
  { 10886, 20, 33, 19, 0, -33 },
  { 10969, 25, 34, 26, 0, -33 },
  { 11076, 17, 41, 18, 2, -40 },
  { 11164, 26, 33, 29, 2, -32 },
  { 11272, 24, 32, 26, 3, -32 },
  { 11368, 35, 32, 37, 4, -32 },
  { 11508, 29, 32, 26, -2, -32 },
  { 11624, 29, 44, 26, -2, -32 },
  { 11784, 27, 32, 26, -1, -32 },
  { 11892, 19, 58, 17, 1, -47 },
  { 12030, 13, 51, 15, 1, -43 },
  { 12113, 18, 58, 17, -2, -47 },
  { 12244, 29, 13, 33, 2, -24 },
};

const GFXfont RobotoCondensed_SemiBoldItalic60pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic60pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic60pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC60PT7B_H_
