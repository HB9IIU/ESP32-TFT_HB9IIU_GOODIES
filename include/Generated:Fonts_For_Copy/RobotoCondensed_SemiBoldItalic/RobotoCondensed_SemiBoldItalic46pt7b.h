#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC46PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x78, 0x00, 0x3C,
  0x79, 0xE3, 0xCF, 0x3E, 0xF9, 0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0xCF, 0x1C,
  0x70, 0xE3, 0x8F, 0x3C, 0x79, 0xE3, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x3C,
  0x78, 0x00, 0x78, 0xF0, 0x00, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F,
  0x00, 0x0E, 0x1C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x3C, 0x78, 0x00,
  0x78, 0xF0, 0x00, 0xF1, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F,
  0x1C, 0x00, 0x1C, 0x78, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0x0F, 0x1E, 0x00, 0x1C, 0x78, 0x00, 0x78, 0xF0,
  0x00, 0xF1, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00,
  0x1C, 0x38, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xFF,
  0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xF8, 0xFC, 0x1F,
  0x83, 0xE0, 0xFC, 0x1F, 0x87, 0xC0, 0xFC, 0x3E, 0x07, 0xE1, 0xF0, 0x3F,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x7E, 0x3E, 0x03,
  0xE1, 0xF0, 0x1F, 0x0F, 0xC1, 0xF8, 0x7E, 0x1F, 0xC1, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x7F, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x78, 0xF0, 0x63, 0xC3,
  0xC1, 0xEF, 0x0F, 0x0F, 0x3C, 0x3C, 0x78, 0xF0, 0xF3, 0xC3, 0xC3, 0xCF,
  0x0F, 0x1E, 0x78, 0x1E, 0xFB, 0xC0, 0x7F, 0xCF, 0x00, 0xFF, 0x78, 0x01,
  0xF3, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x3E, 0x00, 0x7B, 0xFC, 0x03, 0xDF, 0xF8, 0x1E, 0x7F, 0xE0, 0x7B, 0xC7,
  0x83, 0xCF, 0x0E, 0x1E, 0x3C, 0x38, 0x78, 0xE0, 0xE3, 0xC3, 0x87, 0x9E,
  0x0E, 0x1E, 0x70, 0x3C, 0x78, 0x40, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0x8F, 0x80, 0x7C, 0x3E, 0x01,
  0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x7C, 0x01, 0xF3,
  0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xE1, 0xF1, 0xFF, 0xC7, 0xCF, 0xFF, 0x1F, 0x7E,
  0x7E, 0x7D, 0xF9, 0xFB, 0xEF, 0xC3, 0xFF, 0xBF, 0x07, 0xFE, 0xFC, 0x1F,
  0xF3, 0xF0, 0x3F, 0xCF, 0xC0, 0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFE, 0x7E, 0x07, 0xE1, 0xF8, 0x3C,
  0xF7, 0xDF, 0x79, 0xE7, 0x9E, 0x7B, 0xCF, 0x3C, 0x00, 0x08, 0x00, 0x70,
  0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x18, 0x00, 0x20, 0x00, 0x01, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3C, 0x00,
  0xE0, 0x01, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x40, 0xE0, 0x4E, 0x1C, 0x3B, 0xF3, 0xBF, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFC, 0x1F, 0xFC, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x1F,
  0xF0, 0x03, 0xCF, 0x00, 0xF9, 0xE0, 0x3E, 0x1E, 0x0F, 0x83, 0xC0, 0x60,
  0x70, 0x00, 0x04, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x07, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C,
  0x3E, 0x0F, 0x87, 0xC1, 0xE0, 0x10, 0x00, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFC, 0x10, 0xFB, 0xF7, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x0F, 0xC7, 0xE0,
  0xF8, 0xF8, 0x1F, 0x3F, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0xBF, 0x01,
  0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x81, 0xFB, 0xE0, 0x3F, 0x7C, 0x07,
  0xEF, 0x80, 0xFF, 0xF0, 0x1F, 0x7E, 0x03, 0xEF, 0xC0, 0x7D, 0xF8, 0x1F,
  0xBE, 0x03, 0xF7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x83, 0xF3, 0xF0, 0x7C,
  0x3E, 0x1F, 0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0,
  0x0F, 0xE0, 0x00, 0x00, 0x18, 0x03, 0xC0, 0xFE, 0x1F, 0xF7, 0xFF, 0xBF,
  0xFD, 0xFF, 0xDF, 0xBE, 0xF1, 0xF4, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E,
  0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F,
  0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x3E, 0x0F, 0x80, 0xF8, 0x7E, 0x03,
  0xE1, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0,
  0x3E, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xE0, 0x7E,
  0x3F, 0x03, 0xF1, 0xFC, 0x3F, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF,
  0xF8, 0x03, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1E, 0xFC,
  0x01, 0xF7, 0xC0, 0x1F, 0x3E, 0x00, 0xFB, 0xF0, 0x0F, 0x9F, 0x80, 0xF8,
  0xFC, 0x07, 0xC7, 0xE0, 0x7C, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x1F, 0x83,
  0xE0, 0xFC, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x3E, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0x7C, 0x3F, 0x07, 0xE1, 0xF8, 0x7F, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF,
  0x81, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xFD, 0xF0, 0x3E, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF,
  0xFF, 0x7F, 0x0F, 0xDF, 0x83, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xE7,
  0xC1, 0xF9, 0xF8, 0xFE, 0x7F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F,
  0xE0, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFF,
  0x07, 0xF1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3F, 0x0F, 0x81, 0xF8, 0x7C,
  0x0F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xFC, 0x7E, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xC3,
  0xE0, 0x7C, 0x1F, 0x87, 0xE0, 0x7C, 0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x1F,
  0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xE0, 0x7E, 0x1F, 0x03, 0xF0, 0xFC, 0x3F,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F,
  0xFF, 0x8F, 0xC3, 0xE3, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x07, 0xDF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0x7E, 0x1F, 0xDF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F,
  0xFF, 0x83, 0xE7, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x01,
  0xFC, 0x00, 0x7C, 0x00, 0x00, 0x02, 0x03, 0xE1, 0xFC, 0x7F, 0x1F, 0xC3,
  0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x7C, 0x3F, 0x0F, 0xE3, 0xF8, 0xFC,
  0x1E, 0x00, 0x00, 0x40, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03,
  0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0xFF, 0xE0,
  0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xE0, 0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x04, 0x00, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0x08, 0x00,
  0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0,
  0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00,
  0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF3, 0xF0,
  0xFD, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x01,
  0xF0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x1C, 0x07, 0xC0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x0E, 0x0F, 0x00, 0xF8, 0x0E, 0x0F, 0x03, 0xFE, 0x0E, 0x1E,
  0x07, 0xFF, 0x0E, 0x1E, 0x0F, 0xFF, 0x0E, 0x3C, 0x1F, 0x0F, 0x0E, 0x3C,
  0x1E, 0x1E, 0x0E, 0x3C, 0x3E, 0x1E, 0x0E, 0x78, 0x3C, 0x1E, 0x0E, 0x78,
  0x7C, 0x1E, 0x0E, 0x78, 0x78, 0x3C, 0x0E, 0x78, 0x78, 0x3C, 0x1E, 0xF0,
  0xF8, 0x3C, 0x1E, 0xF0, 0xF8, 0x3C, 0x1C, 0xF0, 0xF8, 0x78, 0x1C, 0xF0,
  0xF0, 0x78, 0x3C, 0xF0, 0xF0, 0x78, 0x38, 0xF0, 0xF0, 0xF8, 0x78, 0xF0,
  0xF9, 0xF8, 0x78, 0xF0, 0xFF, 0xFD, 0xF0, 0xF0, 0x7F, 0xBF, 0xE0, 0xF0,
  0x7F, 0x3F, 0xC0, 0xF0, 0x3E, 0x1F, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xE7,
  0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x01, 0xF8,
  0x7C, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x3E,
  0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x87, 0xE0, 0x07, 0xE3,
  0xF0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xE0,
  0x7F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0xFE, 0x0F, 0xC3,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01,
  0xFC, 0x3E, 0x01, 0xF8, 0x7E, 0x07, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC1, 0xFC, 0x1F, 0xC7, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00, 0x3E,
  0x7E, 0x00, 0x7C, 0xFC, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x07,
  0xE1, 0xF8, 0x0F, 0xC3, 0xF8, 0x7F, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x07, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F,
  0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x7E,
  0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0x01, 0xF8, 0x3E, 0x03, 0xF8, 0x7E, 0x0F, 0xF0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F,
  0x80, 0x7E, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x0F, 0xFE, 0x7E, 0x0F, 0xFC, 0x7C, 0x1F, 0xFC, 0xFC, 0x1F, 0xFC, 0xFC,
  0x1F, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7F,
  0x07, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F,
  0x03, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07,
  0xE0, 0xFC, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F,
  0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81,
  0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00,
  0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0,
  0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0,
  0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x03, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8,
  0x1F, 0x81, 0xF8, 0x7F, 0x03, 0xF1, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x0F, 0xF0, 0x3F, 0x01, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8,
  0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E,
  0x1F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xEF, 0xC0, 0x03,
  0xFC, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07,
  0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x3E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00,
  0x7E, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0xC0, 0x7C, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x03, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFE, 0x07,
  0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF8,
  0x3F, 0xF8, 0x0F, 0xFC, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xEF, 0x81, 0xF7,
  0xC0, 0xFB, 0xE0, 0xFB, 0xF0, 0x7E, 0x78, 0x3E, 0xFC, 0x1F, 0x9E, 0x1F,
  0x3F, 0x07, 0xE7, 0x87, 0xCF, 0x81, 0xF9, 0xE1, 0xE7, 0xE0, 0x7C, 0x78,
  0xF9, 0xF8, 0x1F, 0x1F, 0x3C, 0x7E, 0x0F, 0xC7, 0xDF, 0x1F, 0x83, 0xF1,
  0xF7, 0xC7, 0xC0, 0xFC, 0x7F, 0xE3, 0xF0, 0x3F, 0x0F, 0xF8, 0xFC, 0x0F,
  0xC3, 0xFC, 0x3F, 0x03, 0xE0, 0xFF, 0x0F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0,
  0x7E, 0x0F, 0xE0, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x1F,
  0x81, 0xF8, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0x81, 0xF8, 0x00, 0x03, 0xF0,
  0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x7F, 0x80, 0x3E,
  0x07, 0xF8, 0x07, 0xE0, 0x7F, 0x80, 0x7E, 0x07, 0xFC, 0x07, 0xE0, 0x7F,
  0xC0, 0x7E, 0x07, 0xFC, 0x07, 0xE0, 0xFF, 0xC0, 0xFC, 0x0F, 0xFE, 0x0F,
  0xC0, 0xFD, 0xE0, 0xFC, 0x0F, 0xDE, 0x0F, 0xC0, 0xFD, 0xF0, 0xFC, 0x0F,
  0x9F, 0x0F, 0x81, 0xF8, 0xF1, 0xF8, 0x1F, 0x8F, 0x1F, 0x81, 0xF8, 0xF9,
  0xF8, 0x1F, 0x87, 0x9F, 0x81, 0xF8, 0x79, 0xF8, 0x1F, 0x07, 0xDF, 0x03,
  0xF0, 0x7F, 0xF0, 0x3F, 0x03, 0xFF, 0x03, 0xF0, 0x3F, 0xF0, 0x3F, 0x03,
  0xFF, 0x03, 0xF0, 0x3F, 0xF0, 0x3E, 0x01, 0xFE, 0x07, 0xE0, 0x1F, 0xE0,
  0x7E, 0x01, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xE0,
  0x0F, 0xE0, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xE0, 0xFE,
  0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F,
  0x3F, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0x7E, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0,
  0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x3E, 0x01, 0xFC, 0x3F, 0x01, 0xFE, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xE0, 0xFE, 0x1F,
  0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3F, 0x3F,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x7E,
  0x03, 0xF0, 0x7F, 0x0F, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x80, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x3F, 0x07,
  0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F,
  0x81, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x3F,
  0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x7E,
  0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x7E, 0x01, 0xF8, 0x7E,
  0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFC, 0x1F, 0x83, 0xF0,
  0x1F, 0x87, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x7E,
  0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE1, 0xF8, 0x1F, 0xC3, 0xF8,
  0x7F, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F,
  0x80, 0x3F, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3F,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC,
  0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0x7E,
  0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3E,
  0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x3F,
  0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x3E, 0xFC, 0x07, 0xC0,
  0x7E, 0xFC, 0x07, 0xC0, 0x7E, 0xFC, 0x0F, 0xC0, 0x7C, 0xFC, 0x0F, 0xC0,
  0xFC, 0xFC, 0x1F, 0xC0, 0xFC, 0xFC, 0x1F, 0xC0, 0xFC, 0xFC, 0x1F, 0xE1,
  0xF8, 0xFC, 0x3F, 0xE1, 0xF8, 0xFC, 0x3F, 0xE1, 0xF8, 0xFC, 0x3F, 0xE1,
  0xF0, 0xFC, 0x7F, 0xE3, 0xF0, 0xFC, 0x7F, 0xE3, 0xF0, 0xFC, 0x7F, 0xE3,
  0xE0, 0xFC, 0xFB, 0xE7, 0xE0, 0xFC, 0xFB, 0xE7, 0xE0, 0x7C, 0xF3, 0xE7,
  0xC0, 0x7D, 0xF3, 0xEF, 0xC0, 0x7D, 0xF3, 0xEF, 0xC0, 0x7D, 0xE3, 0xEF,
  0x80, 0x7F, 0xE3, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x7F, 0xC1, 0xFF,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0xFE,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x81, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x1F,
  0x83, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0xFE,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFB,
  0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFE, 0x3F, 0x00,
  0x0F, 0xC1, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x81, 0xF8, 0x03, 0xF8,
  0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0xFE, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xF3, 0xF0, 0x0F,
  0xC7, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0,
  0x3E, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x7E, 0x00, 0xF9, 0xF8, 0x01,
  0xF3, 0xF0, 0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x07, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x00,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x87, 0xE1, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7E,
  0x1F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0x7C, 0x1F, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xBC,
  0x1F, 0x78, 0x3C, 0xF0, 0xF8, 0xF1, 0xE1, 0xE7, 0xC3, 0xCF, 0x07, 0xBE,
  0x0F, 0x7C, 0x1E, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0x80, 0xFC, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x00,
  0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xE3,
  0xF3, 0xF0, 0x7C, 0xFC, 0x1F, 0x00, 0x0F, 0xC0, 0xFF, 0xF0, 0xFF, 0xFC,
  0xFF, 0xFF, 0x7F, 0xFF, 0x9F, 0x83, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xF8,
  0x1F, 0xBE, 0x07, 0xEF, 0xC3, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x7C, 0x7C, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x9F,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F,
  0xC3, 0xF0, 0xFC, 0x0F, 0x87, 0xE0, 0x7E, 0x3E, 0x03, 0xF1, 0xF0, 0x1F,
  0x1F, 0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xE0, 0x3E, 0x3F, 0x03, 0xF1, 0xF0,
  0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xC7, 0xE0, 0x7E, 0x3F, 0x87, 0xF1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFD, 0xFF, 0x87, 0xEF, 0xF8, 0x3E, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x7E, 0x0F, 0x8F, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0x80,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x7C, 0xFC, 0x0F, 0x9F, 0x83, 0xF1, 0xF0, 0xFC, 0x3F, 0xFF,
  0x87, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7C, 0x7C, 0x07, 0xF9, 0xF0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0x87,
  0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7C, 0x07, 0xE1, 0xF0, 0x1F, 0x8F, 0xC0,
  0x7C, 0x3F, 0x01, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC,
  0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0x83, 0xF8, 0x7E, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xF9, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F,
  0x0F, 0xCF, 0xC1, 0xF9, 0xF0, 0x1F, 0x7E, 0x03, 0xEF, 0xC0, 0xFD, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x41, 0xF8, 0x3C, 0x3F, 0xFF, 0x83, 0xFF,
  0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0xFE,
  0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF8,
  0xFF, 0xF8, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x0F, 0xFB, 0xF0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8,
  0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x3F,
  0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3E, 0x1F,
  0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x83, 0xF0, 0xFE, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xF3, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x02, 0x01, 0xF8, 0x1C, 0x0F, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0xF8, 0x0F, 0xBF, 0xC0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xC3, 0xF1, 0xF8, 0x3F, 0x1F, 0x03,
  0xF1, 0xF0, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xE3, 0xF0,
  0x3E, 0x3E, 0x07, 0xE3, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E,
  0x07, 0xC7, 0xE0, 0x7C, 0x7C, 0x0F, 0xC7, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF,
  0xC0, 0xF8, 0xFC, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x07, 0xF0, 0x7E, 0x03,
  0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x7F, 0xC0, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x7F, 0x0F, 0xC3, 0xF8, 0x3E, 0x1F, 0xC0, 0xF8, 0xFE,
  0x07, 0xE3, 0xF0, 0x1F, 0x9F, 0xC0, 0x7E, 0xFE, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xF3, 0xE0, 0x1F, 0x8F, 0xC0,
  0x7E, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xC1, 0xF8, 0x1F, 0x07, 0xE0, 0xFC,
  0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E,
  0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xFC,
  0x00, 0x0F, 0xCF, 0x81, 0xF0, 0x1F, 0x7F, 0x8F, 0xF8, 0x3F, 0xFF, 0xBF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xF8, 0x7F, 0x0F,
  0xC7, 0xE0, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0x3F, 0x1F, 0x03, 0xF0, 0x7E,
  0x3E, 0x07, 0xE0, 0xFC, 0xFC, 0x0F, 0x81, 0xF9, 0xF8, 0x1F, 0x03, 0xF3,
  0xF0, 0x7E, 0x07, 0xC7, 0xE0, 0xFC, 0x0F, 0x8F, 0x81, 0xF8, 0x3F, 0x1F,
  0x03, 0xF0, 0x7E, 0x7E, 0x07, 0xC0, 0xFC, 0xFC, 0x0F, 0x81, 0xF9, 0xF8,
  0x3F, 0x03, 0xE3, 0xF0, 0x7E, 0x07, 0xC7, 0xC0, 0xFC, 0x1F, 0x8F, 0x81,
  0xF8, 0x3F, 0x3F, 0x03, 0xE0, 0x7E, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x8F,
  0x80, 0xFB, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFC,
  0x3F, 0x1F, 0x83, 0xF1, 0xF0, 0x3F, 0x1F, 0x03, 0xF3, 0xF0, 0x3F, 0x3F,
  0x03, 0xF3, 0xF0, 0x3E, 0x3F, 0x03, 0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xE7,
  0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xC0, 0xFC,
  0x7C, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xF8,
  0x7E, 0x3F, 0x03, 0xE7, 0xE0, 0x3E, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7C,
  0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x07, 0xEF,
  0xC0, 0x7E, 0xFC, 0x07, 0xC7, 0xC0, 0xFC, 0x7E, 0x1F, 0x87, 0xFF, 0xF8,
  0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xE7,
  0xE0, 0x07, 0xDF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFE, 0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3F, 0x07, 0xC0, 0x7E,
  0x0F, 0x80, 0xF8, 0x3F, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0xFC, 0x07, 0xC1,
  0xF8, 0x1F, 0x83, 0xE0, 0x3F, 0x07, 0xC0, 0x7E, 0x1F, 0x80, 0xF8, 0x3F,
  0x03, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x0F, 0xDF, 0xF0, 0x1F, 0x8F, 0x80, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF1, 0xF0,
  0x3F, 0xCF, 0x83, 0xFF, 0x7C, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0x83,
  0xF8, 0xFC, 0x0F, 0x8F, 0xC0, 0x7C, 0x7E, 0x07, 0xE3, 0xE0, 0x3F, 0x1F,
  0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7C, 0x7E, 0x07, 0xE3, 0xF0, 0x3F,
  0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7C, 0x3F, 0x87, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xF3, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x0F, 0xDE, 0x1F, 0x7C, 0x3F, 0xF8, 0x7F, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0xE0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFE, 0xFE, 0x3F, 0x0F, 0xC7,
  0xC1, 0xF8, 0xF8, 0x1F, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0xFC,
  0x0F, 0x9F, 0x81, 0xF1, 0xF0, 0x7E, 0x3F, 0xBF, 0xC3, 0xFF, 0xF0, 0x7F,
  0xFC, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8,
  0x0F, 0x81, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xF8, 0x7F, 0x87, 0xF8,
  0x3F, 0x01, 0xF0, 0x1F, 0x81, 0xF1, 0xF8, 0x3F, 0x1F, 0x03, 0xF1, 0xF0,
  0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x3E, 0x3F, 0x03, 0xE3, 0xF0, 0x7E, 0x3E,
  0x07, 0xE3, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7C, 0x7E, 0x07, 0xC7,
  0xC0, 0xFC, 0x7C, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8,
  0x7E, 0x3F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF,
  0x81, 0xF9, 0xF0, 0xFC, 0x07, 0xEF, 0x81, 0xF9, 0xF0, 0x3F, 0x3E, 0x07,
  0xC7, 0xC1, 0xF8, 0xF8, 0x3E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3E,
  0x07, 0xCF, 0xC0, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0x7D, 0xF0,
  0x0F, 0xBE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0xF8, 0x1E, 0x07, 0xDF, 0x07, 0xC1, 0xFB, 0xE0, 0xF8, 0x3F, 0x7C, 0x3F,
  0x07, 0xCF, 0x87, 0xE1, 0xF9, 0xF0, 0xFC, 0x3E, 0x3E, 0x3F, 0x87, 0xC7,
  0xC7, 0xF9, 0xF8, 0xF9, 0xFF, 0x3E, 0x1F, 0x3D, 0xE7, 0xC3, 0xE7, 0xBD,
  0xF0, 0x7D, 0xF7, 0xBE, 0x0F, 0xBC, 0xF7, 0xC1, 0xFF, 0x9F, 0xF0, 0x3F,
  0xE3, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x8F, 0xF0, 0x1F, 0xE1, 0xFE,
  0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0xF8,
  0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0xC1, 0xFC,
  0x3F, 0x07, 0xE0, 0x7C, 0x3F, 0x01, 0xF0, 0xFC, 0x07, 0xE7, 0xE0, 0x0F,
  0x9F, 0x00, 0x3E, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0x7C, 0x01, 0xF9,
  0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x81, 0xF8, 0x3E, 0x07, 0xE0, 0xFC,
  0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x3E, 0x07, 0xE0, 0xF8, 0x1F, 0x83,
  0xE0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x7E, 0x03, 0xF1,
  0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0x7D, 0xF8, 0x01, 0xF7, 0xE0,
  0x07, 0xDF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x00, 0x0C, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xC0,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x1F, 0xC0,
  0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0x80, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x01, 0x00, 0x07, 0x00, 0x3E,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xF0, 0x0F, 0xC0,
  0x7F, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80,
  0x7C, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x07, 0x00, 0x10, 0x00,
  0x0F, 0x80, 0x00, 0xFE, 0x03, 0xCF, 0xF8, 0x1E, 0xFF, 0xE0, 0xF7, 0xFF,
  0x8F, 0xFC, 0x7F, 0xFB, 0xE1, 0xFF, 0xDE, 0x07, 0xFC, 0xF0, 0x1F, 0xC0,
  0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_SemiBoldItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 11, 33, 11, 1, -33 },
  { 47, 13, 12, 14, 3, -35 },
  { 67, 23, 33, 24, 1, -33 },
  { 162, 21, 42, 22, 1, -38 },
  { 273, 22, 33, 28, 4, -33 },
  { 364, 22, 33, 25, 1, -33 },
  { 455, 6, 12, 7, 3, -35 },
  { 464, 14, 47, 14, 2, -37 },
  { 547, 14, 46, 14, -2, -36 },
  { 628, 19, 20, 20, 2, -33 },
  { 676, 20, 23, 21, 1, -27 },
  { 734, 10, 13, 10, -3, -5 },
  { 751, 11, 5, 15, 2, -17 },
  { 758, 7, 7, 13, 1, -7 },
  { 765, 21, 36, 15, -3, -33 },
  { 860, 19, 33, 22, 2, -33 },
  { 939, 13, 33, 22, 5, -33 },
  { 993, 22, 33, 22, 0, -33 },
  { 1084, 21, 33, 22, 1, -33 },
  { 1171, 21, 33, 22, 0, -33 },
  { 1258, 21, 33, 22, 2, -33 },
  { 1345, 18, 33, 22, 2, -33 },
  { 1420, 22, 33, 22, 2, -33 },
  { 1511, 21, 33, 22, 1, -33 },
  { 1598, 18, 33, 22, 3, -33 },
  { 1673, 10, 26, 12, 1, -26 },
  { 1706, 13, 34, 11, -2, -26 },
  { 1762, 18, 21, 20, 1, -25 },
  { 1810, 19, 15, 22, 2, -22 },
  { 1846, 18, 22, 20, 1, -25 },
  { 1896, 17, 33, 20, 3, -33 },
  { 1967, 32, 42, 34, 1, -32 },
  { 2135, 25, 33, 26, -2, -33 },
  { 2239, 24, 33, 25, 0, -33 },
  { 2338, 23, 33, 25, 2, -33 },
  { 2433, 24, 33, 25, 0, -33 },
  { 2532, 24, 33, 22, 0, -33 },
  { 2631, 23, 33, 21, 0, -33 },
  { 2726, 24, 33, 26, 2, -33 },
  { 2825, 28, 33, 27, 0, -33 },
  { 2941, 11, 33, 12, 1, -33 },
  { 2987, 23, 33, 22, 0, -33 },
  { 3082, 28, 33, 25, 0, -33 },
  { 3198, 19, 33, 21, 0, -33 },
  { 3277, 34, 33, 34, 0, -33 },
  { 3418, 28, 33, 27, 0, -33 },
  { 3534, 24, 33, 27, 2, -33 },
  { 3633, 25, 33, 25, 0, -33 },
  { 3737, 24, 39, 27, 2, -33 },
  { 3854, 24, 33, 24, 0, -33 },
  { 3953, 23, 33, 24, 1, -33 },
  { 4048, 22, 33, 24, 4, -33 },
  { 4139, 24, 33, 25, 2, -33 },
  { 4238, 24, 33, 26, 4, -33 },
  { 4337, 32, 33, 34, 4, -33 },
  { 4469, 28, 33, 25, -1, -33 },
  { 4585, 23, 33, 24, 4, -33 },
  { 4680, 26, 33, 24, -1, -33 },
  { 4788, 16, 45, 12, -1, -38 },
  { 4878, 10, 36, 17, 4, -33 },
  { 4923, 16, 45, 12, -3, -38 },
  { 5013, 15, 16, 17, 2, -33 },
  { 5043, 18, 5, 18, -3, 0 },
  { 5055, 9, 7, 15, 5, -35 },
  { 5063, 18, 24, 21, 1, -24 },
  { 5117, 21, 35, 22, 0, -35 },
  { 5209, 19, 24, 21, 1, -24 },
  { 5266, 22, 35, 22, 1, -35 },
  { 5363, 19, 24, 21, 1, -24 },
  { 5420, 16, 35, 15, 2, -35 },
  { 5490, 22, 33, 22, 0, -24 },
  { 5581, 20, 35, 22, 0, -35 },
  { 5669, 12, 33, 11, 0, -33 },
  { 5719, 16, 42, 11, -5, -33 },
  { 5803, 22, 35, 21, 0, -35 },
  { 5900, 12, 35, 11, 0, -35 },
  { 5953, 31, 24, 33, 0, -24 },
  { 6046, 20, 24, 22, 0, -24 },
  { 6106, 20, 24, 22, 1, -24 },
  { 6166, 23, 33, 22, -2, -24 },
  { 6261, 21, 33, 22, 1, -24 },
  { 6348, 15, 24, 14, 0, -24 },
  { 6393, 19, 24, 20, 0, -24 },
  { 6450, 12, 30, 14, 2, -30 },
  { 6495, 20, 24, 22, 1, -24 },
  { 6555, 19, 24, 20, 2, -24 },
  { 6612, 27, 24, 28, 3, -24 },
  { 6693, 22, 24, 20, -1, -24 },
  { 6759, 22, 33, 20, -1, -24 },
  { 6850, 21, 24, 20, -1, -24 },
  { 6913, 14, 44, 13, 1, -36 },
  { 6990, 10, 39, 11, 1, -33 },
  { 7039, 14, 44, 13, -2, -36 },
  { 7116, 21, 10, 25, 2, -19 },
};

const GFXfont RobotoCondensed_SemiBoldItalic46pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic46pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic46pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC46PT7B_H_
