#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC34PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x38, 0x38, 0x78, 0x78, 0x00, 0x00, 0x00, 0x60, 0xF0, 0xF0, 0xF0,
  0x60, 0x39, 0xDE, 0x77, 0x39, 0xCE, 0x73, 0x9C, 0xE6, 0x31, 0x8C, 0xE7,
  0x00, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x31, 0x80, 0x39, 0xC0, 0x1C, 0xE0,
  0x0C, 0x60, 0x0E, 0x70, 0x3F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0x81, 0xCE,
  0x00, 0xC7, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x31, 0xC1, 0xFF, 0xF8, 0xFF,
  0xFC, 0x7F, 0xFE, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x03, 0x8C, 0x01,
  0xCE, 0x00, 0xE7, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00,
  0x1F, 0x00, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x1E, 0x1E, 0x3C, 0x3C, 0x78,
  0x78, 0xF0, 0xF1, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x7C,
  0x7C, 0x7F, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0x7C, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0xE3, 0x86, 0xE3,
  0x8E, 0xE3, 0x9C, 0xE3, 0xB8, 0xE3, 0x38, 0xFF, 0x70, 0x7E, 0xE0, 0x3C,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x3C, 0x07, 0x7E, 0x0E, 0xFF, 0x1D,
  0xC7, 0x1D, 0xC7, 0x39, 0xC7, 0x71, 0xC7, 0xE1, 0xCE, 0x21, 0xFE, 0x00,
  0xFC, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x1E,
  0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0xF8, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0x80, 0x1F, 0xC7, 0x3F, 0xCF, 0x7B, 0xEF, 0xF9, 0xEF, 0xF1,
  0xFE, 0xF0, 0xFE, 0xF0, 0xFC, 0xF0, 0x78, 0xFF, 0xFC, 0x7F, 0xFC, 0x7F,
  0xFE, 0x1F, 0x1E, 0x3B, 0xDC, 0xE7, 0x39, 0xDC, 0xE0, 0x00, 0x40, 0x70,
  0x3C, 0x1E, 0x07, 0x03, 0xC1, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0x81, 0xE0,
  0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01,
  0xE0, 0x38, 0x06, 0x00, 0x80, 0x02, 0x00, 0x60, 0x1E, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x0F, 0x03,
  0xC0, 0x70, 0x0C, 0x01, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x43, 0x8B, 0xED, 0xFF, 0xFF, 0xCF, 0xFC, 0x0F, 0x80, 0x7E, 0x03,
  0xF8, 0x0E, 0x70, 0x71, 0xE1, 0xC3, 0x82, 0x08, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x1E, 0x3C, 0x78, 0xE3, 0xC7, 0x9E, 0x3C,
  0xF0, 0xC0, 0x7F, 0xBF, 0x9F, 0xCF, 0xE0, 0x67, 0xBF, 0xE7, 0x00, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x01, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE1, 0xE3, 0xE7, 0x83, 0xCF,
  0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0xF8, 0x3D, 0xE0, 0xFB, 0xC1, 0xE7, 0x83,
  0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0xF8, 0x7D, 0xE0, 0xF1, 0xE1, 0xE3,
  0xC7, 0x87, 0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0x07, 0xC0, 0x00, 0xC1, 0xE1,
  0xFB, 0xFE, 0xFF, 0xBD, 0xEC, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC1, 0xF0, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x1F,
  0x1F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3E, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFC, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE3, 0xE3,
  0xE7, 0x83, 0xCF, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x03, 0xF0, 0x1F, 0xC0,
  0x3F, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x79, 0xE0,
  0xF3, 0xC1, 0xE7, 0x87, 0xCF, 0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE,
  0x01, 0xFE, 0x03, 0xFE, 0x03, 0xBC, 0x07, 0xBC, 0x0F, 0x3C, 0x0F, 0x3C,
  0x1E, 0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE,
  0xFF, 0xFE, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3D, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3E, 0xF8,
  0x08, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0xF0, 0x7C,
  0xF0, 0x78, 0xF8, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0x80,
  0x00, 0x78, 0x07, 0xE0, 0x3F, 0x81, 0xFE, 0x0F, 0x80, 0x7C, 0x01, 0xE0,
  0x0F, 0x80, 0x3D, 0xE0, 0xFF, 0xE7, 0xFF, 0x9F, 0xFF, 0x7C, 0x7D, 0xE0,
  0xF7, 0x83, 0xDE, 0x0F, 0x78, 0x3D, 0xE0, 0xF7, 0x87, 0x9E, 0x1E, 0x7F,
  0xF0, 0xFF, 0xC1, 0xFE, 0x03, 0xE0, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB,
  0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF1, 0xE3,
  0xE3, 0xC3, 0xCF, 0x87, 0x9F, 0x1F, 0x1E, 0x3C, 0x3F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x03, 0xFF, 0x0F, 0x9F, 0x1E, 0x1E, 0x7C, 0x3C, 0xF0, 0x79, 0xE0,
  0xF3, 0xC1, 0xE7, 0xC7, 0xC7, 0xFF, 0x0F, 0xFE, 0x0F, 0xF8, 0x0F, 0xC0,
  0x07, 0xC0, 0x3F, 0xC1, 0xFF, 0x0F, 0xFE, 0x7C, 0x79, 0xE1, 0xE7, 0x83,
  0xDE, 0x0F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0x9E, 0x1E, 0x7D, 0xF9, 0xFF,
  0xE3, 0xFF, 0x87, 0xBC, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x7F,
  0x81, 0xFC, 0x07, 0xE0, 0x1E, 0x00, 0x1C, 0x7C, 0xF9, 0xF1, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x78, 0xF9, 0xE1, 0xC0, 0x03,
  0x81, 0xF0, 0x7C, 0x1F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70,
  0x3C, 0x0F, 0x07, 0x81, 0xC0, 0x20, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x3E,
  0x0F, 0xE1, 0xFF, 0x3F, 0xC3, 0xF8, 0x1F, 0x00, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0x70, 0x01, 0x00, 0x3F, 0xFC, 0xFF, 0xF3,
  0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF9,
  0xFF, 0xE7, 0xFF, 0xBF, 0xFE, 0x20, 0x01, 0xC0, 0x0F, 0x80, 0x7F, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0x01, 0xF8, 0x3F, 0xC7, 0xF9, 0xFF,
  0x0F, 0xE0, 0x7C, 0x03, 0x80, 0x10, 0x00, 0x0F, 0xC0, 0xFF, 0x0F, 0xFC,
  0xFF, 0xE7, 0x8F, 0xBC, 0x7F, 0xE3, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1E, 0x01, 0xC0, 0x78, 0x01,
  0xC1, 0xE0, 0x03, 0x83, 0x80, 0x03, 0x0E, 0x0F, 0x87, 0x1C, 0x3F, 0x8E,
  0x70, 0xFF, 0x1C, 0xE3, 0xCE, 0x3B, 0x8F, 0x1C, 0x77, 0x1C, 0x38, 0xEE,
  0x38, 0x71, 0xF8, 0xF1, 0xC3, 0xF1, 0xC3, 0x87, 0xE3, 0x87, 0x0D, 0xC7,
  0x0E, 0x1B, 0x8E, 0x38, 0x77, 0x1C, 0x70, 0xCE, 0x39, 0xE3, 0x9C, 0x7F,
  0xEE, 0x38, 0xFD, 0xF8, 0x70, 0xF1, 0xE0, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x01, 0xEF, 0x00, 0x79, 0xC0, 0x3C, 0x78, 0x0F, 0x1E, 0x07, 0x87, 0x81,
  0xE1, 0xE0, 0xF8, 0x78, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE3, 0xFF,
  0xFC, 0xF0, 0x0F, 0x7C, 0x03, 0xDE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0x07, 0xC3,
  0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1E, 0x0F, 0x87, 0x87, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0x87, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C,
  0x3C, 0x0F, 0x1F, 0x03, 0xC7, 0xC1, 0xF1, 0xE0, 0x7C, 0x7F, 0xFE, 0x1F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7F,
  0xF0, 0x3F, 0xFE, 0x1F, 0x07, 0x87, 0x81, 0xF3, 0xE0, 0x7C, 0xF0, 0x1F,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x1E, 0x03, 0xC7, 0x81,
  0xF1, 0xF0, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0x80,
  0x0F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0x0F, 0x83,
  0xC1, 0xE1, 0xF0, 0x7C, 0x7C, 0x0F, 0x1E, 0x07, 0xC7, 0x81, 0xF1, 0xE0,
  0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x3E,
  0x3C, 0x0F, 0x9F, 0x03, 0xC7, 0xC1, 0xF1, 0xE0, 0xF8, 0x7F, 0xFC, 0x1F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF0,
  0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFE,
  0x1F, 0x07, 0x87, 0x81, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x7F, 0x9E, 0x1F, 0xE7, 0x87,
  0xF9, 0xE0, 0x3E, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x81, 0xF1, 0xF0, 0x7C,
  0x3F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0xF8,
  0x7C, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80,
  0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xF0, 0x0F,
  0x07, 0x80, 0x78, 0x3C, 0x03, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0xF0,
  0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x3E, 0x1F, 0x01, 0xF0,
  0x07, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x3E, 0x1F, 0x0F, 0x07,
  0x83, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x0F, 0x87, 0x83,
  0xC1, 0xE0, 0xF0, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x7C, 0x3E, 0x3E, 0x1E, 0x1F, 0x1F, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x00, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x03,
  0xC1, 0xF8, 0x1E, 0x1F, 0x80, 0xF0, 0xF8, 0x07, 0x8F, 0x80, 0x7C, 0xF8,
  0x03, 0xEF, 0x80, 0x1E, 0x7C, 0x00, 0xF7, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFD, 0xE0, 0x07, 0xCF, 0x00,
  0x3C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0x00, 0xF0, 0x7C, 0x07, 0x83,
  0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x7F, 0xFD, 0xFF, 0xF7,
  0xFF, 0xBF, 0xFE, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07,
  0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x81,
  0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0x70, 0xF7, 0x87, 0xB8,
  0x7F, 0xC7, 0xDC, 0x3B, 0xC3, 0xCE, 0x3D, 0xE1, 0xE7, 0x1C, 0xF0, 0xF3,
  0x9E, 0x78, 0x79, 0xEE, 0x7C, 0x3C, 0xFF, 0x3E, 0x3E, 0x3F, 0x1E, 0x1F,
  0x1F, 0x8F, 0x0F, 0x0F, 0x87, 0x87, 0x87, 0xC7, 0xC3, 0xC3, 0xE3, 0xE1,
  0xE1, 0xE1, 0xE1, 0xF0, 0xF0, 0xF0, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0x83,
  0xE0, 0x3C, 0x1F, 0x81, 0xE0, 0xFC, 0x0F, 0x07, 0xE0, 0xF8, 0x7F, 0x87,
  0xC3, 0xFC, 0x3C, 0x1E, 0xE1, 0xE0, 0xF7, 0x0F, 0x07, 0xBC, 0x78, 0x7C,
  0xE7, 0xC3, 0xE7, 0x3C, 0x1F, 0x3D, 0xE0, 0xF0, 0xEF, 0x07, 0x87, 0x78,
  0x3C, 0x3F, 0xC3, 0xE1, 0xFE, 0x1F, 0x07, 0xE0, 0xF0, 0x3F, 0x07, 0x81,
  0xF8, 0x3C, 0x07, 0xC1, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0x07, 0x87, 0x81, 0xF3, 0xE0,
  0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xDF, 0x00, 0xF7, 0xC0, 0x3D, 0xE0, 0x1F,
  0x78, 0x07, 0xDE, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x0F, 0x9E,
  0x03, 0xC7, 0x81, 0xF1, 0xF0, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF,
  0x80, 0x1F, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF,
  0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x87, 0xC0, 0xF8, 0xF8, 0x1F, 0x1E, 0x03,
  0xC3, 0xC0, 0xF8, 0x78, 0x1F, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC,
  0x0F, 0xFE, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0x07, 0x87,
  0x81, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xDF, 0x00, 0xF7, 0x80,
  0x7D, 0xE0, 0x1F, 0x78, 0x07, 0xDE, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E,
  0x78, 0x0F, 0x9E, 0x03, 0xC7, 0x81, 0xF1, 0xF0, 0xF8, 0x7F, 0xFE, 0x0F,
  0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xC0, 0x00, 0x20, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0x07, 0xC3, 0xC1, 0xF1, 0xF0, 0x3C, 0x7C, 0x0F, 0x1E, 0x07, 0xC7,
  0x81, 0xE1, 0xE0, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF,
  0x80, 0xF1, 0xF0, 0x3C, 0x7C, 0x1F, 0x0F, 0x07, 0xC3, 0xC1, 0xE0, 0xF8,
  0x78, 0x3E, 0x1E, 0x07, 0x87, 0x81, 0xF3, 0xE0, 0x7C, 0x01, 0xF8, 0x03,
  0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xE1, 0xF0, 0xF1, 0xF0, 0x7C, 0xF8, 0x3E,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0xF0, 0x3E, 0x78, 0x1F, 0x3C,
  0x0F, 0x9F, 0x0F, 0x87, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x1F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x3E, 0x07, 0xCF,
  0x81, 0xF3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x03, 0xE7, 0xC0,
  0xF9, 0xF0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x7C,
  0xF8, 0x1F, 0x3E, 0x07, 0x8F, 0x81, 0xE1, 0xE0, 0xF8, 0x7F, 0xFC, 0x1F,
  0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0xF0, 0x07, 0xFC, 0x03, 0xEF, 0x80,
  0xFB, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0x87, 0x83, 0xE1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x1F, 0x07, 0x87, 0x81, 0xE3, 0xE0, 0x78, 0xF0, 0x1E,
  0x3C, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0xF0, 0x38, 0x1F, 0xE0, 0xF8, 0x3F, 0xC1, 0xF0, 0xFF, 0x83, 0xE1, 0xEF,
  0x0F, 0xC3, 0xDE, 0x1F, 0x8F, 0xBC, 0x3F, 0x1E, 0x78, 0xFE, 0x3C, 0xF1,
  0xFC, 0xF9, 0xE3, 0xF9, 0xE3, 0xCF, 0xF3, 0xC7, 0x9C, 0xEF, 0x0F, 0x79,
  0xDE, 0x1E, 0xF3, 0xBC, 0x3D, 0xC7, 0xF0, 0x7F, 0x8F, 0xE0, 0xFF, 0x1F,
  0xC1, 0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xC1, 0xF0,
  0x0F, 0x83, 0xE0, 0x1E, 0x07, 0xC0, 0x3C, 0x0F, 0x00, 0x0F, 0x80, 0xF8,
  0x3C, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x3C, 0x7C, 0x01, 0xE3,
  0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xBE, 0x00, 0x7C, 0xF0, 0x07, 0xC7, 0x80, 0x3E,
  0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x07, 0x81, 0xF0, 0x3E, 0x1F, 0x81, 0xF0,
  0xF8, 0x0F, 0xFC, 0x0F, 0xBE, 0x07, 0xCF, 0x07, 0xC7, 0x83, 0xC3, 0xC3,
  0xE1, 0xF1, 0xE0, 0x79, 0xF0, 0x3C, 0xF0, 0x1E, 0xF0, 0x0F, 0x78, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF,
  0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0,
  0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0xF0, 0x1E,
  0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x83,
  0xF0, 0xFC, 0x1F, 0x80, 0x03, 0x80, 0x78, 0x1F, 0x07, 0xE0, 0xFC, 0x3F,
  0x87, 0x71, 0xEE, 0x38, 0xEF, 0x1D, 0xC3, 0xF8, 0x70, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x78, 0xF8, 0xF0, 0xF0, 0xE0, 0x03, 0xF0, 0x3F, 0xE1, 0xFF,
  0xC7, 0xDF, 0x3E, 0x3C, 0xF0, 0xF0, 0x03, 0xC1, 0xFF, 0x1F, 0xFC, 0xFF,
  0xF7, 0xC7, 0x9E, 0x1E, 0xF8, 0x7B, 0xE3, 0xE7, 0xFF, 0x9F, 0xFE, 0x3F,
  0xF8, 0x79, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0xF8, 0x3F, 0xF8, 0x7F, 0xF9,
  0xFF, 0xF3, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0xF8,
  0x3D, 0xE0, 0x7B, 0xC1, 0xF7, 0x83, 0xCF, 0x07, 0x9F, 0xFF, 0x7F, 0xFC,
  0xF7, 0xF1, 0xE7, 0xC0, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x8F, 0xFE, 0x78,
  0x79, 0xE0, 0xEF, 0x83, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0xF3, 0xC3, 0xCF, 0xFF, 0x1F, 0xF8, 0x3F, 0xC0, 0x7E, 0x00,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x0F, 0x9E, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xFC,
  0x7C, 0x7C, 0x78, 0x3C, 0xF8, 0x3C, 0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0x78,
  0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF8, 0xFF, 0xF0, 0x7F, 0xF0,
  0x7F, 0xF0, 0x3E, 0xF0, 0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFE, 0x7C,
  0x3D, 0xE0, 0xF7, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xE0, 0x87, 0xFF, 0x1F, 0xFC, 0x3F, 0xE0, 0x7E, 0x00,
  0x01, 0xF0, 0x3F, 0x07, 0xF0, 0xFF, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0,
  0x7F, 0xC7, 0xFC, 0x7F, 0xC1, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0xF8, 0x0F, 0x00, 0x07, 0xCF, 0x0F, 0xEF, 0x1F, 0xFF, 0x1F, 0xFF, 0x3E,
  0x1E, 0x3C, 0x1E, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x78,
  0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xF8, 0x1F, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x40, 0xF0, 0x7B, 0xF0, 0xFF,
  0xE0, 0x7F, 0xC0, 0x3F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0xF8, 0x3F, 0xF8,
  0x7F, 0xF1, 0xFF, 0xF3, 0xE3, 0xE7, 0x87, 0xCF, 0x0F, 0x9E, 0x1F, 0x3C,
  0x3C, 0xF8, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x87, 0xCF, 0x0F, 0x1E, 0x1E,
  0x7C, 0x3C, 0xF0, 0x79, 0xE0, 0xF0, 0x06, 0x07, 0x83, 0xE1, 0xE0, 0x70,
  0x00, 0x00, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x1F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0x00, 0x00,
  0x60, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x7F, 0x07, 0xE0, 0x7C, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x1F, 0x0F, 0x1F, 0x07, 0x9F, 0x07, 0xCF,
  0x83, 0xEF, 0x81, 0xEF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xBC, 0x07, 0x9F, 0x03, 0xC7, 0x81, 0xE3, 0xC1,
  0xF1, 0xF0, 0xF0, 0x78, 0x78, 0x3E, 0x00, 0x07, 0x87, 0xC3, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xF0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0x7C,
  0x00, 0x1E, 0xF8, 0x78, 0x3F, 0xFB, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF3, 0xE3, 0xE1, 0xE7, 0x87, 0xC3, 0xCF, 0x0F, 0x87, 0x9E, 0x1E, 0x0F,
  0x3C, 0x3C, 0x3E, 0x78, 0x78, 0x79, 0xF0, 0xF0, 0xF3, 0xC1, 0xE1, 0xE7,
  0x87, 0xC3, 0xCF, 0x0F, 0x07, 0x9E, 0x1E, 0x1F, 0x7C, 0x3C, 0x3C, 0xF8,
  0x78, 0x79, 0xE0, 0xF0, 0xF0, 0x1E, 0xF8, 0x3F, 0xF8, 0x7F, 0xF1, 0xFF,
  0xF3, 0xE3, 0xE7, 0x87, 0xCF, 0x0F, 0x9E, 0x1E, 0x3C, 0x3C, 0xF8, 0x79,
  0xE0, 0xF3, 0xC1, 0xE7, 0x87, 0xCF, 0x0F, 0x1E, 0x1E, 0x7C, 0x3C, 0xF0,
  0x79, 0xE0, 0xF0, 0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFF, 0x7C, 0x3D,
  0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F,
  0xF0, 0x7B, 0xE3, 0xE7, 0xFF, 0x1F, 0xFC, 0x3F, 0xC0, 0x7E, 0x00, 0x0F,
  0x7C, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0x0F, 0x1E, 0x0F, 0x1E,
  0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3E, 0x0F, 0x3C, 0x1F, 0x3C,
  0x1E, 0x3C, 0x3E, 0x3F, 0xFE, 0x7F, 0xFC, 0x7B, 0xF8, 0x79, 0xF0, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x0F, 0x9E, 0x3F, 0xBC, 0xFF, 0xFB, 0xFF, 0xE7, 0xC3, 0xCF, 0x07,
  0xBE, 0x0F, 0x78, 0x3E, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF,
  0x07, 0x9E, 0x1F, 0x3F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0x7D, 0xE0, 0x03,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x1E, 0xE3, 0xFC, 0x7F, 0x8F, 0xF3, 0xF0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C,
  0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E,
  0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x87, 0x9F, 0x3C, 0x3C, 0xF0, 0xF3,
  0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x00, 0x3E, 0xF0, 0x7B,
  0xC1, 0xE7, 0x8F, 0x1F, 0xFC, 0x3F, 0xE0, 0x3E, 0x00, 0x0F, 0x07, 0xC1,
  0xE0, 0x78, 0x7F, 0xBF, 0xEF, 0xF8, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0xE1, 0xF8, 0x7E, 0x0F,
  0x80, 0x3C, 0x1E, 0x78, 0x7C, 0xF0, 0xF3, 0xE1, 0xE7, 0x83, 0xCF, 0x07,
  0x9E, 0x0F, 0x3C, 0x3E, 0x78, 0x79, 0xF0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF,
  0x0F, 0x9E, 0x1F, 0x3F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0x7D, 0xE0, 0xF0,
  0x7F, 0x87, 0xFC, 0x3D, 0xE1, 0xEF, 0x1E, 0x78, 0xF1, 0xC7, 0x8E, 0x78,
  0x7B, 0xC3, 0xDC, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0xE0, 0xFF, 0x0E, 0x1E, 0xF1, 0xF1,
  0xEF, 0x1F, 0x1C, 0xF3, 0xF3, 0xCF, 0x3F, 0x3C, 0xF3, 0xF7, 0x8F, 0x7F,
  0x78, 0xF7, 0x77, 0x8F, 0xF7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xE0, 0x7C,
  0x7E, 0x07, 0xC7, 0xE0, 0x7C, 0x7C, 0x07, 0x87, 0xC0, 0x78, 0x7C, 0x07,
  0x07, 0x80, 0x1F, 0x0F, 0x0F, 0x1F, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x7C,
  0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3E, 0xF8, 0x7C, 0x78, 0x78, 0x78,
  0xF8, 0x7C, 0x1E, 0x0F, 0x0F, 0x0F, 0x87, 0x87, 0x83, 0xC3, 0xC1, 0xE3,
  0xE0, 0xF1, 0xE0, 0x79, 0xF0, 0x1C, 0xF0, 0x0F, 0x78, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x3F, 0xF8,
  0xFF, 0xF1, 0xFF, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0xFC,
  0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0xC0, 0x70, 0x3C, 0x1E, 0x07,
  0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x07,
  0xC3, 0xE0, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x08, 0x00,
  0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x87,
  0x0C, 0x18, 0x70, 0xE1, 0xC3, 0x86, 0x0C, 0x38, 0x70, 0xE1, 0xC3, 0x86,
  0x00, 0x04, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC1, 0xF0,
  0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0,
  0x38, 0x1E, 0x0F, 0x03, 0x80, 0xC0, 0x00, 0x1E, 0x00, 0x3F, 0x87, 0x7F,
  0xC7, 0x7F, 0xFF, 0x71, 0xFE, 0xF0, 0xFE, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_SemiBoldItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 24, 8, 1, -24 },
  { 25, 10, 9, 11, 2, -26 },
  { 37, 17, 24, 18, 1, -24 },
  { 88, 15, 31, 17, 1, -28 },
  { 147, 16, 24, 21, 3, -24 },
  { 195, 16, 24, 19, 1, -24 },
  { 243, 5, 9, 5, 2, -26 },
  { 249, 10, 35, 11, 2, -27 },
  { 293, 11, 35, 11, -2, -27 },
  { 342, 14, 15, 15, 2, -24 },
  { 369, 14, 18, 16, 1, -20 },
  { 401, 7, 10, 8, -2, -4 },
  { 410, 9, 4, 11, 1, -13 },
  { 415, 5, 5, 9, 1, -5 },
  { 419, 15, 26, 11, -2, -24 },
  { 468, 15, 24, 17, 1, -24 },
  { 513, 10, 24, 17, 4, -24 },
  { 543, 16, 24, 17, 0, -24 },
  { 591, 15, 24, 17, 1, -24 },
  { 636, 16, 24, 17, 0, -24 },
  { 684, 16, 24, 17, 1, -24 },
  { 732, 14, 24, 17, 1, -24 },
  { 774, 15, 24, 17, 2, -24 },
  { 819, 15, 24, 17, 1, -24 },
  { 864, 14, 24, 17, 2, -24 },
  { 906, 7, 19, 9, 1, -19 },
  { 923, 10, 25, 8, -2, -19 },
  { 955, 13, 15, 15, 1, -18 },
  { 980, 14, 12, 16, 1, -17 },
  { 1001, 13, 16, 15, 1, -18 },
  { 1027, 13, 24, 15, 2, -24 },
  { 1066, 23, 32, 25, 1, -24 },
  { 1158, 18, 24, 20, -1, -24 },
  { 1212, 18, 24, 18, 0, -24 },
  { 1266, 18, 24, 19, 1, -24 },
  { 1320, 18, 24, 19, 0, -24 },
  { 1374, 18, 24, 16, 0, -24 },
  { 1428, 17, 24, 16, 0, -24 },
  { 1479, 18, 24, 19, 1, -24 },
  { 1533, 21, 24, 20, 0, -24 },
  { 1596, 9, 24, 9, 0, -24 },
  { 1623, 17, 24, 16, 0, -24 },
  { 1674, 21, 24, 18, 0, -24 },
  { 1737, 14, 24, 16, 0, -24 },
  { 1779, 25, 24, 25, 0, -24 },
  { 1854, 21, 24, 20, 0, -24 },
  { 1917, 18, 24, 20, 1, -24 },
  { 1971, 19, 24, 19, 0, -24 },
  { 2028, 18, 28, 20, 1, -24 },
  { 2091, 18, 24, 18, 0, -24 },
  { 2145, 17, 24, 18, 1, -24 },
  { 2196, 16, 24, 18, 3, -24 },
  { 2244, 18, 24, 19, 1, -24 },
  { 2298, 18, 24, 19, 3, -24 },
  { 2352, 23, 24, 25, 3, -24 },
  { 2421, 21, 24, 18, -1, -24 },
  { 2484, 17, 24, 18, 3, -24 },
  { 2535, 19, 24, 17, 0, -24 },
  { 2592, 12, 34, 9, -1, -28 },
  { 2643, 8, 26, 12, 3, -24 },
  { 2669, 11, 34, 9, -2, -28 },
  { 2716, 11, 12, 13, 1, -24 },
  { 2733, 13, 3, 13, -2, 0 },
  { 2738, 7, 5, 11, 3, -25 },
  { 2743, 14, 18, 16, 0, -18 },
  { 2775, 15, 26, 16, 0, -26 },
  { 2824, 14, 18, 15, 1, -18 },
  { 2856, 16, 26, 16, 1, -26 },
  { 2908, 14, 18, 16, 1, -18 },
  { 2940, 12, 26, 11, 1, -26 },
  { 2979, 16, 25, 17, 0, -18 },
  { 3029, 15, 26, 16, 0, -26 },
  { 3078, 9, 25, 8, 0, -25 },
  { 3107, 12, 32, 8, -4, -25 },
  { 3155, 17, 26, 16, 0, -26 },
  { 3211, 9, 26, 8, 0, -26 },
  { 3241, 23, 18, 25, 0, -18 },
  { 3293, 15, 18, 16, 0, -18 },
  { 3327, 14, 18, 16, 1, -18 },
  { 3359, 16, 25, 16, -1, -18 },
  { 3409, 15, 25, 16, 1, -18 },
  { 3456, 11, 18, 11, 0, -18 },
  { 3481, 14, 18, 15, 0, -18 },
  { 3513, 10, 22, 10, 1, -22 },
  { 3541, 15, 18, 16, 1, -18 },
  { 3575, 13, 18, 15, 2, -18 },
  { 3605, 20, 18, 21, 2, -18 },
  { 3650, 16, 18, 15, -1, -18 },
  { 3686, 17, 25, 14, -1, -18 },
  { 3740, 15, 18, 15, 0, -18 },
  { 3774, 10, 33, 10, 1, -27 },
  { 3816, 7, 28, 8, 1, -24 },
  { 3841, 10, 33, 10, -1, -27 },
  { 3883, 16, 7, 19, 1, -13 },
};

const GFXfont RobotoCondensed_SemiBoldItalic34pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic34pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic34pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC34PT7B_H_
