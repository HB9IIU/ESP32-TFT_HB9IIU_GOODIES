#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC9PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x48, 0xF0, 0x29, 0x9E, 0xAF, 0x32, 0x80, 0x23, 0x54, 0x21,
  0x96, 0x40, 0xCD, 0xE4, 0x7B, 0x30, 0x32, 0x9C, 0xCB, 0x49, 0xC0, 0xC0,
  0x29, 0x29, 0x22, 0x40, 0x55, 0x56, 0x80, 0x27, 0x66, 0x22, 0xF6, 0x40,
  0x54, 0xC0, 0x80, 0x11, 0x12, 0x24, 0x44, 0x35, 0x55, 0x99, 0x60, 0x79,
  0x24, 0x90, 0x75, 0x13, 0x24, 0xF0, 0x75, 0x12, 0x19, 0x60, 0x13, 0x55,
  0xF2, 0x20, 0x74, 0x71, 0x19, 0x60, 0x34, 0x75, 0xDD, 0x60, 0x78, 0x84,
  0x42, 0x21, 0x00, 0x35, 0x56, 0xD9, 0x60, 0xF6, 0xDE, 0xA0, 0x40, 0x80,
  0x40, 0xA8, 0x1E, 0xC2, 0x70, 0xF0, 0x43, 0x68, 0xF5, 0xA8, 0x20, 0x3D,
  0x15, 0xEB, 0xB6, 0xF8, 0x1C, 0x31, 0x8C, 0xA7, 0x4A, 0x60, 0x72, 0x56,
  0xED, 0x4B, 0xC0, 0x32, 0x50, 0x8C, 0x69, 0xC0, 0x72, 0xD2, 0xBD, 0x4B,
  0x80, 0x7A, 0x10, 0xEC, 0x43, 0xC0, 0x72, 0x10, 0xEC, 0x42, 0x00, 0x3A,
  0x50, 0xBD, 0xA9, 0xC0, 0x4A, 0x52, 0xFC, 0xCE, 0x40, 0x55, 0x78, 0x11,
  0x11, 0x1A, 0xE0, 0x4A, 0x9C, 0xCF, 0x4A, 0x40, 0x44, 0x44, 0xC8, 0xF0,
  0x66, 0xC9, 0xB3, 0x6F, 0x56, 0xA9, 0x00, 0x4B, 0x5A, 0xDD, 0xCE, 0x40,
  0x32, 0x52, 0x9C, 0xA9, 0xC0, 0x72, 0x52, 0xEC, 0x42, 0x00, 0x32, 0x52,
  0x9C, 0xE9, 0xC2, 0x72, 0x56, 0xEF, 0x4A, 0x40, 0x32, 0x50, 0xE1, 0x49,
  0xC0, 0xF4, 0x44, 0x44, 0xC0, 0x4A, 0x52, 0xBD, 0x69, 0xC0, 0x94, 0xAD,
  0x4A, 0x63, 0x00, 0xA6, 0xBA, 0xB6, 0xDB, 0x49, 0x00, 0x4A, 0x8C, 0x47,
  0x2A, 0x40, 0x9A, 0xA4, 0x44, 0xC0, 0x78, 0x8C, 0x44, 0x63, 0xC0, 0x69,
  0x2D, 0x26, 0xAA, 0xA5, 0x22, 0x22, 0x26, 0x44, 0x2D, 0x80, 0x70, 0x90,
  0x71, 0x7A, 0xE0, 0x44, 0x75, 0xD9, 0xE0, 0x6D, 0x8A, 0x60, 0x10, 0x9D,
  0xA9, 0x49, 0x80, 0x75, 0xF8, 0x60, 0x2B, 0xA4, 0xA0, 0x7D, 0x99, 0x72,
  0xE0, 0x44, 0x75, 0xD9, 0xA0, 0x45, 0xE8, 0x20, 0x96, 0x92, 0xC0, 0x44,
  0x56, 0xEA, 0xA0, 0x55, 0xE8, 0x7D, 0x5D, 0x6D, 0xA4, 0x75, 0xD9, 0xA0,
  0x7D, 0x99, 0x60, 0x75, 0xD9, 0xE8, 0x80, 0x7D, 0x99, 0x62, 0x20, 0x6B,
  0x48, 0x64, 0x6A, 0xE0, 0x5D, 0x2C, 0x80, 0x55, 0xD9, 0xE0, 0x56, 0x66,
  0x40, 0xAF, 0xBD, 0x6A, 0x00, 0x56, 0x66, 0xA0, 0x56, 0x66, 0x44, 0x80,
  0x72, 0x44, 0xE0, 0x29, 0x28, 0x92, 0x40, 0x55, 0x6A, 0x55, 0x5A, 0x80,
  0x6D, 0x80,
};

const GFXglyph RobotoCondensed_SemiBoldItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 7, 2, 0, -7 },
  { 3, 2, 2, 3, 1, -7 },
  { 4, 5, 7, 5, 0, -7 },
  { 9, 4, 9, 4, 0, -8 },
  { 14, 4, 7, 6, 1, -7 },
  { 18, 5, 7, 5, 0, -7 },
  { 23, 1, 2, 1, 1, -7 },
  { 24, 3, 9, 3, 0, -7 },
  { 28, 2, 9, 3, 0, -7 },
  { 31, 4, 4, 4, 0, -7 },
  { 33, 4, 5, 4, 0, -5 },
  { 36, 2, 3, 2, -1, -1 },
  { 37, 3, 1, 3, 0, -3 },
  { 38, 2, 1, 2, 0, -1 },
  { 39, 4, 8, 3, -1, -7 },
  { 43, 4, 7, 4, 0, -7 },
  { 47, 3, 7, 4, 1, -7 },
  { 50, 4, 7, 4, 0, -7 },
  { 54, 4, 7, 4, 0, -7 },
  { 58, 4, 7, 4, 0, -7 },
  { 62, 4, 7, 4, 0, -7 },
  { 66, 4, 7, 4, 0, -7 },
  { 70, 5, 7, 4, 0, -7 },
  { 75, 4, 7, 4, 0, -7 },
  { 79, 3, 7, 4, 1, -7 },
  { 82, 2, 5, 2, 0, -5 },
  { 84, 2, 7, 2, 0, -5 },
  { 86, 4, 4, 4, 0, -5 },
  { 88, 4, 3, 4, 0, -4 },
  { 90, 4, 4, 4, 0, -5 },
  { 92, 3, 7, 4, 1, -7 },
  { 95, 6, 8, 7, 0, -6 },
  { 101, 5, 7, 5, 0, -7 },
  { 106, 5, 7, 5, 0, -7 },
  { 111, 5, 7, 5, 0, -7 },
  { 116, 5, 7, 5, 0, -7 },
  { 121, 5, 7, 4, 0, -7 },
  { 126, 5, 7, 4, 0, -7 },
  { 131, 5, 7, 5, 0, -7 },
  { 136, 5, 7, 5, 0, -7 },
  { 141, 2, 7, 2, 0, -7 },
  { 143, 4, 7, 4, 0, -7 },
  { 147, 5, 7, 5, 0, -7 },
  { 152, 4, 7, 4, 0, -7 },
  { 156, 7, 7, 7, 0, -7 },
  { 163, 5, 7, 5, 0, -7 },
  { 168, 5, 7, 5, 0, -7 },
  { 173, 5, 7, 5, 0, -7 },
  { 178, 5, 8, 5, 0, -7 },
  { 183, 5, 7, 5, 0, -7 },
  { 188, 5, 7, 5, 0, -7 },
  { 193, 4, 7, 5, 1, -7 },
  { 197, 5, 7, 5, 0, -7 },
  { 202, 5, 7, 5, 1, -7 },
  { 207, 6, 7, 7, 1, -7 },
  { 213, 5, 7, 5, 0, -7 },
  { 218, 4, 7, 5, 1, -7 },
  { 222, 5, 7, 5, 0, -7 },
  { 227, 3, 8, 2, 0, -7 },
  { 230, 2, 8, 3, 1, -7 },
  { 232, 4, 8, 2, -1, -7 },
  { 236, 3, 3, 3, 0, -7 },
  { 238, 4, 1, 4, -1, 0 },
  { 239, 2, 2, 3, 1, -7 },
  { 240, 4, 5, 4, 0, -5 },
  { 243, 4, 7, 4, 0, -7 },
  { 247, 4, 5, 4, 0, -5 },
  { 250, 5, 7, 4, 0, -7 },
  { 255, 4, 5, 4, 0, -5 },
  { 258, 3, 7, 3, 0, -7 },
  { 261, 4, 7, 4, 0, -5 },
  { 265, 4, 7, 4, 0, -7 },
  { 269, 2, 7, 2, 0, -7 },
  { 271, 3, 9, 2, -1, -7 },
  { 275, 4, 7, 4, 0, -7 },
  { 279, 2, 7, 2, 0, -7 },
  { 281, 6, 5, 7, 0, -5 },
  { 285, 4, 5, 4, 0, -5 },
  { 288, 4, 5, 4, 0, -5 },
  { 291, 4, 7, 4, 0, -5 },
  { 295, 4, 7, 4, 0, -5 },
  { 299, 3, 5, 3, 0, -5 },
  { 301, 4, 5, 4, 0, -5 },
  { 304, 3, 6, 3, 0, -6 },
  { 307, 4, 5, 4, 0, -5 },
  { 310, 4, 5, 4, 0, -5 },
  { 313, 5, 5, 6, 1, -5 },
  { 317, 4, 5, 4, 0, -5 },
  { 320, 4, 7, 4, 0, -5 },
  { 324, 4, 5, 4, 0, -5 },
  { 327, 3, 9, 3, 0, -7 },
  { 331, 2, 8, 2, 0, -7 },
  { 333, 2, 9, 3, 0, -7 },
  { 336, 5, 2, 5, 0, -4 },
};

const GFXfont RobotoCondensed_SemiBoldItalic9pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic9pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic9pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC9PT7B_H_
