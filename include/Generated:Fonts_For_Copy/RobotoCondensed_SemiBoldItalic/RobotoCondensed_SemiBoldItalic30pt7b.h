#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC30PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x78, 0xE3, 0xC7, 0x8F, 0x1E, 0x38, 0x70, 0xE3, 0xC7,
  0x8E, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x8F, 0x1C, 0x00, 0x73, 0x77, 0x77,
  0x67, 0x67, 0xE6, 0xE6, 0xC6, 0x01, 0xCC, 0x03, 0x38, 0x06, 0x60, 0x1C,
  0xC0, 0x33, 0x80, 0x67, 0x01, 0xCC, 0x1F, 0xFF, 0x3F, 0xFC, 0x1C, 0xC0,
  0x31, 0x80, 0x67, 0x01, 0xCC, 0x1F, 0xFF, 0x3F, 0xFC, 0x1C, 0xC0, 0x39,
  0x80, 0x67, 0x00, 0xCC, 0x03, 0x98, 0x06, 0x70, 0x0C, 0xE0, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x07, 0x80, 0xFF, 0x0F, 0xF8, 0x79, 0xE7, 0x8F,
  0x3C, 0x39, 0xE1, 0xCF, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x07, 0xBC, 0x3D, 0xE1, 0xEF, 0x0E, 0x7C, 0xF1, 0xFF,
  0x07, 0xF8, 0x1F, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x3C, 0x01, 0xF8,
  0x0E, 0xE1, 0x39, 0x86, 0xC6, 0x33, 0x19, 0xCC, 0x6E, 0x3B, 0xB0, 0xFD,
  0xC1, 0xEE, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0xF0, 0x37, 0xE1, 0xF9, 0x8E,
  0xE7, 0x33, 0x1D, 0xCC, 0x7E, 0x31, 0x90, 0xEE, 0x01, 0xF0, 0x07, 0x80,
  0x03, 0xC0, 0x3F, 0x80, 0xFF, 0x07, 0x9C, 0x1C, 0x70, 0x71, 0xC1, 0xCF,
  0x07, 0x38, 0x1F, 0xE0, 0x7E, 0x01, 0xF0, 0x0F, 0xC7, 0x7F, 0x9F, 0xDE,
  0x7F, 0x3F, 0xBC, 0xFE, 0xE1, 0xFB, 0xC7, 0xCF, 0x1F, 0x3F, 0xFC, 0x7F,
  0xF8, 0xF9, 0xE0, 0x77, 0x76, 0xEE, 0xEE, 0x00, 0x80, 0x60, 0x38, 0x1C,
  0x0F, 0x03, 0x81, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x06, 0x01,
  0x80, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x06, 0x00, 0x80, 0x08, 0x06,
  0x03, 0x80, 0xC0, 0x70, 0x38, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38,
  0x3C, 0x1C, 0x1E, 0x0E, 0x0E, 0x0E, 0x06, 0x02, 0x00, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x61, 0xE6, 0x7F, 0xFF, 0x3F, 0xE1, 0xE0, 0x3F, 0x03, 0xB0,
  0x73, 0x8E, 0x18, 0x01, 0x00, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x71, 0xCF, 0x38, 0xE7, 0xBC, 0x60,
  0x7E, 0x7E, 0xFE, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x7F, 0x87, 0xFC, 0x3C, 0xF3, 0xC7, 0x9C, 0x3C, 0xE1, 0xEF, 0x0F,
  0x78, 0x7B, 0xC3, 0xDC, 0x1E, 0xE0, 0xE7, 0x07, 0x78, 0x3B, 0xC3, 0xDE,
  0x1E, 0xF0, 0xE7, 0x8F, 0x1E, 0x78, 0xFF, 0x83, 0xF8, 0x0F, 0x80, 0x01,
  0x83, 0xCF, 0xEF, 0xE7, 0xF7, 0x3A, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x81,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0x03, 0xE0, 0x1F, 0xE0, 0xFF, 0x87, 0x8F, 0x1C, 0x3C, 0xF0, 0xF3, 0xC3,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0xFE, 0xFF,
  0xF3, 0xFF, 0xC0, 0x07, 0xC0, 0x7F, 0x87, 0xFC, 0x79, 0xF3, 0xC7, 0xBC,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x7F, 0x03, 0xF0, 0x1F, 0xC0, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x1E, 0xE0, 0xE7, 0x0F, 0x3C, 0xF9, 0xFF, 0x87,
  0xF8, 0x1F, 0x80, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8,
  0x0F, 0xE0, 0x3F, 0x81, 0xDE, 0x07, 0x78, 0x39, 0xC1, 0xE7, 0x07, 0x3C,
  0x38, 0xF1, 0xE3, 0xC7, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x87,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0xF0, 0x3F, 0xE1, 0xFF, 0x83,
  0x8F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0xF0, 0xF3,
  0xC3, 0x8F, 0x9E, 0x1F, 0xF0, 0x3F, 0x80, 0x7C, 0x00, 0x00, 0xF0, 0x3F,
  0x07, 0xE0, 0xF8, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xBC, 0x7F, 0xE7, 0xFF,
  0x7C, 0xF7, 0x8F, 0x70, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0xF7, 0x0E,
  0x79, 0xE7, 0xFC, 0x3F, 0x81, 0xF0, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC0,
  0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x7F,
  0x87, 0xFC, 0x3C, 0xF3, 0xC7, 0x9E, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0xF0,
  0xFF, 0x07, 0xF0, 0x7F, 0x87, 0x9E, 0x78, 0x73, 0xC3, 0xDE, 0x1E, 0xF0,
  0xF7, 0x8F, 0x3C, 0x78, 0xFF, 0x87, 0xF8, 0x0F, 0x80, 0x0F, 0x81, 0xFC,
  0x3F, 0xE7, 0xDE, 0x78, 0xE7, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xEF, 0x1E, 0x7F, 0xE7, 0xFE, 0x3D, 0xC0, 0x1C, 0x03, 0xC0, 0x78,
  0x1F, 0x07, 0xE0, 0x7C, 0x07, 0x00, 0x3C, 0xF3, 0xCE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF3, 0xCF, 0x38, 0x0E, 0x0F, 0x0F, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x70,
  0xF0, 0xE0, 0x40, 0x00, 0x20, 0x1C, 0x0F, 0x87, 0xF3, 0xFD, 0xFC, 0x3E,
  0x07, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xC0, 0x38, 0x01, 0x00, 0x3F,
  0xF1, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x8F, 0xFC,
  0xFF, 0xE0, 0x20, 0x03, 0x80, 0x3C, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xE0, 0x3E, 0x0F, 0xE7, 0xF8, 0xFE, 0x0F, 0x80, 0xE0, 0x08, 0x00, 0x0F,
  0x07, 0xF9, 0xFF, 0x3C, 0xFF, 0x1F, 0xE3, 0xC0, 0x78, 0x1E, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03,
  0xE3, 0xC0, 0x70, 0x0E, 0x0E, 0x00, 0x61, 0xC0, 0x07, 0x18, 0x3C, 0x33,
  0x8F, 0xE3, 0x31, 0xEE, 0x37, 0x1C, 0xE3, 0x63, 0x8E, 0x36, 0x38, 0xE3,
  0xE7, 0x0C, 0x3E, 0x71, 0xC3, 0xC7, 0x1C, 0x7C, 0x71, 0xC6, 0xC7, 0x18,
  0x6C, 0x73, 0x8E, 0xC7, 0xFD, 0xCC, 0x7F, 0xF8, 0xC3, 0x8F, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE7, 0x00, 0x1F,
  0xF0, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x01, 0xFC, 0x01, 0xDC, 0x01, 0xDC, 0x03, 0xDE, 0x03, 0x9E,
  0x07, 0x9E, 0x07, 0x1E, 0x0F, 0x0E, 0x0F, 0x0E, 0x1F, 0xFE, 0x1F, 0xFE,
  0x3F, 0xFF, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F,
  0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x1E, 0x1E, 0x1E, 0x0F, 0x1E, 0x0F,
  0x1E, 0x0F, 0x1E, 0x1E, 0x1C, 0x3E, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF8,
  0x3C, 0x3C, 0x3C, 0x1C, 0x38, 0x1C, 0x78, 0x1C, 0x78, 0x3C, 0x78, 0x3C,
  0x78, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC0, 0x01, 0xF0, 0x07, 0xFC,
  0x0F, 0xFE, 0x1F, 0x3E, 0x3C, 0x0E, 0x3C, 0x0E, 0x38, 0x0F, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x3C, 0xF0, 0x3C, 0x70, 0x78, 0x78, 0xF8, 0x7F, 0xF0,
  0x3F, 0xE0, 0x0F, 0x80, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x1E, 0x3E,
  0x1E, 0x1E, 0x1E, 0x0E, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x3C, 0x0F,
  0x3C, 0x0E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x1C,
  0x78, 0x3C, 0x78, 0x7C, 0x78, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0x80,
  0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF0, 0x0F, 0xFE, 0x1F, 0xFC,
  0x3F, 0xF8, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x1E, 0x3E, 0x0E,
  0x3C, 0x0F, 0x38, 0x0F, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0xFE, 0x70, 0xFE, 0xF0, 0xFE, 0xF0, 0x1C, 0xF0, 0x3C, 0x70, 0x3C,
  0x78, 0x3C, 0x7C, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xC0, 0x0F, 0x03,
  0xC3, 0xC0, 0xF0, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xE1,
  0xE0, 0x78, 0x78, 0x1E, 0x1C, 0x07, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF,
  0xFC, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F,
  0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x70, 0x1E, 0x3C, 0x07, 0x80,
  0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF0, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xE1, 0xE1, 0xE7, 0x83, 0xFE, 0x03,
  0xFC, 0x03, 0xE0, 0x00, 0x0F, 0x07, 0xC3, 0xC3, 0xE0, 0xE1, 0xF0, 0x78,
  0x78, 0x1E, 0x3E, 0x07, 0x9F, 0x01, 0xE7, 0x80, 0x7B, 0xC0, 0x1D, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xBC, 0x03,
  0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF8, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1,
  0xF0, 0x70, 0x3C, 0x3C, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0xFF,
  0x7F, 0xFF, 0xFF, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0xC7,
  0xE0, 0x3F, 0x1F, 0x81, 0xFC, 0x7E, 0x07, 0xF1, 0xF8, 0x1F, 0x87, 0x70,
  0xEE, 0x1D, 0xC3, 0xF8, 0xF7, 0x1F, 0xE3, 0xDC, 0x77, 0x8F, 0x73, 0xDC,
  0x3D, 0xCE, 0x70, 0xE7, 0x3B, 0xC3, 0x9D, 0xCF, 0x1E, 0x77, 0x3C, 0x78,
  0xF8, 0xF1, 0xE3, 0xE3, 0x87, 0x8F, 0x1E, 0x1E, 0x3C, 0x78, 0x70, 0xF1,
  0xE3, 0xC3, 0x87, 0x80, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x7E,
  0x0F, 0x1F, 0x83, 0x87, 0xE1, 0xE1, 0xF8, 0x78, 0x7F, 0x1E, 0x1D, 0xC7,
  0x8F, 0x71, 0xE3, 0xCE, 0x70, 0xF3, 0xBC, 0x3C, 0xEF, 0x0F, 0x3B, 0xC3,
  0x87, 0xF1, 0xE1, 0xFC, 0x78, 0x7E, 0x1E, 0x0F, 0x87, 0x83, 0xE1, 0xE0,
  0xF8, 0x70, 0x3E, 0x3C, 0x07, 0x80, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE,
  0x1F, 0x3E, 0x3E, 0x1E, 0x3C, 0x0F, 0x38, 0x0F, 0x78, 0x0F, 0x78, 0x0F,
  0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0E, 0x70, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x1E, 0x70, 0x3C, 0x78, 0x3C, 0x7C, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0,
  0x0F, 0xC0, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x1E, 0x1F, 0x1E, 0x0F,
  0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x3E,
  0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF0, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x3E, 0x3E, 0x1E, 0x3C, 0x0F, 0x38, 0x0F,
  0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0E, 0x70, 0x0E, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0x78, 0x3C, 0x7C, 0xF8,
  0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x30,
  0x00, 0x20, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x1E, 0x1E, 0x1E, 0x0F,
  0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0E, 0x3C, 0x1E, 0x3C, 0x3E,
  0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x70, 0x3C, 0xF0, 0x3C, 0x03, 0xE0,
  0x1F, 0xF0, 0x7F, 0xF0, 0xF9, 0xE3, 0xC3, 0xC7, 0x83, 0xCF, 0x07, 0x9E,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1E, 0x70, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xE7, 0xC3, 0xFF, 0x83,
  0xFE, 0x03, 0xF0, 0x00, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x1E, 0x0F,
  0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0E, 0x3C, 0x1E, 0x3C, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x78, 0x3C,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x78, 0x78, 0xF8,
  0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0xF8, 0x0F, 0x78, 0x1F, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x78, 0x78, 0x78,
  0x38, 0xF0, 0x38, 0xF0, 0x38, 0xE0, 0x39, 0xE0, 0x3D, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0xE0, 0xF0, 0xFE, 0x0F, 0x0F, 0xE1, 0xF0, 0xEE, 0x1F, 0x1E,
  0xE1, 0xF1, 0xEE, 0x3F, 0x1C, 0xE3, 0xF3, 0xCE, 0x3F, 0x3C, 0xE7, 0xF3,
  0xCE, 0x77, 0x38, 0xE7, 0x77, 0x8E, 0xF7, 0x78, 0xEE, 0x77, 0x0E, 0xE7,
  0xF0, 0xFE, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xF8,
  0x7C, 0x0F, 0x87, 0xC0, 0xF0, 0x7C, 0x0F, 0x07, 0x80, 0x0F, 0x03, 0xC1,
  0xE0, 0xF8, 0x3E, 0x1E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x3C, 0x00,
  0xF7, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x1F,
  0x3C, 0x03, 0xC7, 0x80, 0xF8, 0xF0, 0x1E, 0x1E, 0x07, 0xC1, 0xE1, 0xF0,
  0x3C, 0x00, 0xF0, 0x3D, 0xE0, 0x7B, 0xC1, 0xE7, 0x83, 0xC7, 0x0F, 0x0E,
  0x1E, 0x1E, 0x78, 0x3C, 0xE0, 0x3B, 0xC0, 0x77, 0x00, 0xFE, 0x01, 0xF8,
  0x03, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x1F, 0xFF, 0x1F, 0xFF,
  0x1F, 0xFF, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xFF, 0xF8,
  0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0x87, 0xC3, 0xE1, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x0F,
  0x87, 0xC0, 0xE3, 0x8E, 0x3C, 0xF3, 0xCF, 0x1C, 0x71, 0xC7, 0x1E, 0x79,
  0xE7, 0x8E, 0x38, 0xE3, 0xCF, 0x3C, 0xF1, 0xC7, 0x07, 0xC1, 0xF0, 0x7C,
  0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC1, 0xF0, 0x7C, 0x3F, 0x00, 0x07, 0x01,
  0xC0, 0xF0, 0x3E, 0x1F, 0x87, 0xE3, 0xB8, 0xE6, 0x71, 0x9C, 0x7E, 0x1C,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xF1, 0xE3, 0x87, 0x07, 0xC0, 0x7F, 0x87,
  0xFC, 0x78, 0xE3, 0xC7, 0x80, 0x38, 0x3F, 0xC7, 0xFE, 0x7C, 0xF3, 0xC7,
  0x9C, 0x3D, 0xE1, 0xCF, 0x1E, 0x3F, 0xF1, 0xFF, 0x87, 0x9C, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xBC, 0x3F,
  0xF1, 0xFF, 0xCF, 0x9E, 0x78, 0x73, 0xC3, 0x9C, 0x1D, 0xE0, 0xEF, 0x0F,
  0x78, 0x7B, 0xC3, 0xDE, 0x1C, 0xF1, 0xEF, 0xFF, 0x7F, 0xF3, 0xDF, 0x00,
  0x0F, 0x81, 0xFE, 0x3F, 0xE7, 0x8F, 0x70, 0xFF, 0x0F, 0xF0, 0x0F, 0x00,
  0xF0, 0x0E, 0x00, 0xE1, 0xEE, 0x1E, 0xF3, 0xCF, 0xFC, 0x7F, 0x81, 0xE0,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x83, 0xDE, 0x3F, 0xF9, 0xFF, 0xE7, 0x8F, 0x1C, 0x3C, 0xF0, 0xF3, 0xC3,
  0xCF, 0x0F, 0x3C, 0x3C, 0xE0, 0xE3, 0x83, 0x8E, 0x1E, 0x3C, 0xF8, 0xFF,
  0xE1, 0xFF, 0x83, 0xDC, 0x00, 0x07, 0x81, 0xFE, 0x3F, 0xE7, 0x8F, 0x78,
  0xF7, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0xC7, 0xFE, 0x7F, 0xC1, 0xF0, 0x03, 0xC1, 0xF0, 0xFC, 0x7C, 0x1E, 0x07,
  0x81, 0xC1, 0xFE, 0x7F, 0xBF, 0xC3, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x07, 0x9C,
  0x7F, 0xF1, 0xFF, 0xCF, 0x9F, 0x3C, 0x3D, 0xE0, 0xE7, 0x87, 0x9E, 0x1E,
  0x78, 0x79, 0xC1, 0xE7, 0x07, 0x1E, 0x1C, 0x7C, 0xF1, 0xFF, 0xC3, 0xFF,
  0x07, 0xBC, 0x00, 0xE0, 0x07, 0x86, 0x3E, 0x3F, 0xF0, 0xFF, 0x80, 0xFC,
  0x00, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70,
  0x03, 0xBC, 0x3F, 0xF1, 0xFF, 0xCF, 0x1E, 0x78, 0xF3, 0x87, 0x9C, 0x3D,
  0xE1, 0xEF, 0x0F, 0x78, 0x73, 0xC7, 0x9C, 0x3C, 0xE1, 0xEF, 0x0F, 0x78,
  0x73, 0xC3, 0x80, 0x0E, 0x0F, 0x0E, 0x0E, 0x00, 0x00, 0x1E, 0x1C, 0x1C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x78, 0x78, 0x78, 0x70, 0xF0,
  0xF0, 0x01, 0xC0, 0xF0, 0x3C, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x0E, 0x03,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x3F, 0x0F, 0x83, 0xC0,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x1E, 0x3C, 0x78, 0x79, 0xE0, 0xF7, 0xC1, 0xFF, 0x03, 0xFC,
  0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xF7, 0x81, 0xC7, 0x03,
  0x8F, 0x0F, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x0E, 0x0E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0x1D, 0xE1, 0xE1, 0xFF, 0x7F,
  0x3F, 0xFF, 0xF3, 0xE7, 0xCF, 0x3C, 0x78, 0x73, 0xC7, 0x87, 0x38, 0x78,
  0xF3, 0x87, 0x8F, 0x78, 0x70, 0xF7, 0x87, 0x0F, 0x78, 0xF0, 0xF7, 0x8F,
  0x0E, 0x70, 0xF1, 0xEF, 0x0F, 0x1E, 0xF0, 0xE1, 0xEF, 0x0E, 0x1E, 0x1D,
  0xE1, 0xFF, 0x8F, 0xFE, 0x7C, 0xF3, 0xC7, 0x9C, 0x3C, 0xE1, 0xEF, 0x0F,
  0x78, 0x73, 0xC3, 0x9E, 0x3C, 0xE1, 0xE7, 0x0F, 0x78, 0x7B, 0xC3, 0x9E,
  0x1C, 0x0F, 0xC1, 0xFE, 0x3F, 0xF7, 0x8F, 0x78, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0x0E, 0xF1, 0xE7, 0xFC, 0x7F, 0x81,
  0xF0, 0x0E, 0xF0, 0x3F, 0xE1, 0xFF, 0xC7, 0xCF, 0x1E, 0x1C, 0x78, 0x71,
  0xC1, 0xCF, 0x07, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0E, 0x3C, 0x79,
  0xFF, 0xE7, 0xFF, 0x1E, 0xF8, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x39, 0xFF, 0xDF, 0xFE, 0xF1, 0xE7, 0x07,
  0x78, 0x7B, 0xC3, 0xDE, 0x1E, 0xF0, 0xF7, 0x07, 0x38, 0x39, 0xE3, 0xCF,
  0x1E, 0x7F, 0xF1, 0xFF, 0x87, 0xB8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xC0, 0x1D, 0xC7, 0xF3, 0xFC, 0xFF, 0x3C, 0x0F, 0x03,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0,
  0x07, 0xC0, 0xFF, 0x07, 0xFC, 0x79, 0xE3, 0x87, 0x1E, 0x00, 0xF8, 0x03,
  0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x79, 0xE1, 0xCF, 0x1E, 0x3F, 0xF0, 0xFF,
  0x03, 0xE0, 0x1E, 0x1E, 0x1C, 0x1C, 0xFF, 0xFF, 0xFF, 0x3C, 0x38, 0x38,
  0x78, 0x78, 0x78, 0x78, 0x70, 0x70, 0x70, 0x7C, 0x7C, 0x3C, 0x38, 0x7B,
  0xC3, 0xDE, 0x1E, 0xF0, 0xE7, 0x87, 0x38, 0x79, 0xC3, 0xDE, 0x1E, 0xF0,
  0xF7, 0x87, 0x3C, 0x79, 0xE3, 0xCF, 0x3E, 0x7F, 0xF1, 0xFF, 0x07, 0xB8,
  0xE1, 0xEE, 0x1E, 0xE1, 0xEF, 0x3C, 0xF3, 0xCF, 0x38, 0xF7, 0x8F, 0x70,
  0x77, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80,
  0xE1, 0xC7, 0xF1, 0xE3, 0xF8, 0xF1, 0xDC, 0x79, 0xEE, 0x7C, 0xF7, 0x3E,
  0x73, 0xBF, 0x79, 0xDD, 0xB8, 0xEE, 0xDC, 0x7E, 0x7E, 0x3F, 0x3E, 0x1F,
  0x1F, 0x0F, 0x8F, 0x87, 0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xC0, 0x1E, 0x3C,
  0x3C, 0x78, 0x39, 0xE0, 0x73, 0x80, 0xFF, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFF, 0x03, 0xCE, 0x07, 0x9C,
  0x1E, 0x3C, 0x78, 0x78, 0x1C, 0x1E, 0x38, 0x78, 0x78, 0xF0, 0xF3, 0xC1,
  0xE7, 0x83, 0xDE, 0x07, 0xBC, 0x0F, 0x70, 0x1F, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x3F, 0xF9,
  0xFF, 0xCF, 0xFE, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC,
  0x01, 0x81, 0xC1, 0xC1, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x0F,
  0x07, 0x0F, 0x87, 0x03, 0xC0, 0xE0, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x3C, 0x0E, 0x03, 0x00, 0x0E, 0x1C, 0x30, 0x60,
  0xC1, 0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC1, 0x87, 0x0E, 0x1C, 0x30, 0x60,
  0xC3, 0x87, 0x0E, 0x18, 0x30, 0x60, 0xC0, 0x0C, 0x07, 0x03, 0x80, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x78, 0x1C, 0x3E,
  0x1C, 0x1E, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x78,
  0x38, 0x18, 0x00, 0x1E, 0x1C, 0xFC, 0x77, 0xFB, 0xFD, 0xFE, 0xE1, 0xF8,
  0x03, 0xC0,
};

const GFXglyph RobotoCondensed_SemiBoldItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 22, 7, 1, -22 },
  { 21, 8, 8, 9, 2, -23 },
  { 29, 15, 22, 16, 1, -22 },
  { 71, 13, 28, 15, 1, -25 },
  { 117, 14, 22, 19, 3, -22 },
  { 156, 14, 22, 17, 1, -22 },
  { 195, 4, 8, 5, 2, -23 },
  { 199, 10, 31, 9, 1, -24 },
  { 238, 9, 31, 9, -1, -24 },
  { 273, 12, 13, 13, 2, -22 },
  { 293, 12, 16, 14, 1, -18 },
  { 317, 6, 9, 7, -2, -4 },
  { 324, 8, 3, 10, 1, -11 },
  { 327, 4, 4, 8, 1, -4 },
  { 329, 14, 24, 10, -2, -22 },
  { 371, 13, 22, 15, 1, -22 },
  { 407, 9, 22, 15, 3, -22 },
  { 432, 14, 22, 15, 0, -22 },
  { 471, 13, 22, 15, 1, -22 },
  { 507, 14, 22, 15, 0, -22 },
  { 546, 14, 22, 15, 1, -22 },
  { 585, 12, 22, 15, 1, -22 },
  { 618, 14, 22, 15, 1, -22 },
  { 657, 13, 22, 15, 1, -22 },
  { 693, 12, 22, 15, 2, -22 },
  { 726, 6, 16, 8, 1, -16 },
  { 738, 8, 21, 7, -1, -16 },
  { 759, 11, 14, 13, 1, -16 },
  { 779, 13, 9, 14, 1, -14 },
  { 794, 12, 14, 13, 1, -16 },
  { 815, 11, 22, 13, 2, -22 },
  { 846, 20, 28, 22, 1, -21 },
  { 916, 16, 22, 17, -1, -22 },
  { 960, 16, 22, 16, 0, -22 },
  { 1004, 16, 22, 17, 1, -22 },
  { 1048, 16, 22, 16, 0, -22 },
  { 1092, 16, 22, 14, 0, -22 },
  { 1136, 15, 22, 14, 0, -22 },
  { 1178, 16, 22, 17, 1, -22 },
  { 1222, 18, 22, 18, 0, -22 },
  { 1272, 8, 22, 8, 0, -22 },
  { 1294, 15, 22, 14, 0, -22 },
  { 1336, 18, 22, 16, 0, -22 },
  { 1386, 12, 22, 14, 0, -22 },
  { 1419, 22, 22, 22, 0, -22 },
  { 1480, 18, 22, 18, 0, -22 },
  { 1530, 16, 22, 18, 1, -22 },
  { 1574, 16, 22, 16, 0, -22 },
  { 1618, 16, 26, 18, 1, -22 },
  { 1670, 16, 22, 16, 0, -22 },
  { 1714, 15, 22, 16, 1, -22 },
  { 1756, 15, 22, 16, 2, -22 },
  { 1798, 16, 22, 17, 1, -22 },
  { 1842, 16, 22, 17, 2, -22 },
  { 1886, 20, 22, 22, 3, -22 },
  { 1941, 19, 22, 16, -1, -22 },
  { 1994, 15, 22, 16, 3, -22 },
  { 2036, 16, 22, 15, 0, -22 },
  { 2080, 9, 30, 8, 0, -25 },
  { 2114, 6, 24, 11, 3, -22 },
  { 2132, 10, 30, 8, -2, -25 },
  { 2170, 10, 11, 11, 1, -22 },
  { 2184, 12, 3, 12, -2, 0 },
  { 2189, 6, 4, 10, 3, -22 },
  { 2192, 13, 16, 14, 0, -16 },
  { 2218, 13, 23, 14, 0, -23 },
  { 2256, 12, 16, 13, 1, -16 },
  { 2280, 14, 23, 14, 1, -23 },
  { 2321, 12, 16, 14, 1, -16 },
  { 2345, 10, 23, 9, 1, -23 },
  { 2374, 14, 22, 15, 0, -16 },
  { 2413, 13, 23, 14, 0, -23 },
  { 2451, 8, 22, 7, 0, -22 },
  { 2473, 10, 28, 7, -3, -22 },
  { 2508, 15, 23, 14, 0, -23 },
  { 2552, 8, 23, 7, 0, -23 },
  { 2575, 20, 16, 22, 0, -16 },
  { 2615, 13, 16, 14, 0, -16 },
  { 2641, 12, 16, 15, 1, -16 },
  { 2665, 14, 22, 14, -1, -16 },
  { 2704, 13, 22, 14, 1, -16 },
  { 2740, 10, 16, 9, 0, -16 },
  { 2760, 13, 16, 13, 0, -16 },
  { 2786, 8, 20, 9, 1, -20 },
  { 2806, 13, 16, 14, 1, -16 },
  { 2832, 12, 16, 13, 2, -16 },
  { 2856, 17, 16, 19, 2, -16 },
  { 2890, 15, 16, 13, -1, -16 },
  { 2920, 15, 22, 13, -1, -16 },
  { 2962, 13, 16, 13, 0, -16 },
  { 2988, 9, 28, 9, 1, -23 },
  { 3020, 7, 26, 7, 0, -22 },
  { 3043, 9, 28, 9, -1, -23 },
  { 3075, 14, 6, 16, 1, -12 },
};

const GFXfont RobotoCondensed_SemiBoldItalic30pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic30pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic30pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC30PT7B_H_
