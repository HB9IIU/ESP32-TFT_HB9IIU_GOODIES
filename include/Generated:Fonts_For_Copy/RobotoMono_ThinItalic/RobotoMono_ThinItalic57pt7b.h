#ifndef _ROBOTOMONO_THINITALIC57PT7B_H_
#define _ROBOTOMONO_THINITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80,
  0x80, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x81, 0xC0, 0xE0, 0x00,
  0x30, 0x66, 0x0C, 0xC1, 0x10, 0x22, 0x0C, 0x41, 0x98, 0x33, 0x04, 0x60,
  0x88, 0x11, 0x06, 0x60, 0xC0, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x20,
  0x06, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x08,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x20, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00,
  0x80, 0x18, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x02, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x08, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x04, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x40, 0x00, 0x03, 0x00, 0x20, 0x00, 0x01, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x10, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x40, 0x0C, 0x00,
  0x00, 0x60, 0x04, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x10, 0x03, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x40, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x40, 0x0C,
  0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x10, 0x02,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xC7, 0x80, 0x03, 0x80, 0x18, 0x00, 0xE0,
  0x01, 0x80, 0x30, 0x00, 0x10, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x20,
  0x60, 0x00, 0x04, 0x0C, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x18, 0x20, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0x82, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x0C, 0x04, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x38, 0x00,
  0xE0, 0x1C, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x02, 0x00, 0xC0, 0x0C,
  0x60, 0x04, 0x01, 0x86, 0x00, 0x40, 0x10, 0x40, 0x0C, 0x03, 0x04, 0x00,
  0xC0, 0x60, 0x40, 0x0C, 0x0C, 0x0C, 0x00, 0x80, 0xC0, 0xC0, 0x18, 0x18,
  0x04, 0x01, 0x83, 0x00, 0x40, 0x30, 0x20, 0x06, 0x06, 0x06, 0x00, 0x30,
  0xE0, 0xC0, 0x03, 0xF8, 0x08, 0x00, 0x0F, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0xF8, 0x00, 0x10, 0x38, 0xC0, 0x03, 0x06, 0x06, 0x00, 0x60,
  0x40, 0x20, 0x04, 0x0C, 0x03, 0x00, 0xC0, 0x80, 0x30, 0x18, 0x18, 0x03,
  0x03, 0x01, 0x00, 0x30, 0x20, 0x10, 0x03, 0x06, 0x01, 0x00, 0x30, 0xC0,
  0x30, 0x02, 0x08, 0x03, 0x00, 0x21, 0x80, 0x30, 0x06, 0x30, 0x03, 0x00,
  0x40, 0x00, 0x10, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x18, 0x06, 0x00, 0x06, 0x00, 0x40, 0x01,
  0x80, 0x08, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x08,
  0x03, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x07, 0x18, 0x00, 0x01, 0x81, 0x00, 0x00,
  0x60, 0x30, 0x01, 0x08, 0x02, 0x00, 0x23, 0x00, 0x60, 0x0C, 0xC0, 0x06,
  0x01, 0x90, 0x00, 0x40, 0x26, 0x00, 0x0C, 0x0C, 0x80, 0x00, 0xC1, 0xB0,
  0x00, 0x08, 0x66, 0x00, 0x01, 0x8C, 0xC0, 0x00, 0x1B, 0x18, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x38, 0x20, 0x00, 0x07, 0x06, 0x00, 0x01, 0xA0, 0x60,
  0x00, 0xE6, 0x0E, 0x00, 0x30, 0x60, 0xF0, 0x3C, 0x0C, 0x07, 0xFE, 0x00,
  0xC0, 0x08, 0x00, 0x00, 0x25, 0xB6, 0xD2, 0xDA, 0x40, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x01, 0xE0, 0x18, 0x0F, 0x78, 0x18, 0x3C, 0x0F,
  0x11, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xCC, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x06, 0x00, 0x07, 0x03, 0x00, 0x06,
  0x03, 0x00, 0x0C, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x30, 0x00, 0xE0, 0x20,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x30, 0x82, 0x08, 0x61, 0x0C, 0x21, 0x8C, 0x00, 0xFF, 0xFF, 0xE0, 0x6F,
  0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xCF, 0x00, 0x07, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x01, 0x80, 0x01, 0x80,
  0xC0, 0x00, 0x20, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x10, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x07, 0x18, 0x00,
  0x03, 0x44, 0x00, 0x01, 0x93, 0x00, 0x00, 0xC4, 0xC0, 0x00, 0xC1, 0x20,
  0x00, 0x60, 0x48, 0x00, 0x30, 0x32, 0x00, 0x18, 0x0D, 0x80, 0x0C, 0x03,
  0x60, 0x06, 0x00, 0x98, 0x03, 0x00, 0x24, 0x01, 0x80, 0x09, 0x01, 0x80,
  0x06, 0x40, 0xC0, 0x01, 0xB0, 0x60, 0x00, 0x4C, 0x30, 0x00, 0x13, 0x18,
  0x00, 0x0C, 0xCC, 0x00, 0x03, 0x36, 0x00, 0x00, 0x8E, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x18, 0x40, 0x00, 0x0C, 0x10, 0x00, 0x03, 0x04, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x40, 0x20, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x01, 0x80,
  0x1C, 0x00, 0x38, 0x1E, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x73, 0x0F, 0x0C, 0xF0, 0x2E, 0x00,
  0xA0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x70,
  0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x10,
  0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x80, 0x00, 0x0C, 0x30, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x38, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x60, 0x18, 0x00, 0x02, 0x01, 0x00, 0x00, 0x20, 0x30, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x84, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x10, 0x60, 0x00, 0x03, 0x02, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0x70, 0x1E, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x32, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x01,
  0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0x60, 0x00, 0x06, 0x08, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x60, 0x20, 0x00, 0x08, 0x0C, 0x00, 0x03, 0x01,
  0x80, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x04, 0x00, 0x0C, 0x00, 0x80, 0x03,
  0x00, 0x10, 0x00, 0x60, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0x01, 0x80, 0x02, 0x00, 0x60, 0x00, 0x40, 0x18, 0x00, 0x08, 0x03, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x40,
  0x00, 0x0C, 0xFF, 0xC0, 0x00, 0xBC, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x04,
  0x0C, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x18, 0x01, 0xC0, 0x00, 0xE0, 0x78,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x30, 0x7F, 0xE0, 0x18, 0xE0,
  0x38, 0x09, 0xC0, 0x06, 0x0D, 0x80, 0x01, 0x87, 0x80, 0x00, 0x63, 0x80,
  0x00, 0x31, 0x80, 0x00, 0x08, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0x09, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x06,
  0x40, 0x00, 0x02, 0x30, 0x00, 0x03, 0x18, 0x00, 0x03, 0x06, 0x00, 0x01,
  0x83, 0x00, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x30, 0x01, 0x80, 0x0E, 0x03,
  0x80, 0x01, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x38, 0x01, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x02, 0x01, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x01, 0x02, 0x00, 0x00, 0x10, 0x60, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x10, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x60, 0x20, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x30, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0x03, 0x80, 0x03, 0x80, 0x06, 0x00, 0x60, 0x00, 0x30, 0x0C, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0xC4, 0x00,
  0x00, 0x0C, 0x40, 0x00, 0x00, 0x84, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01,
  0x06, 0x00, 0x00, 0x30, 0x20, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0xF9, 0xE0, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x18, 0x0E, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x30, 0x00,
  0x02, 0x20, 0x00, 0x03, 0x60, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x0E, 0x40, 0x00, 0x0E, 0x60, 0x00, 0x16, 0x20, 0x00,
  0x64, 0x30, 0x00, 0xC4, 0x1C, 0x03, 0x8C, 0x0F, 0xFE, 0x08, 0x03, 0xF8,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0,
  0x00, 0x7F, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x1C, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE1, 0xC3, 0x80, 0x00, 0x60, 0x1C, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x20,
  0x0C, 0x01, 0x00, 0x60, 0x18, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x3C, 0x01, 0xC0, 0x30,
  0x18, 0x00, 0xC1, 0x80, 0x03, 0x18, 0x00, 0x08, 0x80, 0x00, 0x4C, 0x00,
  0x03, 0x40, 0x00, 0x1E, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0x80, 0x38, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x70, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x02, 0x01, 0xC0, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x03, 0x03, 0x00, 0xFE, 0x03, 0x06, 0x01, 0x83, 0x01,
  0x06, 0x03, 0x01, 0x01, 0x0C, 0x06, 0x01, 0x01, 0x08, 0x0C, 0x03, 0x01,
  0x18, 0x18, 0x03, 0x01, 0x10, 0x18, 0x02, 0x01, 0x30, 0x30, 0x02, 0x03,
  0x30, 0x30, 0x06, 0x03, 0x20, 0x20, 0x04, 0x03, 0x60, 0x60, 0x04, 0x03,
  0x60, 0x40, 0x0C, 0x02, 0x40, 0x40, 0x0C, 0x02, 0x40, 0xC0, 0x08, 0x06,
  0x40, 0xC0, 0x08, 0x06, 0xC0, 0xC0, 0x18, 0x04, 0xC0, 0x80, 0x18, 0x0C,
  0xC0, 0x80, 0x30, 0x0C, 0xC0, 0x80, 0x70, 0x08, 0xC0, 0x80, 0x50, 0x18,
  0xC0, 0x80, 0xD0, 0x30, 0xC0, 0xC1, 0x98, 0x60, 0x40, 0x67, 0x1C, 0xE0,
  0x40, 0x3C, 0x0F, 0x80, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0x40, 0x00, 0x00, 0x36, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x08, 0x20, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x10, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x20,
  0x30, 0x00, 0x06, 0x01, 0x00, 0x00, 0x40, 0x10, 0x00, 0x0C, 0x01, 0x00,
  0x00, 0xC0, 0x10, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x30,
  0x01, 0x80, 0x03, 0x00, 0x08, 0x00, 0x60, 0x00, 0x80, 0x06, 0x00, 0x08,
  0x00, 0xC0, 0x00, 0x80, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x04, 0x02, 0x00, 0x00,
  0x40, 0x60, 0x00, 0x04, 0x04, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x08,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x02, 0x10, 0x00, 0x00, 0x23, 0x00, 0x00,
  0x02, 0x20, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0x00, 0x0F, 0x00, 0x30,
  0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x04, 0x02, 0x00, 0x00,
  0x60, 0x20, 0x00, 0x02, 0x02, 0x00, 0x00, 0x20, 0x60, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x20, 0x60, 0x00, 0x02, 0x04, 0x00, 0x00, 0x60, 0x40, 0x00,
  0x04, 0x04, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x60, 0x08, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x01, 0x80, 0x01, 0xC0, 0x18, 0x00, 0x06, 0x01, 0x00, 0x00, 0x30,
  0x10, 0x00, 0x01, 0x81, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00,
  0x82, 0x00, 0x00, 0x08, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x10, 0x60,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x60, 0x40, 0x00, 0x0C, 0x04, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x70, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xE7, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x60,
  0x01, 0xC0, 0x18, 0x00, 0x18, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x10,
  0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x88, 0x00, 0x00, 0x13, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x09, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0x81, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x0C, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00,
  0x70, 0x3C, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x60, 0x03, 0xC0, 0x02, 0x00, 0x07,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x80, 0x80,
  0x00, 0x06, 0x04, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x04, 0x18, 0x00, 0x00, 0x20, 0x80, 0x00, 0x01, 0x04, 0x00, 0x00, 0x08,
  0x20, 0x00, 0x00, 0x43, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x02, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x84, 0x00, 0x00, 0x08,
  0x20, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x20, 0x00, 0x01, 0x01, 0x00, 0x00,
  0x18, 0x08, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x38, 0x01, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x40,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x38, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60,
  0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0x20, 0x20, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x3F, 0xFC, 0x40, 0x00, 0x00, 0x44, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x84,
  0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x84, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x18, 0x20, 0x00, 0x01, 0x03, 0x00, 0x00, 0x10,
  0x10, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x1C, 0x00, 0x70,
  0x0F, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x02, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00,
  0x20, 0x30, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x01, 0x80, 0x80, 0x00, 0x02,
  0x01, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x10,
  0x18, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x01, 0x00,
  0x80, 0x00, 0x02, 0x03, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x08, 0x0C,
  0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x80, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x18, 0x08, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x40, 0x20, 0x00,
  0x00, 0x80, 0xC0, 0x00, 0x01, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x0C, 0x04, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00,
  0x40, 0x60, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x03, 0x01, 0x00, 0x00, 0x06,
  0x02, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x20,
  0x30, 0x00, 0x00, 0x40, 0x60, 0x00, 0x01, 0x80, 0x80, 0x00, 0x03, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x06, 0x02, 0x00, 0x00, 0x30, 0x10, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x38, 0x00, 0x60,
  0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x05, 0x01, 0x80, 0x00, 0x0E, 0x01, 0x00,
  0x00, 0x1C, 0x01, 0x00, 0x00, 0x38, 0x01, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x04, 0x01,
  0x80, 0x00, 0x04, 0x03, 0x00, 0x00, 0x04, 0x0E, 0x00, 0x00, 0x0C, 0x1C,
  0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x08, 0x78, 0x00, 0x00, 0x08, 0xC8,
  0x00, 0x00, 0x09, 0x8C, 0x00, 0x00, 0x1B, 0x06, 0x00, 0x00, 0x1E, 0x06,
  0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x10, 0x01,
  0x80, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x08, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0x40, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x40, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xE0, 0x34, 0x00, 0x03, 0x40, 0x68,
  0x00, 0x06, 0x80, 0xD0, 0x00, 0x1B, 0x01, 0x30, 0x00, 0x26, 0x02, 0x60,
  0x00, 0xCC, 0x04, 0x40, 0x01, 0x10, 0x18, 0x80, 0x06, 0x20, 0x31, 0x00,
  0x18, 0x40, 0x63, 0x00, 0x31, 0x80, 0x86, 0x00, 0xC3, 0x01, 0x04, 0x01,
  0x06, 0x02, 0x08, 0x06, 0x08, 0x0C, 0x10, 0x08, 0x10, 0x18, 0x30, 0x30,
  0x20, 0x30, 0x60, 0xC0, 0xC0, 0x40, 0x41, 0x81, 0x80, 0x80, 0x86, 0x03,
  0x03, 0x01, 0x08, 0x04, 0x06, 0x03, 0x30, 0x08, 0x0C, 0x06, 0x40, 0x30,
  0x10, 0x05, 0x80, 0x60, 0x20, 0x0E, 0x00, 0xC0, 0x40, 0x1C, 0x01, 0x01,
  0x80, 0x30, 0x02, 0x03, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x18, 0x08,
  0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x80, 0xC0,
  0x00, 0x01, 0x01, 0x80, 0x00, 0x02, 0x03, 0x00, 0x00, 0x0C, 0x04, 0x00,
  0x00, 0x18, 0x08, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x40, 0x60, 0x00,
  0x00, 0x80, 0xC0, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x08, 0x06, 0x00, 0x00, 0x10, 0x1C, 0x00, 0x00, 0x20, 0x3C, 0x00,
  0x00, 0xC0, 0x48, 0x00, 0x01, 0x80, 0x98, 0x00, 0x02, 0x01, 0x10, 0x00,
  0x04, 0x02, 0x20, 0x00, 0x08, 0x0C, 0x60, 0x00, 0x10, 0x18, 0x40, 0x00,
  0x60, 0x20, 0x80, 0x00, 0xC0, 0x41, 0x80, 0x01, 0x00, 0x81, 0x00, 0x02,
  0x01, 0x03, 0x00, 0x04, 0x06, 0x02, 0x00, 0x18, 0x0C, 0x04, 0x00, 0x30,
  0x10, 0x0C, 0x00, 0x60, 0x20, 0x08, 0x00, 0x80, 0x40, 0x10, 0x01, 0x01,
  0x80, 0x30, 0x02, 0x03, 0x00, 0x20, 0x0C, 0x06, 0x00, 0x60, 0x18, 0x08,
  0x00, 0x40, 0x30, 0x10, 0x00, 0x80, 0x40, 0x20, 0x01, 0x80, 0x80, 0xC0,
  0x01, 0x01, 0x01, 0x80, 0x02, 0x06, 0x03, 0x00, 0x06, 0x0C, 0x04, 0x00,
  0x04, 0x18, 0x08, 0x00, 0x0C, 0x20, 0x10, 0x00, 0x08, 0x40, 0x60, 0x00,
  0x10, 0x80, 0xC0, 0x00, 0x33, 0x01, 0x00, 0x00, 0x26, 0x02, 0x00, 0x00,
  0x4C, 0x04, 0x00, 0x00, 0xD0, 0x08, 0x00, 0x00, 0xA0, 0x30, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x01, 0x80, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xEF, 0x80, 0x01, 0xC0, 0x18, 0x00, 0x60, 0x01, 0x80, 0x18,
  0x00, 0x18, 0x06, 0x00, 0x01, 0x01, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x41, 0x00, 0x00, 0x08, 0x60, 0x00, 0x01, 0x88, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x09, 0x00, 0x00,
  0x01, 0x20, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x05, 0x80, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x90, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x11, 0x00,
  0x00, 0x06, 0x20, 0x00, 0x00, 0x84, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x04,
  0x18, 0x00, 0x01, 0x81, 0x00, 0x00, 0x20, 0x30, 0x00, 0x0C, 0x06, 0x00,
  0x03, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x00, 0x70, 0x38, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xC0, 0x00, 0xE0, 0x06, 0x00, 0x01, 0x80, 0x20, 0x00,
  0x06, 0x01, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x06, 0x08,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x01, 0x06, 0x00, 0x00, 0x08, 0x30, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x06, 0x08, 0x00, 0x00, 0x60, 0x40, 0x00, 0x02,
  0x02, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x70, 0x0C,
  0x00, 0x0F, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0x80, 0x0C, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x80, 0xC0, 0x00, 0x06, 0x04, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00,
  0x82, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x31, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x64, 0x00, 0x00, 0x03, 0x20, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x26, 0x00, 0x00, 0x03, 0x20, 0x00,
  0x00, 0x19, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x30, 0x40, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0x80, 0x40, 0x00, 0x18, 0x03, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x01, 0x80, 0x00, 0xE0, 0x78,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x86, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0x00, 0x07, 0x00, 0x10, 0x00, 0x18, 0x01, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x20, 0x20, 0x00, 0x03, 0x02, 0x00,
  0x00, 0x30, 0x20, 0x00, 0x03, 0x02, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x30, 0x40, 0x00, 0x02, 0x04, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x30, 0x08, 0x00, 0x0E, 0x00, 0x80, 0x03, 0x80, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x06,
  0x00, 0x10, 0x00, 0x60, 0x01, 0x00, 0x02, 0x00, 0x30, 0x00, 0x30, 0x03,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x10, 0x02, 0x00, 0x01, 0x80, 0x20, 0x00,
  0x08, 0x02, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x40,
  0x40, 0x00, 0x06, 0x04, 0x00, 0x00, 0x60, 0x40, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC,
  0xF8, 0x00, 0x1E, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x30, 0x08, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x04,
  0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x81, 0x00, 0x00, 0x04, 0x18, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x86, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x06, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x20, 0x00, 0x00, 0x81, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x03, 0x04, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01, 0x06, 0x00,
  0x00, 0x18, 0x20, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x01, 0x06, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x30, 0x40, 0x00, 0x01, 0x06, 0x00,
  0x00, 0x08, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x08, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x01, 0x02, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x41,
  0x80, 0x00, 0x06, 0x08, 0x00, 0x00, 0x30, 0x40, 0x00, 0x01, 0x82, 0x00,
  0x00, 0x08, 0x10, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x04, 0x06, 0x00, 0x00,
  0x60, 0x10, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x07, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x02, 0x30, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x18, 0x40, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x10, 0x30, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x80, 0x40, 0x00, 0x30, 0x08, 0x00, 0x04, 0x01, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x20, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x20, 0x03, 0x00, 0x06, 0x00, 0x40,
  0x00, 0xC0, 0x18, 0x00, 0x18, 0x03, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x20,
  0x18, 0x00, 0x04, 0x02, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x10, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x20, 0x80, 0x00, 0x04, 0x30, 0x00, 0x00, 0x84,
  0x00, 0x00, 0x11, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x0D, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0x60, 0x07, 0x80, 0x1B,
  0x00, 0x3C, 0x00, 0xD8, 0x01, 0x60, 0x04, 0xC0, 0x1B, 0x00, 0x26, 0x00,
  0xD8, 0x03, 0x30, 0x04, 0xC0, 0x11, 0x80, 0x62, 0x00, 0x8C, 0x03, 0x10,
  0x0C, 0x60, 0x10, 0x80, 0x43, 0x01, 0x84, 0x02, 0x18, 0x0C, 0x20, 0x30,
  0xC0, 0x41, 0x01, 0x06, 0x06, 0x08, 0x08, 0x30, 0x20, 0x40, 0xC1, 0x81,
  0x02, 0x06, 0x0C, 0x18, 0x10, 0x20, 0x60, 0x80, 0x83, 0x03, 0x0C, 0x04,
  0x18, 0x18, 0x60, 0x20, 0x80, 0xC2, 0x01, 0x04, 0x06, 0x30, 0x0C, 0x60,
  0x31, 0x80, 0x62, 0x01, 0x88, 0x03, 0x10, 0x0C, 0xC0, 0x19, 0x80, 0x66,
  0x00, 0xC8, 0x03, 0x20, 0x06, 0x40, 0x1B, 0x00, 0x36, 0x00, 0xD8, 0x01,
  0xA0, 0x06, 0x80, 0x0D, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0,
  0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x60, 0x00, 0x08, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x04, 0x10,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x04,
  0x30, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x02, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x40, 0x01, 0x80, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x06, 0x08, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60,
  0x30, 0x00, 0x0C, 0x02, 0x00, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00,
  0x10, 0x00, 0x80, 0x06, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x20, 0x00,
  0x20, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x08, 0x18,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0x80, 0x00, 0x02, 0x30, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x80,
  0x30, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x60, 0x08, 0x02,
  0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x20,
  0x08, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x60, 0x18, 0x06, 0x00,
  0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x60, 0x18,
  0x02, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x00, 0x7F, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x07, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xA0, 0x00, 0x12, 0x00, 0x03, 0x30, 0x00, 0x23, 0x00, 0x06,
  0x30, 0x00, 0xC1, 0x00, 0x08, 0x10, 0x01, 0x81, 0x80, 0x10, 0x18, 0x03,
  0x00, 0x80, 0x20, 0x08, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x08, 0x00, 0xC1,
  0x80, 0x04, 0x10, 0x00, 0x63, 0x00, 0x06, 0x20, 0x00, 0x66, 0x00, 0x02,
  0xC0, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC1, 0x82, 0x0C,
  0x10, 0x60, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0x00,
  0xE0, 0x07, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x01, 0x80, 0x00, 0x60, 0x40,
  0x00, 0x08, 0x30, 0x00, 0x02, 0x08, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xC0, 0x01, 0x03, 0x80,
  0x00, 0x41, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x10,
  0x00, 0x00, 0x84, 0x00, 0x00, 0x23, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0E,
  0x30, 0x00, 0x07, 0x84, 0x00, 0x03, 0x61, 0x80, 0x01, 0x98, 0x30, 0x01,
  0xC6, 0x06, 0x01, 0xC1, 0x80, 0xFF, 0xC0, 0x60, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x06, 0x01, 0xC0, 0x01, 0x87, 0xFE, 0x00, 0x43, 0x80, 0xC0,
  0x13, 0x80, 0x18, 0x05, 0x80, 0x03, 0x01, 0xC0, 0x00, 0x40, 0xE0, 0x00,
  0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x82, 0x00, 0x00, 0x20, 0x80,
  0x00, 0x08, 0x20, 0x00, 0x02, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x21,
  0x80, 0x00, 0x08, 0x40, 0x00, 0x02, 0x10, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x04, 0x20, 0x00, 0x03, 0x08, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0x21, 0x80, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x18,
  0x00, 0x02, 0x07, 0x00, 0x01, 0x81, 0x60, 0x00, 0xC0, 0x4C, 0x00, 0xE0,
  0x31, 0xC0, 0xF0, 0x0C, 0x3F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x38, 0x07, 0x00, 0x30, 0x01, 0xC0, 0x30,
  0x00, 0x60, 0x30, 0x00, 0x18, 0x30, 0x00, 0x04, 0x10, 0x00, 0x02, 0x18,
  0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x64, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x18, 0x80, 0x00,
  0x08, 0x40, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x08, 0x00, 0x0C, 0x06, 0x00,
  0x0E, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0xC0,
  0x07, 0xFE, 0x08, 0x00, 0xE0, 0x30, 0x80, 0x18, 0x00, 0x98, 0x03, 0x00,
  0x05, 0x80, 0x60, 0x00, 0x78, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30,
  0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x10, 0x30, 0x00, 0x03, 0x02, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x02, 0x06, 0x00, 0x00, 0x20, 0x40, 0x00, 0x02,
  0x04, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x04, 0x0C, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x04, 0x0C, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x08, 0x06,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x38, 0x03, 0x00, 0x07, 0x80, 0x18, 0x01,
  0xD8, 0x00, 0xC0, 0x71, 0x80, 0x07, 0xFC, 0x10, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x3C, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x30, 0x00, 0x60, 0x30, 0x00, 0x18, 0x30, 0x00, 0x04, 0x30, 0x00,
  0x03, 0x18, 0x00, 0x01, 0x98, 0x00, 0x00, 0x48, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x1B, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x03,
  0x03, 0x00, 0x03, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7C, 0x08, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x10, 0x01, 0xFF,
  0x82, 0x00, 0x38, 0x0C, 0x20, 0x06, 0x00, 0x62, 0x00, 0xC0, 0x01, 0x60,
  0x18, 0x00, 0x1E, 0x03, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x04, 0x0C, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x08, 0x10, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x10, 0x30, 0x00, 0x01, 0x03, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x30, 0x10, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x60, 0x18, 0x00, 0x0E, 0x00, 0xC0, 0x01, 0xE0, 0x06, 0x00, 0x76, 0x00,
  0x30, 0x1C, 0x60, 0x01, 0xFF, 0x04, 0x00, 0x01, 0x00, 0x40, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x04, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x00, 0x18, 0x03, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x01, 0xE0, 0x01, 0x03, 0xFF, 0x00, 0x41,
  0xC0, 0x60, 0x11, 0xC0, 0x0C, 0x0C, 0xC0, 0x01, 0x83, 0x60, 0x00, 0x60,
  0xB0, 0x00, 0x08, 0x28, 0x00, 0x02, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x08, 0x60, 0x00, 0x02, 0x18, 0x00, 0x00, 0x84, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x18, 0x40, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x10, 0x80, 0x00, 0x04, 0x20, 0x00, 0x03,
  0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x21, 0x80, 0x00, 0x08, 0x60, 0x00,
  0x02, 0x10, 0x00, 0x01, 0x84, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x04, 0x30, 0x00, 0x01, 0x08, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x02,
  0x07, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xC1, 0x00, 0x00, 0xE0, 0x20, 0x00,
  0x38, 0x04, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x30, 0x01, 0xC0, 0x06,
  0x00, 0x60, 0x00, 0x80, 0x18, 0x00, 0x10, 0x0E, 0x00, 0x02, 0x03, 0x80,
  0x00, 0xC0, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x47,
  0x80, 0x00, 0x09, 0x98, 0x00, 0x01, 0xE3, 0x00, 0x00, 0x70, 0x30, 0x00,
  0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x20, 0x06, 0x00, 0x04, 0x00,
  0x60, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0xC0, 0x10, 0x00, 0x18, 0x02, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x18, 0x18, 0x00, 0x01, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x38,
  0x01, 0x1F, 0xE0, 0xFF, 0x01, 0xB8, 0x38, 0xC0, 0xC0, 0xB0, 0x0C, 0xC0,
  0x30, 0x70, 0x02, 0xC0, 0x18, 0x30, 0x01, 0xC0, 0x04, 0x18, 0x00, 0xC0,
  0x02, 0x18, 0x00, 0x60, 0x01, 0x0C, 0x00, 0x20, 0x01, 0x86, 0x00, 0x10,
  0x00, 0xC2, 0x00, 0x18, 0x00, 0x61, 0x00, 0x0C, 0x00, 0x20, 0x80, 0x06,
  0x00, 0x10, 0xC0, 0x02, 0x00, 0x08, 0x60, 0x01, 0x00, 0x0C, 0x30, 0x00,
  0x80, 0x06, 0x10, 0x00, 0xC0, 0x03, 0x08, 0x00, 0x60, 0x01, 0x04, 0x00,
  0x30, 0x00, 0x86, 0x00, 0x10, 0x00, 0x43, 0x00, 0x08, 0x00, 0x61, 0x00,
  0x04, 0x00, 0x30, 0x80, 0x06, 0x00, 0x10, 0x40, 0x03, 0x00, 0x08, 0x20,
  0x01, 0x80, 0x04, 0x30, 0x00, 0x80, 0x02, 0x18, 0x00, 0x40, 0x03, 0x08,
  0x00, 0x20, 0x01, 0x84, 0x00, 0x30, 0x00, 0x82, 0x00, 0x18, 0x00, 0x43,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x01, 0xE0, 0x01, 0x83, 0xFF, 0x00, 0x41,
  0xC0, 0x60, 0x11, 0xC0, 0x0C, 0x0C, 0xC0, 0x01, 0x83, 0x60, 0x00, 0x60,
  0xF0, 0x00, 0x08, 0x28, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x21, 0x80, 0x00, 0x08, 0x60, 0x00, 0x02, 0x18, 0x00, 0x00, 0x84, 0x00,
  0x00, 0x61, 0x00, 0x00, 0x18, 0x40, 0x00, 0x06, 0x30, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x10, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x03,
  0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x21, 0x80, 0x00, 0x08, 0x60, 0x00,
  0x02, 0x10, 0x00, 0x01, 0x84, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x04, 0x30, 0x00, 0x01, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x03, 0x00, 0x38,
  0x00, 0x30, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x20, 0x60, 0x00, 0x06,
  0x18, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x01, 0x10, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x90, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x02, 0x30,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x10, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x30, 0xFF, 0xC0, 0x04, 0x78, 0x1C, 0x00, 0x9C, 0x00, 0xC0, 0x16,
  0x00, 0x0C, 0x07, 0x80, 0x00, 0x80, 0xE0, 0x00, 0x18, 0x18, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x20, 0x40, 0x00, 0x04, 0x08, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x10, 0x60, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x41, 0x00, 0x00, 0x08,
  0x20, 0x00, 0x01, 0x04, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00,
  0x01, 0x06, 0x00, 0x00, 0x20, 0x80, 0x00, 0x0C, 0x10, 0x00, 0x01, 0x82,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x40, 0x70, 0x00, 0x18, 0x0B, 0x00, 0x06, 0x03, 0x30, 0x03, 0x80, 0x63,
  0x81, 0xE0, 0x0C, 0x3F, 0xF0, 0x01, 0x00, 0x60, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x40, 0x1F, 0xF8, 0x20, 0x0E, 0x03, 0x88, 0x06, 0x00, 0x72,
  0x03, 0x00, 0x05, 0x81, 0x80, 0x01, 0xE0, 0xC0, 0x00, 0x38, 0x60, 0x00,
  0x0C, 0x18, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x43, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0x84, 0x00, 0x00, 0x21,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x04, 0x30, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0xC1, 0x00, 0x00, 0x30, 0x40, 0x00, 0x08, 0x18, 0x00, 0x06, 0x06,
  0x00, 0x03, 0x80, 0xC0, 0x01, 0xE0, 0x18, 0x01, 0xD8, 0x03, 0x01, 0xC6,
  0x00, 0x7F, 0xC1, 0x00, 0x01, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7C, 0x08, 0x0F,
  0xFC, 0x10, 0x78, 0x00, 0x63, 0x80, 0x00, 0xCC, 0x00, 0x01, 0xB0, 0x00,
  0x02, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x78, 0x07, 0x80, 0x60,
  0x00, 0xE0, 0x60, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x20, 0x00, 0x02, 0x10,
  0x00, 0x01, 0x18, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x09, 0x80, 0x00, 0x04, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x10, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x03, 0x00, 0xF0, 0x0F, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x01, 0x88, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x11, 0x80, 0x00, 0x18, 0x80, 0x00, 0x0C, 0x40, 0x00,
  0x06, 0x20, 0x00, 0x02, 0x30, 0x00, 0x01, 0x18, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x62, 0x00, 0x00, 0x31, 0x00, 0x00, 0x11, 0x80,
  0x00, 0x08, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x20, 0x00, 0x03, 0x10,
  0x00, 0x01, 0x08, 0x00, 0x00, 0x84, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x61,
  0x00, 0x00, 0x70, 0x80, 0x00, 0x38, 0x60, 0x00, 0x38, 0x10, 0x00, 0x34,
  0x0C, 0x00, 0x72, 0x03, 0x81, 0xE3, 0x00, 0xFF, 0xC1, 0x80, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x10, 0x40, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x60, 0x0C, 0x00, 0x08, 0x00, 0x80, 0x03, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x06, 0x00, 0x04, 0x00, 0x80, 0x00, 0xC0,
  0x30, 0x00, 0x18, 0x04, 0x00, 0x03, 0x01, 0x80, 0x00, 0x20, 0x60, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01, 0x18,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0x00,
  0x0C, 0x00, 0x2C, 0x00, 0x70, 0x01, 0x90, 0x01, 0x40, 0x04, 0x40, 0x0D,
  0x00, 0x31, 0x00, 0x34, 0x00, 0xC4, 0x00, 0x90, 0x02, 0x10, 0x06, 0x40,
  0x18, 0x40, 0x11, 0x00, 0x61, 0x00, 0xC4, 0x03, 0x04, 0x03, 0x18, 0x0C,
  0x18, 0x08, 0x60, 0x20, 0x60, 0x61, 0x81, 0x81, 0x81, 0x06, 0x06, 0x06,
  0x0C, 0x18, 0x30, 0x18, 0x20, 0x60, 0xC0, 0x61, 0x80, 0x82, 0x01, 0x86,
  0x02, 0x18, 0x06, 0x10, 0x08, 0x60, 0x18, 0xC0, 0x21, 0x00, 0x62, 0x00,
  0x8C, 0x01, 0x98, 0x02, 0x20, 0x02, 0x40, 0x09, 0x80, 0x09, 0x00, 0x26,
  0x00, 0x2C, 0x00, 0xD0, 0x00, 0xA0, 0x03, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x31, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0xE0, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x08, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x03, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x02,
  0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x02, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x04, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x04, 0x60, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x9F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80,
  0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x60, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x0C, 0x30, 0x70, 0x00, 0x18, 0xC0, 0x30, 0x00,
  0x23, 0x00, 0x30, 0x00, 0xC4, 0x00, 0x30, 0x03, 0x18, 0x00, 0x30, 0x06,
  0x20, 0x00, 0x38, 0x38, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0E, 0x00,
};

const GFXglyph RobotoMono_ThinItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 9, 41, 33, 12, -41 },
  { 48, 11, 12, 33, 14, -43 },
  { 65, 33, 41, 33, 1, -41 },
  { 235, 27, 52, 33, 4, -46 },
  { 411, 28, 42, 33, 3, -41 },
  { 558, 27, 42, 33, 3, -41 },
  { 700, 3, 12, 33, 17, -43 },
  { 705, 17, 58, 33, 10, -45 },
  { 829, 17, 58, 33, 5, -45 },
  { 953, 24, 23, 33, 8, -41 },
  { 1022, 28, 30, 33, 3, -34 },
  { 1127, 6, 11, 33, 7, -4 },
  { 1136, 19, 1, 33, 7, -19 },
  { 1139, 4, 3, 33, 13, -3 },
  { 1141, 25, 44, 33, 5, -41 },
  { 1279, 26, 42, 33, 4, -41 },
  { 1416, 14, 41, 33, 9, -41 },
  { 1488, 27, 41, 33, 1, -41 },
  { 1627, 28, 42, 33, 1, -41 },
  { 1774, 27, 41, 33, 2, -41 },
  { 1913, 28, 42, 33, 5, -41 },
  { 2060, 25, 42, 33, 3, -41 },
  { 2192, 26, 41, 33, 7, -41 },
  { 2326, 28, 42, 33, 3, -41 },
  { 2473, 24, 42, 33, 6, -41 },
  { 2599, 7, 27, 33, 15, -27 },
  { 2623, 11, 34, 33, 11, -27 },
  { 2670, 25, 23, 33, 5, -30 },
  { 2742, 26, 13, 33, 4, -25 },
  { 2785, 26, 23, 33, 3, -30 },
  { 2860, 21, 41, 33, 9, -41 },
  { 2968, 32, 41, 33, 1, -41 },
  { 3132, 28, 41, 33, 0, -41 },
  { 3276, 28, 41, 33, 3, -41 },
  { 3420, 27, 42, 33, 4, -41 },
  { 3562, 29, 41, 33, 2, -41 },
  { 3711, 29, 41, 33, 3, -41 },
  { 3860, 30, 41, 33, 3, -41 },
  { 4014, 28, 42, 33, 3, -41 },
  { 4161, 31, 41, 33, 2, -41 },
  { 4320, 29, 41, 33, 3, -41 },
  { 4469, 29, 42, 33, 2, -41 },
  { 4622, 32, 41, 33, 3, -41 },
  { 4786, 22, 41, 33, 4, -41 },
  { 4899, 31, 41, 33, 2, -41 },
  { 5058, 31, 41, 33, 2, -41 },
  { 5217, 27, 42, 33, 4, -41 },
  { 5359, 29, 41, 33, 4, -41 },
  { 5508, 29, 48, 33, 3, -41 },
  { 5682, 28, 41, 33, 3, -41 },
  { 5826, 29, 42, 33, 3, -41 },
  { 5979, 27, 41, 33, 7, -41 },
  { 6118, 29, 42, 33, 4, -41 },
  { 6271, 27, 41, 33, 7, -41 },
  { 6410, 29, 41, 33, 6, -41 },
  { 6559, 33, 41, 33, 1, -41 },
  { 6729, 27, 41, 33, 7, -41 },
  { 6868, 30, 41, 33, 1, -41 },
  { 7022, 17, 55, 33, 9, -46 },
  { 7139, 10, 45, 33, 12, -41 },
  { 7196, 17, 55, 33, 8, -46 },
  { 7313, 20, 23, 33, 7, -41 },
  { 7371, 23, 2, 33, 2, 0 },
  { 7377, 6, 7, 33, 17, -42 },
  { 7383, 26, 32, 33, 3, -31 },
  { 7487, 26, 44, 33, 3, -43 },
  { 7630, 25, 32, 33, 4, -31 },
  { 7730, 28, 44, 33, 4, -43 },
  { 7884, 25, 32, 33, 4, -31 },
  { 7984, 27, 43, 33, 8, -43 },
  { 8130, 28, 43, 33, 2, -31 },
  { 8281, 26, 43, 33, 3, -43 },
  { 8421, 22, 41, 33, 4, -41 },
  { 8534, 26, 53, 33, 0, -41 },
  { 8707, 27, 43, 33, 4, -43 },
  { 8853, 22, 43, 33, 4, -43 },
  { 8972, 33, 31, 33, -1, -31 },
  { 9100, 26, 31, 33, 3, -31 },
  { 9201, 27, 32, 33, 3, -31 },
  { 9309, 27, 43, 33, 1, -31 },
  { 9455, 26, 43, 33, 4, -31 },
  { 9595, 23, 31, 33, 8, -31 },
  { 9685, 25, 32, 33, 4, -31 },
  { 9785, 21, 39, 33, 7, -38 },
  { 9888, 25, 31, 33, 5, -30 },
  { 9985, 27, 30, 33, 5, -30 },
  { 10087, 30, 30, 33, 4, -30 },
  { 10200, 30, 30, 33, 1, -30 },
  { 10313, 34, 42, 33, -1, -30 },
  { 10492, 29, 30, 33, 1, -30 },
  { 10601, 22, 56, 33, 9, -44 },
  { 10755, 9, 49, 33, 12, -41 },
  { 10811, 22, 56, 33, 5, -44 },
  { 10965, 31, 10, 33, 1, -22 },
};

const GFXfont RobotoMono_ThinItalic57pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic57pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic57pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _ROBOTOMONO_THINITALIC57PT7B_H_
