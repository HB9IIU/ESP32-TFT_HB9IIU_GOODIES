#ifndef _ROBOTOMONO_THINITALIC39PT7B_H_
#define _ROBOTOMONO_THINITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x41, 0x0C, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41,
  0x04, 0x20, 0x82, 0x08, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x42, 0x85,
  0x12, 0x28, 0x50, 0xA1, 0x46, 0x00, 0x18, 0x10, 0x00, 0x40, 0x40, 0x01,
  0x03, 0x00, 0x08, 0x08, 0x00, 0x20, 0x20, 0x00, 0x81, 0x00, 0x04, 0x04,
  0x00, 0x10, 0x10, 0x1F, 0xFF, 0xFC, 0x02, 0x02, 0x00, 0x08, 0x08, 0x00,
  0x20, 0x40, 0x01, 0x01, 0x00, 0x04, 0x04, 0x00, 0x30, 0x20, 0x00, 0x80,
  0x80, 0x02, 0x02, 0x00, 0x18, 0x10, 0x00, 0x40, 0x40, 0x3F, 0xFF, 0xF8,
  0x08, 0x08, 0x00, 0x20, 0x20, 0x00, 0x81, 0x80, 0x04, 0x04, 0x00, 0x10,
  0x10, 0x00, 0x40, 0x80, 0x02, 0x02, 0x00, 0x08, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0xFE, 0x00, 0xE0, 0xC0,
  0x60, 0x18, 0x30, 0x02, 0x08, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x40,
  0x01, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x12, 0x00,
  0x08, 0x40, 0x02, 0x18, 0x01, 0x03, 0x01, 0x80, 0x7F, 0x80, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x02, 0x10, 0x00,
  0x82, 0x00, 0x20, 0x20, 0x64, 0x04, 0x08, 0x80, 0x82, 0x10, 0x20, 0x44,
  0x04, 0x10, 0x80, 0x84, 0x18, 0x31, 0x81, 0x04, 0x20, 0x33, 0x08, 0x01,
  0x83, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x08, 0x01, 0x87, 0xC0,
  0x21, 0x0C, 0x08, 0x40, 0x83, 0x08, 0x10, 0x42, 0x02, 0x10, 0x40, 0x44,
  0x08, 0x08, 0x81, 0x01, 0x20, 0x20, 0x40, 0x04, 0x08, 0x00, 0xC2, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x30, 0xC0, 0x0C, 0x08, 0x01, 0x01, 0x00,
  0x60, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x20, 0x04, 0x08, 0x00,
  0xC2, 0x00, 0x08, 0x80, 0x01, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01,
  0x20, 0x00, 0x42, 0x00, 0x10, 0x60, 0x24, 0x04, 0x0D, 0x00, 0x41, 0x20,
  0x08, 0x2C, 0x00, 0x89, 0x00, 0x09, 0x20, 0x01, 0x44, 0x00, 0x18, 0x40,
  0x07, 0x08, 0x01, 0xA0, 0xC0, 0xC2, 0x0F, 0xF0, 0x60, 0x25, 0xA4, 0x94,
  0x00, 0x20, 0x0C, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x02, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x18, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x30,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08,
  0x02, 0x04, 0x0F, 0xC2, 0x38, 0x1D, 0x70, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x90, 0x00, 0x84, 0x00, 0x83, 0x00, 0x80, 0x80, 0x80, 0x20, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x03, 0xFF, 0xFF,
  0x80, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x11, 0x22,
  0x24, 0xC8, 0xFF, 0xF8, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0xC0, 0x80, 0x60, 0x10, 0x30, 0x02, 0x08, 0x00,
  0x84, 0x00, 0x21, 0x00, 0x04, 0x80, 0x03, 0x20, 0x01, 0x58, 0x00, 0x94,
  0x00, 0xC5, 0x00, 0x61, 0x40, 0x30, 0x90, 0x10, 0x24, 0x08, 0x0A, 0x04,
  0x02, 0x82, 0x00, 0xA3, 0x00, 0x49, 0x80, 0x12, 0xC0, 0x04, 0xC0, 0x01,
  0x20, 0x00, 0x88, 0x00, 0x22, 0x00, 0x10, 0x40, 0x0C, 0x10, 0x06, 0x03,
  0x03, 0x00, 0x7F, 0x00, 0x00, 0x40, 0x70, 0xE4, 0xE2, 0xC0, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x00, 0xFC, 0x00, 0xE0, 0xC0, 0x60, 0x18, 0x30, 0x02,
  0x08, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0xC0, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x30, 0x30, 0x08,
  0x03, 0x02, 0x00, 0x20, 0x80, 0x06, 0x10, 0x00, 0x44, 0x00, 0x08, 0x80,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x48, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00,
  0x46, 0x00, 0x08, 0x40, 0x02, 0x0C, 0x00, 0x80, 0xC0, 0x60, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x40, 0x00,
  0x48, 0x00, 0x11, 0x00, 0x06, 0x60, 0x01, 0x88, 0x00, 0x21, 0x00, 0x08,
  0x20, 0x02, 0x04, 0x00, 0x80, 0x80, 0x30, 0x20, 0x0C, 0x04, 0x01, 0x00,
  0x80, 0x40, 0x10, 0x10, 0x02, 0x04, 0x00, 0x41, 0x80, 0x10, 0x7F, 0xFF,
  0xF0, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xE0, 0x40,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x09, 0xFC,
  0x01, 0xC0, 0x60, 0x20, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x80, 0x02,
  0x10, 0x00, 0x82, 0x00, 0x10, 0x40, 0x04, 0x04, 0x01, 0x80, 0x40, 0x60,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x1C, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x0C, 0x7F, 0x04, 0xC0, 0xC2, 0x80, 0x32, 0x80, 0x09, 0x80, 0x02, 0x80,
  0x01, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x18, 0x00, 0x1A,
  0x00, 0x09, 0x00, 0x04, 0x80, 0x04, 0x60, 0x06, 0x10, 0x06, 0x06, 0x06,
  0x01, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1C, 0x18, 0x03, 0x00, 0x40, 0x60,
  0x02, 0x04, 0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x20, 0x80, 0x02, 0x08,
  0x00, 0x20, 0x80, 0x06, 0x08, 0x00, 0x40, 0x40, 0x08, 0x06, 0x03, 0x00,
  0x1F, 0xC0, 0x03, 0x9E, 0x00, 0xC0, 0x30, 0x10, 0x01, 0x82, 0x00, 0x08,
  0x40, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x48, 0x00, 0x0C, 0x80, 0x00,
  0x84, 0x00, 0x08, 0x40, 0x01, 0x02, 0x00, 0x20, 0x30, 0x0C, 0x00, 0xFF,
  0x00, 0x01, 0xF8, 0x03, 0x06, 0x02, 0x00, 0x82, 0x00, 0x42, 0x00, 0x13,
  0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x80, 0x01, 0xC0, 0x00, 0xA0, 0x00,
  0x50, 0x00, 0x28, 0x00, 0x14, 0x00, 0x1B, 0x00, 0x0C, 0x80, 0x0A, 0x60,
  0x1A, 0x18, 0x39, 0x03, 0xF0, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x0F, 0x80,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x30, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x40, 0x81, 0x02, 0x08, 0x30, 0x40, 0x00, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x08, 0x00, 0x00, 0x07, 0xE0, 0x30, 0x61, 0x00, 0x88, 0x01, 0x40, 0x05,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xC1, 0x80, 0x18, 0x01,
  0x00, 0xC0, 0x06, 0x06, 0x00, 0x08, 0x30, 0x00, 0x20, 0x81, 0xE0, 0xC4,
  0x18, 0x41, 0x10, 0xC1, 0x04, 0x82, 0x04, 0x12, 0x10, 0x10, 0x50, 0x40,
  0x83, 0x42, 0x02, 0x09, 0x08, 0x08, 0x28, 0x20, 0x20, 0xA1, 0x01, 0x02,
  0x84, 0x04, 0x12, 0x10, 0x30, 0x48, 0x40, 0xC1, 0x21, 0x05, 0x08, 0x84,
  0x24, 0x62, 0x09, 0x1F, 0x08, 0x18, 0x30, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x05, 0x00, 0x00, 0x90, 0x00, 0x22, 0x00,
  0x04, 0x40, 0x01, 0x08, 0x00, 0x21, 0x00, 0x08, 0x20, 0x01, 0x02, 0x00,
  0x40, 0x40, 0x08, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x04, 0x02,
  0x00, 0x80, 0x80, 0x08, 0x10, 0x01, 0x07, 0xFF, 0xE0, 0x80, 0x04, 0x30,
  0x00, 0x84, 0x00, 0x11, 0x80, 0x02, 0x20, 0x00, 0x6C, 0x00, 0x05, 0x00,
  0x00, 0xE0, 0x00, 0x10, 0x07, 0xF8, 0x00, 0x80, 0xE0, 0x20, 0x02, 0x04,
  0x00, 0x20, 0x80, 0x06, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x10,
  0x00, 0x42, 0x00, 0x08, 0x40, 0x02, 0x08, 0x00, 0xC1, 0x00, 0x60, 0x3F,
  0xF0, 0x08, 0x03, 0x81, 0x00, 0x08, 0x20, 0x00, 0x84, 0x00, 0x10, 0x80,
  0x01, 0x20, 0x00, 0x24, 0x00, 0x04, 0x80, 0x01, 0x10, 0x00, 0x22, 0x00,
  0x08, 0x40, 0x03, 0x10, 0x00, 0xC2, 0x00, 0x60, 0x7F, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x30, 0x30, 0x0C, 0x03, 0x03, 0x00, 0x20, 0xC0, 0x02, 0x10,
  0x00, 0x44, 0x00, 0x08, 0x80, 0x01, 0x20, 0x00, 0x24, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x24, 0x00,
  0x08, 0x80, 0x01, 0x10, 0x00, 0x42, 0x00, 0x18, 0x20, 0x02, 0x04, 0x00,
  0x80, 0x40, 0x60, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x01, 0x00, 0xC0, 0x20,
  0x06, 0x04, 0x00, 0x40, 0x80, 0x04, 0x10, 0x00, 0xC4, 0x00, 0x08, 0x80,
  0x01, 0x10, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x12, 0x00,
  0x02, 0x40, 0x00, 0x48, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x64, 0x00,
  0x09, 0x00, 0x01, 0x20, 0x00, 0x64, 0x00, 0x08, 0x80, 0x03, 0x10, 0x00,
  0x44, 0x00, 0x10, 0x80, 0x04, 0x10, 0x03, 0x02, 0x01, 0xC0, 0x7F, 0xE0,
  0x00, 0x07, 0xFF, 0xF0, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0xFF, 0xF0,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x01, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0xFF, 0xF0, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x30, 0x30, 0x0C, 0x03, 0x02, 0x00, 0x20, 0xC0, 0x02, 0x10, 0x00, 0x44,
  0x00, 0x08, 0x80, 0x01, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x01, 0xFE, 0xC0,
  0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x48, 0x00, 0x08, 0x80,
  0x01, 0x10, 0x00, 0x22, 0x00, 0x04, 0x20, 0x00, 0x86, 0x00, 0x60, 0x60,
  0x38, 0x07, 0xFC, 0x00, 0x04, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x02,
  0x08, 0x00, 0x10, 0x80, 0x00, 0x84, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00,
  0x02, 0x08, 0x00, 0x10, 0x80, 0x00, 0x84, 0x00, 0x04, 0x20, 0x00, 0x41,
  0x00, 0x02, 0x0F, 0xFF, 0xF0, 0x40, 0x00, 0x84, 0x00, 0x04, 0x20, 0x00,
  0x41, 0x00, 0x02, 0x08, 0x00, 0x10, 0x40, 0x00, 0x82, 0x00, 0x04, 0x20,
  0x00, 0x21, 0x00, 0x02, 0x08, 0x00, 0x10, 0x40, 0x00, 0x82, 0x00, 0x04,
  0x10, 0x00, 0x21, 0x00, 0x01, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x40, 0x00, 0x84, 0x00, 0x10, 0x40,
  0x01, 0x04, 0x00, 0x30, 0x40, 0x06, 0x02, 0x00, 0xC0, 0x10, 0x18, 0x00,
  0xFE, 0x00, 0x04, 0x00, 0x0C, 0x10, 0x00, 0x40, 0x40, 0x02, 0x02, 0x00,
  0x10, 0x08, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x20, 0x02, 0x01, 0x00,
  0x08, 0x08, 0x00, 0x40, 0xC0, 0x01, 0x06, 0x00, 0x04, 0x30, 0x00, 0x11,
  0x80, 0x00, 0x4E, 0x00, 0x01, 0x6C, 0x00, 0x0A, 0x10, 0x00, 0x30, 0x20,
  0x00, 0x80, 0x80, 0x02, 0x01, 0x00, 0x08, 0x06, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x10, 0x04, 0x00, 0x40, 0x10, 0x00, 0x80, 0x40, 0x03, 0x01, 0x00,
  0x04, 0x04, 0x00, 0x08, 0x20, 0x00, 0x30, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0xFF, 0xFF, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x60, 0x01, 0x81,
  0x80, 0x0A, 0x05, 0x00, 0x28, 0x24, 0x01, 0x20, 0x90, 0x0D, 0x02, 0x40,
  0x24, 0x09, 0x01, 0x10, 0x22, 0x04, 0x41, 0x88, 0x21, 0x04, 0x20, 0x84,
  0x10, 0x84, 0x20, 0x42, 0x30, 0x81, 0x04, 0x82, 0x04, 0x14, 0x08, 0x20,
  0x50, 0x20, 0x81, 0x80, 0x82, 0x06, 0x04, 0x08, 0x00, 0x10, 0x20, 0x00,
  0x40, 0x80, 0x01, 0x04, 0x00, 0x04, 0x10, 0x00, 0x10, 0x40, 0x00, 0x81,
  0x00, 0x02, 0x04, 0x00, 0x08, 0x30, 0x00, 0x20, 0x04, 0x00, 0x08, 0x30,
  0x00, 0x41, 0x80, 0x02, 0x0C, 0x00, 0x10, 0x90, 0x00, 0x84, 0x80, 0x08,
  0x24, 0x00, 0x41, 0x10, 0x02, 0x08, 0x80, 0x10, 0x42, 0x00, 0x84, 0x10,
  0x08, 0x20, 0x80, 0x41, 0x02, 0x02, 0x08, 0x10, 0x10, 0x40, 0x80, 0x84,
  0x02, 0x04, 0x20, 0x10, 0x41, 0x00, 0x42, 0x08, 0x02, 0x10, 0x40, 0x10,
  0x82, 0x00, 0x44, 0x20, 0x02, 0x21, 0x00, 0x12, 0x08, 0x00, 0x50, 0x40,
  0x02, 0x82, 0x00, 0x0C, 0x10, 0x00, 0x61, 0x00, 0x03, 0x00, 0x00, 0x7E,
  0x00, 0x30, 0x20, 0x0C, 0x02, 0x03, 0x00, 0x20, 0xC0, 0x04, 0x10, 0x00,
  0x44, 0x00, 0x08, 0x80, 0x01, 0x20, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00,
  0xB0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x12, 0x00, 0x02,
  0x40, 0x00, 0x48, 0x00, 0x0B, 0x00, 0x01, 0x60, 0x00, 0x44, 0x00, 0x08,
  0x80, 0x02, 0x10, 0x00, 0x42, 0x00, 0x10, 0x20, 0x06, 0x04, 0x01, 0x80,
  0x40, 0x60, 0x07, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x40, 0x18, 0x04, 0x00,
  0x60, 0x40, 0x02, 0x04, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80,
  0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x31, 0x00, 0x02, 0x10,
  0x00, 0x41, 0x00, 0x0C, 0x10, 0x03, 0x01, 0xFF, 0xE0, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x18, 0x18, 0x03, 0x00, 0xC0, 0x40,
  0x04, 0x08, 0x00, 0x21, 0x80, 0x02, 0x10, 0x00, 0x23, 0x00, 0x01, 0x20,
  0x00, 0x12, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x24,
  0x00, 0x02, 0x40, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x04,
  0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0xC8, 0x00, 0x08, 0x40, 0x01,
  0x04, 0x00, 0x10, 0x40, 0x02, 0x02, 0x00, 0x40, 0x10, 0x18, 0x00, 0xFF,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x07, 0xFC, 0x00, 0x80, 0x60, 0x10, 0x02, 0x04, 0x00, 0x20,
  0x80, 0x02, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x22,
  0x00, 0x04, 0x40, 0x01, 0x08, 0x00, 0x21, 0x00, 0x08, 0x20, 0x02, 0x04,
  0x01, 0x81, 0xFF, 0xC0, 0x20, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10,
  0x06, 0x02, 0x00, 0x40, 0x80, 0x08, 0x10, 0x00, 0x82, 0x00, 0x10, 0x40,
  0x02, 0x08, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0xC0, 0x00, 0x7E, 0x00,
  0x18, 0x18, 0x06, 0x00, 0x40, 0x40, 0x06, 0x08, 0x00, 0x21, 0x80, 0x02,
  0x10, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x48, 0x00, 0x0C, 0x80, 0x00, 0x84, 0x00, 0x08, 0x40, 0x01, 0x02,
  0x00, 0x30, 0x10, 0x0C, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x90, 0x00, 0x12,
  0x00, 0x02, 0x40, 0x00, 0x88, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x48,
  0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x44, 0x00, 0x08, 0x80, 0x01, 0x10,
  0x00, 0x24, 0x00, 0x04, 0x80, 0x01, 0x90, 0x00, 0x22, 0x00, 0x04, 0x40,
  0x00, 0x88, 0x00, 0x11, 0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x20, 0xC0,
  0x0C, 0x08, 0x03, 0x00, 0x80, 0xC0, 0x0F, 0xE0, 0x00, 0xC0, 0x00, 0x28,
  0x00, 0x0D, 0x00, 0x01, 0x20, 0x00, 0x24, 0x00, 0x08, 0x80, 0x01, 0x10,
  0x00, 0x41, 0x00, 0x08, 0x20, 0x02, 0x04, 0x00, 0x40, 0x80, 0x10, 0x10,
  0x02, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x04, 0x00, 0x80, 0x80, 0x10,
  0x30, 0x02, 0x04, 0x00, 0x41, 0x80, 0x04, 0x20, 0x00, 0x84, 0x00, 0x11,
  0x00, 0x02, 0x20, 0x00, 0x48, 0x00, 0x09, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x48, 0x12, 0x04,
  0x81, 0x20, 0x48, 0x12, 0x08, 0x82, 0x20, 0x88, 0x22, 0x08, 0x82, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0xC2, 0x10, 0x88, 0x22, 0x08, 0x82,
  0x20, 0x98, 0x22, 0x09, 0x02, 0x40, 0x90, 0x34, 0x0B, 0x03, 0x40, 0xA0,
  0x18, 0x0A, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x01, 0x00, 0xC0, 0x10, 0x08,
  0x01, 0x00, 0x08, 0x00, 0x04, 0x10, 0x00, 0x20, 0x40, 0x01, 0x80, 0x80,
  0x04, 0x02, 0x00, 0x20, 0x04, 0x01, 0x00, 0x10, 0x0C, 0x00, 0x20, 0x60,
  0x00, 0x81, 0x00, 0x03, 0x08, 0x00, 0x04, 0x40, 0x00, 0x1B, 0x00, 0x00,
  0x28, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x14, 0x00, 0x00, 0xC8,
  0x00, 0x02, 0x20, 0x00, 0x10, 0x40, 0x00, 0x81, 0x00, 0x06, 0x02, 0x00,
  0x10, 0x08, 0x00, 0x80, 0x10, 0x04, 0x00, 0x40, 0x20, 0x00, 0x80, 0x80,
  0x02, 0x04, 0x00, 0x0C, 0x20, 0x00, 0x10, 0xC0, 0x00, 0x28, 0x00, 0x09,
  0x00, 0x01, 0x10, 0x00, 0x42, 0x00, 0x10, 0x40, 0x06, 0x04, 0x00, 0x80,
  0x80, 0x20, 0x10, 0x0C, 0x01, 0x01, 0x00, 0x20, 0x40, 0x04, 0x18, 0x00,
  0x42, 0x00, 0x08, 0x80, 0x01, 0x20, 0x00, 0x14, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xF8,
  0x03, 0xE0, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x60, 0x08, 0x01, 0xF8, 0x00, 0x81, 0x03, 0x02, 0x04, 0x08, 0x10, 0x30,
  0x20, 0x40, 0x81, 0x03, 0x02, 0x04, 0x08, 0x10, 0x30, 0x20, 0x40, 0x81,
  0x03, 0x02, 0x04, 0x08, 0x10, 0x30, 0x20, 0x40, 0x03, 0xE0, 0x84, 0x00,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x81, 0xF0,
  0x00, 0x00, 0x40, 0x06, 0x00, 0x70, 0x02, 0x80, 0x22, 0x01, 0x10, 0x10,
  0x80, 0x84, 0x08, 0x30, 0xC0, 0x84, 0x04, 0x40, 0x22, 0x01, 0x20, 0x07,
  0x00, 0x20, 0xFF, 0xFF, 0x84, 0x42, 0x30, 0x00, 0xFC, 0x00, 0xC0, 0xC0,
  0x40, 0x18, 0x20, 0x02, 0x10, 0x00, 0x84, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x07, 0xE0, 0x7F, 0xF8, 0x60, 0x02, 0x20, 0x01,
  0x10, 0x00, 0x44, 0x00, 0x12, 0x00, 0x04, 0x80, 0x03, 0x20, 0x01, 0x44,
  0x00, 0xA1, 0x80, 0xC8, 0x3F, 0xC3, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x7C, 0x02, 0x61, 0x81, 0x60, 0x10, 0x70, 0x06, 0x18, 0x00,
  0x84, 0x00, 0x21, 0x00, 0x08, 0xC0, 0x02, 0x20, 0x00, 0xC8, 0x00, 0x22,
  0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x90, 0x00, 0x64, 0x00, 0x11, 0x00,
  0x04, 0x40, 0x02, 0x18, 0x01, 0x86, 0x00, 0xC2, 0x40, 0x60, 0x8F, 0xE0,
  0x00, 0x01, 0xF8, 0x03, 0x86, 0x03, 0x00, 0x83, 0x00, 0x23, 0x00, 0x11,
  0x00, 0x05, 0x00, 0x02, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x04, 0x80,
  0x06, 0x20, 0x02, 0x10, 0x02, 0x06, 0x06, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x01, 0xF0, 0x80, 0xC1, 0x90, 0x20, 0x1A,
  0x08, 0x01, 0x43, 0x00, 0x10, 0x40, 0x02, 0x10, 0x00, 0x42, 0x00, 0x08,
  0x40, 0x01, 0x10, 0x00, 0x22, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x21,
  0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x04, 0x08, 0x01, 0x81,
  0x00, 0x70, 0x10, 0x1A, 0x01, 0xFC, 0x40, 0x00, 0xFC, 0x00, 0xE0, 0xC0,
  0x60, 0x10, 0x30, 0x02, 0x18, 0x00, 0x84, 0x00, 0x12, 0x00, 0x04, 0x80,
  0x01, 0x40, 0x00, 0x5F, 0xFF, 0xF4, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x30, 0x60, 0x30, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xA0, 0x07, 0x88,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0xC0, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xF8, 0x40, 0xC1, 0x90,
  0x60, 0x34, 0x20, 0x05, 0x18, 0x00, 0x84, 0x00, 0x22, 0x00, 0x08, 0x80,
  0x02, 0x20, 0x00, 0x90, 0x00, 0x24, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01,
  0x10, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x40, 0x02, 0x08, 0x01, 0x82,
  0x00, 0xE0, 0x40, 0x68, 0x0F, 0xE2, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x08, 0x20, 0x06, 0x0C, 0x03, 0x01, 0x81, 0x80, 0x3F, 0x80,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x7C, 0x04, 0x70, 0xC1,
  0x30, 0x18, 0x50, 0x02, 0x18, 0x00, 0x84, 0x00, 0x33, 0x00, 0x04, 0x80,
  0x02, 0x20, 0x00, 0x88, 0x00, 0x22, 0x00, 0x08, 0x80, 0x02, 0x40, 0x00,
  0x90, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00, 0x48,
  0x00, 0x12, 0x00, 0x08, 0x80, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x03, 0xF8, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0xC4, 0x00, 0x61, 0x00,
  0x20, 0x40, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x02, 0x04, 0x00, 0x86, 0x00,
  0x23, 0x00, 0x09, 0x80, 0x03, 0xB0, 0x01, 0xC4, 0x00, 0x40, 0x80, 0x10,
  0x10, 0x04, 0x06, 0x01, 0x00, 0x80, 0x40, 0x10, 0x20, 0x06, 0x08, 0x00,
  0x82, 0x00, 0x10, 0x80, 0x06, 0x00, 0x07, 0xFC, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0xFF, 0xFF, 0x13, 0xE0, 0xF0, 0x58, 0x4C, 0x21, 0x81, 0x40,
  0x44, 0x03, 0x01, 0x30, 0x08, 0x04, 0x80, 0x20, 0x12, 0x01, 0x00, 0x48,
  0x04, 0x01, 0x20, 0x10, 0x08, 0x80, 0x40, 0x24, 0x01, 0x00, 0x90, 0x04,
  0x02, 0x40, 0x20, 0x09, 0x00, 0x80, 0x44, 0x02, 0x01, 0x10, 0x08, 0x04,
  0x80, 0x20, 0x12, 0x01, 0x00, 0x48, 0x04, 0x01, 0x20, 0x10, 0x08, 0x80,
  0x40, 0x20, 0x18, 0x7E, 0x04, 0x70, 0xC1, 0x20, 0x18, 0x50, 0x02, 0x18,
  0x00, 0x84, 0x00, 0x23, 0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x88, 0x00,
  0x22, 0x00, 0x08, 0x80, 0x02, 0x40, 0x00, 0x90, 0x00, 0x44, 0x00, 0x11,
  0x00, 0x04, 0x40, 0x01, 0x10, 0x00, 0x48, 0x00, 0x22, 0x00, 0x08, 0x80,
  0x02, 0x00, 0x00, 0xFC, 0x00, 0xC1, 0x80, 0x40, 0x10, 0x20, 0x02, 0x10,
  0x00, 0x8C, 0x00, 0x12, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x50, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x28, 0x00, 0x0B,
  0x00, 0x04, 0x40, 0x03, 0x10, 0x00, 0x82, 0x00, 0xC0, 0x40, 0x60, 0x0F,
  0xE0, 0x00, 0x04, 0x7E, 0x02, 0x70, 0xC0, 0xB0, 0x08, 0x38, 0x03, 0x0C,
  0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0x44, 0x00,
  0x11, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00, 0x48, 0x00, 0x32, 0x00, 0x08,
  0x80, 0x02, 0x20, 0x01, 0x08, 0x00, 0xC3, 0x00, 0x61, 0x20, 0x30, 0x47,
  0xF0, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x83, 0x06,
  0x43, 0x01, 0xA2, 0x00, 0x53, 0x00, 0x11, 0x00, 0x09, 0x00, 0x04, 0x80,
  0x02, 0x40, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24,
  0x00, 0x12, 0x00, 0x09, 0x00, 0x04, 0x80, 0x04, 0x20, 0x06, 0x10, 0x07,
  0x04, 0x06, 0x81, 0xFC, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x08, 0x3F,
  0x08, 0xE0, 0x13, 0x00, 0x16, 0x00, 0x14, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x01, 0xF8, 0x03, 0x03, 0x06, 0x00, 0x42, 0x00,
  0x12, 0x00, 0x09, 0x00, 0x04, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x02, 0x80, 0x02, 0x40, 0x01, 0x30, 0x01, 0x0C, 0x03, 0x01, 0xFF,
  0x00, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x03, 0xFF, 0xF0,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x1F, 0xC0, 0x10,
  0x00, 0x90, 0x00, 0x48, 0x00, 0x24, 0x00, 0x12, 0x00, 0x09, 0x00, 0x0C,
  0x80, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00,
  0x6C, 0x00, 0x24, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04, 0x80, 0x06, 0x60,
  0x05, 0x10, 0x07, 0x0C, 0x04, 0x81, 0xFC, 0x40, 0x80, 0x00, 0x60, 0x00,
  0x28, 0x00, 0x0B, 0x00, 0x04, 0x40, 0x03, 0x10, 0x00, 0x84, 0x00, 0x41,
  0x80, 0x10, 0x20, 0x08, 0x08, 0x06, 0x02, 0x01, 0x00, 0x40, 0xC0, 0x10,
  0x20, 0x04, 0x10, 0x01, 0x04, 0x00, 0x22, 0x00, 0x09, 0x80, 0x02, 0x40,
  0x00, 0xB0, 0x00, 0x18, 0x00, 0x04, 0x00, 0x00, 0x80, 0x20, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x68, 0x1A, 0x04, 0x81,
  0x20, 0x48, 0x12, 0x08, 0x82, 0x20, 0x8C, 0x22, 0x18, 0xC4, 0x21, 0x04,
  0x42, 0x10, 0x44, 0x22, 0x04, 0x83, 0x20, 0x48, 0x12, 0x05, 0x01, 0x40,
  0x50, 0x14, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10,
  0x00, 0x08, 0x00, 0x10, 0xC0, 0x02, 0x04, 0x00, 0x60, 0x20, 0x0C, 0x02,
  0x01, 0x80, 0x10, 0x30, 0x01, 0x86, 0x00, 0x08, 0xC0, 0x00, 0x48, 0x00,
  0x07, 0x00, 0x00, 0x20, 0x00, 0x07, 0x00, 0x00, 0x90, 0x00, 0x10, 0x80,
  0x02, 0x0C, 0x00, 0x60, 0x40, 0x0C, 0x02, 0x01, 0x80, 0x20, 0x30, 0x01,
  0x06, 0x00, 0x18, 0xC0, 0x00, 0xC0, 0x08, 0x00, 0x03, 0x0C, 0x00, 0x02,
  0x04, 0x00, 0x04, 0x04, 0x00, 0x04, 0x04, 0x00, 0x08, 0x02, 0x00, 0x18,
  0x02, 0x00, 0x10, 0x02, 0x00, 0x20, 0x03, 0x00, 0x60, 0x01, 0x00, 0x40,
  0x01, 0x00, 0xC0, 0x01, 0x00, 0x80, 0x00, 0x81, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x82, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x44, 0x00, 0x00, 0x48, 0x00,
  0x00, 0x58, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF1,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x06, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x30, 0x03,
  0x80, 0x07, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x04, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0x82, 0x18,
  0x41, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x80, 0x03, 0x00, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x38, 0x00, 0x70, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xCC, 0x00, 0x58, 0x10, 0x04, 0x80,
  0x40, 0x28, 0x01, 0x02, 0x40, 0x07, 0xE0, 0x00, 0x04, 0x00,
};

const GFXglyph RobotoMono_ThinItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 6, 28, 23, 8, -28 },
  { 22, 7, 8, 23, 10, -29 },
  { 29, 22, 28, 23, 1, -28 },
  { 106, 18, 36, 23, 3, -32 },
  { 187, 19, 28, 23, 2, -28 },
  { 254, 19, 28, 23, 2, -28 },
  { 321, 3, 8, 23, 11, -29 },
  { 324, 11, 40, 23, 7, -31 },
  { 379, 11, 40, 23, 4, -31 },
  { 434, 17, 15, 23, 5, -28 },
  { 466, 19, 20, 23, 2, -23 },
  { 514, 4, 8, 23, 5, -3 },
  { 518, 13, 1, 23, 5, -13 },
  { 520, 2, 2, 23, 9, -2 },
  { 521, 18, 30, 23, 3, -28 },
  { 589, 18, 28, 23, 3, -28 },
  { 652, 10, 28, 23, 6, -28 },
  { 687, 18, 28, 23, 1, -28 },
  { 750, 19, 28, 23, 1, -28 },
  { 817, 19, 28, 23, 1, -28 },
  { 884, 19, 28, 23, 3, -28 },
  { 951, 17, 28, 23, 2, -28 },
  { 1011, 17, 28, 23, 5, -28 },
  { 1071, 20, 28, 23, 2, -28 },
  { 1141, 17, 28, 23, 4, -28 },
  { 1201, 5, 19, 23, 10, -19 },
  { 1213, 7, 24, 23, 8, -19 },
  { 1234, 18, 15, 23, 3, -20 },
  { 1268, 18, 9, 23, 3, -17 },
  { 1289, 18, 15, 23, 2, -20 },
  { 1323, 14, 28, 23, 6, -28 },
  { 1372, 22, 28, 23, 1, -28 },
  { 1449, 19, 28, 23, 0, -28 },
  { 1516, 19, 28, 23, 2, -28 },
  { 1583, 19, 28, 23, 2, -28 },
  { 1650, 19, 28, 23, 2, -28 },
  { 1717, 20, 28, 23, 2, -28 },
  { 1787, 20, 28, 23, 2, -28 },
  { 1857, 19, 28, 23, 2, -28 },
  { 1924, 21, 28, 23, 1, -28 },
  { 1998, 20, 28, 23, 2, -28 },
  { 2068, 20, 28, 23, 1, -28 },
  { 2138, 22, 28, 23, 2, -28 },
  { 2215, 16, 28, 23, 2, -28 },
  { 2271, 22, 28, 23, 1, -28 },
  { 2348, 21, 28, 23, 1, -28 },
  { 2422, 19, 28, 23, 2, -28 },
  { 2489, 20, 28, 23, 2, -28 },
  { 2559, 20, 33, 23, 2, -28 },
  { 2642, 19, 28, 23, 2, -28 },
  { 2709, 20, 28, 23, 2, -28 },
  { 2779, 19, 28, 23, 5, -28 },
  { 2846, 19, 28, 23, 3, -28 },
  { 2913, 19, 28, 23, 4, -28 },
  { 2980, 20, 28, 23, 4, -28 },
  { 3050, 22, 28, 23, 1, -28 },
  { 3127, 19, 28, 23, 4, -28 },
  { 3194, 20, 28, 23, 1, -28 },
  { 3264, 11, 38, 23, 6, -32 },
  { 3317, 7, 30, 23, 8, -28 },
  { 3344, 11, 38, 23, 6, -32 },
  { 3397, 13, 15, 23, 5, -28 },
  { 3422, 16, 1, 23, 1, 0 },
  { 3424, 4, 5, 23, 12, -29 },
  { 3427, 18, 21, 23, 2, -21 },
  { 3475, 18, 29, 23, 2, -29 },
  { 3541, 17, 21, 23, 3, -21 },
  { 3586, 19, 29, 23, 3, -29 },
  { 3655, 18, 21, 23, 2, -21 },
  { 3703, 19, 30, 23, 5, -30 },
  { 3775, 18, 29, 23, 2, -21 },
  { 3841, 18, 29, 23, 2, -29 },
  { 3907, 16, 28, 23, 2, -28 },
  { 3963, 18, 36, 23, 0, -28 },
  { 4044, 18, 29, 23, 3, -29 },
  { 4110, 16, 29, 23, 2, -29 },
  { 4168, 22, 21, 23, 0, -21 },
  { 4226, 18, 21, 23, 2, -21 },
  { 4274, 18, 21, 23, 2, -21 },
  { 4322, 18, 29, 23, 1, -21 },
  { 4388, 17, 29, 23, 3, -21 },
  { 4450, 16, 21, 23, 5, -21 },
  { 4492, 17, 21, 23, 3, -21 },
  { 4537, 14, 26, 23, 5, -26 },
  { 4583, 17, 21, 23, 3, -21 },
  { 4628, 18, 21, 23, 4, -21 },
  { 4676, 20, 21, 23, 3, -21 },
  { 4729, 20, 21, 23, 1, -21 },
  { 4782, 24, 29, 23, -1, -21 },
  { 4869, 20, 21, 23, 1, -21 },
  { 4922, 15, 38, 23, 6, -30 },
  { 4994, 6, 33, 23, 8, -28 },
  { 5019, 15, 38, 23, 3, -30 },
  { 5091, 21, 7, 23, 1, -15 },
};

const GFXfont RobotoMono_ThinItalic39pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic39pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _ROBOTOMONO_THINITALIC39PT7B_H_
