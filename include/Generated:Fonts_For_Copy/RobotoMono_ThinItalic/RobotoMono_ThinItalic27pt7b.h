#ifndef _ROBOTOMONO_THINITALIC27PT7B_H_
#define _ROBOTOMONO_THINITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x12, 0x22, 0x22, 0x24, 0x44, 0x44, 0x00, 0x00, 0x80, 0x4C,
  0x65, 0x29, 0x00, 0x00, 0x82, 0x00, 0x84, 0x00, 0x84, 0x01, 0x04, 0x01,
  0x08, 0x1F, 0xFF, 0x02, 0x08, 0x02, 0x10, 0x04, 0x10, 0x04, 0x20, 0x04,
  0x20, 0x08, 0x20, 0x08, 0x40, 0xFF, 0xFC, 0x10, 0x40, 0x10, 0x80, 0x10,
  0x80, 0x20, 0x80, 0x21, 0x00, 0x00, 0x80, 0x04, 0x00, 0x60, 0x0C, 0xC1,
  0x81, 0x08, 0x08, 0x80, 0x24, 0x01, 0x20, 0x01, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x24, 0x01, 0x20, 0x09,
  0x00, 0x84, 0x0C, 0x1D, 0x80, 0x10, 0x00, 0x80, 0x08, 0x00, 0x78, 0x02,
  0x20, 0x21, 0x0D, 0x08, 0x48, 0x44, 0x42, 0x42, 0x22, 0x1A, 0x20, 0x22,
  0x00, 0x10, 0x01, 0x08, 0x11, 0x21, 0x10, 0x89, 0x04, 0x88, 0x28, 0x42,
  0xC2, 0x10, 0x10, 0x80, 0x78, 0x03, 0xC0, 0x21, 0x02, 0x08, 0x10, 0x40,
  0x82, 0x04, 0x20, 0x22, 0x00, 0xE0, 0x04, 0x00, 0x50, 0x04, 0x80, 0x42,
  0x14, 0x08, 0xA0, 0x46, 0x01, 0x50, 0x04, 0x40, 0x22, 0x06, 0x8F, 0xC2,
  0x5A, 0x80, 0x03, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x20, 0x40, 0x40,
  0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x02, 0x02, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04,
  0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x40, 0x80, 0x06, 0x00, 0x80, 0x10,
  0x42, 0x37, 0x58, 0x1C, 0x03, 0x00, 0x90, 0x21, 0x08, 0x30, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x3F, 0xBE, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x24, 0xAC, 0xFF,
  0x80, 0xC0, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x00, 0x07, 0xE0,
  0x81, 0x10, 0x12, 0x01, 0x20, 0x14, 0x03, 0x40, 0x54, 0x09, 0x81, 0x18,
  0x21, 0x8C, 0x19, 0x01, 0xA0, 0x2C, 0x02, 0x80, 0x28, 0x04, 0x80, 0x44,
  0x08, 0x3F, 0x00, 0x06, 0x37, 0x88, 0x10, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x0F, 0xE1, 0x01, 0x20,
  0x12, 0x01, 0x40, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0xFF,
  0xE0, 0x07, 0xE0, 0x40, 0x84, 0x02, 0x40, 0x12, 0x00, 0x80, 0x08, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x3C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0A,
  0x00, 0x90, 0x04, 0x80, 0x42, 0x04, 0x0F, 0xC0, 0x00, 0x30, 0x01, 0x80,
  0x14, 0x01, 0x40, 0x12, 0x01, 0x10, 0x10, 0x80, 0x84, 0x08, 0x20, 0x82,
  0x08, 0x10, 0x80, 0x88, 0x04, 0x7F, 0xFC, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x0F, 0xFC, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x0B, 0xE0, 0x30, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x88, 0x02, 0x20, 0x08, 0x40, 0x41, 0x02, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x11, 0xC2, 0xC6,
  0xA0, 0x58, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x02, 0x80,
  0x48, 0x10, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x00, 0x07, 0xE0, 0xC0,
  0x84, 0x02, 0x40, 0x12, 0x00, 0x90, 0x04, 0x80, 0x44, 0x04, 0x18, 0xC0,
  0xFC, 0x08, 0x18, 0x80, 0x48, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x04, 0x80,
  0x22, 0x06, 0x0F, 0xC0, 0x1F, 0x84, 0x09, 0x00, 0xA0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x02, 0xA0, 0xA3, 0xE4, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x83, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x20,
  0x84, 0x30, 0x00, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x00, 0x80, 0x00, 0x1F, 0x88, 0x14,
  0x06, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x01, 0x01, 0x80, 0x80, 0x20,
  0x10, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x03, 0xF8, 0x08,
  0x08, 0x60, 0x10, 0x80, 0x12, 0x3E, 0x28, 0x84, 0x51, 0x08, 0xC4, 0x21,
  0x88, 0x43, 0x10, 0x8A, 0x41, 0x14, 0x84, 0x29, 0x08, 0x92, 0x31, 0x23,
  0x9C, 0x40, 0x00, 0x80, 0x00, 0x80, 0x80, 0xFE, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x28, 0x01, 0x40, 0x12, 0x00, 0x90, 0x08, 0x40, 0x42, 0x04, 0x10,
  0x20, 0x82, 0x04, 0x10, 0x21, 0xFF, 0x08, 0x04, 0x80, 0x24, 0x01, 0x40,
  0x0A, 0x00, 0x60, 0x02, 0x0F, 0xE0, 0x40, 0x41, 0x00, 0x84, 0x02, 0x10,
  0x08, 0x40, 0x22, 0x00, 0x88, 0x04, 0x20, 0x60, 0xFF, 0x82, 0x01, 0x08,
  0x04, 0x40, 0x09, 0x00, 0x24, 0x01, 0x10, 0x04, 0x40, 0x21, 0x01, 0x0F,
  0xF8, 0x00, 0x07, 0xE0, 0xC0, 0x84, 0x04, 0x40, 0x14, 0x00, 0xA0, 0x05,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x1A, 0x00, 0x90, 0x04, 0x80, 0x42, 0x04, 0x0F, 0xC0, 0x1F, 0xE0, 0x40,
  0x41, 0x00, 0x84, 0x02, 0x10, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20,
  0x04, 0x80, 0x14, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x44, 0x01, 0x10,
  0x08, 0x80, 0x42, 0x02, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x10, 0xFF,
  0x82, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF9, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x03, 0xFF, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00,
  0x07, 0xE0, 0xC0, 0x88, 0x04, 0x40, 0x14, 0x00, 0xA0, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0xFD, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00,
  0x90, 0x04, 0x80, 0x22, 0x02, 0x0F, 0xE0, 0x10, 0x04, 0x40, 0x11, 0x00,
  0x48, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x88, 0x02, 0x20, 0x09, 0x7F,
  0xE4, 0x00, 0x90, 0x02, 0x40, 0x11, 0x00, 0x44, 0x01, 0x20, 0x04, 0x80,
  0x12, 0x00, 0x48, 0x02, 0x00, 0x0F, 0xFC, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10,
  0x0F, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x48, 0x02, 0x20, 0x08, 0x80, 0x41, 0x02, 0x03, 0xF0,
  0x00, 0x10, 0x04, 0x80, 0x22, 0x01, 0x08, 0x18, 0x20, 0x80, 0x84, 0x02,
  0x20, 0x11, 0x00, 0x48, 0x01, 0x50, 0x06, 0x20, 0x10, 0x80, 0x41, 0x02,
  0x04, 0x08, 0x08, 0x20, 0x10, 0x80, 0x42, 0x00, 0x88, 0x03, 0x00, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0F, 0xFC, 0x10,
  0x06, 0x30, 0x18, 0x60, 0x30, 0xC0, 0xA2, 0x81, 0x44, 0x84, 0x89, 0x09,
  0x12, 0x24, 0x24, 0x88, 0x49, 0x11, 0x0C, 0x22, 0x18, 0x44, 0x20, 0x88,
  0x02, 0x10, 0x04, 0x40, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0x40, 0x10,
  0x04, 0x60, 0x11, 0x80, 0x4A, 0x01, 0x24, 0x04, 0x90, 0x12, 0x20, 0x88,
  0x82, 0x22, 0x09, 0x04, 0x24, 0x10, 0x90, 0x42, 0x40, 0x91, 0x02, 0x44,
  0x05, 0x20, 0x14, 0x80, 0x52, 0x00, 0x88, 0x02, 0x00, 0x07, 0xE0, 0xC0,
  0x84, 0x04, 0x40, 0x24, 0x00, 0xA0, 0x05, 0x00, 0x30, 0x01, 0x80, 0x14,
  0x00, 0xA0, 0x05, 0x00, 0x28, 0x01, 0x40, 0x12, 0x00, 0x90, 0x08, 0x80,
  0x42, 0x04, 0x0F, 0xC0, 0x1F, 0xE0, 0x40, 0x42, 0x00, 0x88, 0x02, 0x20,
  0x04, 0x80, 0x22, 0x00, 0x88, 0x02, 0x40, 0x11, 0x01, 0x87, 0xF8, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x00, 0x07, 0xF0, 0x20, 0x21, 0x00, 0x84, 0x01, 0x20, 0x04, 0x80,
  0x14, 0x00, 0x50, 0x01, 0x40, 0x05, 0x00, 0x18, 0x00, 0x60, 0x02, 0x80,
  0x0A, 0x00, 0x28, 0x01, 0x10, 0x04, 0x40, 0x20, 0x81, 0x01, 0xF8, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x1F, 0xC1, 0x01, 0x88, 0x04, 0x40, 0x12,
  0x00, 0x90, 0x04, 0x80, 0x48, 0x02, 0x40, 0x22, 0x06, 0x1F, 0xC0, 0x82,
  0x04, 0x08, 0x40, 0x42, 0x02, 0x10, 0x08, 0x80, 0x44, 0x01, 0x20, 0x08,
  0x07, 0xF0, 0x20, 0x21, 0x00, 0x44, 0x01, 0x20, 0x04, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x28, 0x00, 0x90, 0x04, 0x40, 0x10, 0x80, 0x81, 0xFC, 0x00, 0xFF, 0xF8,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x09, 0x00, 0x48, 0x02, 0x80, 0x14,
  0x00, 0xA0, 0x05, 0x00, 0x48, 0x02, 0x40, 0x14, 0x00, 0xA0, 0x05, 0x00,
  0x28, 0x02, 0x40, 0x12, 0x00, 0x90, 0x08, 0x80, 0x42, 0x04, 0x0F, 0xC0,
  0x80, 0x0C, 0x00, 0xA0, 0x04, 0x80, 0x44, 0x02, 0x20, 0x21, 0x01, 0x08,
  0x08, 0x40, 0x81, 0x04, 0x08, 0x40, 0x42, 0x02, 0x20, 0x11, 0x00, 0x90,
  0x04, 0x80, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x82, 0x06, 0x08, 0x28, 0x60,
  0xA1, 0x42, 0x85, 0x12, 0x24, 0x48, 0x91, 0x22, 0x44, 0x91, 0x22, 0x44,
  0x89, 0x12, 0x28, 0x50, 0xA1, 0x42, 0x85, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x82, 0x04, 0x08, 0x10, 0x00, 0x08, 0x01, 0x08, 0x02, 0x04, 0x04, 0x04,
  0x08, 0x02, 0x08, 0x02, 0x10, 0x01, 0x20, 0x01, 0x40, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x40, 0x02, 0x40, 0x04, 0x40, 0x04, 0x20, 0x08, 0x20, 0x10,
  0x10, 0x20, 0x10, 0x40, 0x08, 0xC0, 0x08, 0x80, 0x0A, 0x00, 0x90, 0x08,
  0x80, 0x42, 0x04, 0x10, 0x40, 0x82, 0x02, 0x20, 0x12, 0x00, 0x90, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x1F, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80,
  0x80, 0xF0, 0x88, 0x88, 0x84, 0x44, 0x44, 0x22, 0x22, 0x21, 0x11, 0x11,
  0x10, 0x0F, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04,
  0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10,
  0x10, 0x10, 0xF0, 0x02, 0x01, 0x40, 0x50, 0x24, 0x09, 0x04, 0x21, 0x08,
  0x82, 0x40, 0xB0, 0x30, 0xFF, 0xE0, 0x89, 0x10, 0x01, 0x80, 0x33, 0x04,
  0x04, 0x20, 0x12, 0x00, 0x80, 0x04, 0x00, 0x41, 0xFE, 0x30, 0x12, 0x00,
  0x90, 0x05, 0x00, 0x48, 0x06, 0x20, 0x50, 0xFC, 0x80, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0xC0, 0x59, 0x85, 0x02, 0x30, 0x11,
  0x00, 0x48, 0x02, 0x40, 0x12, 0x00, 0xA0, 0x09, 0x00, 0x48, 0x02, 0x40,
  0x22, 0x01, 0x18, 0x11, 0x3F, 0x00, 0x03, 0x00, 0xCC, 0x10, 0x22, 0x02,
  0x40, 0x14, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x28, 0x04,
  0x80, 0x44, 0x08, 0x3F, 0x00, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x01, 0x03, 0x88, 0x23, 0x46, 0x06, 0x20, 0x22, 0x01, 0x10, 0x09, 0x00,
  0x48, 0x02, 0x40, 0x12, 0x00, 0x90, 0x08, 0x80, 0x44, 0x02, 0x10, 0x70,
  0x7C, 0x80, 0x03, 0x00, 0xCC, 0x10, 0x22, 0x01, 0x40, 0x14, 0x01, 0x80,
  0x1F, 0xFE, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x0C, 0x3F,
  0x00, 0x00, 0xB0, 0x30, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x0F,
  0xFC, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x00, 0x01, 0x80, 0x33,
  0x44, 0x06, 0x20, 0x32, 0x01, 0x10, 0x09, 0x00, 0x48, 0x02, 0x40, 0x12,
  0x00, 0x90, 0x08, 0x80, 0x44, 0x02, 0x10, 0x70, 0x7C, 0x80, 0x04, 0x00,
  0x40, 0x02, 0x20, 0x20, 0x86, 0x03, 0xC0, 0x00, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0xE0, 0x58, 0x85, 0x02, 0x30, 0x09, 0x00,
  0x48, 0x02, 0x40, 0x22, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02, 0x40, 0x12,
  0x01, 0x20, 0x09, 0x00, 0x40, 0x01, 0x80, 0x20, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x04, 0x01, 0x0F, 0xFC, 0x00, 0x30, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x40, 0xF8, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x04, 0x80, 0xC4, 0x08, 0x20, 0x81, 0x08, 0x11,
  0x00, 0x90, 0x05, 0x80, 0x32, 0x01, 0x08, 0x08, 0x40, 0x81, 0x04, 0x04,
  0x20, 0x11, 0x00, 0xC0, 0x1F, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10,
  0x04, 0x01, 0x00, 0x43, 0xFF, 0x06, 0x1C, 0x72, 0x44, 0x83, 0x09, 0x04,
  0x14, 0x08, 0x28, 0x10, 0x50, 0x40, 0xA0, 0x81, 0x41, 0x02, 0x82, 0x0A,
  0x04, 0x14, 0x08, 0x28, 0x20, 0x50, 0x40, 0xA0, 0x81, 0x00, 0x01, 0xC0,
  0xB1, 0x0A, 0x04, 0x60, 0x12, 0x00, 0x90, 0x04, 0x80, 0x48, 0x02, 0x40,
  0x12, 0x00, 0x90, 0x04, 0x80, 0x24, 0x02, 0x40, 0x12, 0x00, 0x80, 0x01,
  0x80, 0x73, 0x04, 0x04, 0x40, 0x12, 0x00, 0xA0, 0x05, 0x00, 0x28, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x04, 0x80, 0x24, 0x02, 0x10, 0x20, 0x7E, 0x00,
  0x00, 0xC0, 0x59, 0x85, 0x02, 0x30, 0x11, 0x00, 0x88, 0x04, 0x40, 0x22,
  0x01, 0x20, 0x09, 0x00, 0x48, 0x02, 0x40, 0x22, 0x01, 0x18, 0x11, 0x3F,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x00, 0x03, 0x00, 0xCD,
  0x30, 0x32, 0x02, 0x40, 0x24, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02,
  0x80, 0x48, 0x04, 0x80, 0x44, 0x1C, 0x3E, 0x40, 0x04, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x01, 0x64, 0xC0, 0xA0, 0x28, 0x06, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x00,
  0x03, 0x81, 0xC6, 0x20, 0x12, 0x01, 0x40, 0x12, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0x80, 0x04, 0x00, 0x28, 0x02, 0x80, 0x24, 0x04, 0x3F, 0x80, 0x04,
  0x01, 0x00, 0x40, 0x10, 0xFB, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x03, 0xE0, 0x20, 0x14,
  0x01, 0x40, 0x14, 0x01, 0x40, 0x24, 0x02, 0x40, 0x28, 0x02, 0x80, 0x28,
  0x02, 0x80, 0x48, 0x04, 0x41, 0xC3, 0xE4, 0xC0, 0x0A, 0x00, 0x90, 0x04,
  0x80, 0x42, 0x02, 0x10, 0x20, 0x82, 0x04, 0x10, 0x11, 0x00, 0x88, 0x04,
  0x80, 0x28, 0x00, 0xC0, 0x04, 0x00, 0x82, 0x06, 0x0C, 0x28, 0x50, 0xA1,
  0x42, 0x85, 0x12, 0x24, 0x48, 0x91, 0x24, 0x48, 0x91, 0x22, 0x45, 0x0A,
  0x14, 0x18, 0x50, 0x40, 0x81, 0x02, 0x00, 0x30, 0x0C, 0x40, 0x40, 0x82,
  0x02, 0x10, 0x04, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x04, 0x80, 0x22,
  0x01, 0x04, 0x08, 0x10, 0x40, 0x22, 0x00, 0x40, 0x20, 0x03, 0x10, 0x02,
  0x10, 0x04, 0x10, 0x08, 0x10, 0x08, 0x08, 0x10, 0x08, 0x10, 0x08, 0x20,
  0x04, 0x40, 0x04, 0x40, 0x04, 0x80, 0x04, 0x80, 0x03, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x7F, 0xF8, 0x00,
  0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x20, 0x08, 0x02, 0x01, 0x80, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x18,
  0x00, 0x11, 0x11, 0x22, 0x22, 0x22, 0x44, 0x44, 0x44, 0x48, 0x88, 0x88,
  0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x60, 0x10, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04,
  0x03, 0x00, 0x00, 0x3C, 0x05, 0x08, 0x18, 0x10, 0xA0, 0x3C,
};

const GFXglyph RobotoMono_ThinItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 19, 16, 6, -19 },
  { 11, 5, 5, 16, 7, -20 },
  { 15, 16, 19, 16, 0, -19 },
  { 53, 13, 25, 16, 2, -22 },
  { 94, 13, 19, 16, 2, -19 },
  { 125, 13, 19, 16, 1, -19 },
  { 156, 2, 5, 16, 8, -20 },
  { 158, 8, 27, 16, 5, -21 },
  { 185, 8, 27, 16, 3, -21 },
  { 212, 11, 10, 16, 4, -19 },
  { 226, 13, 14, 16, 2, -16 },
  { 249, 3, 5, 16, 3, -2 },
  { 251, 9, 1, 16, 3, -9 },
  { 253, 2, 1, 16, 6, -1 },
  { 254, 12, 21, 16, 2, -19 },
  { 286, 12, 19, 16, 2, -19 },
  { 315, 7, 19, 16, 4, -19 },
  { 332, 12, 19, 16, 1, -19 },
  { 361, 13, 19, 16, 1, -19 },
  { 392, 13, 19, 16, 1, -19 },
  { 423, 14, 19, 16, 2, -19 },
  { 457, 11, 19, 16, 2, -19 },
  { 484, 12, 19, 16, 3, -19 },
  { 513, 13, 19, 16, 2, -19 },
  { 544, 11, 19, 16, 3, -19 },
  { 571, 4, 13, 16, 7, -13 },
  { 578, 6, 16, 16, 5, -13 },
  { 590, 12, 11, 16, 2, -14 },
  { 607, 12, 6, 16, 2, -12 },
  { 616, 12, 11, 16, 2, -14 },
  { 633, 10, 19, 16, 4, -19 },
  { 657, 15, 19, 16, 1, -19 },
  { 693, 13, 19, 16, 0, -19 },
  { 724, 14, 19, 16, 1, -19 },
  { 758, 13, 19, 16, 2, -19 },
  { 789, 14, 19, 16, 1, -19 },
  { 823, 14, 19, 16, 1, -19 },
  { 857, 13, 19, 16, 2, -19 },
  { 888, 13, 19, 16, 2, -19 },
  { 919, 14, 19, 16, 1, -19 },
  { 953, 14, 19, 16, 1, -19 },
  { 987, 14, 19, 16, 1, -19 },
  { 1021, 14, 19, 16, 2, -19 },
  { 1055, 10, 19, 16, 2, -19 },
  { 1079, 15, 19, 16, 1, -19 },
  { 1115, 14, 19, 16, 1, -19 },
  { 1149, 13, 19, 16, 2, -19 },
  { 1180, 14, 19, 16, 2, -19 },
  { 1214, 14, 22, 16, 1, -19 },
  { 1253, 13, 19, 16, 2, -19 },
  { 1284, 14, 19, 16, 1, -19 },
  { 1318, 13, 19, 16, 3, -19 },
  { 1349, 13, 19, 16, 2, -19 },
  { 1380, 13, 19, 16, 3, -19 },
  { 1411, 14, 19, 16, 3, -19 },
  { 1445, 16, 19, 16, 0, -19 },
  { 1483, 13, 19, 16, 3, -19 },
  { 1514, 14, 19, 16, 1, -19 },
  { 1548, 8, 26, 16, 4, -22 },
  { 1574, 4, 21, 16, 6, -19 },
  { 1585, 8, 26, 16, 4, -22 },
  { 1611, 10, 10, 16, 3, -19 },
  { 1624, 11, 1, 16, 1, 0 },
  { 1626, 3, 4, 16, 8, -20 },
  { 1628, 13, 15, 16, 1, -15 },
  { 1653, 13, 20, 16, 1, -20 },
  { 1686, 12, 15, 16, 2, -15 },
  { 1709, 13, 20, 16, 2, -20 },
  { 1742, 12, 15, 16, 2, -15 },
  { 1765, 12, 21, 16, 4, -21 },
  { 1797, 13, 21, 16, 1, -15 },
  { 1832, 13, 20, 16, 1, -20 },
  { 1865, 10, 19, 16, 2, -19 },
  { 1889, 12, 25, 16, 0, -19 },
  { 1927, 13, 20, 16, 2, -20 },
  { 1960, 10, 20, 16, 2, -20 },
  { 1985, 15, 15, 16, 0, -15 },
  { 2014, 13, 15, 16, 1, -15 },
  { 2039, 13, 15, 16, 1, -15 },
  { 2064, 13, 20, 16, 0, -15 },
  { 2097, 12, 20, 16, 2, -15 },
  { 2127, 11, 15, 16, 4, -15 },
  { 2148, 12, 15, 16, 2, -15 },
  { 2171, 10, 18, 16, 3, -18 },
  { 2194, 12, 14, 16, 2, -14 },
  { 2215, 13, 14, 16, 2, -14 },
  { 2238, 14, 14, 16, 2, -14 },
  { 2263, 14, 14, 16, 1, -14 },
  { 2288, 16, 20, 16, 0, -14 },
  { 2328, 13, 14, 16, 1, -14 },
  { 2351, 11, 27, 16, 4, -21 },
  { 2389, 4, 23, 16, 6, -19 },
  { 2401, 11, 27, 16, 2, -21 },
  { 2439, 14, 4, 16, 1, -10 },
};

const GFXfont RobotoMono_ThinItalic27pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic27pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic27pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _ROBOTOMONO_THINITALIC27PT7B_H_
