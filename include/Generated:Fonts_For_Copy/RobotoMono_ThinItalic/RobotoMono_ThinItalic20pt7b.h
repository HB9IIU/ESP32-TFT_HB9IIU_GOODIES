#ifndef _ROBOTOMONO_THINITALIC20PT7B_H_
#define _ROBOTOMONO_THINITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x92, 0x52, 0x48, 0x01, 0x00, 0x99, 0xAA, 0x02, 0x20, 0x22,
  0x04, 0x40, 0x44, 0x3F, 0xB0, 0x88, 0x08, 0x81, 0x10, 0x11, 0x0F, 0xFC,
  0x22, 0x02, 0x20, 0x22, 0x04, 0x40, 0x02, 0x01, 0xC0, 0x88, 0x41, 0x20,
  0x48, 0x12, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x80, 0xA0, 0x24,
  0x10, 0xD8, 0x08, 0x02, 0x00, 0x78, 0x22, 0x28, 0x8A, 0x24, 0x8A, 0x1D,
  0x00, 0x40, 0x26, 0x12, 0x45, 0x12, 0x45, 0x11, 0x44, 0x81, 0xE0, 0x0F,
  0x04, 0x42, 0x10, 0x84, 0x16, 0x06, 0x01, 0x00, 0xA0, 0x44, 0x60, 0xA8,
  0x2A, 0x04, 0x83, 0x1F, 0x20, 0xF0, 0x08, 0x84, 0x44, 0x21, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x20, 0x82, 0x00, 0x10, 0x20, 0x81, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x08, 0x20, 0x84, 0x10, 0x82, 0x10, 0x80,
  0x08, 0x08, 0x89, 0x6E, 0x10, 0x28, 0x44, 0x84, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x3F, 0xF0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x5A, 0xFE,
  0x80, 0x01, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08,
  0x08, 0x08, 0x04, 0x04, 0x02, 0x00, 0x0F, 0x84, 0x22, 0x05, 0x03, 0x41,
  0x50, 0x94, 0x46, 0x22, 0x90, 0xA8, 0x2C, 0x0A, 0x04, 0x42, 0x0F, 0x00,
  0x1F, 0x42, 0x10, 0x88, 0x42, 0x10, 0x84, 0x42, 0x10, 0x0F, 0x84, 0x12,
  0x04, 0x81, 0x00, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x3F, 0xE0, 0x1F, 0x10, 0x50, 0x28, 0x10, 0x08, 0x08, 0x78, 0x04,
  0x01, 0x00, 0xA0, 0x50, 0x28, 0x23, 0xE0, 0x01, 0x81, 0x81, 0x40, 0xA0,
  0x90, 0x88, 0x84, 0x84, 0x42, 0x7F, 0xC0, 0x80, 0x40, 0x20, 0x20, 0x3F,
  0x90, 0x08, 0x08, 0x04, 0x03, 0xF1, 0x04, 0x02, 0x01, 0x00, 0xA0, 0x50,
  0x28, 0x23, 0xE0, 0x07, 0x8C, 0x04, 0x04, 0x04, 0x43, 0xD9, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x24, 0x21, 0xE0, 0xFF, 0x01, 0x02, 0x02, 0x04,
  0x08, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0x80, 0x80, 0x1F, 0x88, 0x12,
  0x04, 0x81, 0x20, 0x48, 0x21, 0xF0, 0x84, 0x40, 0xA0, 0x28, 0x0A, 0x02,
  0x81, 0x1F, 0x80, 0x3E, 0x20, 0x90, 0x30, 0x18, 0x0C, 0x06, 0x05, 0x06,
  0x45, 0x1C, 0x80, 0x80, 0x80, 0x87, 0x80, 0x20, 0x00, 0x00, 0x10, 0x10,
  0x00, 0x00, 0x00, 0x44, 0x48, 0x03, 0x8E, 0x18, 0x10, 0x06, 0x00, 0xC0,
  0x18, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x70, 0x06, 0x00, 0xC0,
  0x10, 0x70, 0xC3, 0x80, 0x3E, 0x86, 0x08, 0x10, 0x20, 0x82, 0x08, 0x20,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x07, 0xC0, 0x82, 0x11, 0x12, 0x69, 0x48,
  0x94, 0x89, 0x51, 0x19, 0x12, 0x91, 0x29, 0x22, 0x95, 0xC4, 0x80, 0x40,
  0x03, 0xF0, 0x01, 0x00, 0xC0, 0x30, 0x14, 0x04, 0x82, 0x20, 0x88, 0x42,
  0x10, 0x8F, 0xE2, 0x09, 0x01, 0x40, 0x60, 0x10, 0x3F, 0x88, 0x12, 0x04,
  0x81, 0x40, 0x90, 0x67, 0xE1, 0x04, 0x40, 0x90, 0x28, 0x0A, 0x02, 0x81,
  0x3F, 0x80, 0x1F, 0x88, 0x12, 0x05, 0x01, 0x40, 0x10, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x0A, 0x04, 0x41, 0x0F, 0x80, 0x3F, 0x08, 0x22, 0x05,
  0x01, 0x40, 0x50, 0x14, 0x05, 0x01, 0x40, 0x60, 0x28, 0x0A, 0x04, 0x82,
  0x3F, 0x00, 0x3F, 0xC8, 0x02, 0x00, 0x80, 0x40, 0x10, 0x07, 0xF1, 0x00,
  0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xC0, 0x3F, 0xC8, 0x02, 0x00,
  0x80, 0x20, 0x10, 0x07, 0xF1, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x20, 0x00, 0x1F, 0x88, 0x12, 0x05, 0x01, 0x40, 0x20, 0x08, 0x02, 0x1C,
  0x80, 0xA0, 0x28, 0x0A, 0x02, 0x41, 0x8F, 0x80, 0x20, 0x48, 0x14, 0x05,
  0x01, 0x40, 0x50, 0x17, 0xF9, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x81,
  0x20, 0x40, 0x3F, 0xC1, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x3F, 0xC0, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x48, 0x12, 0x04, 0x82,
  0x1F, 0x00, 0x20, 0x24, 0x18, 0x84, 0x11, 0x02, 0x40, 0x90, 0x16, 0x03,
  0x40, 0x44, 0x08, 0x41, 0x08, 0x40, 0x88, 0x11, 0x01, 0x00, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0xFF,
  0x20, 0x64, 0x09, 0x43, 0x28, 0xA5, 0x14, 0xA4, 0x92, 0x92, 0x64, 0x88,
  0x90, 0x12, 0x02, 0x40, 0x48, 0x09, 0x02, 0x00, 0x20, 0x48, 0x15, 0x05,
  0x41, 0x48, 0x52, 0x14, 0x89, 0x12, 0x84, 0xA0, 0xA8, 0x2A, 0x0A, 0x81,
  0x20, 0x40, 0x1F, 0x88, 0x22, 0x05, 0x01, 0x40, 0x50, 0x18, 0x06, 0x01,
  0x80, 0xA0, 0x28, 0x0A, 0x04, 0x42, 0x0F, 0x00, 0x3F, 0x84, 0x08, 0x80,
  0x90, 0x12, 0x04, 0x40, 0x90, 0x23, 0xF8, 0x40, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x00, 0x1F, 0x88, 0x12, 0x05, 0x01, 0x40, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x28, 0x0A, 0x04, 0x41, 0x0F, 0x80, 0x20, 0x08,
  0x01, 0x00, 0x3F, 0x88, 0x12, 0x04, 0x81, 0x20, 0x50, 0x24, 0x19, 0xF8,
  0x42, 0x10, 0x88, 0x12, 0x04, 0x81, 0x20, 0x20, 0x1F, 0x88, 0x12, 0x05,
  0x01, 0x20, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x28, 0x0A, 0x02, 0x41,
  0x0F, 0x80, 0xFF, 0xC1, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x00, 0x20, 0x48, 0x14, 0x05,
  0x01, 0x40, 0x50, 0x14, 0x05, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x42,
  0x0F, 0x00, 0x80, 0x60, 0x28, 0x09, 0x04, 0x41, 0x10, 0x84, 0x21, 0x10,
  0x44, 0x09, 0x02, 0x80, 0xA0, 0x30, 0x08, 0x00, 0x84, 0x63, 0x18, 0xC6,
  0x31, 0x94, 0xA5, 0x29, 0x4A, 0x94, 0xA5, 0x31, 0x4C, 0x63, 0x18, 0x84,
  0x21, 0x00, 0x10, 0x11, 0x02, 0x08, 0x40, 0x88, 0x05, 0x00, 0x50, 0x02,
  0x00, 0x60, 0x09, 0x00, 0x90, 0x11, 0x02, 0x08, 0x40, 0x88, 0x04, 0x80,
  0x50, 0x24, 0x11, 0x04, 0x22, 0x09, 0x02, 0x40, 0x60, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x00, 0x1F, 0xE0, 0x08, 0x02, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x01, 0xFF,
  0x00, 0x1C, 0x42, 0x08, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x04,
  0x20, 0x82, 0x0E, 0x00, 0x88, 0x84, 0x44, 0x44, 0x22, 0x22, 0x21, 0x10,
  0x1C, 0x10, 0x42, 0x08, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x41, 0x08,
  0x20, 0x8E, 0x00, 0x08, 0x62, 0x89, 0x45, 0x18, 0x61, 0xFF, 0x94, 0x0F,
  0x18, 0x50, 0x20, 0x10, 0x09, 0xFD, 0x03, 0x01, 0x81, 0x41, 0x9F, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0xE2, 0x89, 0x82, 0x81, 0x40, 0xA0, 0x50,
  0x30, 0x18, 0x16, 0x12, 0xF0, 0x0F, 0x08, 0x48, 0x28, 0x14, 0x04, 0x02,
  0x01, 0x00, 0x81, 0x20, 0x8F, 0x80, 0x00, 0x40, 0x10, 0x04, 0x01, 0x0E,
  0x4C, 0x62, 0x09, 0x02, 0x40, 0xA0, 0x28, 0x0A, 0x04, 0x81, 0x10, 0xC3,
  0xD0, 0x0F, 0x08, 0x48, 0x28, 0x14, 0x0D, 0xFA, 0x01, 0x00, 0x80, 0x20,
  0x8F, 0x80, 0x0F, 0x88, 0x04, 0x02, 0x0F, 0xE1, 0x00, 0x80, 0x40, 0x20,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x0E, 0x98, 0xC8, 0x28, 0x14,
  0x0C, 0x06, 0x03, 0x02, 0x81, 0x21, 0x8F, 0x40, 0x20, 0x24, 0x11, 0xF0,
  0x20, 0x10, 0x08, 0x04, 0x02, 0xF2, 0x85, 0x82, 0x81, 0x40, 0xA0, 0x50,
  0x30, 0x18, 0x14, 0x0A, 0x04, 0x02, 0x00, 0x00, 0x3C, 0x04, 0x04, 0x04,
  0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0xFF, 0x00, 0x80, 0x00, 0x01, 0xE0,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10,
  0x08, 0x08, 0x78, 0x00, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x48, 0x62,
  0x21, 0x10, 0x48, 0x1E, 0x04, 0x81, 0x10, 0x42, 0x20, 0x88, 0x10, 0x1E,
  0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08,
  0x08, 0xFF, 0x5C, 0xCC, 0x65, 0x08, 0xA1, 0x14, 0x43, 0x08, 0x61, 0x0C,
  0x21, 0x84, 0x30, 0x8A, 0x21, 0x00, 0x2F, 0x28, 0x58, 0x28, 0x14, 0x0A,
  0x05, 0x03, 0x01, 0x81, 0x40, 0xA0, 0x40, 0x0E, 0x18, 0x90, 0x28, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x81, 0x20, 0x8F, 0x80, 0x17, 0x0A, 0x23, 0x04,
  0x81, 0x20, 0x48, 0x12, 0x05, 0x01, 0x40, 0x98, 0x45, 0xE1, 0x00, 0x40,
  0x20, 0x08, 0x00, 0x0E, 0x98, 0xC8, 0x28, 0x14, 0x0C, 0x06, 0x03, 0x02,
  0x81, 0x21, 0x8F, 0x40, 0x20, 0x10, 0x10, 0x08, 0x4F, 0x50, 0x60, 0x40,
  0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1F, 0x10, 0x48, 0x28, 0x02,
  0x00, 0xE0, 0x0C, 0x01, 0x80, 0xC0, 0x9F, 0x80, 0x10, 0x23, 0xF9, 0x02,
  0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x03, 0xC0, 0x41, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x82, 0x82, 0x86, 0x7A, 0x80, 0xC0, 0x60, 0x50, 0x24,
  0x22, 0x11, 0x10, 0x90, 0x28, 0x18, 0x08, 0x00, 0x88, 0x62, 0x19, 0x8A,
  0x62, 0x99, 0x29, 0x4A, 0x53, 0x18, 0xC6, 0x21, 0x08, 0x40, 0x20, 0x22,
  0x08, 0x42, 0x04, 0x80, 0x60, 0x08, 0x01, 0x80, 0x48, 0x11, 0x04, 0x13,
  0x03, 0x00, 0x40, 0x12, 0x02, 0x20, 0x22, 0x04, 0x10, 0x81, 0x08, 0x11,
  0x01, 0x20, 0x0A, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x10, 0x01, 0x00, 0xE0,
  0x00, 0x3F, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x03, 0xFF, 0x00, 0x01, 0x06, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x10, 0x10, 0x20, 0xC0, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x18, 0x24, 0x92, 0x4A, 0x49, 0x25, 0x24, 0x80, 0x30, 0x10, 0x20, 0x20,
  0x40, 0x81, 0x04, 0x08, 0x08, 0x08, 0x60, 0x82, 0x04, 0x08, 0x10, 0x40,
  0x86, 0x00, 0x38, 0x08, 0x85, 0x08, 0xC0, 0xE0,
};

const GFXglyph RobotoMono_ThinItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 3, 14, 12, 4, -14 },
  { 7, 4, 4, 12, 5, -15 },
  { 9, 12, 14, 12, 0, -14 },
  { 30, 10, 18, 12, 1, -16 },
  { 53, 10, 14, 12, 1, -14 },
  { 71, 10, 14, 12, 1, -14 },
  { 89, 1, 4, 12, 6, -15 },
  { 90, 5, 21, 12, 4, -16 },
  { 104, 6, 21, 12, 2, -16 },
  { 120, 8, 8, 12, 3, -14 },
  { 128, 10, 11, 12, 1, -12 },
  { 142, 2, 4, 12, 3, -2 },
  { 143, 7, 1, 12, 2, -7 },
  { 144, 1, 1, 12, 5, -1 },
  { 145, 9, 15, 12, 2, -14 },
  { 162, 10, 14, 12, 1, -14 },
  { 180, 5, 14, 12, 3, -14 },
  { 189, 10, 14, 12, 0, -14 },
  { 207, 9, 14, 12, 1, -14 },
  { 223, 9, 14, 12, 1, -14 },
  { 239, 9, 14, 12, 2, -14 },
  { 255, 9, 14, 12, 1, -14 },
  { 271, 8, 14, 12, 3, -14 },
  { 285, 10, 14, 12, 1, -14 },
  { 303, 9, 14, 12, 2, -14 },
  { 319, 3, 10, 12, 5, -10 },
  { 323, 4, 12, 12, 4, -10 },
  { 329, 9, 7, 12, 2, -10 },
  { 337, 10, 5, 12, 1, -9 },
  { 344, 9, 7, 12, 1, -10 },
  { 352, 7, 14, 12, 3, -14 },
  { 365, 12, 14, 12, 0, -14 },
  { 386, 10, 14, 12, 0, -14 },
  { 404, 10, 14, 12, 1, -14 },
  { 422, 10, 14, 12, 1, -14 },
  { 440, 10, 14, 12, 1, -14 },
  { 458, 10, 14, 12, 1, -14 },
  { 476, 10, 14, 12, 1, -14 },
  { 494, 10, 14, 12, 1, -14 },
  { 512, 10, 14, 12, 1, -14 },
  { 530, 10, 14, 12, 1, -14 },
  { 548, 10, 14, 12, 1, -14 },
  { 566, 11, 14, 12, 1, -14 },
  { 586, 8, 14, 12, 1, -14 },
  { 600, 11, 14, 12, 1, -14 },
  { 620, 10, 14, 12, 1, -14 },
  { 638, 10, 14, 12, 1, -14 },
  { 656, 11, 14, 12, 1, -14 },
  { 676, 10, 17, 12, 1, -14 },
  { 698, 10, 14, 12, 1, -14 },
  { 716, 10, 14, 12, 1, -14 },
  { 734, 10, 14, 12, 2, -14 },
  { 752, 10, 14, 12, 1, -14 },
  { 770, 10, 14, 12, 2, -14 },
  { 788, 10, 14, 12, 2, -14 },
  { 806, 12, 14, 12, 0, -14 },
  { 827, 10, 14, 12, 2, -14 },
  { 845, 11, 14, 12, 0, -14 },
  { 865, 6, 19, 12, 3, -16 },
  { 880, 4, 15, 12, 4, -14 },
  { 888, 6, 19, 12, 3, -16 },
  { 903, 6, 8, 12, 3, -14 },
  { 909, 8, 1, 12, 1, 0 },
  { 910, 2, 3, 12, 6, -15 },
  { 911, 9, 11, 12, 1, -11 },
  { 924, 9, 15, 12, 1, -15 },
  { 941, 9, 11, 12, 1, -11 },
  { 954, 10, 15, 12, 1, -15 },
  { 973, 9, 11, 12, 1, -11 },
  { 986, 9, 15, 12, 3, -15 },
  { 1003, 9, 15, 12, 1, -11 },
  { 1020, 9, 15, 12, 1, -15 },
  { 1037, 8, 14, 12, 1, -14 },
  { 1051, 9, 18, 12, 0, -14 },
  { 1072, 10, 15, 12, 1, -15 },
  { 1091, 8, 15, 12, 1, -15 },
  { 1106, 11, 11, 12, 0, -11 },
  { 1122, 9, 11, 12, 1, -11 },
  { 1135, 9, 11, 12, 1, -11 },
  { 1148, 10, 15, 12, 0, -11 },
  { 1167, 9, 15, 12, 1, -11 },
  { 1184, 8, 11, 12, 3, -11 },
  { 1195, 9, 11, 12, 1, -11 },
  { 1208, 7, 13, 12, 3, -13 },
  { 1220, 8, 11, 12, 2, -11 },
  { 1231, 9, 11, 12, 2, -11 },
  { 1244, 10, 11, 12, 2, -11 },
  { 1258, 11, 11, 12, 0, -11 },
  { 1274, 12, 15, 12, 0, -11 },
  { 1297, 11, 11, 12, 0, -11 },
  { 1313, 8, 20, 12, 3, -16 },
  { 1333, 3, 17, 12, 4, -14 },
  { 1340, 7, 20, 12, 2, -16 },
  { 1358, 11, 4, 12, 0, -8 },
};

const GFXfont RobotoMono_ThinItalic20pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic20pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _ROBOTOMONO_THINITALIC20PT7B_H_
