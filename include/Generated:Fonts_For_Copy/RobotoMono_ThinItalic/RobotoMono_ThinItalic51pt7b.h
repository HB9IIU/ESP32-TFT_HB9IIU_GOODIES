#ifndef _ROBOTOMONO_THINITALIC51PT7B_H_
#define _ROBOTOMONO_THINITALIC51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x02, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C,
  0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30,
  0x30, 0x20, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0xE0,
  0xC0, 0x20, 0xB0, 0xD8, 0x6C, 0x34, 0x12, 0x09, 0x05, 0x86, 0xC3, 0x41,
  0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x08, 0x02, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x04, 0x01, 0x80, 0x00, 0x20, 0x08, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x10, 0x04, 0x00, 0x00, 0x80, 0x20, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x40,
  0x10, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x00, 0x40,
  0x00, 0x18, 0x02, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x04, 0x01, 0x00, 0x00,
  0x60, 0x08, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x10, 0x04, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x08, 0x03, 0x00, 0x00, 0x40, 0x10, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x20, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x00,
  0x80, 0x20, 0x00, 0x04, 0x01, 0x00, 0x00, 0x60, 0x18, 0x00, 0x02, 0x00,
  0x80, 0x00, 0x10, 0x04, 0x00, 0x01, 0x80, 0x60, 0x00, 0x08, 0x02, 0x00,
  0x00, 0xC0, 0x10, 0x00, 0x06, 0x01, 0x80, 0x00, 0x20, 0x08, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xC0, 0x30, 0x01, 0x80,
  0x0C, 0x01, 0x80, 0x02, 0x01, 0x80, 0x01, 0x80, 0x80, 0x00, 0x40, 0xC0,
  0x00, 0x20, 0x40, 0x00, 0x10, 0x20, 0x00, 0x08, 0x10, 0x00, 0x04, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x80, 0x00, 0x08, 0x40, 0x00, 0x0C, 0x20, 0x00, 0x06, 0x10, 0x00,
  0x02, 0x0C, 0x00, 0x03, 0x02, 0x00, 0x01, 0x01, 0x80, 0x01, 0x80, 0x60,
  0x03, 0x80, 0x1C, 0x07, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x06, 0x08, 0x00, 0x06, 0x06, 0x00,
  0x02, 0x01, 0x00, 0x03, 0x00, 0x80, 0x31, 0x00, 0x40, 0x30, 0x80, 0x20,
  0x10, 0xC0, 0x10, 0x10, 0x60, 0x18, 0x18, 0x20, 0x0C, 0x18, 0x10, 0x04,
  0x08, 0x0C, 0x06, 0x0C, 0x06, 0x02, 0x0C, 0x01, 0x03, 0x04, 0x00, 0xE7,
  0x06, 0x00, 0x1E, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x03, 0xF0, 0x01, 0x83, 0x08,
  0x01, 0x83, 0x02, 0x00, 0x83, 0x01, 0x00, 0x81, 0x00, 0xC0, 0xC1, 0x80,
  0x60, 0xC0, 0x80, 0x30, 0x40, 0x40, 0x10, 0x60, 0x20, 0x08, 0x60, 0x30,
  0x04, 0x20, 0x18, 0x06, 0x30, 0x04, 0x02, 0x10, 0x02, 0x03, 0x00, 0x01,
  0x01, 0x00, 0x00, 0x43, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x02, 0x00,
  0x04, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x02, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x10, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x18, 0x00, 0x30, 0x18,
  0x00, 0x08, 0x18, 0x00, 0x04, 0x18, 0x00, 0x03, 0x18, 0x00, 0x00, 0x98,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x34, 0x00, 0x00, 0x23,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x60, 0x20, 0x04, 0x20, 0x18, 0x02, 0x30,
  0x04, 0x03, 0x30, 0x03, 0x01, 0x10, 0x00, 0xC0, 0x98, 0x00, 0x20, 0xC8,
  0x00, 0x18, 0x44, 0x00, 0x06, 0x62, 0x00, 0x01, 0x61, 0x00, 0x00, 0xF0,
  0x80, 0x00, 0x30, 0x60, 0x00, 0x38, 0x18, 0x00, 0x36, 0x06, 0x00, 0x61,
  0x01, 0x80, 0xE0, 0x40, 0x7F, 0xC0, 0x30, 0x02, 0x00, 0x00, 0x25, 0xB4,
  0x92, 0xD0, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x01, 0x00, 0xC0,
  0x7E, 0x04, 0x0F, 0x1E, 0x23, 0xC0, 0x1F, 0xF0, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x19, 0x00, 0x01, 0x84, 0x00, 0x18, 0x30, 0x00, 0x80, 0xC0,
  0x08, 0x02, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x60, 0x40, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x20, 0x82, 0x18, 0x41, 0x0C, 0x63,
  0x00, 0xFF, 0xFF, 0xC0, 0x5F, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x03, 0x80, 0xC0, 0x0C, 0x00, 0xC0, 0x30,
  0x00, 0xC0, 0xC0, 0x00, 0x81, 0x00, 0x01, 0x04, 0x00, 0x03, 0x18, 0x00,
  0x02, 0x20, 0x00, 0x0C, 0x40, 0x00, 0x39, 0x80, 0x00, 0xD2, 0x00, 0x03,
  0x24, 0x00, 0x0C, 0x58, 0x00, 0x30, 0xB0, 0x00, 0x81, 0x40, 0x06, 0x06,
  0x80, 0x18, 0x09, 0x00, 0x60, 0x12, 0x01, 0x80, 0x2C, 0x06, 0x00, 0x58,
  0x18, 0x01, 0xA0, 0x40, 0x03, 0x43, 0x00, 0x04, 0x8C, 0x00, 0x09, 0x30,
  0x00, 0x12, 0xC0, 0x00, 0x67, 0x00, 0x00, 0x8C, 0x00, 0x03, 0x10, 0x00,
  0x04, 0x30, 0x00, 0x18, 0x20, 0x00, 0x20, 0x40, 0x00, 0xC0, 0xC0, 0x03,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x70, 0x00, 0xFF, 0x80, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x18, 0x07, 0xC0, 0xE4, 0x1C, 0x27, 0x81, 0x60, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x60, 0x18, 0x01, 0xC0, 0x0C,
  0x03, 0x00, 0x06, 0x02, 0x00, 0x02, 0x06, 0x00, 0x03, 0x04, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x08, 0x00, 0x03, 0x18, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x1C, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x18, 0x00, 0x08, 0x08, 0x00,
  0x06, 0x0C, 0x00, 0x03, 0x04, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x61, 0x00, 0x00, 0x20, 0x80, 0x00, 0x30, 0x60, 0x00, 0x10, 0x18, 0x00,
  0x30, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x70, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x80,
  0x00, 0x02, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x03, 0x20, 0x00, 0x03, 0x10,
  0x00, 0x03, 0x08, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x06, 0x00, 0x01, 0x02,
  0x00, 0x01, 0x81, 0x00, 0x01, 0x80, 0x80, 0x01, 0x80, 0x40, 0x01, 0x80,
  0x60, 0x00, 0x80, 0x30, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0xC0, 0x02, 0x00, 0x40, 0x03, 0x00, 0x40, 0x01, 0x80, 0x60,
  0x00, 0x80, 0x60, 0x00, 0x40, 0x60, 0x00, 0x20, 0x7F, 0xFF, 0xFF, 0xC0,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x7C,
  0x00, 0x13, 0xFF, 0x80, 0x1E, 0x00, 0xC0, 0x38, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x80, 0x00, 0x10, 0x80, 0x00, 0x30, 0x80, 0x00, 0x20, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x40, 0x40, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x18, 0x0E, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x7C,
  0x01, 0x0F, 0xFC, 0x0C, 0xE0, 0x18, 0x26, 0x00, 0x30, 0xA0, 0x00, 0x67,
  0x00, 0x00, 0x98, 0x00, 0x02, 0x60, 0x00, 0x0D, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x50, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xB0, 0x00, 0x02, 0xC0, 0x00, 0x19, 0x00, 0x00, 0x44, 0x00, 0x03, 0x18,
  0x00, 0x08, 0x20, 0x00, 0x60, 0xC0, 0x03, 0x01, 0x80, 0x18, 0x03, 0x01,
  0xC0, 0x03, 0xFC, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x1C, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x18, 0x00, 0x08, 0x18, 0x00,
  0x06, 0x08, 0x00, 0x03, 0x04, 0x00, 0x00, 0x86, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x30, 0x20, 0x00, 0x10, 0x18,
  0x00, 0x18, 0x04, 0x00, 0x18, 0x03, 0x00, 0x38, 0x00, 0x70, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x60, 0x00, 0xC0,
  0x60, 0x00, 0x30, 0x60, 0x00, 0x08, 0x60, 0x00, 0x06, 0x20, 0x00, 0x03,
  0x10, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x64, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x31, 0x80, 0x00, 0x10, 0x40, 0x00, 0x18, 0x30, 0x00,
  0x18, 0x0C, 0x00, 0x38, 0x03, 0x80, 0x70, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFE, 0x00, 0x38, 0x0E, 0x01, 0x80,
  0x0C, 0x0C, 0x00, 0x10, 0x60, 0x00, 0x61, 0x00, 0x00, 0x8C, 0x00, 0x02,
  0x20, 0x00, 0x0D, 0x80, 0x00, 0x34, 0x00, 0x00, 0xD0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x02, 0xC0, 0x00,
  0x0B, 0x00, 0x00, 0x64, 0x00, 0x01, 0x90, 0x00, 0x0A, 0x60, 0x00, 0x58,
  0x80, 0x02, 0x41, 0x00, 0x31, 0x03, 0x03, 0x8C, 0x07, 0xF8, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x7F, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04,
  0x1C, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x70, 0xE0, 0x00, 0x80, 0x70,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x0C, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x10, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xC0, 0x38, 0x0E, 0x0C,
  0x00, 0x43, 0x00, 0x0C, 0x40, 0x00, 0x98, 0x00, 0x12, 0x00, 0x02, 0xC0,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0x80, 0x70, 0x00, 0x70, 0x00, 0xC0, 0x06,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x02, 0x06, 0x01, 0xF0, 0x18, 0x30, 0x39, 0xC0, 0xC3, 0x03, 0x03, 0x06,
  0x10, 0x30, 0x10, 0x31, 0x81, 0x00, 0x81, 0x88, 0x10, 0x04, 0x0C, 0xC1,
  0x80, 0x60, 0x64, 0x08, 0x02, 0x02, 0x20, 0x40, 0x10, 0x13, 0x06, 0x00,
  0x80, 0x90, 0x20, 0x0C, 0x04, 0x81, 0x00, 0x40, 0x64, 0x18, 0x02, 0x02,
  0x60, 0xC0, 0x30, 0x13, 0x04, 0x01, 0x00, 0x90, 0x20, 0x18, 0x0C, 0x81,
  0x00, 0xC0, 0x44, 0x08, 0x0A, 0x06, 0x20, 0x40, 0xD0, 0x21, 0x83, 0x0C,
  0x82, 0x0C, 0x0C, 0xC6, 0x70, 0x20, 0x3C, 0x1E, 0x01, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x08, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x14, 0x00, 0x00, 0x1A, 0x00,
  0x00, 0x09, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x04, 0x60, 0x00, 0x06, 0x30,
  0x00, 0x02, 0x08, 0x00, 0x03, 0x04, 0x00, 0x01, 0x02, 0x00, 0x01, 0x81,
  0x00, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x40, 0x30, 0x00, 0x60,
  0x08, 0x00, 0x20, 0x04, 0x00, 0x30, 0x02, 0x00, 0x10, 0x01, 0x00, 0x18,
  0x00, 0xC0, 0x08, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x04, 0x00, 0x08, 0x06,
  0x00, 0x04, 0x03, 0xFF, 0xFE, 0x03, 0x00, 0x01, 0x01, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x60, 0x80, 0x00, 0x30, 0x40, 0x00, 0x08, 0x40, 0x00, 0x04,
  0x20, 0x00, 0x02, 0x20, 0x00, 0x01, 0x10, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x30, 0x03, 0xFF, 0xE0, 0x02, 0x00, 0x78, 0x06, 0x00,
  0x0C, 0x06, 0x00, 0x06, 0x04, 0x00, 0x02, 0x04, 0x00, 0x03, 0x04, 0x00,
  0x01, 0x04, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x08, 0x00,
  0x03, 0x08, 0x00, 0x02, 0x08, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x70, 0x10, 0x03, 0xC0, 0x1F, 0xFF, 0x80, 0x10, 0x00,
  0xE0, 0x10, 0x00, 0x18, 0x30, 0x00, 0x08, 0x20, 0x00, 0x0C, 0x20, 0x00,
  0x04, 0x20, 0x00, 0x06, 0x20, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x04, 0x40, 0x00, 0x04, 0x40, 0x00, 0x0C, 0x40, 0x00, 0x08, 0x40, 0x00,
  0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0x80, 0x01, 0xC0, 0x80, 0x0F,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x1C,
  0x07, 0x00, 0x18, 0x00, 0xC0, 0x18, 0x00, 0x20, 0x18, 0x00, 0x18, 0x18,
  0x00, 0x04, 0x08, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x84, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x22, 0x00, 0x00, 0x13, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x30, 0x00, 0x01, 0x18, 0x00, 0x01, 0x84, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0xC1, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x20, 0x00, 0x60, 0x18,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x01, 0x80, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xC0, 0x0E, 0x00, 0x20, 0x00,
  0xC0, 0x08, 0x00, 0x18, 0x02, 0x00, 0x03, 0x00, 0x80, 0x00, 0x40, 0x60,
  0x00, 0x18, 0x10, 0x00, 0x02, 0x04, 0x00, 0x00, 0x81, 0x00, 0x00, 0x30,
  0x40, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x10, 0x80, 0x00, 0x04, 0x20, 0x00, 0x03, 0x08, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x21, 0x80, 0x00, 0x08, 0x40, 0x00, 0x02, 0x10, 0x00, 0x00, 0x84,
  0x00, 0x00, 0x61, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x04, 0x30, 0x00, 0x03,
  0x08, 0x00, 0x00, 0x82, 0x00, 0x00, 0x60, 0x80, 0x00, 0x10, 0x20, 0x00,
  0x0C, 0x18, 0x00, 0x06, 0x04, 0x00, 0x03, 0x01, 0x00, 0x01, 0x80, 0x40,
  0x00, 0xC0, 0x10, 0x00, 0xE0, 0x0C, 0x01, 0xE0, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x1C, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x18, 0x00, 0x20, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x04, 0x18, 0x00, 0x03, 0x08, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x44, 0x00, 0x00, 0x26, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06,
  0x00, 0x7F, 0xF3, 0x00, 0x00, 0x09, 0x00, 0x00, 0x04, 0x80, 0x00, 0x06,
  0x40, 0x00, 0x03, 0x20, 0x00, 0x01, 0x18, 0x00, 0x00, 0x8C, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x61, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x10, 0x20, 0x00,
  0x08, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x1C, 0x01, 0xC0, 0x38, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x20, 0x40, 0x00, 0x04,
  0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x20, 0x40, 0x00, 0x04, 0x08, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x10, 0x20, 0x00, 0x02, 0x0C, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x10, 0x20, 0x00, 0x02, 0x04, 0x00, 0x00, 0x40, 0x80, 0x00,
  0x08, 0x10, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x08, 0x10,
  0x00, 0x01, 0x03, 0xFF, 0xFF, 0xE0, 0x40, 0x00, 0x04, 0x08, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x30, 0x40, 0x00, 0x04, 0x08, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x10, 0x20, 0x00, 0x02, 0x04, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18,
  0x20, 0x00, 0x02, 0x04, 0x00, 0x00, 0x40, 0x80, 0x00, 0x08, 0x10, 0x00,
  0x01, 0x02, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x08, 0x10, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x20, 0x40, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x08, 0x00, 0x00, 0x82, 0x00, 0x00, 0x60, 0x80, 0x00, 0x10, 0x30, 0x00,
  0x0C, 0x04, 0x00, 0x02, 0x01, 0x00, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x0C,
  0x00, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x70, 0x20, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x80,
  0x20, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x40, 0x00, 0xC0, 0x04, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x04, 0x00, 0x60, 0x00, 0x40, 0x0C, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x80, 0x30, 0x00, 0x08, 0x06, 0x00, 0x00, 0x81,
  0xC0, 0x00, 0x08, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0xE0, 0x00,
  0x01, 0x1B, 0x00, 0x00, 0x13, 0x10, 0x00, 0x01, 0x61, 0x80, 0x00, 0x1C,
  0x08, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x02, 0x00, 0x20,
  0x00, 0x20, 0x03, 0x00, 0x02, 0x00, 0x10, 0x00, 0x20, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x40, 0x04, 0x00, 0x06, 0x00, 0x40, 0x00,
  0x20, 0x04, 0x00, 0x03, 0x00, 0x40, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xFF,
  0xFF, 0x03, 0x00, 0x00, 0x70, 0x30, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xA0,
  0x38, 0x00, 0x1A, 0x06, 0x80, 0x01, 0x60, 0x68, 0x00, 0x36, 0x04, 0x80,
  0x02, 0x40, 0x4C, 0x00, 0x64, 0x04, 0x40, 0x0C, 0x40, 0xC4, 0x00, 0x8C,
  0x0C, 0x40, 0x18, 0xC0, 0x84, 0x01, 0x08, 0x08, 0x60, 0x30, 0x80, 0x82,
  0x02, 0x08, 0x08, 0x20, 0x60, 0x81, 0x82, 0x0C, 0x18, 0x18, 0x20, 0x81,
  0x81, 0x03, 0x18, 0x10, 0x10, 0x11, 0x01, 0x01, 0x01, 0x30, 0x10, 0x10,
  0x12, 0x01, 0x03, 0x01, 0x60, 0x30, 0x30, 0x1C, 0x03, 0x02, 0x00, 0x80,
  0x20, 0x20, 0x00, 0x02, 0x02, 0x00, 0x00, 0x20, 0x20, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x04, 0x00, 0x00, 0x40, 0x40, 0x00,
  0x04, 0x04, 0x00, 0x00, 0x40, 0x40, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x04, 0x0C, 0x00, 0x01, 0x83, 0xC0, 0x00, 0x20, 0x48, 0x00, 0x04,
  0x09, 0x00, 0x00, 0x81, 0x10, 0x00, 0x10, 0x22, 0x00, 0x06, 0x0C, 0x60,
  0x00, 0xC1, 0x84, 0x00, 0x10, 0x20, 0x80, 0x02, 0x04, 0x18, 0x00, 0x40,
  0x81, 0x00, 0x08, 0x10, 0x20, 0x03, 0x06, 0x02, 0x00, 0x60, 0xC0, 0x40,
  0x08, 0x10, 0x0C, 0x01, 0x02, 0x00, 0x80, 0x20, 0x40, 0x10, 0x04, 0x08,
  0x03, 0x01, 0x83, 0x00, 0x20, 0x30, 0x60, 0x04, 0x04, 0x08, 0x00, 0x40,
  0x81, 0x00, 0x08, 0x10, 0x20, 0x01, 0x82, 0x04, 0x00, 0x10, 0xC1, 0x80,
  0x02, 0x18, 0x20, 0x00, 0x62, 0x04, 0x00, 0x04, 0x40, 0x80, 0x00, 0x88,
  0x10, 0x00, 0x09, 0x02, 0x00, 0x01, 0x60, 0xC0, 0x00, 0x38, 0x10, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x60, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x1C, 0x06, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00,
  0x60, 0x18, 0x00, 0x10, 0x18, 0x00, 0x0C, 0x08, 0x00, 0x02, 0x0C, 0x00,
  0x01, 0x04, 0x00, 0x00, 0x86, 0x00, 0x00, 0x42, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x19, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x04, 0x40, 0x00, 0x02, 0x60,
  0x00, 0x01, 0x30, 0x00, 0x00, 0x90, 0x00, 0x00, 0x48, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x13, 0x00, 0x00, 0x09, 0x80, 0x00, 0x04,
  0xC0, 0x00, 0x06, 0x60, 0x00, 0x02, 0x30, 0x00, 0x01, 0x18, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x82, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x40, 0xC0, 0x00,
  0x40, 0x20, 0x00, 0x60, 0x18, 0x00, 0x60, 0x06, 0x00, 0x60, 0x01, 0x80,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0xC0, 0x03, 0x80, 0x20, 0x00, 0x30, 0x08, 0x00, 0x06, 0x02, 0x00, 0x00,
  0x80, 0x80, 0x00, 0x30, 0x60, 0x00, 0x04, 0x18, 0x00, 0x01, 0x04, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x10, 0x40, 0x00, 0x04, 0x10, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x82, 0x00, 0x00, 0x20, 0x80, 0x00, 0x18, 0x20, 0x00, 0x0C,
  0x08, 0x00, 0x06, 0x06, 0x00, 0x03, 0x01, 0x80, 0x03, 0x80, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x18, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x30, 0x00, 0x20, 0x10, 0x00, 0x18,
  0x10, 0x00, 0x04, 0x18, 0x00, 0x03, 0x08, 0x00, 0x00, 0x8C, 0x00, 0x00,
  0x44, 0x00, 0x00, 0x26, 0x00, 0x00, 0x12, 0x00, 0x00, 0x0B, 0x00, 0x00,
  0x05, 0x80, 0x00, 0x02, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0xA0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x05, 0x00, 0x00, 0x06, 0x80, 0x00, 0x02, 0x40,
  0x00, 0x01, 0x20, 0x00, 0x01, 0x90, 0x00, 0x00, 0x88, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x60, 0x80, 0x00, 0x60, 0x60, 0x00, 0x60,
  0x18, 0x00, 0x60, 0x06, 0x00, 0x60, 0x01, 0x80, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x02, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x03,
  0xFF, 0xE0, 0x01, 0x00, 0x1C, 0x00, 0x80, 0x03, 0x00, 0x40, 0x00, 0xC0,
  0x60, 0x00, 0x30, 0x20, 0x00, 0x08, 0x10, 0x00, 0x04, 0x08, 0x00, 0x03,
  0x04, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x30, 0x40, 0x00, 0x10, 0x20, 0x00, 0x18, 0x30, 0x00,
  0x08, 0x18, 0x00, 0x08, 0x08, 0x00, 0x18, 0x04, 0x00, 0x38, 0x03, 0xFF,
  0xF0, 0x01, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40,
  0x03, 0x00, 0x20, 0x00, 0x80, 0x10, 0x00, 0x60, 0x08, 0x00, 0x30, 0x0C,
  0x00, 0x08, 0x04, 0x00, 0x06, 0x02, 0x00, 0x01, 0x01, 0x00, 0x00, 0x80,
  0x80, 0x00, 0x60, 0x40, 0x00, 0x10, 0x60, 0x00, 0x0C, 0x20, 0x00, 0x06,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x38,
  0x03, 0x00, 0x30, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x30, 0x00, 0x08, 0x10,
  0x00, 0x06, 0x18, 0x00, 0x03, 0x08, 0x00, 0x00, 0x84, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x64, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x11, 0x80, 0x00, 0x18, 0x60, 0x00, 0x18, 0x10,
  0x00, 0x18, 0x0E, 0x00, 0x18, 0x01, 0x80, 0x78, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x41,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x08, 0x00, 0x00,
  0x82, 0x00, 0x00, 0x20, 0x80, 0x00, 0x08, 0x20, 0x00, 0x02, 0x18, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x41, 0x00, 0x00, 0x10, 0x40, 0x00, 0x04, 0x10,
  0x00, 0x01, 0x04, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x08,
  0x20, 0x00, 0x02, 0x08, 0x00, 0x00, 0x82, 0x00, 0x00, 0x20, 0x80, 0x00,
  0x18, 0x60, 0x00, 0x06, 0x10, 0x00, 0x01, 0x04, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x10, 0x40, 0x00, 0x04, 0x10, 0x00, 0x03, 0x04, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x20, 0x40, 0x00, 0x18, 0x10, 0x00, 0x04, 0x06, 0x00, 0x03,
  0x00, 0x80, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x00, 0xC0,
  0x70, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0x40, 0x00, 0x04,
  0x40, 0x00, 0x0C, 0x40, 0x00, 0x08, 0x40, 0x00, 0x18, 0x60, 0x00, 0x10,
  0x60, 0x00, 0x30, 0x20, 0x00, 0x20, 0x20, 0x00, 0x60, 0x20, 0x00, 0x40,
  0x20, 0x00, 0xC0, 0x30, 0x00, 0x80, 0x30, 0x01, 0x80, 0x10, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x10, 0x02, 0x00, 0x10, 0x02, 0x00, 0x18, 0x06, 0x00,
  0x18, 0x04, 0x00, 0x08, 0x0C, 0x00, 0x08, 0x08, 0x00, 0x08, 0x18, 0x00,
  0x08, 0x10, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x0C, 0x60, 0x00,
  0x04, 0x40, 0x00, 0x04, 0xC0, 0x00, 0x04, 0x80, 0x00, 0x05, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x02, 0x00, 0x00, 0x80, 0x08, 0x00,
  0xE0, 0x06, 0x00, 0x28, 0x01, 0x80, 0x0A, 0x00, 0x60, 0x06, 0x80, 0x38,
  0x01, 0x20, 0x0B, 0x00, 0x48, 0x02, 0xC0, 0x32, 0x01, 0xB0, 0x08, 0x80,
  0x4C, 0x02, 0x20, 0x13, 0x01, 0x88, 0x0C, 0xC0, 0x42, 0x02, 0x30, 0x10,
  0x80, 0x8C, 0x0C, 0x20, 0x63, 0x02, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10,
  0x20, 0x83, 0x04, 0x18, 0x20, 0x81, 0x04, 0x08, 0x20, 0x41, 0x02, 0x18,
  0x10, 0xC0, 0x84, 0x04, 0x20, 0x23, 0x01, 0x08, 0x08, 0xC0, 0x46, 0x02,
  0x20, 0x11, 0x00, 0x98, 0x04, 0x40, 0x26, 0x01, 0x30, 0x09, 0x00, 0x48,
  0x02, 0xC0, 0x12, 0x00, 0xA0, 0x05, 0x80, 0x28, 0x01, 0x40, 0x0E, 0x00,
  0x50, 0x03, 0x00, 0x14, 0x00, 0xC0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x00, 0x60, 0x02, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x18, 0x08, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x08, 0x01, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x40, 0x00,
  0x20, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x04, 0x02, 0x00, 0x00, 0x30,
  0x20, 0x00, 0x00, 0x83, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x13, 0x00,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x08,
  0x40, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x40, 0x60,
  0x00, 0x04, 0x01, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0x20, 0x00,
  0x20, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x30, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x80, 0x30, 0x00, 0x06, 0x01, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x40,
  0x00, 0x06, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x08, 0x20, 0x00, 0x10, 0x30,
  0x00, 0x30, 0x10, 0x00, 0x20, 0x10, 0x00, 0x40, 0x18, 0x00, 0xC0, 0x08,
  0x00, 0x80, 0x08, 0x01, 0x00, 0x0C, 0x03, 0x00, 0x04, 0x06, 0x00, 0x04,
  0x04, 0x00, 0x06, 0x0C, 0x00, 0x02, 0x18, 0x00, 0x02, 0x10, 0x00, 0x03,
  0x30, 0x00, 0x01, 0x60, 0x00, 0x01, 0x40, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x60, 0x08, 0x02, 0x00,
  0x80, 0x30, 0x0C, 0x01, 0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x20, 0x08,
  0x02, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80,
  0x20, 0x08, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x60, 0x18, 0x02,
  0x00, 0x80, 0x20, 0x0C, 0x00, 0xFE, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x3F, 0x80, 0xFF, 0x00,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x09, 0x00, 0x0C, 0x80, 0x04,
  0x40, 0x04, 0x30, 0x06, 0x08, 0x02, 0x04, 0x03, 0x02, 0x01, 0x01, 0x81,
  0x80, 0xC0, 0x80, 0x20, 0x80, 0x10, 0xC0, 0x0C, 0x40, 0x06, 0x60, 0x01,
  0x20, 0x00, 0xB0, 0x00, 0x50, 0x00, 0x30, 0xFF, 0xFF, 0xF0, 0xC3, 0x08,
  0x61, 0x0C, 0x20, 0x00, 0x7F, 0xE0, 0x03, 0xC0, 0xE0, 0x0C, 0x00, 0x60,
  0x30, 0x00, 0x60, 0xC0, 0x00, 0x41, 0x00, 0x00, 0x86, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x07, 0xFF, 0xC0, 0x7C, 0x01, 0x03, 0x80, 0x02, 0x1C, 0x00,
  0x04, 0x20, 0x00, 0x08, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x88, 0x00, 0x03, 0x10, 0x00, 0x06, 0x20, 0x00, 0x14, 0x60, 0x00, 0xC8,
  0x60, 0x03, 0x30, 0x60, 0x1C, 0x60, 0x7F, 0xE0, 0xC0, 0x08, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x61, 0xFE, 0x00, 0x8E,
  0x07, 0x01, 0x30, 0x02, 0x02, 0xC0, 0x02, 0x06, 0x00, 0x06, 0x0C, 0x00,
  0x0C, 0x30, 0x00, 0x08, 0x60, 0x00, 0x10, 0x80, 0x00, 0x21, 0x00, 0x00,
  0x42, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x18, 0x00, 0x02, 0x20, 0x00, 0x04,
  0x40, 0x00, 0x08, 0x80, 0x00, 0x31, 0x00, 0x00, 0x66, 0x00, 0x00, 0x8C,
  0x00, 0x03, 0x10, 0x00, 0x04, 0x20, 0x00, 0x18, 0x60, 0x00, 0x20, 0xC0,
  0x00, 0xC3, 0xC0, 0x03, 0x06, 0xC0, 0x0C, 0x08, 0xC0, 0x70, 0x10, 0xFF,
  0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0x03, 0x80, 0x30,
  0x03, 0x01, 0x80, 0x06, 0x0C, 0x00, 0x08, 0x60, 0x00, 0x23, 0x00, 0x00,
  0xC8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x0C,
  0xC0, 0x00, 0x23, 0x00, 0x01, 0x84, 0x00, 0x04, 0x18, 0x00, 0x20, 0x30,
  0x03, 0x00, 0x60, 0x38, 0x00, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0xFF, 0x04, 0x01, 0x81,
  0xC4, 0x07, 0x00, 0x64, 0x0C, 0x00, 0x3C, 0x08, 0x00, 0x1C, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x08, 0x20, 0x00, 0x08, 0x60, 0x00, 0x08, 0x40, 0x00,
  0x18, 0x40, 0x00, 0x18, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x10, 0x80, 0x00,
  0x10, 0x80, 0x00, 0x10, 0x80, 0x00, 0x30, 0x80, 0x00, 0x30, 0x80, 0x00,
  0x20, 0x80, 0x00, 0x20, 0x80, 0x00, 0x20, 0x80, 0x00, 0x60, 0xC0, 0x00,
  0x60, 0x40, 0x00, 0xE0, 0x60, 0x01, 0xC0, 0x30, 0x03, 0x40, 0x18, 0x0C,
  0x40, 0x0F, 0xF8, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xC0,
  0xE0, 0x06, 0x00, 0x60, 0x18, 0x00, 0x60, 0x60, 0x00, 0x41, 0x80, 0x00,
  0xC6, 0x00, 0x01, 0x88, 0x00, 0x01, 0x30, 0x00, 0x02, 0x40, 0x00, 0x05,
  0x80, 0x00, 0x0B, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE8, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x04, 0x08, 0x00, 0x18, 0x18, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x3F, 0xC1, 0x00, 0x60, 0x31, 0x01, 0xC0, 0x19, 0x03, 0x00,
  0x0F, 0x02, 0x00, 0x07, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x02, 0x08, 0x00,
  0x02, 0x18, 0x00, 0x02, 0x10, 0x00, 0x06, 0x10, 0x00, 0x06, 0x30, 0x00,
  0x04, 0x30, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00,
  0x0C, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x08, 0x20, 0x00, 0x08, 0x20, 0x00,
  0x08, 0x20, 0x00, 0x18, 0x30, 0x00, 0x18, 0x10, 0x00, 0x38, 0x18, 0x00,
  0x70, 0x0C, 0x00, 0xD0, 0x06, 0x03, 0x10, 0x03, 0xFE, 0x30, 0x00, 0x20,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x40, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0x60, 0x03, 0x00, 0x30, 0x0E,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0xFF, 0x00, 0x87, 0x03, 0x81, 0x18, 0x01, 0x02,
  0x40, 0x03, 0x0D, 0x00, 0x02, 0x1C, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x60,
  0x00, 0x18, 0x80, 0x00, 0x31, 0x00, 0x00, 0x46, 0x00, 0x00, 0x8C, 0x00,
  0x01, 0x10, 0x00, 0x02, 0x20, 0x00, 0x0C, 0x40, 0x00, 0x18, 0x80, 0x00,
  0x23, 0x00, 0x00, 0x46, 0x00, 0x00, 0x88, 0x00, 0x01, 0x10, 0x00, 0x06,
  0x20, 0x00, 0x0C, 0x40, 0x00, 0x11, 0x80, 0x00, 0x23, 0x00, 0x00, 0x44,
  0x00, 0x01, 0x88, 0x00, 0x03, 0x10, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x18, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x07,
  0x08, 0x00, 0x0C, 0x08, 0x00, 0x38, 0x08, 0x00, 0x60, 0x18, 0x00, 0xC0,
  0x18, 0x03, 0x80, 0x18, 0x06, 0x00, 0x10, 0x0C, 0x00, 0x10, 0x18, 0x00,
  0x10, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x27, 0x80, 0x00,
  0x2C, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x30, 0x30, 0x00, 0x60, 0x10, 0x00,
  0x60, 0x18, 0x00, 0x40, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00,
  0x40, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0x80, 0x80, 0x00, 0xC0,
  0x80, 0x00, 0x60, 0x80, 0x00, 0x30, 0x01, 0xFF, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xF8, 0x04, 0x7F,
  0x07, 0xF0, 0x17, 0x06, 0x70, 0x60, 0x70, 0x0B, 0x00, 0x81, 0x80, 0x28,
  0x03, 0x0C, 0x00, 0xC0, 0x0C, 0x30, 0x03, 0x00, 0x30, 0x80, 0x08, 0x00,
  0xC2, 0x00, 0x20, 0x02, 0x08, 0x00, 0x80, 0x08, 0x20, 0x02, 0x00, 0x21,
  0x80, 0x18, 0x00, 0x84, 0x00, 0x60, 0x06, 0x10, 0x01, 0x00, 0x18, 0x40,
  0x04, 0x00, 0x41, 0x00, 0x10, 0x01, 0x0C, 0x00, 0x40, 0x04, 0x30, 0x03,
  0x00, 0x10, 0x80, 0x0C, 0x00, 0xC2, 0x00, 0x20, 0x03, 0x08, 0x00, 0x80,
  0x08, 0x20, 0x02, 0x00, 0x21, 0x80, 0x08, 0x00, 0x86, 0x00, 0x60, 0x02,
  0x10, 0x01, 0x00, 0x18, 0x40, 0x04, 0x00, 0x41, 0x00, 0x10, 0x01, 0x0C,
  0x00, 0x40, 0x04, 0x00, 0x0C, 0x1F, 0xE0, 0x10, 0xE0, 0x60, 0x23, 0x00,
  0x20, 0x48, 0x00, 0x61, 0xA0, 0x00, 0x43, 0x80, 0x00, 0x86, 0x00, 0x01,
  0x0C, 0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00, 0x08, 0xC0, 0x00, 0x11,
  0x80, 0x00, 0x22, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x88, 0x00, 0x02, 0x10,
  0x00, 0x04, 0x60, 0x00, 0x08, 0xC0, 0x00, 0x11, 0x00, 0x00, 0x62, 0x00,
  0x00, 0xC4, 0x00, 0x01, 0x18, 0x00, 0x02, 0x30, 0x00, 0x04, 0x60, 0x00,
  0x08, 0x80, 0x00, 0x31, 0x00, 0x00, 0x62, 0x00, 0x00, 0x80, 0x00, 0x7F,
  0xC0, 0x03, 0xC0, 0xE0, 0x0C, 0x00, 0x60, 0x30, 0x00, 0x40, 0xC0, 0x00,
  0xC3, 0x00, 0x00, 0x84, 0x00, 0x01, 0x98, 0x00, 0x01, 0x20, 0x00, 0x02,
  0xC0, 0x00, 0x05, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x05, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x36, 0x00, 0x00, 0x4C, 0x00, 0x01, 0x88, 0x00,
  0x06, 0x18, 0x00, 0x18, 0x10, 0x00, 0x60, 0x30, 0x01, 0x80, 0x18, 0x0E,
  0x00, 0x1F, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x03, 0x0F, 0xF0, 0x02, 0x38,
  0x18, 0x02, 0x60, 0x04, 0x02, 0xC0, 0x06, 0x03, 0x80, 0x02, 0x07, 0x00,
  0x03, 0x06, 0x00, 0x01, 0x04, 0x00, 0x01, 0x04, 0x00, 0x01, 0x04, 0x00,
  0x01, 0x04, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x08, 0x00,
  0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x03, 0x08, 0x00, 0x02, 0x18, 0x00,
  0x02, 0x10, 0x00, 0x06, 0x10, 0x00, 0x04, 0x10, 0x00, 0x0C, 0x10, 0x00,
  0x08, 0x18, 0x00, 0x18, 0x3C, 0x00, 0x30, 0x36, 0x00, 0x60, 0x23, 0x01,
  0xC0, 0x21, 0xFF, 0x00, 0x20, 0x10, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x84, 0x06, 0x07, 0x10, 0x70, 0x06, 0x43, 0x00, 0x0F, 0x08, 0x00, 0x1C,
  0x60, 0x00, 0x63, 0x00, 0x00, 0x88, 0x00, 0x02, 0x60, 0x00, 0x09, 0x00,
  0x00, 0x64, 0x00, 0x01, 0xB0, 0x00, 0x04, 0xC0, 0x00, 0x12, 0x00, 0x00,
  0x48, 0x00, 0x01, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x32, 0x00, 0x00, 0x88,
  0x00, 0x02, 0x20, 0x00, 0x08, 0x80, 0x00, 0x23, 0x00, 0x01, 0x84, 0x00,
  0x0E, 0x18, 0x00, 0x70, 0x30, 0x03, 0x40, 0x60, 0x31, 0x00, 0xFF, 0x84,
  0x00, 0x20, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x0C, 0x0F, 0xF8, 0x61, 0xC0, 0x02, 0x38, 0x00,
  0x13, 0x00, 0x00, 0xB0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x0E, 0x01, 0xC0, 0x60, 0x01, 0x83,
  0x00, 0x02, 0x18, 0x00, 0x0C, 0x40, 0x00, 0x11, 0x00, 0x00, 0x44, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x80, 0x00,
  0x12, 0x00, 0x00, 0x48, 0x00, 0x03, 0x30, 0x00, 0x18, 0x60, 0x00, 0xC0,
  0xE0, 0x1E, 0x00, 0xFF, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x03,
  0xFF, 0xFF, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xFF,
  0x80, 0x03, 0x80, 0x18, 0x00, 0x06, 0x20, 0x00, 0x08, 0x40, 0x00, 0x10,
  0x80, 0x00, 0x21, 0x00, 0x00, 0x46, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x10,
  0x00, 0x04, 0x20, 0x00, 0x08, 0x40, 0x00, 0x11, 0x80, 0x00, 0x23, 0x00,
  0x00, 0xC4, 0x00, 0x01, 0x88, 0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00,
  0x08, 0xC0, 0x00, 0x11, 0x80, 0x00, 0x62, 0x00, 0x00, 0xC4, 0x00, 0x01,
  0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x28, 0x20, 0x00, 0xF0,
  0x60, 0x07, 0x60, 0x70, 0x38, 0x80, 0x7F, 0xC1, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04, 0x40, 0x00, 0x0C,
  0x40, 0x00, 0x08, 0x60, 0x00, 0x18, 0x60, 0x00, 0x30, 0x20, 0x00, 0x20,
  0x20, 0x00, 0x60, 0x30, 0x00, 0x40, 0x30, 0x00, 0xC0, 0x10, 0x00, 0x80,
  0x10, 0x01, 0x80, 0x18, 0x03, 0x00, 0x18, 0x02, 0x00, 0x08, 0x06, 0x00,
  0x0C, 0x04, 0x00, 0x0C, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x04, 0x10, 0x00,
  0x06, 0x30, 0x00, 0x06, 0x20, 0x00, 0x02, 0x60, 0x00, 0x02, 0x40, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x01, 0x00, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0A, 0x00, 0x50, 0x02, 0xC0, 0x14,
  0x01, 0xB0, 0x0D, 0x00, 0x4C, 0x02, 0x40, 0x33, 0x01, 0x90, 0x08, 0xC0,
  0x44, 0x02, 0x30, 0x11, 0x01, 0x8C, 0x0C, 0x40, 0x43, 0x02, 0x18, 0x30,
  0x41, 0x86, 0x08, 0x10, 0x41, 0x82, 0x04, 0x30, 0x61, 0x81, 0x08, 0x08,
  0x40, 0x42, 0x02, 0x30, 0x11, 0x80, 0x88, 0x04, 0x40, 0x22, 0x01, 0x30,
  0x09, 0x80, 0x48, 0x02, 0x40, 0x12, 0x00, 0xB0, 0x05, 0x00, 0x28, 0x01,
  0x40, 0x0A, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x18, 0x04, 0x00, 0x06, 0x00,
  0xC0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x18, 0x06,
  0x00, 0x01, 0x01, 0x80, 0x00, 0x30, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x26, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C,
  0x10, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x02, 0x00,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x40, 0x10, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x83, 0x80, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x03, 0x00, 0x20, 0x00, 0x04, 0x00, 0x40, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x04, 0x00, 0x06, 0x00, 0x18, 0x00, 0x04, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00,
  0x20, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00,
  0x83, 0x00, 0x00, 0x01, 0x04, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x09, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x0F, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x04,
  0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10,
  0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x20, 0x20, 0x60, 0x60, 0x40,
  0x40, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x00, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x01, 0xF0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x31, 0xC3, 0x00, 0x02, 0x30,
  0x1C, 0x00, 0x62, 0x00, 0x60, 0x04, 0x60, 0x02, 0x00, 0xC4, 0x00, 0x18,
  0x18, 0xC0, 0x00, 0xE7, 0x00, 0x00, 0x03, 0xC0,
};

const GFXglyph RobotoMono_ThinItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 8, 36, 30, 11, -36 },
  { 37, 9, 10, 30, 13, -38 },
  { 49, 29, 36, 30, 1, -36 },
  { 180, 25, 46, 30, 3, -41 },
  { 324, 25, 38, 30, 3, -37 },
  { 443, 25, 38, 30, 2, -37 },
  { 562, 3, 10, 30, 15, -38 },
  { 566, 15, 52, 30, 9, -40 },
  { 664, 15, 52, 30, 5, -40 },
  { 762, 21, 20, 30, 7, -36 },
  { 815, 24, 26, 30, 3, -30 },
  { 893, 6, 10, 30, 6, -4 },
  { 901, 18, 1, 30, 6, -17 },
  { 904, 3, 3, 30, 12, -3 },
  { 906, 23, 39, 30, 4, -36 },
  { 1019, 23, 38, 30, 4, -37 },
  { 1129, 13, 36, 30, 8, -36 },
  { 1188, 24, 37, 30, 1, -37 },
  { 1299, 25, 38, 30, 1, -37 },
  { 1418, 25, 36, 30, 1, -36 },
  { 1531, 24, 37, 30, 5, -36 },
  { 1642, 22, 38, 30, 3, -37 },
  { 1747, 23, 36, 30, 6, -36 },
  { 1851, 25, 38, 30, 3, -37 },
  { 1970, 22, 38, 30, 5, -37 },
  { 2075, 7, 25, 30, 13, -25 },
  { 2097, 10, 31, 30, 10, -25 },
  { 2136, 23, 20, 30, 4, -27 },
  { 2194, 23, 11, 30, 4, -22 },
  { 2226, 23, 20, 30, 3, -27 },
  { 2284, 19, 37, 30, 8, -37 },
  { 2372, 29, 37, 30, 1, -37 },
  { 2507, 25, 36, 30, 0, -36 },
  { 2620, 24, 36, 30, 3, -36 },
  { 2728, 25, 38, 30, 3, -37 },
  { 2847, 26, 36, 30, 2, -36 },
  { 2964, 26, 36, 30, 3, -36 },
  { 3081, 26, 36, 30, 3, -36 },
  { 3198, 25, 38, 30, 3, -37 },
  { 3317, 27, 36, 30, 2, -36 },
  { 3439, 25, 36, 30, 3, -36 },
  { 3552, 26, 37, 30, 2, -36 },
  { 3673, 28, 36, 30, 3, -36 },
  { 3799, 20, 36, 30, 3, -36 },
  { 3889, 28, 36, 30, 2, -36 },
  { 4015, 27, 36, 30, 2, -36 },
  { 4137, 25, 38, 30, 3, -37 },
  { 4256, 26, 36, 30, 3, -36 },
  { 4373, 25, 44, 30, 3, -37 },
  { 4511, 25, 36, 30, 3, -36 },
  { 4624, 25, 38, 30, 3, -37 },
  { 4743, 25, 36, 30, 6, -36 },
  { 4856, 26, 37, 30, 3, -36 },
  { 4977, 24, 36, 30, 6, -36 },
  { 5085, 26, 36, 30, 6, -36 },
  { 5202, 29, 36, 30, 1, -36 },
  { 5333, 24, 36, 30, 6, -36 },
  { 5441, 27, 36, 30, 1, -36 },
  { 5563, 15, 49, 30, 8, -41 },
  { 5655, 10, 39, 30, 10, -36 },
  { 5704, 15, 49, 30, 7, -41 },
  { 5796, 17, 20, 30, 7, -36 },
  { 5839, 20, 1, 30, 2, 0 },
  { 5842, 5, 7, 30, 15, -38 },
  { 5847, 23, 28, 30, 3, -27 },
  { 5928, 23, 39, 30, 3, -38 },
  { 6041, 22, 28, 30, 4, -27 },
  { 6118, 24, 39, 30, 4, -38 },
  { 6235, 23, 28, 30, 3, -27 },
  { 6316, 24, 39, 30, 7, -39 },
  { 6433, 24, 38, 30, 2, -27 },
  { 6547, 23, 38, 30, 3, -38 },
  { 6657, 21, 36, 30, 3, -36 },
  { 6752, 23, 47, 30, 0, -36 },
  { 6888, 24, 38, 30, 4, -38 },
  { 7002, 21, 38, 30, 3, -38 },
  { 7102, 30, 27, 30, -1, -27 },
  { 7204, 23, 27, 30, 3, -27 },
  { 7282, 23, 28, 30, 3, -27 },
  { 7363, 24, 37, 30, 1, -27 },
  { 7474, 22, 37, 30, 4, -27 },
  { 7576, 21, 27, 30, 7, -27 },
  { 7647, 22, 28, 30, 4, -27 },
  { 7724, 18, 35, 30, 7, -34 },
  { 7803, 23, 28, 30, 4, -27 },
  { 7884, 24, 27, 30, 5, -27 },
  { 7965, 26, 27, 30, 4, -27 },
  { 8053, 27, 27, 30, 1, -27 },
  { 8145, 31, 38, 30, -1, -27 },
  { 8293, 26, 27, 30, 1, -27 },
  { 8381, 20, 51, 30, 8, -40 },
  { 8509, 8, 43, 30, 11, -36 },
  { 8552, 20, 51, 30, 4, -40 },
  { 8680, 28, 8, 30, 1, -19 },
};

const GFXfont RobotoMono_ThinItalic51pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic51pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic51pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _ROBOTOMONO_THINITALIC51PT7B_H_
