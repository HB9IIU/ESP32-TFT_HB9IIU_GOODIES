#ifndef _ROBOTOMONO_THINITALIC19PT7B_H_
#define _ROBOTOMONO_THINITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x94, 0x92, 0x48, 0x01, 0x00, 0xB6, 0xD0, 0x02, 0x20, 0x88,
  0x11, 0x02, 0x23, 0xFE, 0x11, 0x02, 0x20, 0x88, 0x11, 0x1B, 0xF8, 0x88,
  0x11, 0x02, 0x40, 0x88, 0x00, 0x02, 0x07, 0x84, 0x24, 0x12, 0x09, 0x00,
  0x80, 0x20, 0x0E, 0x00, 0x80, 0x50, 0x18, 0x12, 0x08, 0xD8, 0x10, 0x10,
  0x00, 0x30, 0x24, 0x22, 0x31, 0x28, 0xA4, 0xA1, 0x90, 0x10, 0x13, 0x8A,
  0x49, 0x28, 0x94, 0x48, 0x38, 0x0E, 0x08, 0x88, 0x44, 0x42, 0x20, 0xE0,
  0x40, 0x50, 0x48, 0xC2, 0x60, 0xB0, 0x28, 0x33, 0xE4, 0xF0, 0x04, 0x21,
  0x08, 0x21, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x08, 0x20, 0x41, 0x02,
  0x00, 0x10, 0x82, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x88, 0x42, 0x22,
  0x20, 0x08, 0x10, 0x10, 0xD7, 0x38, 0x28, 0x48, 0x84, 0x04, 0x02, 0x02,
  0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10, 0x10, 0x08, 0x00, 0x5C, 0xFE, 0xC0,
  0x01, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40,
  0x40, 0x80, 0x80, 0x0E, 0x08, 0xC8, 0x28, 0x14, 0x1A, 0x15, 0x13, 0x11,
  0x90, 0xD0, 0x70, 0x50, 0x24, 0x21, 0xE0, 0x09, 0xF2, 0x21, 0x08, 0x42,
  0x11, 0x08, 0x42, 0x10, 0x0F, 0x08, 0x48, 0x24, 0x10, 0x08, 0x04, 0x04,
  0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x07, 0xF8, 0x07, 0x06, 0x22, 0x04,
  0x81, 0x00, 0x40, 0x20, 0x10, 0x3C, 0x00, 0x80, 0x28, 0x0A, 0x02, 0x41,
  0x0F, 0x80, 0x01, 0x00, 0x80, 0xC0, 0xA0, 0x90, 0x90, 0x88, 0x84, 0x42,
  0x41, 0x1F, 0xE0, 0x80, 0x40, 0x20, 0x1F, 0x90, 0x08, 0x08, 0x04, 0x02,
  0xE1, 0x88, 0x04, 0x01, 0x00, 0xA0, 0x50, 0x48, 0x43, 0xC0, 0x03, 0x0C,
  0x10, 0x20, 0x40, 0x5E, 0x61, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C,
  0xFF, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08,
  0x04, 0x04, 0x06, 0x00, 0x0F, 0x08, 0x48, 0x24, 0x14, 0x09, 0x04, 0x44,
  0x7C, 0x41, 0x40, 0x60, 0x30, 0x18, 0x13, 0xF0, 0x1C, 0x22, 0x41, 0x81,
  0x81, 0x81, 0x81, 0x83, 0x45, 0x3A, 0x02, 0x04, 0x08, 0xF0, 0x40, 0x00,
  0x80, 0x20, 0x00, 0x00, 0x4A, 0x00, 0x03, 0x0C, 0x30, 0xC0, 0xC0, 0x30,
  0x0C, 0x02, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x20, 0xE1, 0x81, 0x00, 0x3C, 0x86, 0x0C, 0x10, 0x20, 0x82, 0x08, 0x20,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x03, 0x81, 0x88, 0x40, 0x93, 0x92, 0x8A,
  0x92, 0x54, 0x4C, 0x89, 0x92, 0x32, 0x4A, 0x59, 0x44, 0xC4, 0x00, 0x7C,
  0x00, 0x01, 0x01, 0x00, 0xC0, 0xA0, 0x50, 0x48, 0x24, 0x21, 0x10, 0x9F,
  0xC8, 0x28, 0x14, 0x0C, 0x04, 0x3E, 0x10, 0x88, 0x24, 0x14, 0x0A, 0x05,
  0x0C, 0xFC, 0x41, 0x20, 0x60, 0x30, 0x28, 0x37, 0xE0, 0x0F, 0x08, 0x48,
  0x28, 0x14, 0x0A, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x24, 0x21,
  0xE0, 0x3E, 0x10, 0x88, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x81, 0x40, 0xC0,
  0x60, 0x50, 0x28, 0x27, 0xE0, 0x3F, 0xC8, 0x02, 0x00, 0x80, 0x40, 0x10,
  0x04, 0x01, 0xFC, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xC0, 0x3F,
  0xC8, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0xFC, 0x40, 0x10, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x00, 0x0F, 0x08, 0x48, 0x28, 0x14, 0x04, 0x02,
  0x01, 0x00, 0x87, 0xC0, 0x60, 0x30, 0x24, 0x11, 0xF0, 0x20, 0x48, 0x14,
  0x05, 0x01, 0x40, 0x90, 0x24, 0x0A, 0xFE, 0x80, 0xA0, 0x28, 0x12, 0x04,
  0x81, 0x20, 0x40, 0x3F, 0xC1, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x3F, 0x80, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0xA0, 0x50, 0x48, 0x23,
  0xE0, 0x20, 0x64, 0x08, 0x82, 0x11, 0x84, 0x40, 0x90, 0x14, 0x03, 0x40,
  0x48, 0x08, 0x82, 0x08, 0x41, 0x08, 0x11, 0x01, 0x00, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0xFF, 0x20,
  0x48, 0x16, 0x0D, 0x45, 0x51, 0x54, 0xA5, 0x29, 0x52, 0x88, 0xA2, 0x28,
  0x0A, 0x04, 0x81, 0x20, 0x40, 0x20, 0x48, 0x16, 0x05, 0x41, 0x50, 0x92,
  0x24, 0x89, 0x22, 0x84, 0xA1, 0x28, 0x52, 0x0C, 0x83, 0x20, 0x40, 0x0E,
  0x08, 0xC8, 0x28, 0x14, 0x0A, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x50,
  0x24, 0x21, 0xE0, 0x1F, 0x08, 0x22, 0x04, 0x81, 0x20, 0x50, 0x14, 0x09,
  0x0C, 0x7C, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x00, 0x0F, 0x04, 0x22,
  0x09, 0x01, 0x40, 0x60, 0x18, 0x06, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x04,
  0x82, 0x1F, 0x00, 0x40, 0x08, 0x3E, 0x10, 0x88, 0x24, 0x14, 0x0A, 0x05,
  0x04, 0xF4, 0x44, 0x21, 0x20, 0x90, 0x48, 0x14, 0x08, 0x0F, 0x04, 0x22,
  0x09, 0x01, 0x40, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x28, 0x0A, 0x02,
  0x81, 0x1F, 0x80, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x20, 0x48, 0x14, 0x05, 0x01,
  0x40, 0x90, 0x24, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x12, 0x04, 0x42, 0x0F,
  0x00, 0x80, 0xC0, 0x60, 0x30, 0x24, 0x12, 0x11, 0x08, 0x88, 0x44, 0x24,
  0x0A, 0x06, 0x03, 0x01, 0x00, 0x88, 0x62, 0x18, 0x8A, 0x52, 0x94, 0xA5,
  0x2A, 0x52, 0x94, 0xA5, 0x31, 0x8C, 0x62, 0x10, 0x84, 0x21, 0x00, 0x20,
  0x22, 0x04, 0x41, 0x04, 0x40, 0x90, 0x0A, 0x01, 0x80, 0x20, 0x0A, 0x01,
  0x20, 0x44, 0x10, 0x84, 0x09, 0x01, 0x00, 0x80, 0xC0, 0x50, 0x48, 0x44,
  0x21, 0x20, 0xA0, 0x50, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x1F,
  0xC0, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x01,
  0x00, 0x80, 0x40, 0x3F, 0xE0, 0x3C, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41,
  0x04, 0x10, 0x42, 0x08, 0x20, 0x83, 0x80, 0x92, 0x48, 0x92, 0x48, 0x92,
  0x48, 0x18, 0x42, 0x10, 0x84, 0x42, 0x10, 0x84, 0x21, 0x10, 0x84, 0x26,
  0x00, 0x08, 0x10, 0x50, 0xA2, 0x44, 0x50, 0xC1, 0xFE, 0xB0, 0x1F, 0x10,
  0x50, 0x20, 0x11, 0xF3, 0x0A, 0x05, 0x02, 0x83, 0x3E, 0x80, 0x20, 0x10,
  0x08, 0x04, 0x05, 0xE1, 0x09, 0x02, 0x81, 0x40, 0xA0, 0x60, 0x50, 0x28,
  0x27, 0xE0, 0x1F, 0x10, 0x90, 0x28, 0x08, 0x04, 0x02, 0x01, 0x02, 0x42,
  0x1E, 0x00, 0x00, 0x40, 0x20, 0x08, 0x02, 0x1E, 0x88, 0x64, 0x09, 0x04,
  0x81, 0x20, 0x48, 0x12, 0x04, 0x42, 0x0F, 0x80, 0x1F, 0x10, 0x50, 0x28,
  0x1F, 0xFC, 0x02, 0x01, 0x00, 0x41, 0x1F, 0x00, 0x0F, 0x88, 0x08, 0x04,
  0x0F, 0xE1, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x00,
  0x1E, 0x90, 0xD0, 0x28, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x42, 0x1F, 0x00,
  0x80, 0x48, 0x43, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x05, 0xF3, 0x05, 0x02,
  0x81, 0x40, 0xC0, 0xA0, 0x50, 0x28, 0x14, 0x08, 0x02, 0x02, 0x00, 0x00,
  0x3C, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x00, 0x80,
  0x80, 0x00, 0x01, 0xF0, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x20, 0x10, 0x08, 0x08, 0x78, 0x00, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x09, 0x19, 0x10, 0x90, 0x70, 0x24, 0x11, 0x08, 0x88, 0x24, 0x08, 0x1E,
  0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08,
  0xFF, 0x7D, 0xE8, 0x45, 0x10, 0xA2, 0x18, 0x43, 0x08, 0xA1, 0x14, 0x42,
  0x88, 0x51, 0x08, 0x5F, 0x30, 0x50, 0x28, 0x14, 0x0C, 0x0A, 0x05, 0x02,
  0x81, 0x40, 0x80, 0x1E, 0x10, 0x90, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x02,
  0x82, 0x3E, 0x00, 0x2F, 0x18, 0x48, 0x24, 0x12, 0x09, 0x05, 0x02, 0x81,
  0x41, 0x3F, 0x10, 0x08, 0x08, 0x04, 0x00, 0x1E, 0x90, 0xD0, 0x28, 0x28,
  0x14, 0x0A, 0x05, 0x02, 0x42, 0x1F, 0x00, 0x80, 0x40, 0x20, 0x10, 0x5E,
  0xC1, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x00, 0x1F, 0x10, 0x50, 0x28,
  0x03, 0x80, 0x30, 0x05, 0x02, 0x81, 0x3F, 0x00, 0x08, 0x20, 0x47, 0xF1,
  0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x01, 0xC0, 0x40, 0xA0, 0x50, 0x28,
  0x14, 0x14, 0x0A, 0x05, 0x02, 0x42, 0x3E, 0x80, 0x80, 0xC0, 0xA0, 0x90,
  0x44, 0x42, 0x21, 0x20, 0x50, 0x30, 0x10, 0x00, 0x84, 0x63, 0x18, 0xC6,
  0x52, 0x94, 0xA5, 0x46, 0x51, 0x14, 0x42, 0x10, 0x80, 0x20, 0x44, 0x20,
  0x90, 0x28, 0x04, 0x03, 0x00, 0xA0, 0x44, 0x21, 0x30, 0x20, 0x40, 0x24,
  0x08, 0x81, 0x10, 0x41, 0x10, 0x22, 0x04, 0x80, 0x90, 0x0C, 0x01, 0x00,
  0x20, 0x08, 0x01, 0x01, 0xC0, 0x00, 0x3F, 0xC0, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x3F, 0xE0, 0x02, 0x08, 0x20, 0x81, 0x02,
  0x04, 0x08, 0x21, 0x81, 0x01, 0x02, 0x04, 0x08, 0x20, 0x20, 0x40, 0x40,
  0x24, 0x92, 0x92, 0x49, 0x29, 0x24, 0x80, 0x30, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x0C, 0x30, 0x81, 0x02, 0x04, 0x08, 0x20, 0x82, 0x00,
  0x78, 0x28, 0x8A, 0x0E, 0x00,
};

const GFXglyph RobotoMono_ThinItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 14, 11, 4, -14 },
  { 7, 3, 4, 11, 5, -14 },
  { 9, 11, 14, 11, 0, -14 },
  { 29, 9, 17, 11, 1, -15 },
  { 49, 9, 14, 11, 1, -14 },
  { 65, 9, 14, 11, 1, -14 },
  { 81, 1, 4, 11, 6, -14 },
  { 82, 6, 19, 11, 3, -15 },
  { 97, 5, 19, 11, 2, -15 },
  { 109, 8, 8, 11, 3, -14 },
  { 117, 9, 10, 11, 1, -11 },
  { 129, 2, 3, 11, 2, -1 },
  { 130, 7, 1, 11, 2, -7 },
  { 131, 2, 1, 11, 4, -1 },
  { 132, 8, 15, 11, 2, -14 },
  { 147, 9, 14, 11, 1, -14 },
  { 163, 5, 14, 11, 3, -14 },
  { 172, 9, 14, 11, 0, -14 },
  { 188, 10, 14, 11, 0, -14 },
  { 206, 9, 14, 11, 1, -14 },
  { 222, 9, 14, 11, 2, -14 },
  { 238, 8, 14, 11, 1, -14 },
  { 252, 9, 14, 11, 2, -14 },
  { 268, 9, 14, 11, 1, -14 },
  { 284, 8, 14, 11, 2, -14 },
  { 298, 2, 9, 11, 5, -9 },
  { 301, 3, 11, 11, 4, -9 },
  { 306, 8, 8, 11, 2, -10 },
  { 314, 9, 4, 11, 1, -8 },
  { 319, 9, 8, 11, 1, -10 },
  { 328, 7, 14, 11, 3, -14 },
  { 341, 11, 14, 11, 0, -14 },
  { 361, 9, 14, 11, 0, -14 },
  { 377, 9, 14, 11, 1, -14 },
  { 393, 9, 14, 11, 1, -14 },
  { 409, 9, 14, 11, 1, -14 },
  { 425, 10, 14, 11, 1, -14 },
  { 443, 10, 14, 11, 1, -14 },
  { 461, 9, 14, 11, 1, -14 },
  { 477, 10, 14, 11, 1, -14 },
  { 495, 10, 14, 11, 1, -14 },
  { 513, 9, 14, 11, 1, -14 },
  { 529, 11, 14, 11, 1, -14 },
  { 549, 8, 14, 11, 1, -14 },
  { 563, 10, 14, 11, 1, -14 },
  { 581, 10, 14, 11, 1, -14 },
  { 599, 9, 14, 11, 1, -14 },
  { 615, 10, 14, 11, 1, -14 },
  { 633, 10, 16, 11, 1, -14 },
  { 653, 9, 14, 11, 1, -14 },
  { 669, 10, 14, 11, 1, -14 },
  { 687, 9, 14, 11, 2, -14 },
  { 703, 10, 14, 11, 1, -14 },
  { 721, 9, 14, 11, 2, -14 },
  { 737, 10, 14, 11, 2, -14 },
  { 755, 11, 14, 11, 0, -14 },
  { 775, 9, 14, 11, 2, -14 },
  { 791, 10, 14, 11, 0, -14 },
  { 809, 6, 18, 11, 3, -15 },
  { 823, 3, 15, 11, 4, -14 },
  { 829, 5, 18, 11, 3, -15 },
  { 841, 7, 8, 11, 2, -14 },
  { 848, 7, 1, 11, 1, 0 },
  { 849, 2, 2, 11, 6, -14 },
  { 850, 9, 10, 11, 1, -10 },
  { 862, 9, 14, 11, 1, -14 },
  { 878, 9, 10, 11, 1, -10 },
  { 890, 10, 14, 11, 1, -14 },
  { 908, 9, 10, 11, 1, -10 },
  { 920, 9, 14, 11, 3, -14 },
  { 936, 9, 14, 11, 1, -10 },
  { 952, 9, 14, 11, 1, -14 },
  { 968, 8, 14, 11, 1, -14 },
  { 982, 9, 18, 11, 0, -14 },
  { 1003, 9, 14, 11, 1, -14 },
  { 1019, 8, 14, 11, 1, -14 },
  { 1033, 11, 10, 11, 0, -10 },
  { 1047, 9, 10, 11, 1, -10 },
  { 1059, 9, 10, 11, 1, -10 },
  { 1071, 9, 14, 11, 0, -10 },
  { 1087, 9, 14, 11, 1, -10 },
  { 1103, 7, 10, 11, 3, -10 },
  { 1112, 9, 10, 11, 1, -10 },
  { 1124, 7, 13, 11, 2, -13 },
  { 1136, 9, 10, 11, 1, -10 },
  { 1148, 9, 10, 11, 2, -10 },
  { 1160, 10, 10, 11, 1, -10 },
  { 1173, 10, 10, 11, 0, -10 },
  { 1186, 11, 14, 11, 0, -10 },
  { 1206, 10, 10, 11, 0, -10 },
  { 1219, 7, 19, 11, 3, -15 },
  { 1236, 3, 17, 11, 4, -14 },
  { 1243, 7, 19, 11, 2, -15 },
  { 1260, 11, 3, 11, 0, -7 },
};

const GFXfont RobotoMono_ThinItalic19pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic19pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _ROBOTOMONO_THINITALIC19PT7B_H_
