#ifndef _ROBOTOMONO_THINITALIC29PT7B_H_
#define _ROBOTOMONO_THINITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x08, 0x42, 0x21, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x45, 0x24, 0x92, 0x4A, 0x20, 0x00, 0x41, 0x00, 0x20,
  0x80, 0x20, 0x80, 0x10, 0x40, 0x08, 0x40, 0x08, 0x20, 0x7F, 0xFE, 0x02,
  0x10, 0x02, 0x08, 0x01, 0x04, 0x00, 0x84, 0x00, 0x82, 0x00, 0x41, 0x00,
  0x21, 0x03, 0xFF, 0xF8, 0x10, 0x40, 0x08, 0x40, 0x08, 0x20, 0x04, 0x10,
  0x04, 0x10, 0x02, 0x08, 0x00, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0xF8,
  0x04, 0x10, 0x20, 0x21, 0x00, 0x84, 0x01, 0x20, 0x04, 0x80, 0x01, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x48, 0x01, 0x20, 0x04, 0x80, 0x11, 0x00, 0x84, 0x04, 0x0E, 0xE0, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x38, 0x01, 0x10, 0x04, 0x20, 0x20, 0x86,
  0x82, 0x12, 0x08, 0x88, 0x44, 0x21, 0x20, 0x88, 0x81, 0x84, 0x00, 0x20,
  0x00, 0x80, 0x04, 0x78, 0x22, 0x10, 0x90, 0x44, 0x41, 0x21, 0x05, 0x04,
  0x24, 0x10, 0x80, 0x44, 0x00, 0xF0, 0x01, 0xC0, 0x08, 0x80, 0x41, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x80, 0x84, 0x01, 0x20, 0x05, 0x00, 0x08, 0x00,
  0xE0, 0x04, 0x40, 0x21, 0x04, 0x82, 0x14, 0x04, 0x50, 0x12, 0x40, 0x29,
  0x00, 0x44, 0x03, 0x08, 0x12, 0x1F, 0x84, 0xFC, 0x00, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40,
  0x20, 0x10, 0x04, 0x01, 0x00, 0x80, 0x08, 0x04, 0x02, 0x02, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02,
  0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0xC0, 0x80,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xC2, 0x33, 0xBC, 0x06, 0x00, 0xA0,
  0x11, 0x02, 0x10, 0x60, 0x84, 0x0C, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x3F, 0xFF, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x29, 0x29, 0x00,
  0xFF, 0xC0, 0xC0, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x00, 0x03, 0xE0, 0x20, 0x82, 0x02, 0x20, 0x12,
  0x00, 0x90, 0x05, 0x00, 0x68, 0x05, 0x40, 0x4A, 0x04, 0x50, 0x43, 0x08,
  0x18, 0x80, 0xC8, 0x06, 0x80, 0x58, 0x02, 0x80, 0x24, 0x01, 0x10, 0x10,
  0x81, 0x03, 0xF0, 0x00, 0x02, 0x1D, 0xCC, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x81, 0x00, 0x03,
  0xC0, 0x61, 0x84, 0x02, 0x20, 0x12, 0x00, 0x90, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFF, 0x00, 0x01, 0xE0,
  0x10, 0x40, 0x80, 0x84, 0x01, 0x20, 0x04, 0x80, 0x10, 0x00, 0x80, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x78, 0x00, 0x18, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x20, 0x04, 0x80, 0x12, 0x00, 0x48, 0x02, 0x10, 0x10, 0x3F, 0x80, 0x00,
  0x08, 0x00, 0x60, 0x02, 0x80, 0x14, 0x00, 0x90, 0x02, 0x40, 0x11, 0x00,
  0x84, 0x04, 0x10, 0x20, 0x80, 0x82, 0x04, 0x08, 0x20, 0x21, 0x00, 0x8F,
  0xFB, 0xC0, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x0F, 0xFC, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x2F, 0x81, 0xC1, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x08, 0x80, 0x22, 0x01, 0x08, 0x04, 0x10, 0x20, 0x3F,
  0x00, 0x00, 0x70, 0x38, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04,
  0x30, 0x5C, 0xC6, 0x02, 0x40, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x28, 0x02, 0x40, 0x44, 0x08, 0x3F, 0x00, 0xFF, 0xF8, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x00, 0x03, 0xE0, 0x10, 0x60,
  0x80, 0x84, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x48, 0x02, 0x10, 0x10,
  0x20, 0x80, 0x7C, 0x06, 0x08, 0x60, 0x11, 0x00, 0x28, 0x00, 0xA0, 0x02,
  0x80, 0x0A, 0x00, 0x48, 0x02, 0x10, 0x10, 0x3F, 0x80, 0x07, 0x81, 0x86,
  0x20, 0x24, 0x01, 0x40, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x03, 0x40, 0xE3, 0xF2, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x60, 0x78, 0x00, 0x11, 0x00, 0x00, 0x00, 0x00, 0x00, 0x44,
  0x08, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x11, 0x08, 0x84, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x00, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x08, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x00,
  0x1F, 0x08, 0x24, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x40, 0x60, 0x20, 0x10, 0x04, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x03, 0x04, 0x04, 0x02, 0x08, 0x01, 0x10,
  0x41, 0x21, 0xB1, 0x22, 0x11, 0x44, 0x11, 0x44, 0x21, 0x88, 0x21, 0x88,
  0x21, 0x88, 0x22, 0x90, 0x42, 0x90, 0x42, 0x90, 0xC4, 0x89, 0x44, 0x8E,
  0x38, 0x80, 0x00, 0x40, 0x00, 0x60, 0x40, 0x1F, 0x80, 0x00, 0x20, 0x00,
  0x80, 0x05, 0x00, 0x14, 0x00, 0x90, 0x02, 0x40, 0x11, 0x00, 0x44, 0x02,
  0x10, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x08, 0x20, 0x21, 0xFF, 0x84,
  0x02, 0x20, 0x04, 0x80, 0x14, 0x00, 0x50, 0x01, 0x80, 0x04, 0x0F, 0xE0,
  0x10, 0x30, 0x20, 0x10, 0x80, 0x21, 0x00, 0x22, 0x00, 0x84, 0x01, 0x08,
  0x02, 0x10, 0x08, 0x40, 0x60, 0xFF, 0x81, 0x00, 0x82, 0x00, 0x84, 0x00,
  0x90, 0x01, 0x20, 0x02, 0x40, 0x08, 0x80, 0x11, 0x00, 0x42, 0x03, 0x0F,
  0xF8, 0x00, 0x03, 0xE0, 0x10, 0x40, 0x80, 0x84, 0x02, 0x20, 0x04, 0x80,
  0x14, 0x00, 0x50, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0xA0, 0x04, 0x80, 0x12, 0x00, 0x84, 0x06, 0x10,
  0x30, 0x3F, 0x00, 0x0F, 0x80, 0x10, 0x60, 0x40, 0x20, 0x80, 0x21, 0x00,
  0x42, 0x00, 0x44, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x09,
  0x00, 0x12, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x04, 0x40, 0x08, 0x80,
  0x21, 0x00, 0x84, 0x06, 0x0F, 0xF0, 0x00, 0x1F, 0xFC, 0x40, 0x01, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x07, 0xFE, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0xFF, 0xC2, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x00,
  0x03, 0xE0, 0x10, 0x40, 0x80, 0x84, 0x01, 0x20, 0x05, 0x00, 0x14, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x81, 0xFA, 0x00,
  0x28, 0x00, 0xA0, 0x04, 0x80, 0x12, 0x00, 0x44, 0x01, 0x10, 0x18, 0x3F,
  0x80, 0x10, 0x01, 0x10, 0x01, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10,
  0x02, 0x20, 0x02, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x3F, 0xFC, 0x40,
  0x04, 0x40, 0x04, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0x80,
  0x08, 0x80, 0x08, 0x80, 0x10, 0x80, 0x10, 0x0F, 0xFE, 0x00, 0x80, 0x01,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x0F, 0xFF, 0x00, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x40, 0x08, 0x80, 0x11, 0x00, 0x41, 0x00, 0x82, 0x06,
  0x03, 0xF0, 0x00, 0x10, 0x03, 0x10, 0x04, 0x10, 0x08, 0x10, 0x10, 0x20,
  0x20, 0x20, 0x40, 0x20, 0x80, 0x21, 0x00, 0x22, 0x00, 0x24, 0x00, 0x4C,
  0x00, 0x52, 0x00, 0x61, 0x00, 0x41, 0x00, 0x40, 0x80, 0x80, 0x80, 0x80,
  0x40, 0x80, 0x20, 0x80, 0x20, 0x80, 0x10, 0x80, 0x18, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40,
  0x0F, 0xFE, 0x08, 0x03, 0x18, 0x03, 0x18, 0x05, 0x18, 0x06, 0x14, 0x0A,
  0x14, 0x0A, 0x24, 0x12, 0x24, 0x22, 0x24, 0x24, 0x22, 0x44, 0x22, 0x44,
  0x22, 0x84, 0x42, 0x84, 0x41, 0x04, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08,
  0x40, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x10, 0x10, 0x01, 0x18, 0x02,
  0x18, 0x02, 0x14, 0x02, 0x14, 0x02, 0x14, 0x02, 0x22, 0x02, 0x22, 0x04,
  0x22, 0x04, 0x21, 0x04, 0x21, 0x04, 0x40, 0x84, 0x40, 0x84, 0x40, 0x88,
  0x40, 0x48, 0x40, 0x48, 0x40, 0x48, 0x80, 0x28, 0x80, 0x28, 0x80, 0x10,
  0x80, 0x10, 0x03, 0xE0, 0x10, 0x40, 0x80, 0x84, 0x02, 0x20, 0x04, 0x80,
  0x14, 0x00, 0x50, 0x01, 0x40, 0x06, 0x00, 0x18, 0x00, 0xA0, 0x02, 0x80,
  0x0A, 0x00, 0x28, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x84, 0x04, 0x10,
  0x20, 0x3F, 0x00, 0x1F, 0xE0, 0x20, 0x30, 0x40, 0x10, 0x80, 0x21, 0x00,
  0x24, 0x00, 0x48, 0x00, 0x90, 0x02, 0x20, 0x04, 0x40, 0x10, 0x80, 0x43,
  0xFF, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x00, 0x03, 0xE0, 0x30, 0x41, 0x00,
  0x84, 0x01, 0x20, 0x05, 0x00, 0x14, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80,
  0x12, 0x00, 0x88, 0x02, 0x10, 0x30, 0x3F, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x1F, 0xC0, 0x40, 0xC1, 0x00, 0x84, 0x02, 0x20, 0x04,
  0x80, 0x12, 0x00, 0x48, 0x02, 0x20, 0x08, 0x80, 0x44, 0x02, 0x1F, 0xF0,
  0x40, 0x81, 0x02, 0x04, 0x04, 0x20, 0x10, 0x80, 0x42, 0x00, 0x88, 0x02,
  0x20, 0x08, 0x80, 0x10, 0x03, 0xE0, 0x30, 0x41, 0x00, 0x88, 0x01, 0x20,
  0x04, 0x80, 0x12, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x40, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x48,
  0x01, 0x10, 0x18, 0x3F, 0x80, 0xFF, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x02, 0x40, 0x04, 0x80, 0x11,
  0x00, 0x22, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x04, 0x40, 0x08, 0x80,
  0x11, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x02, 0x20, 0x04, 0x40, 0x08,
  0x80, 0x11, 0x00, 0x41, 0x01, 0x02, 0x04, 0x03, 0xF0, 0x00, 0x80, 0x06,
  0x00, 0x14, 0x00, 0x90, 0x02, 0x40, 0x11, 0x00, 0x44, 0x02, 0x10, 0x08,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x20, 0x20, 0x80, 0x84, 0x02, 0x10,
  0x04, 0x80, 0x12, 0x00, 0x50, 0x01, 0x40, 0x06, 0x00, 0x08, 0x00, 0x81,
  0x03, 0x02, 0x06, 0x04, 0x0C, 0x18, 0x28, 0x30, 0x50, 0xA0, 0xA1, 0x42,
  0x42, 0x84, 0x89, 0x09, 0x12, 0x22, 0x24, 0x44, 0x84, 0x89, 0x0A, 0x12,
  0x14, 0x28, 0x28, 0x50, 0x60, 0xA0, 0xC1, 0x81, 0x83, 0x02, 0x04, 0x04,
  0x08, 0x08, 0x00, 0x08, 0x00, 0x84, 0x00, 0x81, 0x00, 0x40, 0x80, 0x40,
  0x20, 0x40, 0x10, 0x40, 0x04, 0x20, 0x02, 0x20, 0x00, 0xA0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x14, 0x00, 0x11, 0x00, 0x10, 0x80, 0x08,
  0x20, 0x08, 0x10, 0x08, 0x04, 0x08, 0x02, 0x04, 0x00, 0x8C, 0x00, 0x40,
  0x80, 0x05, 0x00, 0x14, 0x00, 0x90, 0x04, 0x20, 0x10, 0x80, 0x82, 0x04,
  0x04, 0x20, 0x10, 0x80, 0x44, 0x00, 0xA0, 0x02, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10,
  0x00, 0x1F, 0xFE, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0xF0, 0x84, 0x21, 0x04,
  0x21, 0x08, 0x41, 0x08, 0x42, 0x10, 0x42, 0x10, 0x84, 0x10, 0x84, 0x20,
  0x07, 0x84, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x1F, 0x00, 0x02, 0x00, 0x80, 0x60,
  0x24, 0x09, 0x04, 0x41, 0x10, 0x82, 0x40, 0x90, 0x28, 0x0A, 0x01, 0xFF,
  0xF0, 0x89, 0x80, 0x03, 0x00, 0x63, 0x04, 0x04, 0x40, 0x24, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x7E, 0x3C, 0x12, 0x00, 0xA0, 0x05, 0x00, 0x48, 0x02,
  0x40, 0x32, 0x02, 0x8F, 0xE4, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x00, 0x8C, 0x05, 0x8C, 0x30, 0x11, 0x00, 0x88, 0x04, 0x80,
  0x14, 0x00, 0xA0, 0x05, 0x00, 0x48, 0x02, 0x80, 0x14, 0x01, 0x20, 0x09,
  0x00, 0x8C, 0x08, 0x5F, 0x80, 0x03, 0x00, 0x63, 0x04, 0x04, 0x40, 0x22,
  0x00, 0xA0, 0x05, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x28, 0x02, 0x20, 0x11, 0x03, 0x07, 0xE0, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x18, 0x83, 0x12, 0x10, 0x28, 0x80,
  0x44, 0x01, 0x10, 0x04, 0x40, 0x12, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80,
  0x22, 0x00, 0x88, 0x02, 0x10, 0x18, 0x40, 0xA0, 0xFC, 0x80, 0x03, 0x80,
  0x63, 0x04, 0x04, 0x40, 0x24, 0x00, 0xA0, 0x06, 0x00, 0x3F, 0xFF, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x10, 0x81, 0x03, 0xF0,
  0x00, 0xFC, 0x0C, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x3F, 0xF8, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x90, 0x81, 0x44, 0x03, 0x20, 0x08,
  0x80, 0x22, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x24, 0x01, 0x10, 0x04,
  0x40, 0x10, 0x80, 0xC2, 0x05, 0x07, 0xE4, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x20, 0x10, 0x40, 0x80, 0xFC, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x06, 0x04, 0xC4, 0x14, 0x08, 0xA0, 0x23,
  0x00, 0x48, 0x01, 0x20, 0x08, 0x80, 0x22, 0x00, 0x90, 0x02, 0x40, 0x09,
  0x00, 0x24, 0x01, 0x10, 0x04, 0x40, 0x12, 0x00, 0x40, 0x00, 0x40, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02,
  0x0F, 0xFE, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x3F, 0x00, 0x08, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x48, 0x06,
  0x20, 0x20, 0x81, 0x02, 0x08, 0x08, 0xC0, 0x24, 0x01, 0x20, 0x07, 0x40,
  0x10, 0x80, 0x41, 0x01, 0x04, 0x04, 0x08, 0x20, 0x10, 0x80, 0x42, 0x00,
  0x80, 0x1F, 0xC0, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x41, 0xFF, 0xC0, 0x07, 0x0E, 0x28, 0x91,
  0x30, 0xA1, 0x20, 0x41, 0x20, 0x81, 0x40, 0x81, 0x40, 0x81, 0x40, 0x81,
  0x40, 0x81, 0x40, 0x81, 0x41, 0x02, 0x81, 0x02, 0x81, 0x02, 0x81, 0x02,
  0x81, 0x02, 0x81, 0x04, 0x00, 0x60, 0x4C, 0x41, 0x40, 0x8A, 0x02, 0x30,
  0x04, 0x80, 0x12, 0x00, 0x88, 0x02, 0x20, 0x09, 0x00, 0x24, 0x00, 0x90,
  0x02, 0x40, 0x11, 0x00, 0x44, 0x01, 0x20, 0x04, 0x01, 0x00, 0x63, 0x04,
  0x04, 0x40, 0x24, 0x00, 0xA0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x05, 0x00, 0x28, 0x02, 0x40, 0x31, 0x03, 0x07, 0xE0, 0x01, 0x80,
  0xB1, 0x86, 0x02, 0x20, 0x12, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x20,
  0x09, 0x00, 0x50, 0x02, 0x80, 0x24, 0x01, 0x20, 0x11, 0x81, 0x0B, 0xF0,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x62, 0x44, 0x0A, 0x40, 0x34, 0x01, 0x20, 0x09, 0x00, 0x50, 0x02, 0x80,
  0x14, 0x00, 0xA0, 0x09, 0x00, 0x48, 0x02, 0x20, 0x31, 0x02, 0x87, 0xE4,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0xF2,
  0x30, 0x2C, 0x03, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x01, 0x80,
  0x63, 0x84, 0x04, 0x40, 0x12, 0x00, 0x90, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x28, 0x01, 0x40, 0x11, 0x01, 0x87, 0xF0,
  0x04, 0x01, 0x00, 0x80, 0x20, 0xFF, 0xC2, 0x00, 0x80, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x01, 0xF0,
  0x20, 0x09, 0x00, 0x48, 0x02, 0x80, 0x14, 0x01, 0x20, 0x09, 0x00, 0x48,
  0x02, 0x40, 0x14, 0x00, 0xA0, 0x09, 0x00, 0x44, 0x06, 0x20, 0x50, 0xFC,
  0x80, 0x80, 0x0C, 0x00, 0xA0, 0x04, 0x80, 0x44, 0x02, 0x20, 0x21, 0x02,
  0x04, 0x10, 0x21, 0x01, 0x08, 0x08, 0x80, 0x24, 0x01, 0x40, 0x0C, 0x00,
  0x20, 0x00, 0x81, 0x03, 0x06, 0x06, 0x0C, 0x14, 0x18, 0x28, 0x48, 0x90,
  0x91, 0x22, 0x22, 0x24, 0x48, 0x48, 0x90, 0xA1, 0x41, 0x42, 0x83, 0x05,
  0x06, 0x0C, 0x08, 0x18, 0x10, 0x20, 0x00, 0x30, 0x06, 0x10, 0x10, 0x20,
  0x40, 0x21, 0x00, 0x46, 0x00, 0x48, 0x00, 0x60, 0x00, 0x80, 0x02, 0x80,
  0x09, 0x00, 0x21, 0x00, 0x81, 0x02, 0x02, 0x08, 0x02, 0x20, 0x02, 0x00,
  0x20, 0x01, 0x88, 0x00, 0x84, 0x00, 0x82, 0x00, 0x40, 0x80, 0x40, 0x40,
  0x40, 0x20, 0x20, 0x10, 0x20, 0x04, 0x10, 0x02, 0x10, 0x01, 0x10, 0x00,
  0x48, 0x00, 0x28, 0x00, 0x18, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x40, 0x30, 0x06, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0x40, 0x08, 0x42, 0x21, 0x08, 0x42, 0x11, 0x08, 0x42,
  0x10, 0x88, 0x42, 0x10, 0x84, 0x22, 0x10, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01,
  0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x70, 0x06, 0x01, 0x80, 0x10, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08,
  0x03, 0x00, 0xC0, 0x00, 0x3C, 0x02, 0x84, 0x06, 0x04, 0x14, 0x04, 0x60,
  0x07, 0x00,
};

const GFXglyph RobotoMono_ThinItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 21, 17, 6, -21 },
  { 15, 6, 6, 17, 7, -22 },
  { 20, 17, 21, 17, 0, -21 },
  { 65, 14, 27, 17, 2, -24 },
  { 113, 14, 21, 17, 2, -21 },
  { 150, 14, 21, 17, 1, -21 },
  { 187, 1, 6, 17, 9, -22 },
  { 188, 9, 30, 17, 5, -23 },
  { 222, 8, 30, 17, 3, -23 },
  { 252, 12, 12, 17, 4, -21 },
  { 270, 14, 15, 17, 2, -17 },
  { 297, 3, 6, 17, 4, -2 },
  { 300, 10, 1, 17, 3, -10 },
  { 302, 1, 2, 17, 7, -2 },
  { 303, 13, 23, 17, 2, -21 },
  { 341, 13, 21, 17, 2, -21 },
  { 376, 7, 21, 17, 5, -21 },
  { 395, 13, 21, 17, 1, -21 },
  { 430, 14, 21, 17, 1, -21 },
  { 467, 14, 21, 17, 1, -21 },
  { 504, 14, 21, 17, 3, -21 },
  { 541, 12, 21, 17, 2, -21 },
  { 573, 13, 21, 17, 4, -21 },
  { 608, 14, 21, 17, 2, -21 },
  { 645, 12, 21, 17, 3, -21 },
  { 677, 4, 14, 17, 7, -14 },
  { 684, 5, 18, 17, 6, -14 },
  { 696, 13, 11, 17, 2, -15 },
  { 714, 13, 7, 17, 2, -13 },
  { 726, 13, 11, 17, 2, -15 },
  { 744, 10, 21, 17, 5, -21 },
  { 771, 16, 21, 17, 1, -21 },
  { 813, 14, 21, 17, 0, -21 },
  { 850, 15, 21, 17, 1, -21 },
  { 890, 14, 21, 17, 2, -21 },
  { 927, 15, 21, 17, 1, -21 },
  { 967, 14, 21, 17, 2, -21 },
  { 1004, 15, 21, 17, 2, -21 },
  { 1044, 14, 21, 17, 2, -21 },
  { 1081, 16, 21, 17, 1, -21 },
  { 1123, 15, 21, 17, 1, -21 },
  { 1163, 15, 21, 17, 1, -21 },
  { 1203, 16, 21, 17, 2, -21 },
  { 1245, 11, 21, 17, 2, -21 },
  { 1274, 16, 21, 17, 1, -21 },
  { 1316, 16, 21, 17, 1, -21 },
  { 1358, 14, 21, 17, 2, -21 },
  { 1395, 15, 21, 17, 2, -21 },
  { 1435, 14, 25, 17, 2, -21 },
  { 1479, 14, 21, 17, 2, -21 },
  { 1516, 14, 21, 17, 2, -21 },
  { 1553, 14, 21, 17, 4, -21 },
  { 1590, 15, 21, 17, 2, -21 },
  { 1630, 14, 21, 17, 3, -21 },
  { 1667, 15, 21, 17, 3, -21 },
  { 1707, 17, 21, 17, 0, -21 },
  { 1752, 14, 21, 17, 3, -21 },
  { 1789, 15, 21, 17, 1, -21 },
  { 1829, 8, 28, 17, 5, -24 },
  { 1857, 5, 23, 17, 6, -21 },
  { 1872, 9, 28, 17, 4, -24 },
  { 1904, 10, 12, 17, 4, -21 },
  { 1919, 12, 1, 17, 1, 0 },
  { 1921, 3, 3, 17, 9, -21 },
  { 1923, 13, 16, 17, 2, -16 },
  { 1949, 13, 22, 17, 2, -22 },
  { 1985, 13, 16, 17, 2, -16 },
  { 2011, 14, 22, 17, 2, -22 },
  { 2050, 13, 16, 17, 2, -16 },
  { 2076, 14, 22, 17, 4, -22 },
  { 2115, 14, 22, 17, 1, -16 },
  { 2154, 14, 22, 17, 1, -22 },
  { 2193, 11, 21, 17, 2, -21 },
  { 2222, 13, 27, 17, 0, -21 },
  { 2266, 14, 22, 17, 2, -22 },
  { 2305, 11, 22, 17, 2, -22 },
  { 2336, 16, 16, 17, 0, -16 },
  { 2368, 14, 16, 17, 1, -16 },
  { 2396, 13, 16, 17, 2, -16 },
  { 2422, 13, 22, 17, 1, -16 },
  { 2458, 13, 22, 17, 2, -16 },
  { 2494, 12, 16, 17, 4, -16 },
  { 2518, 13, 16, 17, 2, -16 },
  { 2544, 10, 19, 17, 4, -19 },
  { 2568, 13, 15, 17, 2, -15 },
  { 2593, 13, 15, 17, 3, -15 },
  { 2618, 15, 15, 17, 2, -15 },
  { 2647, 15, 15, 17, 1, -15 },
  { 2676, 17, 21, 17, 0, -15 },
  { 2721, 14, 15, 17, 1, -15 },
  { 2748, 11, 29, 17, 5, -23 },
  { 2788, 5, 25, 17, 6, -21 },
  { 2804, 12, 29, 17, 2, -23 },
  { 2848, 15, 5, 17, 1, -11 },
};

const GFXfont RobotoMono_ThinItalic29pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic29pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _ROBOTOMONO_THINITALIC29PT7B_H_
