#ifndef _ROBOTOMONO_THINITALIC11PT7B_H_
#define _ROBOTOMONO_THINITALIC11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x62, 0xE0, 0x14, 0x29, 0xF9, 0x42, 0x9F, 0x94, 0x28, 0x13,
  0x63, 0x04, 0x18, 0x31, 0xB2, 0x00, 0xC5, 0x75, 0x43, 0x36, 0xA7, 0x72,
  0x94, 0xCA, 0x56, 0x5D, 0xC0, 0x29, 0x49, 0x24, 0x92, 0x20, 0x44, 0x92,
  0x49, 0x29, 0x40, 0x25, 0xEA, 0x21, 0x3E, 0x44, 0x00, 0x70, 0xF0, 0x80,
  0x08, 0x84, 0x42, 0x21, 0x10, 0x80, 0x74, 0x63, 0x7C, 0xC6, 0x5C, 0x75,
  0x24, 0x92, 0x3A, 0x42, 0x11, 0x11, 0x1F, 0x39, 0x10, 0x42, 0x38, 0x28,
  0x9C, 0x08, 0x61, 0x8A, 0x4B, 0xF0, 0x84, 0x7A, 0x10, 0xE0, 0x86, 0x3E,
  0x34, 0x8F, 0x99, 0x9F, 0xF8, 0x44, 0x22, 0x11, 0x10, 0x7C, 0x62, 0xAB,
  0x46, 0x3E, 0x74, 0x63, 0x19, 0xB4, 0x5C, 0x84, 0x40, 0x18, 0x1B, 0x20,
  0xC1, 0x00, 0xF8, 0x3C, 0xC1, 0x06, 0xC8, 0x00, 0x69, 0x12, 0x44, 0x08,
  0x3D, 0x56, 0xEB, 0xCF, 0x5A, 0x9E, 0x08, 0x8A, 0x54, 0xBE, 0x31, 0x74,
  0x63, 0xE9, 0x46, 0x3E, 0x74, 0x63, 0x08, 0x46, 0x5E, 0x79, 0x14, 0x51,
  0x45, 0x18, 0xBC, 0x7C, 0x21, 0xE8, 0x42, 0x1E, 0x7C, 0x21, 0x0F, 0x42,
  0x10, 0x7C, 0x61, 0x0B, 0xC6, 0x3E, 0x45, 0x14, 0x5F, 0x46, 0x18, 0x62,
  0x79, 0x08, 0x42, 0x11, 0x1E, 0x04, 0x10, 0x41, 0x04, 0x28, 0x9C, 0x46,
  0x29, 0x38, 0xA2, 0x89, 0x22, 0x48, 0x88, 0x88, 0x8F, 0x45, 0x16, 0xDB,
  0x56, 0x18, 0x62, 0x45, 0x16, 0x55, 0x56, 0x58, 0xA2, 0x74, 0x63, 0x18,
  0xC6, 0x5C, 0x7C, 0x63, 0x1F, 0x42, 0x10, 0x74, 0x63, 0x18, 0xC6, 0x5E,
  0x10, 0x74, 0x63, 0x1F, 0x4A, 0x52, 0x7C, 0x60, 0x83, 0x06, 0x3E, 0xFC,
  0x82, 0x08, 0x20, 0x84, 0x10, 0x8C, 0x63, 0x18, 0xC6, 0x5C, 0x86, 0x28,
  0xA4, 0x51, 0x86, 0x10, 0xA6, 0x9A, 0xB6, 0xD2, 0x49, 0x24, 0x42, 0x48,
  0xA0, 0x81, 0x05, 0x12, 0x42, 0x86, 0x25, 0x14, 0x21, 0x04, 0x10, 0x3C,
  0x20, 0x84, 0x20, 0x84, 0x3E, 0x69, 0x49, 0x24, 0x92, 0x00, 0xA9, 0x55,
  0x40, 0x64, 0x94, 0x92, 0x4A, 0x00, 0x22, 0x5D, 0xF8, 0x80, 0x74, 0x4F,
  0x99, 0x78, 0x44, 0x1D, 0x18, 0xC6, 0x5E, 0x74, 0x61, 0x09, 0x78, 0x08,
  0x5F, 0x18, 0xCA, 0x5E, 0x74, 0x7F, 0x08, 0x78, 0x3C, 0x8F, 0x90, 0x41,
  0x04, 0x10, 0x3D, 0x14, 0x62, 0x89, 0xE0, 0xBC, 0x84, 0x3D, 0x18, 0xC6,
  0x52, 0x10, 0x62, 0x22, 0x2F, 0x08, 0x0E, 0x11, 0x08, 0x42, 0x17, 0x00,
  0x42, 0x23, 0x6C, 0x52, 0x92, 0x71, 0x22, 0x22, 0x2F, 0x7E, 0x59, 0x65,
  0xA6, 0x90, 0xF4, 0x63, 0x19, 0x48, 0x74, 0x63, 0x19, 0x78, 0x3A, 0x52,
  0x98, 0xBA, 0x10, 0x7C, 0x63, 0x29, 0x78, 0x42, 0x7A, 0x10, 0x88, 0x40,
  0x74, 0x70, 0x60, 0xF8, 0x2F, 0x24, 0x44, 0x70, 0x8C, 0x63, 0x19, 0x78,
  0x8C, 0x64, 0xA6, 0x20, 0xA6, 0xAE, 0xAA, 0xB2, 0x40, 0x44, 0xA3, 0x0C,
  0x4A, 0x20, 0x45, 0x14, 0x92, 0x30, 0x82, 0x30, 0x7C, 0x21, 0x08, 0x43,
  0xE0, 0x12, 0x44, 0x48, 0x84, 0x88, 0x40, 0x55, 0x5A, 0x80, 0x42, 0x12,
  0x21, 0x22, 0x24, 0xC0, 0xE6, 0x60,
};

const GFXglyph RobotoMono_ThinItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 8, 6, 2, -8 },
  { 3, 2, 2, 6, 3, -8 },
  { 4, 7, 8, 6, 0, -8 },
  { 11, 5, 10, 6, 1, -9 },
  { 18, 5, 8, 6, 1, -8 },
  { 23, 5, 8, 6, 1, -8 },
  { 28, 1, 2, 6, 3, -8 },
  { 29, 3, 12, 6, 2, -9 },
  { 34, 3, 12, 6, 1, -9 },
  { 39, 4, 4, 6, 2, -8 },
  { 41, 5, 5, 6, 1, -6 },
  { 45, 2, 2, 6, 1, -1 },
  { 46, 4, 1, 6, 1, -4 },
  { 47, 1, 1, 6, 2, -1 },
  { 48, 5, 9, 6, 1, -8 },
  { 54, 5, 8, 6, 1, -8 },
  { 59, 3, 8, 6, 2, -8 },
  { 62, 5, 8, 6, 0, -8 },
  { 67, 6, 8, 6, 0, -8 },
  { 73, 6, 8, 6, 0, -8 },
  { 79, 5, 8, 6, 1, -8 },
  { 84, 4, 8, 6, 1, -8 },
  { 88, 5, 8, 6, 1, -8 },
  { 93, 5, 8, 6, 1, -8 },
  { 98, 5, 8, 6, 1, -8 },
  { 103, 1, 6, 6, 3, -6 },
  { 104, 2, 7, 6, 2, -6 },
  { 106, 5, 5, 6, 1, -6 },
  { 110, 5, 3, 6, 1, -5 },
  { 112, 5, 5, 6, 1, -6 },
  { 116, 4, 8, 6, 2, -8 },
  { 120, 6, 8, 6, 0, -8 },
  { 126, 5, 8, 6, 0, -8 },
  { 131, 5, 8, 6, 1, -8 },
  { 136, 5, 8, 6, 1, -8 },
  { 141, 6, 8, 6, 0, -8 },
  { 147, 5, 8, 6, 1, -8 },
  { 152, 5, 8, 6, 1, -8 },
  { 157, 5, 8, 6, 1, -8 },
  { 162, 6, 8, 6, 0, -8 },
  { 168, 5, 8, 6, 1, -8 },
  { 173, 6, 8, 6, 0, -8 },
  { 179, 6, 8, 6, 1, -8 },
  { 185, 4, 8, 6, 1, -8 },
  { 189, 6, 8, 6, 0, -8 },
  { 195, 6, 8, 6, 0, -8 },
  { 201, 5, 8, 6, 1, -8 },
  { 206, 5, 8, 6, 1, -8 },
  { 211, 5, 9, 6, 1, -8 },
  { 217, 5, 8, 6, 1, -8 },
  { 222, 5, 8, 6, 1, -8 },
  { 227, 6, 8, 6, 1, -8 },
  { 233, 5, 8, 6, 1, -8 },
  { 238, 6, 8, 6, 1, -8 },
  { 244, 6, 8, 6, 1, -8 },
  { 250, 7, 8, 6, 0, -8 },
  { 257, 6, 8, 6, 1, -8 },
  { 263, 6, 8, 6, 0, -8 },
  { 269, 3, 11, 6, 2, -9 },
  { 274, 2, 9, 6, 2, -8 },
  { 277, 3, 11, 6, 2, -9 },
  { 282, 4, 4, 6, 1, -8 },
  { 284, 5, 1, 6, 0, 0 },
  { 285, 1, 1, 6, 3, -8 },
  { 286, 5, 6, 6, 1, -6 },
  { 290, 5, 8, 6, 1, -8 },
  { 295, 5, 6, 6, 1, -6 },
  { 299, 5, 8, 6, 1, -8 },
  { 304, 5, 6, 6, 1, -6 },
  { 308, 6, 8, 6, 1, -8 },
  { 314, 6, 8, 6, 0, -6 },
  { 320, 5, 8, 6, 1, -8 },
  { 325, 4, 8, 6, 1, -8 },
  { 329, 5, 10, 6, 0, -8 },
  { 336, 5, 8, 6, 1, -8 },
  { 341, 4, 8, 6, 1, -8 },
  { 345, 6, 6, 6, 0, -6 },
  { 350, 5, 6, 6, 1, -6 },
  { 354, 5, 6, 6, 1, -6 },
  { 358, 5, 8, 6, 0, -6 },
  { 363, 5, 8, 6, 1, -6 },
  { 368, 5, 6, 6, 1, -6 },
  { 372, 5, 6, 6, 1, -6 },
  { 376, 4, 7, 6, 1, -7 },
  { 380, 5, 6, 6, 1, -6 },
  { 384, 5, 6, 6, 1, -6 },
  { 388, 6, 6, 6, 1, -6 },
  { 393, 6, 6, 6, 0, -6 },
  { 398, 6, 8, 6, 0, -6 },
  { 404, 6, 6, 6, 0, -6 },
  { 409, 4, 11, 6, 2, -9 },
  { 415, 2, 9, 6, 2, -8 },
  { 418, 4, 11, 6, 1, -9 },
  { 424, 6, 2, 6, 0, -4 },
};

const GFXfont RobotoMono_ThinItalic11pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic11pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _ROBOTOMONO_THINITALIC11PT7B_H_
