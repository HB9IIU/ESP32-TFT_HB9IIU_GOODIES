#ifndef _ROBOTOMONO_THINITALIC40PT7B_H_
#define _ROBOTOMONO_THINITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x41,
  0x02, 0x04, 0x08, 0x10, 0x60, 0x81, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x86, 0x00, 0x62, 0x85, 0x0A, 0x14, 0x28, 0xA1, 0x42, 0x00, 0x18, 0x18,
  0x00, 0x20, 0x20, 0x00, 0x40, 0x40, 0x01, 0x81, 0x00, 0x02, 0x02, 0x00,
  0x04, 0x04, 0x00, 0x10, 0x10, 0x00, 0x20, 0x20, 0x1F, 0xFF, 0xFE, 0x01,
  0x01, 0x00, 0x02, 0x02, 0x00, 0x04, 0x04, 0x00, 0x10, 0x10, 0x00, 0x20,
  0x20, 0x00, 0x40, 0xC0, 0x01, 0x01, 0x00, 0x02, 0x02, 0x00, 0x0C, 0x0C,
  0x00, 0x10, 0x10, 0x07, 0xFF, 0xFF, 0x00, 0xC0, 0xC0, 0x01, 0x01, 0x00,
  0x02, 0x02, 0x00, 0x0C, 0x08, 0x00, 0x10, 0x10, 0x00, 0x20, 0x20, 0x00,
  0x80, 0x80, 0x01, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x1E, 0x00, 0x1C, 0x30, 0x04, 0x01, 0x01, 0x00, 0x30, 0x40,
  0x02, 0x08, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x21, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x80, 0x00, 0x90, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00,
  0x84, 0x00, 0x20, 0xC0, 0x0C, 0x0C, 0x06, 0x00, 0x7F, 0x80, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x07, 0x00, 0x01, 0x98,
  0x00, 0x30, 0xC0, 0x02, 0x04, 0x00, 0x40, 0x40, 0x44, 0x04, 0x08, 0x40,
  0x41, 0x04, 0x04, 0x10, 0x80, 0x82, 0x08, 0x08, 0x40, 0x41, 0x8C, 0x04,
  0x30, 0x80, 0x3E, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x83, 0x80, 0x08, 0x66, 0x01, 0x08, 0x20, 0x21, 0x83, 0x06, 0x10,
  0x10, 0x41, 0x01, 0x08, 0x20, 0x21, 0x82, 0x02, 0x10, 0x20, 0x22, 0x02,
  0x02, 0x00, 0x20, 0x40, 0x01, 0x0C, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00,
  0x18, 0xC0, 0x04, 0x08, 0x01, 0x80, 0x80, 0x20, 0x10, 0x0C, 0x02, 0x01,
  0x00, 0xC0, 0x20, 0x10, 0x04, 0x04, 0x00, 0x41, 0x00, 0x08, 0x40, 0x01,
  0x30, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x00, 0xA0, 0x00, 0x62, 0x00, 0x18,
  0x40, 0x02, 0x04, 0x04, 0x80, 0xC0, 0xA0, 0x08, 0x34, 0x00, 0x85, 0x80,
  0x18, 0xA0, 0x01, 0x24, 0x00, 0x1C, 0x80, 0x03, 0x08, 0x00, 0x61, 0x80,
  0x32, 0x18, 0x0C, 0x61, 0xFE, 0x04, 0x55, 0xAA, 0x00, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x03, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x81, 0xC1, 0x87,
  0x39, 0x38, 0x07, 0xC0, 0x03, 0x00, 0x06, 0x80, 0x0C, 0x40, 0x18, 0x60,
  0x10, 0x20, 0x20, 0x10, 0x40, 0x18, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x7F, 0xFF, 0xF8, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x11,
  0x12, 0x26, 0x48, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x71, 0xC0, 0x20, 0x18, 0x10,
  0x02, 0x08, 0x00, 0x46, 0x00, 0x11, 0x00, 0x04, 0xC0, 0x01, 0x20, 0x00,
  0xC8, 0x00, 0x56, 0x00, 0x65, 0x00, 0x31, 0x40, 0x18, 0x50, 0x08, 0x14,
  0x04, 0x05, 0x02, 0x02, 0x81, 0x00, 0xA1, 0x80, 0x28, 0xC0, 0x0A, 0x60,
  0x02, 0xB0, 0x01, 0x30, 0x00, 0x48, 0x00, 0x32, 0x00, 0x08, 0xC0, 0x06,
  0x10, 0x01, 0x06, 0x00, 0x80, 0xC0, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0xC1,
  0xD1, 0xC5, 0x81, 0x80, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x00, 0x7C, 0x00,
  0x38, 0x60, 0x0C, 0x02, 0x02, 0x00, 0x60, 0x80, 0x04, 0x10, 0x00, 0x84,
  0x00, 0x10, 0x80, 0x02, 0x30, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x1C, 0x70, 0x0C,
  0x03, 0x03, 0x00, 0x20, 0x40, 0x02, 0x10, 0x00, 0x42, 0x00, 0x08, 0x80,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00,
  0x24, 0x00, 0x04, 0x40, 0x01, 0x08, 0x00, 0x60, 0x80, 0x18, 0x18, 0x06,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x28, 0x00, 0x0D, 0x00, 0x01,
  0x40, 0x00, 0x48, 0x00, 0x11, 0x00, 0x04, 0x20, 0x01, 0x84, 0x00, 0x61,
  0x00, 0x08, 0x20, 0x02, 0x04, 0x00, 0x80, 0x80, 0x20, 0x10, 0x0C, 0x02,
  0x03, 0x00, 0x80, 0x40, 0x10, 0x10, 0x02, 0x04, 0x00, 0x41, 0x00, 0x08,
  0x7F, 0xFF, 0xF0, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x07, 0xFF,
  0xE0, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x47, 0xC0,
  0x17, 0x0C, 0x03, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x31,
  0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x20, 0xC0, 0x0C, 0x08, 0x03, 0x00,
  0x80, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x01, 0x07, 0x00, 0x8F, 0x38, 0x24, 0x03, 0x0E, 0x00,
  0x45, 0x00, 0x09, 0x80, 0x02, 0x40, 0x00, 0x90, 0x00, 0x34, 0x00, 0x0D,
  0x00, 0x02, 0x40, 0x00, 0x90, 0x00, 0x24, 0x00, 0x09, 0x00, 0x04, 0x40,
  0x03, 0x08, 0x00, 0x83, 0x00, 0x40, 0x60, 0x60, 0x0F, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x0E, 0x18, 0x01, 0x80, 0x40, 0x20, 0x02,
  0x04, 0x00, 0x30, 0xC0, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00,
  0x30, 0x80, 0x02, 0x08, 0x00, 0x60, 0xC0, 0x04, 0x04, 0x01, 0x80, 0x30,
  0x70, 0x00, 0xF8, 0x00, 0x70, 0x60, 0x08, 0x01, 0x81, 0x00, 0x08, 0x20,
  0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x04, 0xC0, 0x00, 0x4C,
  0x00, 0x0C, 0x40, 0x00, 0x84, 0x00, 0x18, 0x20, 0x03, 0x01, 0x00, 0xC0,
  0x0F, 0xF8, 0x00, 0x00, 0xF0, 0x03, 0x86, 0x03, 0x00, 0x83, 0x00, 0x23,
  0x00, 0x11, 0x00, 0x0D, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x04, 0x80,
  0x06, 0x40, 0x05, 0x10, 0x0C, 0x86, 0x3C, 0x80, 0xF0, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x70, 0x07, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x10, 0x30, 0x20, 0x20, 0x60, 0x40, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x04, 0x7F, 0xFF, 0xDF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x02, 0x00, 0x00, 0x01, 0xE0, 0x1C, 0x30, 0x60, 0x31, 0x80,
  0x22, 0x00, 0x68, 0x00, 0x50, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0xF3, 0x80, 0x0C, 0x01, 0x80, 0x60, 0x02, 0x02,
  0x00, 0x0C, 0x10, 0x00, 0x10, 0xC0, 0xE0, 0x46, 0x0C, 0xC1, 0x10, 0x40,
  0x84, 0xC3, 0x04, 0x12, 0x08, 0x10, 0x48, 0x40, 0x41, 0x41, 0x01, 0x05,
  0x08, 0x08, 0x14, 0x20, 0x20, 0x60, 0x80, 0x82, 0x82, 0x06, 0x0A, 0x10,
  0x10, 0x28, 0x40, 0x41, 0xA1, 0x03, 0x04, 0x84, 0x14, 0x32, 0x18, 0xD0,
  0x88, 0x3E, 0x7C, 0x30, 0x60, 0x40, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x03, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x50, 0x00, 0x05, 0x00, 0x00, 0x90, 0x00, 0x09, 0x00, 0x01, 0x10, 0x00,
  0x11, 0x00, 0x02, 0x08, 0x00, 0x20, 0x80, 0x04, 0x08, 0x00, 0x40, 0x80,
  0x08, 0x08, 0x00, 0x80, 0x80, 0x18, 0x08, 0x01, 0x00, 0x40, 0x30, 0x04,
  0x02, 0x00, 0x40, 0x60, 0x04, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x08, 0x00,
  0x41, 0x80, 0x02, 0x10, 0x00, 0x23, 0x00, 0x02, 0x20, 0x00, 0x26, 0x00,
  0x02, 0x40, 0x00, 0x2C, 0x00, 0x03, 0x07, 0xFF, 0x00, 0x80, 0x10, 0x30,
  0x01, 0x04, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40,
  0x01, 0x10, 0x00, 0x22, 0x00, 0x08, 0x40, 0x03, 0x08, 0x00, 0xC1, 0x00,
  0x60, 0x3F, 0xF8, 0x08, 0x00, 0xC1, 0x00, 0x0C, 0x20, 0x00, 0xC4, 0x00,
  0x08, 0x80, 0x01, 0x10, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00,
  0x22, 0x00, 0x04, 0x40, 0x01, 0x08, 0x00, 0xC2, 0x00, 0x70, 0x7F, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x38, 0x60, 0x08, 0x06, 0x02, 0x00, 0x60, 0x80,
  0x04, 0x20, 0x00, 0x84, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x28, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x09, 0x00, 0x03, 0x20, 0x00, 0x44, 0x00, 0x18, 0x80, 0x02,
  0x08, 0x00, 0x81, 0x80, 0x20, 0x18, 0x18, 0x01, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x80, 0x18, 0x08, 0x00, 0xC0, 0x80, 0x04, 0x08, 0x00, 0x20, 0x80,
  0x02, 0x10, 0x00, 0x31, 0x00, 0x01, 0x10, 0x00, 0x11, 0x00, 0x01, 0x10,
  0x00, 0x11, 0x00, 0x01, 0x20, 0x00, 0x12, 0x00, 0x02, 0x20, 0x00, 0x22,
  0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x02, 0x40, 0x00, 0x44, 0x00, 0x04,
  0x40, 0x00, 0x84, 0x00, 0x08, 0x40, 0x01, 0x04, 0x00, 0x20, 0x80, 0x06,
  0x08, 0x00, 0x80, 0x80, 0x70, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x0E, 0x38, 0x01, 0x00, 0xC0, 0x20, 0x06, 0x04, 0x00,
  0x20, 0x80, 0x03, 0x18, 0x00, 0x11, 0x00, 0x01, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x3F, 0xE4, 0x00, 0x04, 0x80, 0x00, 0x48,
  0x00, 0x04, 0x80, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x08,
  0x40, 0x00, 0x82, 0x00, 0x08, 0x30, 0x01, 0x01, 0x80, 0x60, 0x07, 0xF8,
  0x00, 0x04, 0x00, 0x04, 0x10, 0x00, 0x10, 0x40, 0x00, 0x81, 0x00, 0x02,
  0x08, 0x00, 0x08, 0x20, 0x00, 0x20, 0x80, 0x00, 0x82, 0x00, 0x04, 0x08,
  0x00, 0x10, 0x20, 0x00, 0x41, 0x00, 0x01, 0x04, 0x00, 0x04, 0x10, 0x00,
  0x10, 0x7F, 0xFF, 0x81, 0x00, 0x02, 0x04, 0x00, 0x08, 0x20, 0x00, 0x20,
  0x80, 0x00, 0x82, 0x00, 0x02, 0x08, 0x00, 0x10, 0x20, 0x00, 0x41, 0x00,
  0x01, 0x04, 0x00, 0x04, 0x10, 0x00, 0x10, 0x40, 0x00, 0x41, 0x00, 0x02,
  0x04, 0x00, 0x08, 0x20, 0x00, 0x20, 0x07, 0xFF, 0xF0, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80,
  0x02, 0x08, 0x00, 0x20, 0x80, 0x04, 0x04, 0x00, 0x80, 0x20, 0x30, 0x01,
  0xFC, 0x00, 0x04, 0x00, 0x0C, 0x10, 0x00, 0x40, 0x40, 0x02, 0x01, 0x00,
  0x10, 0x08, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x60, 0x02, 0x03, 0x00,
  0x08, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x06, 0x00, 0x04, 0x30, 0x00, 0x11,
  0x80, 0x00, 0x4E, 0x00, 0x01, 0x44, 0x00, 0x0A, 0x18, 0x00, 0x30, 0x20,
  0x00, 0x80, 0x40, 0x02, 0x01, 0x00, 0x08, 0x02, 0x00, 0x20, 0x0C, 0x01,
  0x00, 0x10, 0x04, 0x00, 0x20, 0x10, 0x00, 0xC0, 0x40, 0x01, 0x01, 0x00,
  0x02, 0x04, 0x00, 0x08, 0x20, 0x00, 0x10, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x07, 0xFF, 0xF0,
  0x06, 0x00, 0x0C, 0x18, 0x00, 0x70, 0x60, 0x01, 0x41, 0x40, 0x0E, 0x05,
  0x00, 0x28, 0x24, 0x01, 0x20, 0x90, 0x04, 0x82, 0x40, 0x22, 0x08, 0x81,
  0x88, 0x22, 0x04, 0x40, 0x88, 0x31, 0x04, 0x20, 0x84, 0x10, 0x84, 0x10,
  0x41, 0x10, 0x41, 0x04, 0x83, 0x04, 0x16, 0x08, 0x30, 0x50, 0x20, 0x81,
  0x80, 0x82, 0x02, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x60, 0x80, 0x01,
  0x04, 0x00, 0x04, 0x10, 0x00, 0x10, 0x40, 0x00, 0x41, 0x00, 0x01, 0x04,
  0x00, 0x08, 0x30, 0x00, 0x20, 0x06, 0x00, 0x04, 0x18, 0x00, 0x20, 0x60,
  0x00, 0x81, 0x40, 0x02, 0x09, 0x00, 0x08, 0x24, 0x00, 0x20, 0x88, 0x00,
  0x82, 0x20, 0x04, 0x08, 0x40, 0x10, 0x21, 0x00, 0x41, 0x04, 0x01, 0x04,
  0x08, 0x04, 0x10, 0x20, 0x10, 0x40, 0x80, 0x81, 0x01, 0x02, 0x04, 0x04,
  0x08, 0x20, 0x08, 0x20, 0x80, 0x20, 0x82, 0x00, 0x82, 0x08, 0x01, 0x10,
  0x20, 0x04, 0x41, 0x00, 0x11, 0x04, 0x00, 0x24, 0x10, 0x00, 0x90, 0x40,
  0x01, 0x41, 0x00, 0x06, 0x04, 0x00, 0x18, 0x20, 0x00, 0x20, 0x00, 0x7C,
  0x00, 0x38, 0xE0, 0x08, 0x06, 0x02, 0x00, 0x40, 0x80, 0x04, 0x20, 0x00,
  0x84, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00,
  0xA0, 0x00, 0x14, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x02,
  0x80, 0x00, 0x50, 0x00, 0x1A, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x09,
  0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x10, 0x80, 0x06, 0x08, 0x00, 0x81,
  0x80, 0x20, 0x18, 0x18, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x80, 0x0C,
  0x08, 0x00, 0x60, 0x80, 0x02, 0x08, 0x00, 0x11, 0x80, 0x01, 0x10, 0x00,
  0x11, 0x00, 0x01, 0x10, 0x00, 0x11, 0x00, 0x02, 0x10, 0x00, 0x22, 0x00,
  0x04, 0x20, 0x00, 0xC2, 0x00, 0x18, 0x20, 0x06, 0x03, 0xFF, 0x80, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0E, 0x38, 0x03, 0x00,
  0xC0, 0x60, 0x06, 0x04, 0x00, 0x20, 0x80, 0x03, 0x10, 0x00, 0x11, 0x00,
  0x01, 0x20, 0x00, 0x12, 0x00, 0x01, 0x20, 0x00, 0x14, 0x00, 0x01, 0x40,
  0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x03, 0x80, 0x00, 0x28,
  0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x48, 0x00, 0x04,
  0x80, 0x00, 0x84, 0x00, 0x08, 0x40, 0x01, 0x06, 0x00, 0x20, 0x20, 0x04,
  0x01, 0x81, 0x80, 0x0F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x07, 0xFF, 0x00, 0x40, 0x0C, 0x04,
  0x00, 0x40, 0x40, 0x02, 0x08, 0x00, 0x20, 0x80, 0x01, 0x08, 0x00, 0x10,
  0x80, 0x01, 0x08, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x61, 0x00, 0x04,
  0x10, 0x00, 0x81, 0x00, 0x10, 0x10, 0x0E, 0x03, 0xFF, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x04, 0x02, 0x00, 0x40, 0x20, 0x04, 0x04, 0x00,
  0x20, 0x40, 0x02, 0x04, 0x00, 0x30, 0x40, 0x01, 0x04, 0x00, 0x10, 0x40,
  0x00, 0x88, 0x00, 0x08, 0x00, 0x1E, 0x00, 0x0E, 0x18, 0x03, 0x00, 0x40,
  0x40, 0x02, 0x0C, 0x00, 0x20, 0x80, 0x01, 0x18, 0x00, 0x11, 0x00, 0x01,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x48, 0x00, 0x04, 0x80,
  0x00, 0x4C, 0x00, 0x04, 0x40, 0x00, 0x84, 0x00, 0x18, 0x20, 0x03, 0x01,
  0x80, 0x60, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x21, 0x00, 0x02, 0x20, 0x00,
  0x22, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00,
  0x04, 0x40, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x08, 0x40,
  0x00, 0x88, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80, 0x00, 0x88,
  0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x02, 0x08, 0x00, 0x60,
  0x40, 0x04, 0x04, 0x00, 0x80, 0x30, 0x30, 0x01, 0xFE, 0x00, 0x80, 0x00,
  0x70, 0x00, 0x0A, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x10, 0x80, 0x02,
  0x10, 0x00, 0x82, 0x00, 0x10, 0x40, 0x06, 0x08, 0x00, 0x81, 0x00, 0x30,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x01, 0x01, 0x00,
  0x20, 0x20, 0x06, 0x08, 0x00, 0x41, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00,
  0x22, 0x00, 0x04, 0x40, 0x00, 0x90, 0x00, 0x0A, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0xA0, 0x18,
  0x05, 0x00, 0xC0, 0x28, 0x0E, 0x02, 0x40, 0x50, 0x12, 0x02, 0x80, 0x90,
  0x24, 0x08, 0x81, 0x20, 0x44, 0x09, 0x82, 0x20, 0x8C, 0x21, 0x04, 0x21,
  0x08, 0x21, 0x08, 0x42, 0x08, 0x42, 0x10, 0x44, 0x10, 0x82, 0x20, 0x88,
  0x11, 0x04, 0x40, 0x90, 0x22, 0x04, 0x81, 0x20, 0x24, 0x09, 0x01, 0x40,
  0x58, 0x0A, 0x02, 0x80, 0x50, 0x14, 0x03, 0x00, 0xA0, 0x18, 0x06, 0x00,
  0xC0, 0x30, 0x04, 0x01, 0x80, 0x20, 0x00, 0x0C, 0x00, 0x06, 0x08, 0x00,
  0x10, 0x08, 0x00, 0x60, 0x10, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x08,
  0x00, 0x20, 0x30, 0x00, 0x40, 0xC0, 0x00, 0x41, 0x00, 0x00, 0x84, 0x00,
  0x01, 0x90, 0x00, 0x01, 0x60, 0x00, 0x02, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x24, 0x00, 0x00, 0xC8, 0x00, 0x01, 0x08, 0x00, 0x04,
  0x10, 0x00, 0x10, 0x10, 0x00, 0x60, 0x20, 0x00, 0x80, 0x20, 0x02, 0x00,
  0x40, 0x08, 0x00, 0x40, 0x30, 0x00, 0x80, 0x40, 0x01, 0x81, 0x00, 0x01,
  0x04, 0x00, 0x03, 0x00, 0x80, 0x00, 0x70, 0x00, 0x19, 0x00, 0x02, 0x20,
  0x00, 0x84, 0x00, 0x20, 0x40, 0x04, 0x08, 0x01, 0x01, 0x00, 0x40, 0x10,
  0x08, 0x02, 0x02, 0x00, 0x40, 0x80, 0x04, 0x30, 0x00, 0x84, 0x00, 0x11,
  0x00, 0x01, 0x60, 0x00, 0x28, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xF0, 0x3F, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xFC, 0x00,
  0xC0, 0x40, 0x40, 0x40, 0x40, 0x60, 0x20, 0x20, 0x20, 0x20, 0x30, 0x10,
  0x10, 0x10, 0x10, 0x18, 0x08, 0x08, 0x08, 0x08, 0x0C, 0x04, 0x04, 0x04,
  0x04, 0x06, 0x02, 0x02, 0x02, 0x03, 0x03, 0xE0, 0x7C, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x3F, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x1A, 0x00, 0x48, 0x02, 0x20, 0x08, 0x80, 0x41,
  0x03, 0x04, 0x08, 0x10, 0x60, 0x41, 0x01, 0x88, 0x02, 0x20, 0x09, 0x00,
  0x2C, 0x00, 0xC0, 0xFF, 0xFF, 0x80, 0x84, 0x42, 0x21, 0x00, 0x10, 0x00,
  0x7F, 0x80, 0x60, 0x18, 0x30, 0x02, 0x08, 0x00, 0x44, 0x00, 0x11, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x0F, 0xF8, 0x1E, 0x02,
  0x18, 0x00, 0x88, 0x00, 0x24, 0x00, 0x09, 0x00, 0x04, 0x80, 0x01, 0x20,
  0x00, 0xC8, 0x00, 0x71, 0x00, 0x34, 0x60, 0x31, 0x07, 0xF0, 0x40, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x10, 0x02, 0x3F, 0x80, 0xB0, 0x10,
  0x50, 0x02, 0x18, 0x00, 0x86, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x10,
  0x00, 0x48, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0xC8, 0x00,
  0x22, 0x00, 0x09, 0x00, 0x06, 0x40, 0x01, 0x10, 0x00, 0xC6, 0x00, 0x21,
  0x80, 0x10, 0xD8, 0x18, 0x23, 0xFC, 0x00, 0x00, 0x20, 0x01, 0xFE, 0x01,
  0x80, 0x81, 0x00, 0x21, 0x00, 0x09, 0x80, 0x04, 0x80, 0x02, 0x80, 0x01,
  0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x03, 0x60, 0x01, 0x10, 0x01, 0x0C,
  0x01, 0x83, 0x01, 0x80, 0xFF, 0x00, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x20, 0x40, 0x7F, 0x18, 0x10, 0x1A, 0x04, 0x01, 0x41, 0x00,
  0x18, 0x40, 0x03, 0x08, 0x00, 0x22, 0x00, 0x0C, 0x40, 0x01, 0x08, 0x00,
  0x22, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x11, 0x00, 0x06, 0x20, 0x00,
  0x84, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0xC1, 0x00, 0x18, 0x20, 0x06,
  0x02, 0x03, 0x40, 0x3F, 0x88, 0x00, 0x00, 0x20, 0x00, 0x7F, 0x00, 0x60,
  0x30, 0x20, 0x04, 0x10, 0x00, 0x8C, 0x00, 0x22, 0x00, 0x09, 0x00, 0x02,
  0x40, 0x00, 0xA0, 0x00, 0x2F, 0xFF, 0xFA, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x20, 0x80, 0x18, 0x30, 0x18, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0xE0, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x3F,
  0xC4, 0x08, 0x0D, 0x02, 0x00, 0xA0, 0x80, 0x0C, 0x20, 0x01, 0x84, 0x00,
  0x11, 0x00, 0x02, 0x20, 0x00, 0x84, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00,
  0x44, 0x00, 0x08, 0x80, 0x03, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01,
  0x08, 0x00, 0x60, 0x80, 0x0C, 0x10, 0x03, 0x81, 0x81, 0xA0, 0x1F, 0xC4,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x82, 0x00, 0x20,
  0x40, 0x08, 0x06, 0x02, 0x00, 0x7F, 0x80, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x08, 0x02, 0x3F, 0xC1, 0x18, 0x18, 0x48,
  0x02, 0x14, 0x00, 0x46, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x20, 0x00,
  0x48, 0x00, 0x12, 0x00, 0x0C, 0x80, 0x02, 0x20, 0x00, 0x98, 0x00, 0x24,
  0x00, 0x09, 0x00, 0x02, 0x40, 0x01, 0x90, 0x00, 0x44, 0x00, 0x13, 0x00,
  0x04, 0x80, 0x01, 0x20, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x06, 0x00, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x22, 0x00, 0x18, 0x40, 0x06,
  0x08, 0x01, 0x01, 0x00, 0xC0, 0x20, 0x30, 0x04, 0x08, 0x01, 0x06, 0x00,
  0x21, 0x80, 0x04, 0x60, 0x00, 0x98, 0x00, 0x1C, 0x80, 0x07, 0x08, 0x00,
  0x81, 0x80, 0x10, 0x10, 0x02, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x03,
  0x00, 0x20, 0x40, 0x06, 0x08, 0x00, 0x61, 0x00, 0x06, 0x00, 0x03, 0xFC,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x0F,
  0xFF, 0xF8, 0x00, 0xC0, 0x20, 0x27, 0xE3, 0xF0, 0x50, 0x6C, 0x10, 0xC0,
  0x60, 0x21, 0x00, 0xC0, 0x46, 0x01, 0x00, 0xC8, 0x02, 0x01, 0x10, 0x04,
  0x02, 0x20, 0x10, 0x04, 0x40, 0x20, 0x08, 0x80, 0x40, 0x12, 0x00, 0x80,
  0x64, 0x01, 0x00, 0x88, 0x02, 0x01, 0x10, 0x08, 0x02, 0x20, 0x10, 0x04,
  0x40, 0x20, 0x09, 0x00, 0x40, 0x22, 0x00, 0x80, 0x44, 0x01, 0x00, 0x88,
  0x04, 0x01, 0x10, 0x08, 0x02, 0x00, 0x00, 0x08, 0x02, 0x3F, 0xC1, 0x18,
  0x18, 0x48, 0x02, 0x14, 0x00, 0x46, 0x00, 0x11, 0x00, 0x04, 0xC0, 0x01,
  0x20, 0x00, 0x48, 0x00, 0x12, 0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x98,
  0x00, 0x24, 0x00, 0x09, 0x00, 0x02, 0x40, 0x01, 0x10, 0x00, 0x44, 0x00,
  0x13, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x3F,
  0xC0, 0x18, 0x04, 0x06, 0x00, 0x41, 0x80, 0x0C, 0x20, 0x00, 0x88, 0x00,
  0x11, 0x00, 0x03, 0x40, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xE0, 0x00,
  0x28, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x34, 0x00, 0x04, 0x40, 0x01,
  0x88, 0x00, 0x21, 0x80, 0x08, 0x10, 0x02, 0x01, 0x01, 0x80, 0x1F, 0xE0,
  0x00, 0x00, 0x08, 0x00, 0x8F, 0xE0, 0x36, 0x02, 0x05, 0x00, 0x20, 0xC0,
  0x04, 0x18, 0x00, 0xC2, 0x00, 0x08, 0x40, 0x01, 0x18, 0x00, 0x22, 0x00,
  0x04, 0x40, 0x00, 0x88, 0x00, 0x11, 0x00, 0x04, 0x20, 0x00, 0x88, 0x00,
  0x11, 0x00, 0x06, 0x20, 0x00, 0x84, 0x00, 0x30, 0xC0, 0x04, 0x18, 0x01,
  0x04, 0xC0, 0xC0, 0x8F, 0xF0, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0xFF, 0x10, 0x60, 0x68, 0x20, 0x0E, 0x10, 0x01,
  0x88, 0x00, 0x62, 0x00, 0x09, 0x00, 0x02, 0x40, 0x01, 0x10, 0x00, 0x48,
  0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0xC8, 0x00, 0x22, 0x00,
  0x08, 0x80, 0x02, 0x20, 0x00, 0x84, 0x00, 0x61, 0x00, 0x28, 0x20, 0x34,
  0x07, 0xF1, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x06, 0x04,
  0x3F, 0xC2, 0x70, 0x01, 0x60, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0xFF,
  0x80, 0xC0, 0x30, 0x60, 0x02, 0x10, 0x00, 0x88, 0x00, 0x12, 0x00, 0x04,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x20, 0x00,
  0x48, 0x00, 0x21, 0x00, 0x18, 0x60, 0x0C, 0x07, 0xFC, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x3F, 0xFF, 0x81,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x1F,
  0xC0, 0x10, 0x00, 0x48, 0x00, 0x12, 0x00, 0x08, 0x80, 0x02, 0x20, 0x00,
  0x88, 0x00, 0x22, 0x00, 0x09, 0x00, 0x02, 0x40, 0x01, 0x10, 0x00, 0x44,
  0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x20, 0x00, 0x48, 0x00, 0x22, 0x00,
  0x08, 0x80, 0x06, 0x10, 0x01, 0x84, 0x01, 0xA0, 0x80, 0xC8, 0x1F, 0xC4,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x09, 0x00, 0x04, 0x40, 0x01,
  0x10, 0x00, 0x86, 0x00, 0x60, 0x80, 0x10, 0x20, 0x0C, 0x08, 0x02, 0x03,
  0x01, 0x00, 0x40, 0x40, 0x10, 0x20, 0x04, 0x18, 0x00, 0x84, 0x00, 0x23,
  0x00, 0x08, 0x80, 0x02, 0x40, 0x00, 0x50, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x20, 0x1C, 0x03, 0x00, 0xA0, 0x18, 0x05, 0x01, 0x40, 0x48,
  0x0A, 0x02, 0x40, 0x50, 0x32, 0x04, 0x81, 0x18, 0x24, 0x08, 0xC2, 0x30,
  0x82, 0x10, 0x84, 0x11, 0x84, 0x60, 0x88, 0x22, 0x04, 0x41, 0x10, 0x24,
  0x09, 0x01, 0x20, 0x48, 0x0A, 0x02, 0xC0, 0x50, 0x14, 0x02, 0x80, 0xA0,
  0x18, 0x06, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x00, 0x08, 0x00, 0x18,
  0x20, 0x01, 0x81, 0x80, 0x18, 0x04, 0x01, 0x80, 0x10, 0x18, 0x00, 0xC1,
  0x80, 0x02, 0x18, 0x00, 0x19, 0x80, 0x00, 0x48, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xA0, 0x00, 0x08, 0x80, 0x00, 0x84, 0x00, 0x0C, 0x10,
  0x00, 0xC0, 0xC0, 0x0C, 0x02, 0x00, 0xC0, 0x08, 0x0C, 0x00, 0x60, 0xC0,
  0x01, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x01, 0x04, 0x00, 0x02, 0x04,
  0x00, 0x06, 0x04, 0x00, 0x04, 0x02, 0x00, 0x08, 0x02, 0x00, 0x08, 0x02,
  0x00, 0x10, 0x03, 0x00, 0x30, 0x01, 0x00, 0x20, 0x01, 0x00, 0x40, 0x01,
  0x00, 0xC0, 0x00, 0x80, 0x80, 0x00, 0x81, 0x80, 0x00, 0x81, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x46, 0x00, 0x00, 0x44, 0x00, 0x00, 0x4C, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x02, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10, 0x20, 0x40, 0x82,
  0x04, 0x08, 0x10, 0x20, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80,
  0x00, 0x1F, 0x00, 0x09, 0x86, 0x00, 0x58, 0x18, 0x02, 0x80, 0x60, 0x28,
  0x01, 0x82, 0x40, 0x03, 0xE0,
};

const GFXglyph RobotoMono_ThinItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 7, 28, 23, 8, -28 },
  { 26, 7, 8, 23, 10, -30 },
  { 33, 23, 28, 23, 1, -28 },
  { 114, 19, 36, 23, 3, -32 },
  { 200, 20, 29, 23, 2, -29 },
  { 273, 19, 29, 23, 2, -29 },
  { 342, 2, 8, 23, 12, -30 },
  { 344, 12, 41, 23, 7, -32 },
  { 406, 12, 41, 23, 4, -32 },
  { 468, 16, 15, 23, 6, -28 },
  { 498, 20, 21, 23, 2, -24 },
  { 551, 4, 8, 23, 5, -3 },
  { 555, 13, 2, 23, 5, -14 },
  { 559, 3, 2, 23, 9, -2 },
  { 560, 18, 30, 23, 3, -28 },
  { 628, 18, 29, 23, 3, -29 },
  { 694, 10, 28, 23, 6, -28 },
  { 729, 19, 29, 23, 1, -29 },
  { 798, 19, 29, 23, 1, -29 },
  { 867, 19, 28, 23, 1, -28 },
  { 934, 19, 28, 23, 4, -28 },
  { 1001, 18, 29, 23, 2, -29 },
  { 1067, 18, 28, 23, 5, -28 },
  { 1130, 20, 29, 23, 2, -29 },
  { 1203, 17, 29, 23, 4, -29 },
  { 1265, 6, 19, 23, 10, -19 },
  { 1280, 8, 24, 23, 8, -19 },
  { 1304, 18, 16, 23, 3, -21 },
  { 1340, 18, 9, 23, 3, -18 },
  { 1361, 18, 16, 23, 2, -21 },
  { 1397, 15, 29, 23, 6, -29 },
  { 1452, 22, 29, 23, 1, -29 },
  { 1532, 20, 28, 23, 0, -28 },
  { 1602, 19, 28, 23, 2, -28 },
  { 1669, 19, 29, 23, 3, -29 },
  { 1738, 20, 28, 23, 2, -28 },
  { 1808, 21, 28, 23, 2, -28 },
  { 1882, 21, 28, 23, 2, -28 },
  { 1956, 20, 29, 23, 2, -29 },
  { 2029, 22, 28, 23, 1, -28 },
  { 2106, 20, 28, 23, 2, -28 },
  { 2176, 20, 28, 23, 2, -28 },
  { 2246, 22, 28, 23, 2, -28 },
  { 2323, 15, 28, 23, 3, -28 },
  { 2376, 22, 28, 23, 1, -28 },
  { 2453, 22, 28, 23, 1, -28 },
  { 2530, 19, 29, 23, 3, -29 },
  { 2599, 20, 28, 23, 3, -28 },
  { 2669, 20, 34, 23, 2, -29 },
  { 2754, 20, 28, 23, 2, -28 },
  { 2824, 20, 29, 23, 2, -29 },
  { 2897, 19, 28, 23, 5, -28 },
  { 2964, 20, 28, 23, 3, -28 },
  { 3034, 19, 28, 23, 5, -28 },
  { 3101, 21, 28, 23, 4, -28 },
  { 3175, 23, 28, 23, 1, -28 },
  { 3256, 19, 28, 23, 5, -28 },
  { 3323, 21, 28, 23, 1, -28 },
  { 3397, 12, 39, 23, 6, -33 },
  { 3456, 8, 30, 23, 8, -28 },
  { 3486, 11, 39, 23, 6, -33 },
  { 3540, 14, 15, 23, 5, -28 },
  { 3567, 17, 1, 23, 1, 0 },
  { 3570, 4, 6, 23, 12, -30 },
  { 3573, 18, 22, 23, 2, -22 },
  { 3623, 18, 30, 23, 2, -30 },
  { 3691, 17, 22, 23, 3, -22 },
  { 3738, 19, 30, 23, 3, -30 },
  { 3810, 18, 22, 23, 3, -22 },
  { 3860, 19, 30, 23, 5, -30 },
  { 3932, 19, 31, 23, 2, -22 },
  { 4006, 18, 30, 23, 2, -30 },
  { 4074, 17, 29, 23, 2, -29 },
  { 4136, 18, 38, 23, 0, -29 },
  { 4222, 19, 30, 23, 3, -30 },
  { 4294, 17, 30, 23, 2, -30 },
  { 4358, 23, 22, 23, 0, -22 },
  { 4422, 18, 22, 23, 2, -22 },
  { 4472, 19, 22, 23, 2, -22 },
  { 4525, 19, 30, 23, 1, -22 },
  { 4597, 18, 30, 23, 3, -22 },
  { 4665, 17, 22, 23, 5, -22 },
  { 4712, 18, 22, 23, 3, -22 },
  { 4762, 15, 27, 23, 5, -27 },
  { 4813, 18, 21, 23, 3, -21 },
  { 4861, 18, 21, 23, 4, -21 },
  { 4909, 21, 21, 23, 3, -21 },
  { 4965, 21, 21, 23, 1, -21 },
  { 5021, 24, 30, 23, -1, -21 },
  { 5111, 20, 21, 23, 1, -21 },
  { 5164, 16, 40, 23, 6, -31 },
  { 5244, 7, 33, 23, 8, -28 },
  { 5273, 16, 40, 23, 3, -31 },
  { 5353, 21, 6, 23, 1, -15 },
};

const GFXfont RobotoMono_ThinItalic40pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic40pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic40pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _ROBOTOMONO_THINITALIC40PT7B_H_
