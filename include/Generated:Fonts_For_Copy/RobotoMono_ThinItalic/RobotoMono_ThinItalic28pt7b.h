#ifndef _ROBOTOMONO_THINITALIC28PT7B_H_
#define _ROBOTOMONO_THINITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x12, 0x22, 0x22, 0x24, 0x44, 0x40, 0x00, 0x08, 0x4A,
  0x53, 0x19, 0x48, 0x00, 0x42, 0x00, 0x41, 0x00, 0x20, 0x80, 0x10, 0x80,
  0x10, 0x40, 0x08, 0x20, 0x7F, 0xFE, 0x04, 0x10, 0x02, 0x10, 0x01, 0x08,
  0x01, 0x04, 0x00, 0x84, 0x00, 0x82, 0x00, 0x41, 0x03, 0xFF, 0x70, 0x20,
  0x80, 0x10, 0x40, 0x08, 0x40, 0x08, 0x20, 0x04, 0x10, 0x00, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x0F, 0xC0, 0x81, 0x08, 0x04, 0x40, 0x24, 0x01, 0x20,
  0x09, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x04,
  0x00, 0x14, 0x00, 0xA0, 0x05, 0x00, 0x48, 0x02, 0x20, 0x20, 0xEE, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x00, 0x38, 0x02, 0x20, 0x21, 0x05, 0x08, 0x28,
  0x42, 0x42, 0x22, 0x12, 0x11, 0x10, 0x71, 0x00, 0x10, 0x00, 0x80, 0x08,
  0xE0, 0x88, 0x88, 0x84, 0x44, 0x24, 0x21, 0x42, 0x0A, 0x10, 0x40, 0x44,
  0x03, 0xC0, 0x03, 0xC0, 0x10, 0x80, 0x41, 0x02, 0x04, 0x08, 0x20, 0x20,
  0x80, 0x84, 0x01, 0x60, 0x06, 0x00, 0x18, 0x00, 0xA0, 0x04, 0x41, 0x20,
  0x85, 0x02, 0x24, 0x04, 0xA0, 0x12, 0x80, 0x31, 0x00, 0xC4, 0x05, 0x0F,
  0xE2, 0x55, 0xA0, 0x01, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x20,
  0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x02,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02,
  0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x40, 0x80, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x40, 0xE4, 0xF1, 0xF0, 0x0C, 0x00, 0xA0, 0x11,
  0x02, 0x10, 0x40, 0x80, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x03, 0xFF, 0xE0, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x55, 0x80, 0xFF, 0xC0, 0x70, 0x00, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x00, 0x07, 0xE0, 0x40, 0x84,
  0x04, 0x40, 0x12, 0x00, 0xA0, 0x0D, 0x00, 0xA8, 0x09, 0x40, 0x8A, 0x08,
  0x60, 0x85, 0x18, 0x29, 0x01, 0x50, 0x0B, 0x00, 0x50, 0x04, 0x80, 0x22,
  0x02, 0x10, 0x20, 0x7E, 0x00, 0x02, 0x1D, 0xCC, 0x10, 0x20, 0x41, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x80, 0x07,
  0xE0, 0x40, 0x84, 0x04, 0x40, 0x12, 0x00, 0xA0, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x03,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0xFF, 0xC0, 0x07, 0xE0, 0x40, 0x84,
  0x02, 0x40, 0x12, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x3E,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x24,
  0x01, 0x10, 0x30, 0x7E, 0x00, 0x00, 0x10, 0x01, 0x80, 0x14, 0x00, 0xA0,
  0x09, 0x00, 0x88, 0x08, 0x80, 0x84, 0x08, 0x20, 0x41, 0x04, 0x08, 0x40,
  0x44, 0x04, 0x40, 0x23, 0xFF, 0xE0, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x0F, 0xF8, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x08, 0xC0, 0x79, 0x82, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x90, 0x04, 0x80, 0x44, 0x04, 0x10, 0x60, 0x7C, 0x00, 0x01,
  0xE0, 0x20, 0x0C, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x04, 0xF8, 0x70,
  0x44, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80,
  0x28, 0x04, 0x40, 0x83, 0xF0, 0xFF, 0xF0, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x00, 0x07,
  0xE0, 0x40, 0x84, 0x02, 0x40, 0x12, 0x00, 0x90, 0x04, 0x80, 0x24, 0x02,
  0x10, 0x20, 0x7E, 0x06, 0x10, 0x40, 0x44, 0x01, 0x40, 0x0A, 0x00, 0x50,
  0x02, 0x80, 0x14, 0x01, 0x10, 0x10, 0x7F, 0x00, 0x0F, 0x81, 0x04, 0x20,
  0x24, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80,
  0x64, 0x0A, 0x23, 0x20, 0x84, 0x00, 0x40, 0x08, 0x00, 0x80, 0x30, 0x04,
  0x0F, 0x80, 0x13, 0x00, 0x00, 0x00, 0x00, 0x00, 0x4C, 0x08, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x21, 0x08, 0x80, 0x00, 0x08, 0x01, 0x80,
  0x70, 0x0C, 0x01, 0x80, 0x70, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x18,
  0x0E, 0x03, 0x00, 0xC0, 0x00, 0x1F, 0x18, 0x28, 0x0A, 0x01, 0x80, 0x40,
  0x20, 0x08, 0x04, 0x01, 0x01, 0x80, 0x80, 0x40, 0x10, 0x08, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x01, 0xF8, 0x0C, 0x08, 0x20, 0x08,
  0x80, 0x12, 0x1E, 0x24, 0x42, 0x51, 0x08, 0xA2, 0x11, 0x88, 0x23, 0x10,
  0x46, 0x21, 0x0C, 0x82, 0x19, 0x04, 0x52, 0x10, 0xA4, 0x52, 0x47, 0x38,
  0x80, 0x01, 0x00, 0x01, 0x81, 0x00, 0xFC, 0x00, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x28, 0x00, 0x90, 0x04, 0x40, 0x11, 0x00, 0x84, 0x02, 0x10,
  0x10, 0x40, 0x41, 0x02, 0x02, 0x08, 0x08, 0x7F, 0xE1, 0x00, 0x88, 0x02,
  0x20, 0x09, 0x00, 0x24, 0x00, 0x60, 0x01, 0x0F, 0xE0, 0x20, 0x61, 0x00,
  0x44, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x48, 0x02, 0x20, 0x30, 0xFF,
  0x02, 0x02, 0x08, 0x04, 0x20, 0x09, 0x00, 0x24, 0x00, 0x90, 0x02, 0x40,
  0x11, 0x00, 0x44, 0x06, 0x3F, 0xE0, 0x07, 0xE0, 0x40, 0x84, 0x02, 0x40,
  0x12, 0x00, 0xA0, 0x05, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x50, 0x04, 0x80, 0x24, 0x02, 0x10,
  0x20, 0x7E, 0x00, 0x0F, 0xE0, 0x40, 0x41, 0x00, 0x84, 0x01, 0x10, 0x04,
  0x40, 0x12, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01,
  0x40, 0x05, 0x00, 0x24, 0x00, 0x90, 0x04, 0x40, 0x11, 0x00, 0x88, 0x0C,
  0x3F, 0xC0, 0x0F, 0xFE, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x7F, 0xE0, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0xFF, 0x84, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x07, 0xE0, 0x40, 0x84, 0x02, 0x40, 0x12, 0x00, 0xA0,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x07, 0xE8, 0x01,
  0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x14, 0x01, 0x10, 0x18, 0x7F, 0x00,
  0x10, 0x02, 0x20, 0x04, 0x40, 0x08, 0x80, 0x12, 0x00, 0x44, 0x00, 0x88,
  0x01, 0x10, 0x02, 0x20, 0x04, 0x7F, 0xF1, 0x00, 0x22, 0x00, 0x44, 0x00,
  0x88, 0x01, 0x10, 0x02, 0x20, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0x44,
  0x00, 0x80, 0x0F, 0xFE, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x10, 0x07, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x20, 0x04, 0x80, 0x22, 0x01, 0x04,
  0x08, 0x0F, 0xC0, 0x10, 0x02, 0x20, 0x18, 0x80, 0x61, 0x01, 0x02, 0x04,
  0x04, 0x10, 0x08, 0x40, 0x11, 0x00, 0x44, 0x00, 0x98, 0x01, 0x50, 0x03,
  0x10, 0x04, 0x10, 0x08, 0x20, 0x20, 0x20, 0x40, 0x20, 0x80, 0x41, 0x00,
  0x42, 0x00, 0x84, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x7F, 0xF0, 0x18, 0x02, 0x30,
  0x0C, 0x60, 0x18, 0xC0, 0x51, 0x41, 0x24, 0x82, 0x89, 0x09, 0x12, 0x12,
  0x24, 0x44, 0x44, 0x88, 0x8A, 0x12, 0x18, 0x44, 0x30, 0x88, 0x41, 0x10,
  0x02, 0x20, 0x04, 0x40, 0x11, 0x00, 0x22, 0x00, 0x44, 0x00, 0x80, 0x10,
  0x02, 0x30, 0x04, 0x60, 0x08, 0xA0, 0x12, 0x40, 0x44, 0x80, 0x88, 0x81,
  0x11, 0x02, 0x22, 0x04, 0x42, 0x09, 0x04, 0x22, 0x04, 0x44, 0x08, 0x88,
  0x11, 0x10, 0x12, 0x20, 0x28, 0x80, 0x51, 0x00, 0x62, 0x00, 0xC4, 0x00,
  0x80, 0x07, 0xE0, 0x40, 0x84, 0x04, 0x40, 0x12, 0x00, 0xA0, 0x05, 0x00,
  0x28, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x40, 0x0A,
  0x00, 0x50, 0x04, 0x80, 0x24, 0x02, 0x10, 0x20, 0x7E, 0x00, 0x1F, 0xE0,
  0x40, 0x61, 0x00, 0x84, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01,
  0x20, 0x09, 0x00, 0x44, 0x06, 0x1F, 0xE0, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x03, 0xF0, 0x08,
  0x10, 0x20, 0x10, 0x80, 0x22, 0x00, 0x44, 0x00, 0x48, 0x00, 0xA0, 0x01,
  0x40, 0x02, 0x80, 0x09, 0x00, 0x14, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0,
  0x02, 0x20, 0x04, 0x40, 0x10, 0x80, 0x40, 0x81, 0x00, 0xFC, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x1F, 0xC0, 0x81, 0x88, 0x02, 0x40,
  0x12, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x40, 0x12, 0x01, 0x10, 0x30,
  0xFE, 0x04, 0x08, 0x20, 0x42, 0x02, 0x10, 0x08, 0x80, 0x44, 0x01, 0x20,
  0x09, 0x00, 0x40, 0x07, 0xE0, 0x40, 0x84, 0x02, 0x40, 0x12, 0x00, 0x90,
  0x00, 0x80, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x08, 0x00, 0x50, 0x02, 0x80, 0x14, 0x01, 0x10, 0x10, 0x7F, 0x00,
  0xFF, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x40, 0x09, 0x00, 0x24, 0x00, 0x90,
  0x02, 0x40, 0x09, 0x00, 0x28, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x48,
  0x01, 0x20, 0x08, 0x80, 0x22, 0x01, 0x04, 0x08, 0x0F, 0xC0, 0x80, 0x06,
  0x00, 0x28, 0x00, 0x90, 0x04, 0x40, 0x11, 0x00, 0x84, 0x02, 0x10, 0x10,
  0x40, 0x40, 0x82, 0x02, 0x08, 0x08, 0x40, 0x21, 0x00, 0x88, 0x02, 0x20,
  0x05, 0x00, 0x14, 0x00, 0x50, 0x01, 0x80, 0x06, 0x00, 0x81, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x85, 0x0A, 0x14, 0x28, 0x50, 0xA2, 0x44, 0x89,
  0x12, 0x24, 0x49, 0x12, 0x24, 0x48, 0xA1, 0x22, 0x85, 0x0A, 0x14, 0x30,
  0x50, 0xC1, 0x83, 0x06, 0x08, 0x18, 0x20, 0x40, 0x08, 0x01, 0x84, 0x00,
  0x81, 0x00, 0x80, 0x80, 0x80, 0x20, 0x80, 0x10, 0x40, 0x04, 0x40, 0x02,
  0x40, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x28, 0x00, 0x24, 0x00,
  0x21, 0x00, 0x10, 0x80, 0x10, 0x20, 0x10, 0x10, 0x10, 0x04, 0x08, 0x02,
  0x18, 0x00, 0x80, 0x80, 0x0D, 0x00, 0x24, 0x01, 0x10, 0x08, 0x20, 0x20,
  0x81, 0x02, 0x08, 0x04, 0x20, 0x11, 0x00, 0x48, 0x00, 0xA0, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x1F, 0xFC, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x3F,
  0xFC, 0x07, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x3C, 0x00, 0x84, 0x21, 0x04, 0x21,
  0x08, 0x41, 0x08, 0x42, 0x10, 0x42, 0x10, 0x84, 0x10, 0x84, 0x0F, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04,
  0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10,
  0xF0, 0x02, 0x03, 0x02, 0x81, 0x41, 0x10, 0x88, 0x84, 0x82, 0x40, 0xC0,
  0x60, 0x20, 0xFF, 0xE0, 0xC8, 0x90, 0x07, 0xE0, 0x40, 0x84, 0x02, 0x40,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x21, 0xFF, 0x30, 0x12, 0x00, 0x90, 0x05,
  0x00, 0x24, 0x03, 0x20, 0x68, 0xFC, 0x40, 0x10, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x27, 0xC3, 0x82, 0x20, 0x12, 0x01, 0x40, 0x14,
  0x01, 0x40, 0x14, 0x01, 0x40, 0x18, 0x02, 0x80, 0x28, 0x02, 0x80, 0x4C,
  0x08, 0xBF, 0x00, 0x07, 0xC1, 0x82, 0x20, 0x12, 0x01, 0x40, 0x14, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x02, 0x40, 0x44, 0x08,
  0x3F, 0x00, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x78, 0x86, 0x1C, 0x20, 0x30, 0x80, 0x44, 0x01, 0x10, 0x04, 0x80,
  0x12, 0x00, 0x88, 0x02, 0x20, 0x08, 0x80, 0x22, 0x00, 0x88, 0x04, 0x10,
  0x30, 0x3F, 0x40, 0x07, 0xC1, 0x82, 0x20, 0x12, 0x01, 0x40, 0x18, 0x01,
  0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x24, 0x04,
  0x3F, 0x80, 0x01, 0xF8, 0x10, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x03,
  0xFF, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x00, 0x03, 0xC4, 0x30, 0xE1, 0x01, 0x84, 0x02, 0x20, 0x08, 0x80, 0x24,
  0x00, 0x90, 0x04, 0x40, 0x11, 0x00, 0x44, 0x01, 0x10, 0x04, 0x40, 0x20,
  0x81, 0x81, 0xFA, 0x00, 0x08, 0x00, 0x20, 0x01, 0x08, 0x08, 0x10, 0x40,
  0x3E, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x4F, 0x82, 0x82, 0x28, 0x09, 0x80, 0x48, 0x02, 0x40, 0x12, 0x00, 0x90,
  0x05, 0x00, 0x28, 0x02, 0x40, 0x12, 0x00, 0x90, 0x04, 0x80, 0x28, 0x01,
  0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x10, 0x7F, 0xF0, 0x00, 0x18, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x07, 0xC0, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x24,
  0x06, 0x20, 0x41, 0x04, 0x08, 0xC0, 0x88, 0x04, 0x80, 0x3A, 0x01, 0x10,
  0x08, 0x40, 0x41, 0x04, 0x04, 0x20, 0x21, 0x00, 0x88, 0x02, 0x00, 0x1F,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x0F, 0xFE, 0x2F, 0x1E, 0x30, 0xA1, 0x20, 0xC1, 0x20, 0x81,
  0x40, 0x81, 0x40, 0x81, 0x40, 0x82, 0x40, 0x82, 0x41, 0x02, 0x41, 0x02,
  0x81, 0x02, 0x81, 0x02, 0x81, 0x04, 0x82, 0x04, 0x82, 0x04, 0x13, 0xE0,
  0xA0, 0x8A, 0x02, 0x60, 0x12, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x40,
  0x12, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x20, 0x0A, 0x00, 0x80, 0x0F,
  0xC0, 0x81, 0x08, 0x04, 0x80, 0x24, 0x01, 0x40, 0x06, 0x00, 0x30, 0x02,
  0x80, 0x14, 0x00, 0xA0, 0x09, 0x00, 0x48, 0x04, 0x20, 0x40, 0xFC, 0x00,
  0x13, 0xE0, 0xE0, 0x84, 0x04, 0x60, 0x12, 0x00, 0x90, 0x04, 0x80, 0x24,
  0x01, 0x40, 0x0A, 0x00, 0x90, 0x04, 0x80, 0x24, 0x02, 0x30, 0x22, 0x7E,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x00, 0x07,
  0x88, 0xC3, 0x88, 0x0C, 0x40, 0x24, 0x01, 0x20, 0x0A, 0x00, 0x50, 0x04,
  0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0x48, 0x04, 0x20, 0x60, 0xFD, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x23, 0xE5,
  0x80, 0xC0, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x00, 0x0F, 0xC1, 0x03, 0x20, 0x12,
  0x01, 0x20, 0x02, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x02, 0x00, 0x28,
  0x02, 0x80, 0x24, 0x04, 0x3F, 0x80, 0x08, 0x02, 0x00, 0x80, 0x20, 0xFF,
  0xC2, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x01, 0xF0, 0x20, 0x09, 0x00, 0x50, 0x04, 0x80,
  0x24, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02, 0x80, 0x24, 0x01, 0x20, 0x09,
  0x00, 0x48, 0x06, 0x20, 0x50, 0xFD, 0x00, 0x80, 0x0C, 0x00, 0xA0, 0x09,
  0x00, 0x44, 0x04, 0x20, 0x21, 0x02, 0x08, 0x10, 0x21, 0x01, 0x10, 0x08,
  0x80, 0x48, 0x01, 0x40, 0x0C, 0x00, 0x60, 0x00, 0x81, 0x03, 0x06, 0x0A,
  0x0C, 0x14, 0x18, 0x48, 0x50, 0x90, 0xA1, 0x22, 0x44, 0x44, 0x88, 0x91,
  0x21, 0x21, 0x41, 0x42, 0x83, 0x06, 0x06, 0x0C, 0x08, 0x10, 0x10, 0x20,
  0x00, 0x20, 0x04, 0x40, 0x20, 0x81, 0x02, 0x08, 0x04, 0x40, 0x0B, 0x00,
  0x28, 0x00, 0x40, 0x03, 0x00, 0x12, 0x00, 0x84, 0x04, 0x10, 0x20, 0x21,
  0x00, 0x88, 0x01, 0x00, 0x20, 0x01, 0x10, 0x01, 0x10, 0x02, 0x10, 0x04,
  0x10, 0x04, 0x08, 0x08, 0x08, 0x10, 0x08, 0x10, 0x04, 0x20, 0x04, 0x20,
  0x04, 0x40, 0x04, 0x80, 0x02, 0x80, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x20, 0x18, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x38, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x20, 0x03, 0x00, 0x11, 0x11, 0x11, 0x22, 0x22, 0x22, 0x24, 0x44,
  0x44, 0x48, 0x88, 0x88, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x18, 0x0C, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x00, 0x18, 0x00, 0xC8, 0x06, 0x0C,
  0x14, 0x0C, 0x48, 0x07, 0x00,
};

const GFXglyph RobotoMono_ThinItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 20, 16, 6, -20 },
  { 11, 5, 6, 16, 7, -21 },
  { 15, 17, 20, 16, 0, -20 },
  { 58, 13, 26, 16, 2, -23 },
  { 101, 13, 20, 16, 2, -20 },
  { 134, 14, 20, 16, 1, -20 },
  { 169, 2, 6, 16, 8, -21 },
  { 171, 8, 28, 16, 5, -22 },
  { 199, 8, 28, 16, 3, -22 },
  { 227, 12, 11, 16, 4, -20 },
  { 244, 13, 14, 16, 2, -16 },
  { 267, 2, 5, 16, 4, -2 },
  { 269, 10, 1, 16, 3, -10 },
  { 271, 2, 2, 16, 6, -2 },
  { 272, 13, 22, 16, 2, -20 },
  { 308, 13, 20, 16, 2, -20 },
  { 341, 7, 20, 16, 4, -20 },
  { 359, 13, 20, 16, 1, -20 },
  { 392, 13, 20, 16, 1, -20 },
  { 425, 13, 20, 16, 1, -20 },
  { 458, 13, 20, 16, 3, -20 },
  { 491, 12, 20, 16, 2, -20 },
  { 521, 12, 20, 16, 4, -20 },
  { 551, 13, 20, 16, 2, -20 },
  { 584, 12, 20, 16, 3, -20 },
  { 614, 4, 14, 16, 7, -14 },
  { 621, 5, 17, 16, 6, -14 },
  { 632, 13, 11, 16, 2, -15 },
  { 650, 13, 6, 16, 2, -12 },
  { 660, 12, 11, 16, 2, -15 },
  { 677, 10, 20, 16, 5, -20 },
  { 702, 15, 20, 16, 1, -20 },
  { 740, 14, 20, 16, 0, -20 },
  { 775, 14, 20, 16, 1, -20 },
  { 810, 13, 20, 16, 2, -20 },
  { 843, 14, 20, 16, 1, -20 },
  { 878, 15, 20, 16, 1, -20 },
  { 916, 14, 20, 16, 2, -20 },
  { 951, 13, 20, 16, 2, -20 },
  { 984, 15, 20, 16, 1, -20 },
  { 1022, 15, 20, 16, 1, -20 },
  { 1060, 14, 20, 16, 1, -20 },
  { 1095, 15, 20, 16, 2, -20 },
  { 1133, 11, 20, 16, 2, -20 },
  { 1161, 15, 20, 16, 1, -20 },
  { 1199, 15, 20, 16, 1, -20 },
  { 1237, 13, 20, 16, 2, -20 },
  { 1270, 14, 20, 16, 2, -20 },
  { 1305, 15, 24, 16, 1, -20 },
  { 1350, 13, 20, 16, 2, -20 },
  { 1383, 13, 20, 16, 2, -20 },
  { 1416, 14, 20, 16, 3, -20 },
  { 1451, 14, 20, 16, 2, -20 },
  { 1486, 14, 20, 16, 3, -20 },
  { 1521, 14, 20, 16, 3, -20 },
  { 1556, 17, 20, 16, 0, -20 },
  { 1599, 14, 20, 16, 3, -20 },
  { 1634, 14, 20, 16, 1, -20 },
  { 1669, 9, 27, 16, 4, -23 },
  { 1700, 5, 22, 16, 6, -20 },
  { 1714, 8, 27, 16, 4, -23 },
  { 1741, 9, 11, 16, 4, -20 },
  { 1754, 11, 1, 16, 1, 0 },
  { 1756, 3, 4, 16, 8, -21 },
  { 1758, 13, 15, 16, 1, -15 },
  { 1783, 12, 21, 16, 2, -21 },
  { 1815, 12, 15, 16, 2, -15 },
  { 1838, 14, 21, 16, 2, -21 },
  { 1875, 12, 15, 16, 2, -15 },
  { 1898, 13, 21, 16, 4, -21 },
  { 1933, 14, 21, 16, 1, -15 },
  { 1970, 13, 21, 16, 1, -21 },
  { 2005, 11, 20, 16, 2, -20 },
  { 2033, 13, 26, 16, 0, -20 },
  { 2076, 13, 21, 16, 2, -21 },
  { 2111, 11, 21, 16, 2, -21 },
  { 2140, 16, 15, 16, 0, -15 },
  { 2170, 13, 15, 16, 1, -15 },
  { 2195, 13, 15, 16, 2, -15 },
  { 2220, 13, 21, 16, 1, -15 },
  { 2255, 13, 21, 16, 2, -15 },
  { 2290, 11, 15, 16, 4, -15 },
  { 2311, 12, 15, 16, 2, -15 },
  { 2334, 10, 19, 16, 4, -19 },
  { 2358, 13, 15, 16, 2, -15 },
  { 2383, 13, 15, 16, 3, -15 },
  { 2408, 15, 15, 16, 2, -15 },
  { 2437, 14, 15, 16, 1, -15 },
  { 2464, 16, 21, 16, 0, -15 },
  { 2506, 14, 15, 16, 1, -15 },
  { 2533, 11, 28, 16, 4, -22 },
  { 2572, 4, 24, 16, 6, -20 },
  { 2584, 11, 28, 16, 2, -22 },
  { 2623, 15, 5, 16, 1, -11 },
};

const GFXfont RobotoMono_ThinItalic28pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic28pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic28pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _ROBOTOMONO_THINITALIC28PT7B_H_
