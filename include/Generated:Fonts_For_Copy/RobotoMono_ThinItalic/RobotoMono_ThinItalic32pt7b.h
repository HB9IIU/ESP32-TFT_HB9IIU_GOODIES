#ifndef _ROBOTOMONO_THINITALIC32PT7B_H_
#define _ROBOTOMONO_THINITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x44, 0x21, 0x08, 0x42, 0x21, 0x08, 0x42, 0x21, 0x08, 0x40,
  0x00, 0x00, 0x42, 0x00, 0x45, 0x14, 0x52, 0x8A, 0x20, 0x00, 0x20, 0x80,
  0x04, 0x10, 0x01, 0x02, 0x00, 0x20, 0x80, 0x04, 0x10, 0x01, 0x02, 0x00,
  0x20, 0x80, 0xFF, 0xFF, 0x01, 0x02, 0x00, 0x20, 0x80, 0x04, 0x10, 0x01,
  0x02, 0x00, 0x20, 0x80, 0x04, 0x10, 0x01, 0x02, 0x00, 0x20, 0x80, 0xFF,
  0xFF, 0x01, 0x04, 0x00, 0x20, 0x80, 0x08, 0x10, 0x01, 0x04, 0x00, 0x20,
  0x80, 0x08, 0x10, 0x00, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x0F, 0xC0,
  0x60, 0x41, 0x00, 0x82, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x04, 0x40,
  0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x28, 0x00, 0x50, 0x01, 0x10, 0x02, 0x20,
  0x08, 0x20, 0x20, 0x3F, 0x80, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x1C,
  0x00, 0x44, 0x01, 0x04, 0x04, 0x08, 0x28, 0x10, 0x90, 0x42, 0x20, 0x84,
  0x41, 0x10, 0x84, 0x40, 0xF0, 0x80, 0x82, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x47, 0x81, 0x10, 0x84, 0x21, 0x08, 0x82, 0x21, 0x04, 0x82, 0x09, 0x04,
  0x14, 0x08, 0x40, 0x10, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0x08, 0x02,
  0x08, 0x04, 0x08, 0x04, 0x08, 0x04, 0x08, 0x04, 0x10, 0x04, 0x20, 0x04,
  0x40, 0x02, 0x80, 0x03, 0x00, 0x05, 0x00, 0x08, 0x80, 0x10, 0x81, 0x20,
  0x41, 0x40, 0x21, 0x40, 0x22, 0x40, 0x12, 0x40, 0x14, 0x40, 0x08, 0x40,
  0x14, 0x20, 0x24, 0x1F, 0x82, 0x55, 0x70, 0x00, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x20,
  0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x0C, 0x06, 0x02, 0x00, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x41, 0x07, 0xC4, 0xE0, 0xFC, 0x00,
  0xC0, 0x05, 0x00, 0x22, 0x01, 0x04, 0x08, 0x10, 0x60, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x24, 0xA5, 0x00, 0xFF, 0xE0, 0x70,
  0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x00, 0x01, 0xF0, 0x0C, 0x10,
  0x20, 0x10, 0x40, 0x11, 0x00, 0x24, 0x00, 0x48, 0x01, 0x90, 0x05, 0x40,
  0x12, 0x80, 0x45, 0x01, 0x0A, 0x0C, 0x14, 0x20, 0x48, 0x80, 0xA2, 0x01,
  0x48, 0x02, 0xA0, 0x09, 0x80, 0x12, 0x00, 0x22, 0x00, 0x84, 0x02, 0x04,
  0x08, 0x07, 0xE0, 0x00, 0x01, 0x07, 0x39, 0xC1, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x10, 0x10, 0x03, 0xF0, 0x08, 0x10, 0x20, 0x10, 0x80, 0x22, 0x00,
  0x24, 0x00, 0x48, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xF0, 0x0C, 0x18, 0x20, 0x08, 0x80, 0x11, 0x00, 0x24, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x1E, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x05, 0x00, 0x0A, 0x00, 0x24, 0x00,
  0x44, 0x01, 0x0C, 0x04, 0x07, 0xF0, 0x00, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x50, 0x00, 0xA0, 0x02, 0x40, 0x09, 0x00, 0x22, 0x00, 0x84, 0x02, 0x08,
  0x04, 0x10, 0x10, 0x20, 0x40, 0x81, 0x01, 0x04, 0x02, 0x18, 0x04, 0x20,
  0x08, 0xFF, 0xFE, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x07, 0xFE, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x5F, 0xC0, 0xC0, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x09, 0x00,
  0x12, 0x00, 0x44, 0x00, 0x84, 0x02, 0x08, 0x08, 0x0F, 0xE0, 0x00, 0x00,
  0x78, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x27, 0xC1, 0x20, 0xC7, 0x00, 0x90, 0x02, 0x40, 0x0A, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x0A, 0x00, 0x28, 0x00, 0x90, 0x04, 0x40, 0x20,
  0x81, 0x01, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF8, 0x06,
  0x04, 0x08, 0x02, 0x08, 0x02, 0x10, 0x01, 0x10, 0x01, 0x20, 0x02, 0x20,
  0x02, 0x10, 0x04, 0x10, 0x0C, 0x0C, 0x30, 0x07, 0xE0, 0x18, 0x10, 0x20,
  0x08, 0x40, 0x04, 0x40, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x08, 0x40, 0x18, 0x60, 0x30, 0x1F, 0xC0, 0x07, 0xE0, 0x20, 0x41, 0x00,
  0x88, 0x02, 0x40, 0x05, 0x00, 0x14, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xA0, 0x02, 0x40, 0x19, 0x80, 0xA3, 0x0C, 0x83, 0xC4, 0x00,
  0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x07, 0xC0, 0x00,
  0x10, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x18, 0x04, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x10,
  0x20, 0x41, 0x04, 0x00, 0x00, 0x04, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C,
  0x01, 0xC0, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0,
  0x18, 0x00, 0x80, 0x00, 0x0F, 0x81, 0x06, 0x20, 0x24, 0x01, 0x80, 0x18,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x30, 0x00, 0x00, 0x7C, 0x00, 0x60, 0xC0, 0x60, 0x08, 0x30, 0x02,
  0x18, 0x00, 0x84, 0x3E, 0x12, 0x10, 0x84, 0x88, 0x21, 0x42, 0x08, 0x51,
  0x04, 0x18, 0x41, 0x0A, 0x20, 0x42, 0x88, 0x10, 0xA2, 0x08, 0x28, 0x82,
  0x12, 0x21, 0x84, 0x88, 0xA2, 0x22, 0x69, 0x88, 0x20, 0x82, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x0C, 0x01, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x28, 0x00, 0x28, 0x00, 0x48, 0x00, 0x48, 0x00, 0x88, 0x00, 0x88, 0x01,
  0x04, 0x01, 0x04, 0x02, 0x04, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08,
  0x04, 0x0F, 0xFE, 0x10, 0x02, 0x10, 0x02, 0x20, 0x02, 0x20, 0x02, 0x40,
  0x02, 0x40, 0x02, 0x80, 0x01, 0x0F, 0xE0, 0x20, 0x30, 0x40, 0x10, 0x80,
  0x11, 0x00, 0x22, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x04, 0x40, 0x10,
  0x80, 0xC1, 0xFF, 0x04, 0x01, 0x88, 0x01, 0x10, 0x01, 0x20, 0x02, 0x40,
  0x04, 0x80, 0x0A, 0x00, 0x14, 0x00, 0x48, 0x01, 0x10, 0x0C, 0x3F, 0xE0,
  0x00, 0x01, 0xF0, 0x06, 0x0C, 0x08, 0x04, 0x10, 0x02, 0x10, 0x02, 0x20,
  0x02, 0x20, 0x01, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x04, 0x80,
  0x08, 0x80, 0x08, 0x40, 0x10, 0x40, 0x30, 0x20, 0x60, 0x1F, 0x80, 0x0F,
  0xF0, 0x04, 0x06, 0x02, 0x01, 0x81, 0x00, 0x40, 0x80, 0x10, 0x80, 0x08,
  0x40, 0x04, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x48, 0x00, 0x44, 0x00,
  0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x40, 0x04, 0x40, 0x02, 0x20,
  0x02, 0x10, 0x01, 0x08, 0x01, 0x04, 0x01, 0x02, 0x03, 0x03, 0xFE, 0x00,
  0x0F, 0xFF, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x3F, 0xF8,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x3F, 0xF8, 0x20, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x01, 0xF0, 0x06, 0x0C,
  0x08, 0x06, 0x10, 0x02, 0x10, 0x02, 0x20, 0x01, 0x20, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x02, 0x80, 0xFC,
  0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x40, 0x08,
  0x40, 0x08, 0x20, 0x30, 0x1F, 0xC0, 0x08, 0x00, 0x84, 0x00, 0x42, 0x00,
  0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x08, 0x40, 0x04, 0x20, 0x02, 0x20,
  0x01, 0x10, 0x00, 0x88, 0x00, 0x47, 0xFF, 0xC2, 0x00, 0x21, 0x00, 0x11,
  0x00, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x02, 0x10, 0x01, 0x08, 0x00,
  0x88, 0x00, 0x44, 0x00, 0x22, 0x00, 0x10, 0x1F, 0xFF, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x04, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x40, 0x04, 0x20, 0x02, 0x08, 0x02, 0x04,
  0x01, 0x01, 0x03, 0x00, 0x7E, 0x00, 0x08, 0x00, 0x88, 0x00, 0x84, 0x00,
  0x82, 0x00, 0x81, 0x00, 0x80, 0x80, 0x80, 0x40, 0x80, 0x40, 0x80, 0x21,
  0x80, 0x11, 0x80, 0x09, 0x80, 0x05, 0xC0, 0x03, 0x10, 0x03, 0x08, 0x01,
  0x02, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x08, 0x10, 0x02,
  0x08, 0x00, 0x84, 0x00, 0x42, 0x00, 0x10, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x03, 0xFF, 0xE0, 0x08, 0x00, 0xC3,
  0x00, 0x60, 0xC0, 0x18, 0x50, 0x0A, 0x14, 0x02, 0x85, 0x01, 0x21, 0x20,
  0x48, 0x48, 0x24, 0x12, 0x09, 0x08, 0x84, 0x42, 0x22, 0x10, 0x84, 0x84,
  0x21, 0x42, 0x08, 0x50, 0x82, 0x18, 0x21, 0x02, 0x08, 0x40, 0x02, 0x10,
  0x00, 0x84, 0x00, 0x41, 0x00, 0x10, 0x40, 0x04, 0x20, 0x01, 0x08, 0x00,
  0x40, 0x08, 0x00, 0x84, 0x00, 0x43, 0x00, 0x22, 0x80, 0x11, 0x20, 0x08,
  0x90, 0x08, 0x48, 0x04, 0x22, 0x02, 0x21, 0x01, 0x10, 0x80, 0x88, 0x20,
  0x44, 0x10, 0x42, 0x04, 0x21, 0x02, 0x11, 0x01, 0x08, 0x80, 0x44, 0x40,
  0x22, 0x20, 0x12, 0x10, 0x05, 0x08, 0x02, 0x88, 0x00, 0xC4, 0x00, 0x62,
  0x00, 0x20, 0x01, 0xF0, 0x0C, 0x10, 0x20, 0x10, 0x80, 0x11, 0x00, 0x24,
  0x00, 0x48, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x12,
  0x00, 0x22, 0x00, 0x84, 0x02, 0x04, 0x08, 0x07, 0xE0, 0x00, 0x0F, 0xF0,
  0x08, 0x0C, 0x08, 0x02, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01,
  0x10, 0x01, 0x20, 0x01, 0x20, 0x02, 0x20, 0x06, 0x20, 0x0C, 0x3F, 0xF0,
  0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x01, 0xF0, 0x06, 0x0C,
  0x08, 0x04, 0x10, 0x02, 0x20, 0x02, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01,
  0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x10,
  0x40, 0x10, 0x20, 0x60, 0x1F, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x10, 0x0F, 0xE0, 0x10, 0x18, 0x10, 0x04, 0x10, 0x02, 0x10, 0x02,
  0x10, 0x02, 0x10, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x04, 0x20, 0x08,
  0x20, 0x10, 0x3F, 0xE0, 0x40, 0x40, 0x40, 0x40, 0x40, 0x20, 0x40, 0x20,
  0x40, 0x20, 0x40, 0x10, 0x80, 0x10, 0x80, 0x10, 0x80, 0x08, 0x80, 0x08,
  0x01, 0xF0, 0x06, 0x0C, 0x08, 0x02, 0x10, 0x02, 0x20, 0x01, 0x20, 0x01,
  0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x80, 0x04,
  0x80, 0x04, 0x80, 0x08, 0x40, 0x08, 0x60, 0x30, 0x1F, 0xC0, 0xFF, 0xFE,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x04, 0x00, 0x00, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01,
  0x20, 0x01, 0x20, 0x01, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x80, 0x04,
  0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x08, 0x40, 0x10, 0x40, 0x20,
  0x20, 0x40, 0x1F, 0x80, 0x80, 0x03, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x28,
  0x00, 0x90, 0x01, 0x10, 0x04, 0x20, 0x08, 0x40, 0x20, 0x80, 0x41, 0x01,
  0x02, 0x02, 0x02, 0x08, 0x04, 0x10, 0x08, 0x40, 0x10, 0x80, 0x22, 0x00,
  0x44, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x03, 0x00, 0x06, 0x00, 0x00,
  0x81, 0x01, 0x81, 0x01, 0x81, 0x02, 0x83, 0x02, 0x83, 0x02, 0x85, 0x04,
  0x85, 0x04, 0x85, 0x04, 0x89, 0x08, 0x88, 0x88, 0x88, 0x88, 0x90, 0x90,
  0x90, 0x90, 0x90, 0x90, 0xA0, 0x90, 0xA0, 0xA0, 0xA0, 0xA0, 0xC0, 0xA0,
  0xC0, 0xC0, 0xC0, 0xC0, 0x80, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x08, 0x00,
  0x20, 0x80, 0x08, 0x10, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x02, 0x04,
  0x00, 0x41, 0x00, 0x04, 0x60, 0x00, 0x88, 0x00, 0x0A, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x01, 0x40, 0x00, 0x44, 0x00, 0x10, 0x80,
  0x04, 0x08, 0x00, 0x81, 0x00, 0x20, 0x10, 0x08, 0x02, 0x02, 0x00, 0x20,
  0x40, 0x04, 0x30, 0x00, 0x40, 0x80, 0x03, 0x00, 0x0A, 0x00, 0x12, 0x00,
  0x44, 0x01, 0x08, 0x02, 0x08, 0x08, 0x10, 0x20, 0x20, 0x80, 0x21, 0x00,
  0x44, 0x00, 0x90, 0x00, 0xA0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0xFF, 0xF8, 0x07,
  0x82, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x03, 0xE0, 0x84, 0x21,
  0x08, 0x21, 0x08, 0x42, 0x08, 0x42, 0x10, 0x82, 0x10, 0x84, 0x20, 0x84,
  0x21, 0x08, 0x0F, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x83,
  0xC0, 0x01, 0x00, 0x60, 0x0A, 0x02, 0x40, 0x48, 0x11, 0x02, 0x10, 0x82,
  0x20, 0x44, 0x09, 0x01, 0x20, 0x18, 0x02, 0xFF, 0xF8, 0x91, 0x30, 0x07,
  0xF0, 0x20, 0x21, 0x00, 0x48, 0x01, 0x20, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x1D, 0x1F, 0x88, 0x80, 0x24, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x48,
  0x03, 0x30, 0x34, 0x3F, 0x10, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0xF8, 0x2C, 0x18, 0xC0, 0x22, 0x00,
  0x48, 0x01, 0x20, 0x05, 0x00, 0x14, 0x00, 0x50, 0x01, 0x40, 0x05, 0x00,
  0x24, 0x00, 0xA0, 0x02, 0x80, 0x13, 0x00, 0x8A, 0x04, 0x27, 0xE0, 0x03,
  0xF0, 0x30, 0x21, 0x00, 0x48, 0x01, 0x20, 0x05, 0x00, 0x14, 0x00, 0x10,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x09, 0x00, 0x44,
  0x01, 0x08, 0x18, 0x1F, 0x80, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x07, 0xE2, 0x08, 0x14, 0x10,
  0x0C, 0x20, 0x04, 0x20, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x08, 0x80,
  0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x10, 0x40, 0x10, 0x40,
  0x30, 0x20, 0x50, 0x1F, 0x90, 0x03, 0xF0, 0x30, 0x21, 0x00, 0x48, 0x01,
  0x20, 0x05, 0x00, 0x14, 0x00, 0x5F, 0xFF, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x01, 0x08, 0x0C, 0x1F, 0xC0, 0x00,
  0x7E, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x7F, 0xFC, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x03, 0xF1, 0x04, 0x0A,
  0x08, 0x06, 0x10, 0x02, 0x10, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x04,
  0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x20, 0x08,
  0x20, 0x18, 0x10, 0x28, 0x0F, 0xC8, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10,
  0x80, 0x20, 0x40, 0x40, 0x20, 0x80, 0x1F, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0xFC, 0x24, 0x08,
  0xA0, 0x13, 0x00, 0x48, 0x01, 0x20, 0x05, 0x00, 0x14, 0x00, 0x50, 0x01,
  0x40, 0x09, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x01,
  0x20, 0x04, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x01, 0x03, 0xFF, 0xE0, 0x00, 0x04, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x60, 0x1F, 0x00,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x03, 0x10, 0x0C, 0x20, 0x20, 0x40, 0x81, 0x06, 0x02,
  0x10, 0x04, 0x40, 0x0B, 0x00, 0x19, 0x00, 0x21, 0x00, 0x82, 0x01, 0x02,
  0x02, 0x02, 0x04, 0x04, 0x08, 0x04, 0x20, 0x04, 0x40, 0x0C, 0x0F, 0xE0,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x1F,
  0xFF, 0x27, 0x8F, 0x8A, 0x14, 0x13, 0x02, 0x04, 0x80, 0x81, 0x20, 0x40,
  0x48, 0x10, 0x14, 0x04, 0x05, 0x01, 0x02, 0x40, 0x40, 0x90, 0x20, 0x24,
  0x08, 0x09, 0x02, 0x02, 0x80, 0x80, 0xA0, 0x20, 0x48, 0x08, 0x12, 0x04,
  0x04, 0x81, 0x01, 0x00, 0x23, 0xF0, 0x90, 0x22, 0x80, 0x4C, 0x01, 0x20,
  0x04, 0x80, 0x14, 0x00, 0x50, 0x01, 0x40, 0x05, 0x00, 0x24, 0x00, 0xA0,
  0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x04, 0x80, 0x10, 0x07, 0xE0,
  0x10, 0x30, 0x40, 0x21, 0x00, 0x24, 0x00, 0x48, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x28, 0x00, 0x90, 0x02,
  0x10, 0x0C, 0x10, 0x30, 0x1F, 0x80, 0x11, 0xF0, 0x2C, 0x18, 0x60, 0x10,
  0x80, 0x11, 0x00, 0x22, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40,
  0x04, 0x80, 0x11, 0x00, 0x24, 0x00, 0x48, 0x01, 0x18, 0x04, 0x28, 0x10,
  0x4F, 0xC0, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x07, 0xE2, 0x10, 0x28, 0x40, 0x31, 0x00, 0x22, 0x00,
  0x48, 0x00, 0x90, 0x01, 0x20, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x24,
  0x00, 0x48, 0x01, 0x08, 0x02, 0x10, 0x0C, 0x10, 0x28, 0x1F, 0x90, 0x00,
  0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x10, 0xFC, 0x4C, 0x01, 0x40, 0x06, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x00, 0x07, 0xF0, 0x10, 0x10, 0x40, 0x11,
  0x00, 0x22, 0x00, 0x24, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x40, 0x00, 0x90, 0x01, 0x10, 0x02, 0x30, 0x18,
  0x1F, 0xC0, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFF, 0xF0, 0x40, 0x04,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x0F, 0xC0, 0x40, 0x05,
  0x00, 0x14, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x28, 0x00, 0xA0, 0x02,
  0x80, 0x12, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x88, 0x06,
  0x30, 0x28, 0x7F, 0x20, 0x80, 0x03, 0x00, 0x09, 0x00, 0x12, 0x00, 0x44,
  0x01, 0x08, 0x02, 0x08, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0x80, 0x42,
  0x00, 0x88, 0x01, 0x10, 0x02, 0x40, 0x02, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x80, 0x80, 0xC0, 0x40, 0x50, 0x60, 0x48, 0x30, 0x24, 0x28, 0x22, 0x12,
  0x11, 0x09, 0x08, 0x88, 0x88, 0x44, 0x44, 0x24, 0x24, 0x12, 0x12, 0x09,
  0x09, 0x05, 0x05, 0x02, 0x82, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0x40, 0x20,
  0x00, 0x10, 0x01, 0x84, 0x01, 0x02, 0x01, 0x00, 0x81, 0x00, 0x21, 0x80,
  0x11, 0x80, 0x05, 0x80, 0x02, 0x80, 0x00, 0x80, 0x00, 0xA0, 0x00, 0x90,
  0x00, 0x84, 0x00, 0x83, 0x00, 0x80, 0x80, 0x80, 0x20, 0x80, 0x10, 0x80,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x80, 0x02, 0x08, 0x00, 0x40, 0x40, 0x0C,
  0x04, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x20, 0x20, 0x02, 0x06,
  0x00, 0x20, 0x40, 0x02, 0x08, 0x00, 0x10, 0x80, 0x01, 0x10, 0x00, 0x12,
  0x00, 0x00, 0xA0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xFF, 0xFE,
  0x00, 0x10, 0x06, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x0E, 0x00,
  0xE0, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x30,
  0x08, 0x42, 0x21, 0x08, 0x42, 0x11, 0x08, 0x42, 0x10, 0x84, 0x42, 0x10,
  0x84, 0x22, 0x10, 0x84, 0x20, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x80, 0x07, 0x00, 0x70, 0x08, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x60, 0x08, 0x00, 0x3E, 0x00, 0xA0, 0x80, 0x50, 0x20, 0x50,
  0x08, 0x48, 0x03, 0xC0,
};

const GFXglyph RobotoMono_ThinItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 23, 19, 7, -23 },
  { 16, 6, 6, 19, 8, -24 },
  { 21, 19, 23, 19, 0, -23 },
  { 76, 15, 29, 19, 2, -26 },
  { 131, 15, 23, 19, 2, -23 },
  { 175, 16, 23, 19, 1, -23 },
  { 221, 2, 6, 19, 9, -24 },
  { 223, 9, 32, 19, 6, -25 },
  { 259, 10, 32, 19, 3, -25 },
  { 299, 14, 13, 19, 4, -23 },
  { 322, 15, 17, 19, 2, -19 },
  { 354, 3, 6, 19, 4, -2 },
  { 357, 11, 1, 19, 4, -11 },
  { 359, 2, 2, 19, 7, -2 },
  { 360, 14, 25, 19, 3, -23 },
  { 404, 15, 23, 19, 2, -23 },
  { 448, 8, 23, 19, 5, -23 },
  { 471, 15, 23, 19, 1, -23 },
  { 515, 15, 23, 19, 1, -23 },
  { 559, 15, 23, 19, 1, -23 },
  { 603, 15, 23, 19, 3, -23 },
  { 647, 14, 23, 19, 2, -23 },
  { 688, 14, 23, 19, 4, -23 },
  { 729, 16, 23, 19, 2, -23 },
  { 775, 14, 23, 19, 3, -23 },
  { 816, 5, 16, 19, 8, -16 },
  { 826, 7, 20, 19, 6, -16 },
  { 844, 14, 13, 19, 3, -17 },
  { 867, 15, 7, 19, 2, -14 },
  { 881, 14, 13, 19, 2, -17 },
  { 904, 12, 23, 19, 5, -23 },
  { 939, 18, 23, 19, 1, -23 },
  { 991, 16, 23, 19, 0, -23 },
  { 1037, 15, 23, 19, 2, -23 },
  { 1081, 16, 23, 19, 2, -23 },
  { 1127, 17, 23, 19, 1, -23 },
  { 1176, 16, 23, 19, 2, -23 },
  { 1222, 16, 23, 19, 2, -23 },
  { 1268, 16, 23, 19, 2, -23 },
  { 1314, 17, 23, 19, 1, -23 },
  { 1363, 16, 23, 19, 2, -23 },
  { 1409, 17, 23, 19, 1, -23 },
  { 1458, 17, 23, 19, 2, -23 },
  { 1507, 13, 23, 19, 2, -23 },
  { 1545, 18, 23, 19, 1, -23 },
  { 1597, 17, 23, 19, 1, -23 },
  { 1646, 15, 23, 19, 2, -23 },
  { 1690, 16, 23, 19, 2, -23 },
  { 1736, 16, 27, 19, 2, -23 },
  { 1790, 16, 23, 19, 2, -23 },
  { 1836, 16, 23, 19, 2, -23 },
  { 1882, 15, 23, 19, 4, -23 },
  { 1926, 16, 23, 19, 2, -23 },
  { 1972, 15, 23, 19, 4, -23 },
  { 2016, 16, 23, 19, 4, -23 },
  { 2062, 19, 23, 19, 0, -23 },
  { 2117, 15, 23, 19, 4, -23 },
  { 2161, 16, 23, 19, 1, -23 },
  { 2207, 9, 31, 19, 5, -26 },
  { 2242, 5, 25, 19, 7, -23 },
  { 2258, 9, 31, 19, 5, -26 },
  { 2293, 11, 13, 19, 4, -23 },
  { 2311, 13, 1, 19, 1, 0 },
  { 2313, 3, 4, 19, 10, -24 },
  { 2315, 14, 17, 19, 2, -17 },
  { 2345, 14, 24, 19, 2, -24 },
  { 2387, 14, 17, 19, 2, -17 },
  { 2417, 16, 24, 19, 2, -24 },
  { 2465, 14, 17, 19, 2, -17 },
  { 2495, 15, 24, 19, 4, -24 },
  { 2540, 16, 24, 19, 1, -17 },
  { 2588, 14, 24, 19, 2, -24 },
  { 2630, 13, 23, 19, 2, -23 },
  { 2668, 15, 30, 19, 0, -23 },
  { 2725, 15, 24, 19, 2, -24 },
  { 2770, 13, 24, 19, 2, -24 },
  { 2809, 18, 17, 19, 0, -17 },
  { 2848, 14, 17, 19, 2, -17 },
  { 2878, 15, 17, 19, 2, -17 },
  { 2910, 15, 24, 19, 1, -17 },
  { 2955, 15, 24, 19, 2, -17 },
  { 3000, 14, 17, 19, 4, -17 },
  { 3030, 15, 17, 19, 2, -17 },
  { 3062, 12, 21, 19, 4, -21 },
  { 3094, 14, 17, 19, 3, -17 },
  { 3124, 15, 17, 19, 3, -17 },
  { 3156, 17, 17, 19, 2, -17 },
  { 3193, 17, 17, 19, 1, -17 },
  { 3230, 20, 24, 19, -1, -17 },
  { 3290, 16, 17, 19, 1, -17 },
  { 3324, 12, 32, 19, 5, -25 },
  { 3372, 5, 27, 19, 7, -23 },
  { 3389, 12, 32, 19, 3, -25 },
  { 3437, 17, 5, 19, 1, -12 },
};

const GFXfont RobotoMono_ThinItalic32pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic32pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _ROBOTOMONO_THINITALIC32PT7B_H_
