#ifndef _ROBOTOMONO_THINITALIC7PT7B_H_
#define _ROBOTOMONO_THINITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x80, 0x80, 0x37, 0x6F, 0xA0, 0x25, 0x42, 0x1A, 0x40, 0xDE,
  0x25, 0xB0, 0x66, 0x4B, 0xF0, 0x80, 0x5A, 0xA9, 0x95, 0x5A, 0x5E, 0x80,
  0x2B, 0x44, 0xC0, 0xC0, 0x00, 0x29, 0x48, 0xF7, 0xDC, 0xD5, 0x80, 0x64,
  0xAE, 0x71, 0x61, 0xE0, 0x22, 0x6F, 0x20, 0xF8, 0x9C, 0x6A, 0xDE, 0xE5,
  0x48, 0x75, 0x69, 0xE0, 0xF6, 0xBC, 0x80, 0x4A, 0x71, 0x00, 0x7E, 0x43,
  0xE0, 0xE5, 0x48, 0x7F, 0xBB, 0xE0, 0x2D, 0xBA, 0x75, 0x69, 0xE0, 0x79,
  0x89, 0xE0, 0x79, 0x99, 0xE0, 0x74, 0x68, 0xE0, 0x74, 0x68, 0x80, 0x78,
  0xA9, 0xF0, 0x59, 0x79, 0x90, 0x72, 0x24, 0xE0, 0x11, 0x11, 0xE0, 0x56,
  0x4A, 0x90, 0x4A, 0x4E, 0x5D, 0xB9, 0x90, 0x5D, 0xBA, 0xA0, 0x79, 0x99,
  0xE0, 0x75, 0xF8, 0x80, 0x79, 0x99, 0xE2, 0x75, 0xEA, 0x90, 0x74, 0x21,
  0xF0, 0xE9, 0x48, 0x59, 0x99, 0xE0, 0xB7, 0x68, 0xFE, 0xEC, 0x56, 0x26,
  0x90, 0xB7, 0x48, 0x72, 0x44, 0xE0, 0x5A, 0xA8, 0xA5, 0x40, 0x55, 0x58,
  0x7C, 0xE0, 0x80, 0x61, 0xFE, 0x46, 0x99, 0xE0, 0xD6, 0x60, 0x17, 0x99,
  0xE0, 0x6F, 0x8F, 0x7E, 0x48, 0x79, 0x9A, 0xE0, 0x47, 0x99, 0x90, 0x2C,
  0x9E, 0x0C, 0x92, 0xA0, 0x45, 0x6A, 0xA0, 0x64, 0x9E, 0xFB, 0xDD, 0x79,
  0x99, 0x69, 0x9E, 0x76, 0xF8, 0xF6, 0xE4, 0x72, 0x40, 0x74, 0x3F, 0x7A,
  0xC0, 0xB6, 0xE0, 0xB7, 0x40, 0xBF, 0x60, 0x52, 0x4A, 0x99, 0x64, 0x48,
  0x72, 0x4E, 0x69, 0x49, 0x10, 0x56, 0xA0, 0x55, 0x68, 0xF0,
};

const GFXglyph RobotoMono_ThinItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 5, 4, 1, -5 },
  { 3, 1, 1, 4, 2, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 7, 4, 0, -6 },
  { 11, 4, 5, 4, 0, -5 },
  { 14, 4, 5, 4, 0, -5 },
  { 17, 1, 1, 4, 2, -5 },
  { 18, 2, 8, 4, 1, -6 },
  { 20, 2, 8, 4, 1, -6 },
  { 22, 3, 3, 4, 1, -5 },
  { 24, 4, 4, 4, 0, -4 },
  { 26, 1, 2, 4, 1, -1 },
  { 27, 2, 1, 4, 1, -3 },
  { 28, 1, 1, 4, 1, -1 },
  { 29, 3, 5, 4, 1, -5 },
  { 31, 3, 5, 4, 1, -5 },
  { 33, 2, 5, 4, 1, -5 },
  { 35, 3, 5, 4, 0, -5 },
  { 37, 4, 5, 4, 0, -5 },
  { 40, 4, 5, 4, 0, -5 },
  { 43, 3, 5, 4, 1, -5 },
  { 45, 3, 5, 4, 0, -5 },
  { 47, 3, 5, 4, 1, -5 },
  { 49, 4, 5, 4, 0, -5 },
  { 52, 3, 5, 4, 1, -5 },
  { 54, 1, 3, 4, 2, -3 },
  { 55, 2, 4, 4, 1, -3 },
  { 56, 3, 3, 4, 1, -4 },
  { 58, 4, 2, 4, 0, -3 },
  { 59, 4, 3, 4, 0, -4 },
  { 61, 3, 5, 4, 1, -5 },
  { 63, 4, 5, 4, 0, -5 },
  { 66, 3, 5, 4, 0, -5 },
  { 68, 4, 5, 4, 0, -5 },
  { 71, 4, 5, 4, 0, -5 },
  { 74, 4, 5, 4, 0, -5 },
  { 77, 4, 5, 4, 0, -5 },
  { 80, 4, 5, 4, 0, -5 },
  { 83, 4, 5, 4, 0, -5 },
  { 86, 4, 5, 4, 0, -5 },
  { 89, 4, 5, 4, 0, -5 },
  { 92, 4, 5, 4, 0, -5 },
  { 95, 4, 5, 4, 0, -5 },
  { 98, 3, 5, 4, 0, -5 },
  { 100, 4, 5, 4, 0, -5 },
  { 103, 4, 5, 4, 0, -5 },
  { 106, 4, 5, 4, 0, -5 },
  { 109, 4, 5, 4, 0, -5 },
  { 112, 4, 6, 4, 0, -5 },
  { 115, 4, 5, 4, 0, -5 },
  { 118, 4, 5, 4, 0, -5 },
  { 121, 3, 5, 4, 1, -5 },
  { 123, 4, 5, 4, 0, -5 },
  { 126, 3, 5, 4, 1, -5 },
  { 128, 3, 5, 4, 1, -5 },
  { 130, 4, 5, 4, 0, -5 },
  { 133, 3, 5, 4, 1, -5 },
  { 135, 4, 5, 4, 0, -5 },
  { 138, 2, 7, 4, 1, -6 },
  { 140, 2, 5, 4, 1, -5 },
  { 142, 2, 7, 4, 1, -6 },
  { 144, 2, 3, 4, 1, -5 },
  { 145, 3, 1, 4, 0, 0 },
  { 146, 1, 1, 4, 2, -5 },
  { 147, 4, 4, 4, 0, -4 },
  { 149, 4, 5, 4, 0, -5 },
  { 152, 3, 4, 4, 1, -4 },
  { 154, 4, 5, 4, 0, -5 },
  { 157, 4, 4, 4, 0, -4 },
  { 159, 3, 5, 4, 1, -5 },
  { 161, 4, 5, 4, 0, -4 },
  { 164, 4, 5, 4, 0, -5 },
  { 167, 3, 5, 4, 0, -5 },
  { 169, 3, 7, 4, 0, -5 },
  { 172, 4, 5, 4, 0, -5 },
  { 175, 3, 5, 4, 0, -5 },
  { 177, 4, 4, 4, 0, -4 },
  { 179, 4, 4, 4, 0, -4 },
  { 181, 4, 4, 4, 0, -4 },
  { 183, 3, 5, 4, 0, -4 },
  { 185, 3, 5, 4, 1, -4 },
  { 187, 3, 4, 4, 1, -4 },
  { 189, 4, 4, 4, 0, -4 },
  { 191, 2, 5, 4, 1, -5 },
  { 193, 3, 4, 4, 1, -4 },
  { 195, 3, 4, 4, 1, -4 },
  { 197, 3, 4, 4, 1, -4 },
  { 199, 4, 4, 4, 0, -4 },
  { 201, 4, 6, 4, 0, -4 },
  { 204, 4, 4, 4, 0, -4 },
  { 206, 3, 7, 4, 1, -5 },
  { 209, 2, 6, 4, 1, -5 },
  { 211, 2, 7, 4, 1, -5 },
  { 213, 4, 1, 4, 0, -3 },
};

const GFXfont RobotoMono_ThinItalic7pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic7pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _ROBOTOMONO_THINITALIC7PT7B_H_
