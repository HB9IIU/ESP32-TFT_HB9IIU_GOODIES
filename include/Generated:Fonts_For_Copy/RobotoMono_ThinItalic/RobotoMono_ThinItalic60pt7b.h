#ifndef _ROBOTOMONO_THINITALIC60PT7B_H_
#define _ROBOTOMONO_THINITALIC60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80,
  0x80, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x70,
  0x30, 0x00, 0x30, 0x66, 0x0C, 0xC1, 0x90, 0x22, 0x04, 0xC1, 0x98, 0x33,
  0x06, 0x40, 0xC8, 0x13, 0x02, 0x60, 0xC0, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x40, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x40, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x40, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x04, 0x00, 0x40, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x18,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0x20, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x38, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0x18, 0x03, 0x00, 0x00, 0x40,
  0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x08, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x02, 0x06, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x81, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x02, 0x08, 0x00, 0x00, 0x10, 0x40, 0x00, 0x01, 0x82, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x71, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60,
  0x10, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x21, 0x00, 0x30,
  0x03, 0x18, 0x01, 0x80, 0x30, 0xC0, 0x0C, 0x03, 0x06, 0x00, 0x60, 0x18,
  0x20, 0x02, 0x01, 0x81, 0x00, 0x10, 0x18, 0x08, 0x01, 0x80, 0x80, 0x40,
  0x0C, 0x0C, 0x02, 0x00, 0xC0, 0xC0, 0x18, 0x06, 0x0C, 0x00, 0x40, 0x60,
  0x60, 0x03, 0x0E, 0x06, 0x00, 0x0F, 0xE0, 0x60, 0x00, 0x08, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x0F, 0xC0, 0x01, 0x81, 0xE7, 0x00, 0x0C,
  0x1C, 0x08, 0x00, 0xC0, 0xC0, 0x60, 0x0C, 0x0C, 0x01, 0x00, 0x40, 0x40,
  0x08, 0x06, 0x06, 0x00, 0x40, 0x60, 0x30, 0x02, 0x02, 0x01, 0x00, 0x10,
  0x30, 0x08, 0x00, 0x83, 0x00, 0xC0, 0x0C, 0x30, 0x06, 0x00, 0x61, 0x80,
  0x30, 0x03, 0x18, 0x01, 0x80, 0x30, 0x80, 0x0C, 0x01, 0x80, 0x00, 0x20,
  0x18, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x30,
  0x01, 0x80, 0x01, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x20, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x01, 0x01, 0x80, 0x00, 0x08,
  0x18, 0x00, 0x00, 0x63, 0x80, 0x00, 0x01, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x06, 0x10, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x18, 0x60,
  0x08, 0x00, 0xC6, 0x00, 0x60, 0x06, 0x20, 0x01, 0x80, 0x23, 0x00, 0x04,
  0x03, 0x30, 0x00, 0x30, 0x19, 0x80, 0x00, 0xC1, 0x88, 0x00, 0x06, 0x0C,
  0x40, 0x00, 0x18, 0xC6, 0x00, 0x00, 0x46, 0x30, 0x00, 0x03, 0x61, 0x80,
  0x00, 0x0F, 0x04, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x81, 0x80, 0x00,
  0x76, 0x06, 0x00, 0x07, 0x10, 0x18, 0x00, 0xE0, 0xC0, 0x70, 0x1E, 0x03,
  0x01, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x25, 0xB6, 0xD2, 0xDA,
  0x40, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x40, 0x0C, 0x01, 0xFC, 0x06, 0x07, 0xC7, 0xC3, 0x1F, 0x00,
  0x7D, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0x60,
  0x00, 0xC0, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x00,
  0xC0, 0x20, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x20, 0x82, 0x18, 0x61, 0x0C, 0x31,
  0x8C, 0x30, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x38, 0x03, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x02, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x07, 0x08, 0x00, 0x00, 0xF1, 0x80, 0x00, 0x1B, 0x18,
  0x00, 0x03, 0x31, 0x00, 0x00, 0xE3, 0x30, 0x00, 0x18, 0x33, 0x00, 0x03,
  0x03, 0x30, 0x00, 0x60, 0x22, 0x00, 0x0C, 0x02, 0x20, 0x01, 0x80, 0x22,
  0x00, 0x30, 0x06, 0x60, 0x0E, 0x00, 0x66, 0x01, 0x80, 0x06, 0x60, 0x30,
  0x00, 0x44, 0x06, 0x00, 0x04, 0x40, 0xC0, 0x00, 0xC4, 0x18, 0x00, 0x0C,
  0x43, 0x00, 0x00, 0xCC, 0xE0, 0x00, 0x08, 0xD8, 0x00, 0x01, 0x8F, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x01, 0x04, 0x00, 0x00, 0x30, 0x40, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x02, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xF0, 0x3C,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x38,
  0x01, 0xF0, 0x0E, 0x60, 0xF0, 0xC7, 0x81, 0xB8, 0x02, 0x40, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x38, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x18,
  0x00, 0x02, 0x01, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x01, 0x04, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x78, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x02, 0x06, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00,
  0x83, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x84,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x03,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x18, 0x10, 0x00, 0x01, 0x80, 0x80, 0x00, 0x18, 0x04, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x18, 0x03, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x0C, 0x00,
  0x80, 0x00, 0xC0, 0x04, 0x00, 0x0C, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x04, 0x00, 0x60,
  0x00, 0x20, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x06, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x06, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x04, 0x1F, 0xC0, 0x00, 0x27, 0xFF, 0x80, 0x03, 0xF0, 0x0E,
  0x00, 0x1E, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20,
  0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x80, 0x80,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x40, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x60, 0x02, 0x00, 0x06, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x7F, 0x80,
  0x10, 0x7F, 0xF8, 0x0C, 0x70, 0x07, 0x03, 0x30, 0x00, 0x60, 0xB0, 0x00,
  0x18, 0x78, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x46, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x06, 0x40, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x1A, 0x00, 0x00, 0x06, 0x80, 0x00, 0x01, 0x30, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x03,
  0x00, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0x80, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x60, 0x20, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x60, 0x00, 0xC0, 0x07, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x20, 0x80, 0x00, 0x00, 0x86, 0x00, 0x00, 0x02, 0x18,
  0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x21, 0x00, 0x00, 0x01, 0x84, 0x00,
  0x00, 0x06, 0x10, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x1C,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x1E, 0x00, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0x18, 0x06, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x60,
  0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x26, 0x00, 0x00, 0x09,
  0x80, 0x00, 0x03, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x90, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x51, 0x80, 0x00, 0x34, 0x30, 0x00, 0x1B, 0x06, 0x00, 0x1C,
  0xC1, 0xC0, 0x1C, 0x20, 0x1E, 0x3E, 0x18, 0x03, 0xFE, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x03, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x06, 0x00, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x1E, 0x1E, 0x01, 0x80, 0x18, 0x38, 0x00, 0x61, 0x80, 0x03, 0x18, 0x00,
  0x0D, 0x80, 0x00, 0x68, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3C, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0xE0, 0x0F, 0xC0, 0x30, 0x30, 0x0F, 0x38,
  0x0C, 0x18, 0x06, 0x03, 0x03, 0x06, 0x03, 0x00, 0xC0, 0xC3, 0x01, 0x80,
  0x20, 0x30, 0xC0, 0xC0, 0x08, 0x0C, 0x60, 0x30, 0x06, 0x03, 0x18, 0x18,
  0x01, 0x00, 0xCC, 0x06, 0x00, 0x40, 0x33, 0x03, 0x00, 0x30, 0x0C, 0xC0,
  0xC0, 0x0C, 0x02, 0x20, 0x20, 0x02, 0x00, 0x98, 0x18, 0x00, 0x80, 0x66,
  0x06, 0x00, 0x60, 0x19, 0x01, 0x80, 0x18, 0x04, 0x40, 0x40, 0x04, 0x01,
  0x10, 0x10, 0x03, 0x00, 0xCC, 0x0C, 0x00, 0xC0, 0x33, 0x03, 0x00, 0x70,
  0x08, 0xC0, 0xC0, 0x18, 0x06, 0x30, 0x30, 0x0A, 0x01, 0x0C, 0x0C, 0x06,
  0x80, 0xC3, 0x01, 0x03, 0x20, 0x60, 0xC0, 0x61, 0x8C, 0x30, 0x10, 0x0F,
  0xC1, 0xF8, 0x06, 0x01, 0xC0, 0x3C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x08, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x16, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x09, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00,
  0x61, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x02, 0x00,
  0x00, 0x60, 0x10, 0x00, 0x06, 0x00, 0x80, 0x00, 0x30, 0x06, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x60, 0x00, 0x60,
  0x03, 0x00, 0x03, 0x00, 0x30, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x18,
  0x00, 0x02, 0x00, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x06, 0x02, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x20, 0x80, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x0C, 0x40,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x02, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x60, 0x01, 0xE0, 0x03, 0x00, 0x01, 0x80, 0x10, 0x00, 0x06, 0x00,
  0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x40, 0x60, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x18, 0x10, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x0C, 0x04, 0x00, 0x00, 0xE0, 0x20, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x20, 0x00, 0x38, 0x03, 0x00, 0x00, 0x70, 0x18, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x02, 0x18, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x86, 0x00, 0x00,
  0x0C, 0x20, 0x00, 0x00, 0x61, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x81, 0x00,
  0x00, 0x18, 0x08, 0x00, 0x01, 0x80, 0x40, 0x00, 0x38, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF8, 0x78,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x10, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x01, 0x88, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x10, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x60,
  0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x20, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x03, 0x04, 0x00, 0x00, 0x0C, 0x10, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x03,
  0x08, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x21, 0x80, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x00, 0x82, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x06, 0x01, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x80, 0x30,
  0x00, 0x1C, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x02, 0x04, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xE4, 0x00, 0x00, 0x03, 0x20,
  0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x04, 0x40, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x86, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x20, 0x80, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x07, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x01, 0x80, 0x00,
  0x01, 0x01, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x02, 0x02, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00,
  0x0C, 0x04, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00,
  0x08, 0x0C, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00,
  0x18, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x08, 0x00, 0x00,
  0x10, 0x18, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00,
  0x30, 0x10, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00,
  0x20, 0x30, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00,
  0x60, 0x20, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x40, 0x60, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00,
  0x80, 0xC0, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x07, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x01, 0x80, 0x08, 0x00, 0x01, 0x80, 0x04, 0x00, 0x01, 0x80, 0x02,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x03, 0x80, 0x00, 0x40, 0x03, 0x80, 0x00, 0x20, 0x03, 0x80, 0x00,
  0x10, 0x03, 0x80, 0x00, 0x18, 0x03, 0x80, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x00, 0xC3, 0xC0, 0x00, 0x00, 0x63, 0x60, 0x00,
  0x00, 0x33, 0x18, 0x00, 0x00, 0x17, 0x06, 0x00, 0x00, 0x0F, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x20, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x06, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x03, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x02, 0x00,
  0x00, 0x20, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x20, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x01, 0xA0, 0x16, 0x00, 0x00, 0xF0, 0x0B, 0x00,
  0x00, 0xD8, 0x04, 0x80, 0x00, 0x6C, 0x06, 0x40, 0x00, 0x64, 0x03, 0x20,
  0x00, 0x32, 0x01, 0x98, 0x00, 0x31, 0x00, 0x8C, 0x00, 0x31, 0x80, 0x42,
  0x00, 0x18, 0xC0, 0x21, 0x00, 0x18, 0x60, 0x30, 0x80, 0x0C, 0x20, 0x18,
  0x60, 0x0C, 0x10, 0x0C, 0x30, 0x04, 0x08, 0x04, 0x08, 0x06, 0x0C, 0x02,
  0x04, 0x02, 0x06, 0x03, 0x02, 0x03, 0x03, 0x01, 0x81, 0x83, 0x01, 0x00,
  0xC0, 0xC1, 0x80, 0x80, 0x60, 0x21, 0x80, 0xC0, 0x20, 0x10, 0x80, 0x60,
  0x10, 0x08, 0xC0, 0x30, 0x18, 0x06, 0x40, 0x18, 0x0C, 0x03, 0x60, 0x08,
  0x06, 0x00, 0xE0, 0x04, 0x03, 0x00, 0x70, 0x06, 0x01, 0x00, 0x30, 0x03,
  0x00, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x40, 0x30, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00,
  0x18, 0x04, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00,
  0x02, 0x01, 0x80, 0x00, 0x01, 0x00, 0x80, 0x00, 0x01, 0x80, 0x40, 0x00,
  0x00, 0xC0, 0x20, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x01, 0x80, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x03, 0x01,
  0x40, 0x00, 0x03, 0x01, 0x40, 0x00, 0x02, 0x01, 0x60, 0x00, 0x02, 0x03,
  0x20, 0x00, 0x02, 0x03, 0x30, 0x00, 0x06, 0x02, 0x30, 0x00, 0x06, 0x02,
  0x10, 0x00, 0x06, 0x02, 0x18, 0x00, 0x04, 0x06, 0x08, 0x00, 0x04, 0x06,
  0x08, 0x00, 0x04, 0x06, 0x0C, 0x00, 0x0C, 0x04, 0x04, 0x00, 0x0C, 0x04,
  0x06, 0x00, 0x0C, 0x04, 0x06, 0x00, 0x08, 0x0C, 0x02, 0x00, 0x08, 0x0C,
  0x03, 0x00, 0x08, 0x0C, 0x01, 0x00, 0x18, 0x08, 0x01, 0x00, 0x18, 0x08,
  0x01, 0x80, 0x18, 0x08, 0x00, 0x80, 0x10, 0x18, 0x00, 0xC0, 0x10, 0x18,
  0x00, 0xC0, 0x10, 0x18, 0x00, 0x40, 0x30, 0x10, 0x00, 0x60, 0x30, 0x10,
  0x00, 0x20, 0x30, 0x10, 0x00, 0x20, 0x20, 0x30, 0x00, 0x30, 0x20, 0x30,
  0x00, 0x10, 0x20, 0x30, 0x00, 0x18, 0x60, 0x20, 0x00, 0x18, 0x60, 0x20,
  0x00, 0x08, 0x60, 0x20, 0x00, 0x0C, 0x40, 0x60, 0x00, 0x04, 0x40, 0x60,
  0x00, 0x04, 0xC0, 0x60, 0x00, 0x06, 0xC0, 0x40, 0x00, 0x02, 0xC0, 0x40,
  0x00, 0x03, 0x80, 0x40, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x38,
  0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x20, 0x60, 0x00, 0x02, 0x06, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x11, 0x80, 0x00, 0x01, 0x18, 0x00, 0x00,
  0x11, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x13, 0x00, 0x00, 0x01, 0x20,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x16, 0x00, 0x00,
  0x03, 0x40, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x00, 0x88, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x03, 0x04, 0x00, 0x00, 0x60, 0x60, 0x00, 0x04,
  0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x01, 0x00, 0x03, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x04, 0x00, 0x07,
  0x00, 0x08, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x02, 0x00, 0x00, 0x0C,
  0x04, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x20,
  0x60, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x01, 0x81, 0x00, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0xC0, 0x40, 0x00, 0x03, 0x00, 0x80, 0x00, 0x0C, 0x01, 0x00,
  0x00, 0x70, 0x06, 0x00, 0x03, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xC0, 0x0C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x30, 0x07, 0x00, 0x00, 0x40, 0x18,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x02, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00,
  0x04, 0x60, 0x00, 0x00, 0x11, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x01,
  0x30, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0x58,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x00, 0x90, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x61, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x08, 0x18,
  0x00, 0x00, 0x60, 0x20, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x1C, 0x07,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x3C, 0x00,
  0x60, 0x00, 0x38, 0x01, 0x80, 0x00, 0x70, 0x04, 0x00, 0x00, 0xC0, 0x10,
  0x00, 0x01, 0x80, 0x40, 0x00, 0x06, 0x03, 0x00, 0x00, 0x08, 0x0C, 0x00,
  0x00, 0x20, 0x30, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x03, 0x02, 0x00, 0x00,
  0x08, 0x08, 0x00, 0x00, 0x20, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06,
  0x04, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x00, 0x80,
  0x01, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x40, 0x00, 0x60, 0x01, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x10, 0x02, 0x00, 0x00, 0x60, 0x08,
  0x00, 0x01, 0x80, 0x20, 0x00, 0x02, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x40, 0x00, 0x01, 0x81, 0x00, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3E,
  0x1E, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0x80, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x23, 0x00, 0x00,
  0x01, 0x84, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x38, 0x06, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x1C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x10, 0x40,
  0x00, 0x00, 0xC1, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x20, 0xC0, 0x00, 0x00, 0x83, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00,
  0x18, 0x20, 0x00, 0x00, 0x60, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x04,
  0x18, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x03, 0x04,
  0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00,
  0x41, 0x80, 0x00, 0x03, 0x04, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x83, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x30, 0x10, 0x00, 0x01, 0x80, 0x60, 0x00, 0x04, 0x01, 0x80, 0x00,
  0x30, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x38, 0x0F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x61, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x10, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x08,
  0x08, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x04, 0x02, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x02, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x18, 0x00, 0x80, 0x00, 0xC0, 0x04, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x01,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00,
  0x40, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x02, 0x03, 0x00,
  0x00, 0x10, 0x10, 0x00, 0x00, 0x81, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x23,
  0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0xC0, 0x02, 0x80, 0x07, 0x00, 0x0A, 0x00, 0x3C, 0x00, 0x68, 0x00,
  0xF0, 0x01, 0x20, 0x02, 0xC0, 0x04, 0x80, 0x1B, 0x00, 0x32, 0x00, 0x64,
  0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x0C, 0x40, 0x18, 0x80, 0x31, 0x00,
  0x62, 0x00, 0x84, 0x01, 0x08, 0x06, 0x10, 0x0C, 0x20, 0x18, 0x40, 0x30,
  0x80, 0x41, 0x00, 0x82, 0x03, 0x04, 0x06, 0x08, 0x0C, 0x10, 0x18, 0x20,
  0x20, 0x40, 0x40, 0x81, 0x81, 0x01, 0x02, 0x06, 0x06, 0x0C, 0x08, 0x30,
  0x18, 0x20, 0x20, 0xC0, 0x60, 0x80, 0x83, 0x01, 0x86, 0x02, 0x18, 0x06,
  0x10, 0x08, 0x60, 0x18, 0x40, 0x21, 0x00, 0x63, 0x00, 0x8C, 0x01, 0x8C,
  0x02, 0x30, 0x06, 0x20, 0x08, 0x80, 0x19, 0x80, 0x26, 0x00, 0x66, 0x00,
  0x98, 0x01, 0x90, 0x02, 0x40, 0x06, 0xC0, 0x0B, 0x00, 0x1B, 0x00, 0x2C,
  0x00, 0x68, 0x00, 0xA0, 0x01, 0xA0, 0x03, 0x80, 0x07, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x70, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x03,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x10,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x08, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x80, 0xC0, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x00, 0x10, 0x60, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x30, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0x90, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x10, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x10, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x10, 0x01, 0x80, 0x00, 0xC0, 0x08,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x10, 0x0C, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x02,
  0x30, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x3F, 0xE0, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x06,
  0x00, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x00,
  0x30, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x08,
  0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x06, 0x00,
  0xC0, 0x08, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x30,
  0x06, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xA0, 0x00, 0x12, 0x00, 0x03, 0x30, 0x00, 0x63, 0x00, 0x06, 0x10, 0x00,
  0xC1, 0x00, 0x0C, 0x18, 0x01, 0x81, 0x80, 0x10, 0x18, 0x03, 0x00, 0x80,
  0x60, 0x0C, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0x41, 0x80, 0x04,
  0x10, 0x00, 0x63, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x02, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0x82, 0x0C,
  0x10, 0x60, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xC3, 0xE0, 0x03, 0xC0,
  0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xE0, 0x00,
  0xC0, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x02, 0x1C, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x62, 0x00, 0x00, 0x08,
  0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0xE1, 0x00, 0x00, 0x34, 0x30, 0x00,
  0x0D, 0x86, 0x00, 0x03, 0x30, 0x60, 0x01, 0xC6, 0x07, 0x01, 0xE0, 0xC0,
  0x7F, 0xF0, 0x18, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x0F, 0xF0, 0x00, 0x87, 0x87, 0x80, 0x33, 0x80,
  0x18, 0x06, 0xE0, 0x01, 0x80, 0xF0, 0x00, 0x10, 0x1C, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x20, 0x60, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x03, 0x08, 0x00, 0x00, 0x61, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0x10, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x06, 0x10, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x10,
  0x40, 0x00, 0x06, 0x18, 0x00, 0x01, 0x83, 0x80, 0x00, 0x30, 0x78, 0x00,
  0x0C, 0x0F, 0x00, 0x03, 0x01, 0x38, 0x01, 0xC0, 0x23, 0xC0, 0xF0, 0x0C,
  0x1F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0x0F, 0x00, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x20, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x46, 0x00, 0x00, 0x13, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x11, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x02, 0x18, 0x00, 0x01, 0x82, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x70, 0x18, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x3C, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x0F, 0xF0, 0x30, 0x01, 0xF1,
  0xE1, 0x80, 0x1C, 0x01, 0x8C, 0x01, 0x80, 0x06, 0x40, 0x18, 0x00, 0x1A,
  0x01, 0x80, 0x00, 0x70, 0x18, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x60, 0x40, 0x00, 0x02, 0x06, 0x00, 0x00, 0x10, 0x30, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x83, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x81, 0x80, 0x00, 0x04, 0x04, 0x00, 0x00, 0x60, 0x20, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x1C, 0x01,
  0x80, 0x01, 0xA0, 0x06, 0x00, 0x3B, 0x00, 0x1C, 0x0F, 0x18, 0x00, 0x7F,
  0xE0, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xC7,
  0x80, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x01, 0x80, 0x30, 0x00, 0x18, 0x0C,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x02, 0x18, 0x00, 0x00,
  0x46, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x90, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x00, 0x9F, 0xFF, 0xFF, 0xF6, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x70, 0x01,
  0xC0, 0x38, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x30, 0x03, 0xE3, 0xC3, 0x00, 0x70,
  0x06, 0x30, 0x0C, 0x00, 0x33, 0x01, 0x80, 0x01, 0xA0, 0x30, 0x00, 0x0A,
  0x06, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x04, 0x18, 0x00, 0x00, 0x41, 0x80, 0x00, 0x04, 0x10, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x08, 0x20,
  0x00, 0x00, 0x82, 0x00, 0x00, 0x08, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x10, 0x20, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x30, 0x20, 0x00, 0x03, 0x03, 0x00, 0x00, 0x70, 0x30, 0x00,
  0x07, 0x01, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x1A, 0x00, 0xC0, 0x07, 0x20,
  0x07, 0x03, 0xC6, 0x00, 0x1F, 0xF0, 0x60, 0x00, 0x30, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x38, 0x07, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x0C, 0x07, 0xFC, 0x01, 0x83, 0xC1, 0xC0, 0x30, 0xE0, 0x0C, 0x04,
  0x70, 0x00, 0xC0, 0x98, 0x00, 0x08, 0x16, 0x00, 0x01, 0x86, 0x80, 0x00,
  0x30, 0xE0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x21, 0x00, 0x00, 0x04, 0x20, 0x00, 0x01, 0x84, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x10,
  0x80, 0x00, 0x02, 0x10, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x43, 0x00, 0x00, 0x08, 0x40, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1C, 0x08, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x03, 0x00, 0x30, 0x00, 0x30,
  0x01, 0x00, 0x07, 0x00, 0x08, 0x00, 0x70, 0x00, 0xC0, 0x06, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x30, 0x0E, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x08, 0x0C,
  0x00, 0x00, 0x41, 0xC0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x31, 0xC0, 0x00,
  0x01, 0xBB, 0x00, 0x00, 0x0F, 0x8C, 0x00, 0x00, 0x70, 0x30, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x60, 0x03, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x30,
  0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x18, 0x02,
  0x00, 0x00, 0xC0, 0x10, 0x00, 0x03, 0x00, 0x80, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x02, 0x1F, 0xC0, 0x7F, 0x00, 0x4F,
  0x1C, 0x3C, 0x70, 0x1B, 0x00, 0xCE, 0x03, 0x03, 0xC0, 0x1B, 0x00, 0x20,
  0x70, 0x01, 0xC0, 0x06, 0x0C, 0x00, 0x38, 0x00, 0xC1, 0x80, 0x06, 0x00,
  0x18, 0x20, 0x00, 0x80, 0x03, 0x0C, 0x00, 0x10, 0x00, 0x61, 0x80, 0x02,
  0x00, 0x08, 0x30, 0x00, 0xC0, 0x01, 0x04, 0x00, 0x18, 0x00, 0x20, 0x80,
  0x03, 0x00, 0x0C, 0x10, 0x00, 0x40, 0x01, 0x86, 0x00, 0x08, 0x00, 0x30,
  0xC0, 0x03, 0x00, 0x04, 0x18, 0x00, 0x60, 0x00, 0x82, 0x00, 0x0C, 0x00,
  0x10, 0x40, 0x01, 0x80, 0x06, 0x08, 0x00, 0x20, 0x00, 0xC3, 0x00, 0x04,
  0x00, 0x10, 0x60, 0x01, 0x80, 0x02, 0x0C, 0x00, 0x30, 0x00, 0x41, 0x00,
  0x06, 0x00, 0x18, 0x20, 0x00, 0x80, 0x03, 0x04, 0x00, 0x10, 0x00, 0x61,
  0x80, 0x02, 0x00, 0x08, 0x30, 0x00, 0xC0, 0x01, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x80, 0x03, 0x00, 0x0C, 0x10, 0x00, 0x40, 0x01, 0x86, 0x00, 0x08,
  0x00, 0x30, 0x06, 0x03, 0xFC, 0x00, 0xC1, 0xE0, 0xE0, 0x18, 0x60, 0x06,
  0x02, 0x38, 0x00, 0x60, 0x4C, 0x00, 0x0C, 0x0B, 0x00, 0x00, 0xC3, 0x40,
  0x00, 0x18, 0x70, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C,
  0x20, 0x00, 0x01, 0x84, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x86, 0x00, 0x00, 0x10, 0x80, 0x00, 0x02, 0x10, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x08, 0x40, 0x00, 0x03, 0x08, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x21, 0x80, 0x00, 0x04, 0x20, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x10, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x70, 0x07,
  0x00, 0x1C, 0x00, 0x18, 0x03, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0xC4, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0x30, 0x00, 0x06,
  0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x07,
  0x01, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x81,
  0xFE, 0x00, 0x0C, 0x3C, 0x3C, 0x00, 0x67, 0x00, 0x70, 0x03, 0x70, 0x00,
  0xC0, 0x16, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x02, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x06, 0x04, 0x00, 0x00, 0x30, 0x20, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x04, 0x00, 0x00, 0x10,
  0x20, 0x00, 0x00, 0x81, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x02, 0x06, 0x00, 0x00, 0x30, 0x20, 0x00, 0x01, 0x81, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x40,
  0x38, 0x00, 0x06, 0x01, 0x60, 0x00, 0x60, 0x09, 0xC0, 0x0E, 0x00, 0xC7,
  0x81, 0xE0, 0x06, 0x0F, 0xFC, 0x00, 0x30, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x60, 0x0F, 0x8F, 0x0C, 0x03, 0x80, 0x31,
  0x80, 0xC0, 0x03, 0x30, 0x30, 0x00, 0x34, 0x0C, 0x00, 0x02, 0x83, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x02, 0x18, 0x00, 0x00, 0x42, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x62, 0x00, 0x00, 0x08, 0x40, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x04, 0x30, 0x00, 0x00, 0x82, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x38, 0x18, 0x00, 0x0E,
  0x03, 0x00, 0x03, 0x40, 0x30, 0x01, 0xC8, 0x03, 0x81, 0xE3, 0x00, 0x1F,
  0xF0, 0x60, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x06, 0x01, 0xFF, 0x83, 0x03,
  0xE0, 0x41, 0x87, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x46, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0x00, 0x0E, 0x01, 0x80, 0x00,
  0xC0, 0x60, 0x00, 0x0C, 0x08, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x61, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x18,
  0x00, 0x00, 0x21, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0x00, 0x08, 0x00, 0x00, 0x46,
  0x00, 0x00, 0x11, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x10, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0x33, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x02, 0x30, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x62, 0x00, 0x00, 0x18, 0x80, 0x00, 0x06, 0x60,
  0x00, 0x01, 0x18, 0x00, 0x00, 0x46, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C,
  0x40, 0x00, 0x03, 0x10, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x23, 0x00, 0x00,
  0x08, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x88, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xC1,
  0x00, 0x00, 0xF0, 0x60, 0x00, 0xEC, 0x0C, 0x00, 0x72, 0x01, 0xC0, 0xF0,
  0x80, 0x3F, 0xF0, 0x60, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x04, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x30, 0x10, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x10, 0x06, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x18, 0x00, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x06, 0x00, 0x06, 0x00, 0x20, 0x00, 0x30, 0x03,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x04, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x20, 0x40, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x30,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0A,
  0x00, 0x1C, 0x00, 0x34, 0x00, 0x38, 0x00, 0x48, 0x00, 0x50, 0x01, 0x98,
  0x01, 0xA0, 0x03, 0x30, 0x02, 0x40, 0x04, 0x60, 0x0C, 0x80, 0x18, 0xC0,
  0x19, 0x00, 0x21, 0x80, 0x23, 0x00, 0xC3, 0x00, 0xC6, 0x01, 0x86, 0x01,
  0x0C, 0x02, 0x0C, 0x06, 0x18, 0x0C, 0x18, 0x0C, 0x30, 0x10, 0x30, 0x30,
  0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0x81, 0x81, 0x01, 0x83, 0x01,
  0x06, 0x01, 0x04, 0x02, 0x0C, 0x02, 0x18, 0x04, 0x30, 0x04, 0x30, 0x08,
  0x60, 0x08, 0x40, 0x10, 0x80, 0x11, 0x80, 0x23, 0x00, 0x22, 0x00, 0x66,
  0x00, 0x4C, 0x00, 0xD8, 0x00, 0x90, 0x01, 0xB0, 0x01, 0x60, 0x03, 0x40,
  0x02, 0xC0, 0x07, 0x80, 0x05, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x07, 0x00,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x03, 0x38, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x70, 0x0C, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x01, 0xC0, 0x06, 0x00,
  0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x08,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x78, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20,
  0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x18,
  0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xC3,
  0x83, 0x80, 0x00, 0x43, 0x00, 0x60, 0x00, 0x63, 0x00, 0x18, 0x00, 0x21,
  0x80, 0x06, 0x00, 0x31, 0x80, 0x01, 0x80, 0x30, 0xC0, 0x00, 0x60, 0x30,
  0x40, 0x00, 0x1F, 0xF0, 0x40, 0x00, 0x03, 0xE0, 0x00,
};

const GFXglyph RobotoMono_ThinItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 9, 43, 35, 13, -43 },
  { 50, 11, 12, 35, 15, -45 },
  { 67, 35, 43, 35, 1, -43 },
  { 256, 29, 55, 35, 4, -49 },
  { 456, 29, 44, 35, 4, -43 },
  { 616, 29, 44, 35, 3, -43 },
  { 776, 3, 12, 35, 18, -45 },
  { 781, 17, 62, 35, 11, -48 },
  { 913, 17, 62, 35, 6, -48 },
  { 1045, 25, 24, 35, 8, -43 },
  { 1120, 28, 31, 35, 4, -35 },
  { 1229, 6, 12, 35, 8, -5 },
  { 1238, 21, 1, 35, 7, -20 },
  { 1241, 3, 3, 35, 14, -3 },
  { 1243, 27, 47, 35, 5, -43 },
  { 1402, 28, 44, 35, 4, -43 },
  { 1556, 15, 43, 35, 10, -43 },
  { 1637, 28, 43, 35, 1, -43 },
  { 1788, 29, 44, 35, 2, -43 },
  { 1948, 29, 43, 35, 2, -43 },
  { 2104, 29, 44, 35, 5, -43 },
  { 2264, 26, 44, 35, 4, -43 },
  { 2407, 26, 43, 35, 8, -43 },
  { 2547, 30, 44, 35, 3, -43 },
  { 2712, 26, 44, 35, 6, -43 },
  { 2855, 9, 29, 35, 15, -29 },
  { 2888, 12, 36, 35, 12, -29 },
  { 2942, 27, 23, 35, 5, -31 },
  { 3020, 28, 13, 35, 4, -26 },
  { 3066, 26, 23, 35, 4, -31 },
  { 3141, 21, 43, 35, 10, -43 },
  { 3254, 34, 43, 35, 1, -43 },
  { 3437, 29, 43, 35, 0, -43 },
  { 3593, 29, 43, 35, 3, -43 },
  { 3749, 29, 44, 35, 4, -43 },
  { 3909, 30, 43, 35, 3, -43 },
  { 4071, 31, 43, 35, 3, -43 },
  { 4238, 31, 43, 35, 3, -43 },
  { 4405, 29, 44, 35, 4, -43 },
  { 4565, 32, 43, 35, 2, -43 },
  { 4737, 30, 43, 35, 3, -43 },
  { 4899, 31, 44, 35, 2, -43 },
  { 5070, 33, 43, 35, 3, -43 },
  { 5248, 24, 43, 35, 4, -43 },
  { 5377, 33, 43, 35, 2, -43 },
  { 5555, 32, 43, 35, 2, -43 },
  { 5727, 28, 44, 35, 4, -43 },
  { 5881, 31, 43, 35, 4, -43 },
  { 6048, 30, 51, 35, 3, -43 },
  { 6240, 30, 43, 35, 3, -43 },
  { 6402, 30, 44, 35, 3, -43 },
  { 6567, 29, 43, 35, 7, -43 },
  { 6723, 30, 44, 35, 4, -43 },
  { 6888, 29, 43, 35, 7, -43 },
  { 7044, 30, 43, 35, 7, -43 },
  { 7206, 35, 43, 35, 1, -43 },
  { 7395, 29, 43, 35, 7, -43 },
  { 7551, 32, 43, 35, 1, -43 },
  { 7723, 18, 58, 35, 9, -49 },
  { 7854, 11, 47, 35, 12, -43 },
  { 7919, 17, 58, 35, 9, -49 },
  { 8043, 20, 24, 35, 8, -43 },
  { 8103, 24, 2, 35, 2, 0 },
  { 8109, 6, 7, 35, 18, -44 },
  { 8115, 27, 33, 35, 3, -32 },
  { 8227, 27, 46, 35, 3, -45 },
  { 8383, 26, 33, 35, 4, -32 },
  { 8491, 29, 46, 35, 4, -45 },
  { 8658, 27, 33, 35, 4, -32 },
  { 8770, 28, 46, 35, 8, -46 },
  { 8931, 28, 45, 35, 3, -32 },
  { 9089, 27, 45, 35, 3, -45 },
  { 9241, 24, 43, 35, 4, -43 },
  { 9370, 27, 56, 35, 0, -43 },
  { 9559, 29, 45, 35, 4, -45 },
  { 9723, 24, 45, 35, 4, -45 },
  { 9858, 35, 32, 35, -1, -32 },
  { 9998, 27, 32, 35, 3, -32 },
  { 10106, 28, 33, 35, 3, -32 },
  { 10222, 29, 44, 35, 1, -32 },
  { 10382, 27, 44, 35, 4, -32 },
  { 10531, 25, 32, 35, 8, -32 },
  { 10631, 27, 33, 35, 4, -32 },
  { 10743, 22, 41, 35, 8, -40 },
  { 10856, 26, 33, 35, 5, -32 },
  { 10964, 29, 32, 35, 5, -32 },
  { 11080, 31, 32, 35, 5, -32 },
  { 11204, 32, 32, 35, 1, -32 },
  { 11332, 36, 45, 35, -1, -32 },
  { 11535, 31, 32, 35, 1, -32 },
  { 11659, 23, 60, 35, 9, -47 },
  { 11832, 9, 51, 35, 13, -43 },
  { 11890, 23, 60, 35, 5, -47 },
  { 12063, 33, 10, 35, 1, -23 },
};

const GFXfont RobotoMono_ThinItalic60pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic60pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic60pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _ROBOTOMONO_THINITALIC60PT7B_H_
