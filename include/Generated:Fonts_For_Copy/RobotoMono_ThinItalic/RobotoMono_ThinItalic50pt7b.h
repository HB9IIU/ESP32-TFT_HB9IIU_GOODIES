#ifndef _ROBOTOMONO_THINITALIC50PT7B_H_
#define _ROBOTOMONO_THINITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x01, 0x01, 0x03, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0x06,
  0x04, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x18, 0x18,
  0x10, 0x10, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0xE0,
  0x60, 0x61, 0xB0, 0xD0, 0x48, 0x24, 0x12, 0x1B, 0x0D, 0x84, 0x82, 0x41,
  0x20, 0x80, 0x00, 0x01, 0x00, 0x40, 0x00, 0x08, 0x02, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x04, 0x01, 0x00, 0x00, 0x20, 0x18, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x10, 0x04, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x40, 0x10, 0x00, 0x06, 0x01, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0x00,
  0x40, 0x00, 0x18, 0x06, 0x00, 0x00, 0x80, 0x20, 0x00, 0x04, 0x01, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x02, 0x00, 0x80, 0x00, 0x10, 0x04, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x08, 0x02, 0x00, 0x00, 0x40, 0x10, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x20, 0x08, 0x00, 0x01, 0x00, 0xC0, 0x87, 0xFF, 0xFF, 0xF8,
  0x00, 0x80, 0x20, 0x00, 0x04, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x02,
  0x00, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x40, 0x00, 0x08, 0x02,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x04, 0x01, 0x00, 0x00, 0x20, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x38, 0x38, 0x00, 0xE0,
  0x0C, 0x01, 0x80, 0x06, 0x03, 0x00, 0x06, 0x02, 0x00, 0x02, 0x06, 0x00,
  0x03, 0x04, 0x00, 0x03, 0x04, 0x00, 0x01, 0x04, 0x00, 0x01, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x40, 0x00,
  0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x18, 0x60, 0x00,
  0x18, 0x20, 0x00, 0x30, 0x30, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x0C, 0x03,
  0x80, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x07, 0xC0, 0x00, 0x0C, 0xE0,
  0x00, 0x10, 0x20, 0x00, 0x20, 0x30, 0x00, 0x60, 0x10, 0x04, 0x40, 0x10,
  0x0C, 0x40, 0x10, 0x08, 0xC0, 0x30, 0x10, 0xC0, 0x30, 0x30, 0x80, 0x20,
  0x60, 0x80, 0x20, 0x40, 0x80, 0x60, 0xC0, 0xC0, 0x41, 0x80, 0x40, 0xC1,
  0x00, 0x61, 0x82, 0x00, 0x3F, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x7C, 0x00, 0x60,
  0xC6, 0x00, 0xC1, 0x02, 0x00, 0x83, 0x03, 0x01, 0x06, 0x01, 0x03, 0x04,
  0x01, 0x06, 0x04, 0x01, 0x04, 0x04, 0x01, 0x0C, 0x0C, 0x03, 0x18, 0x0C,
  0x03, 0x10, 0x08, 0x02, 0x20, 0x0C, 0x02, 0x20, 0x0C, 0x06, 0x00, 0x04,
  0x0C, 0x00, 0x06, 0x18, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0E, 0x70, 0x00, 0x18, 0x0C, 0x00, 0x08, 0x02, 0x00, 0x0C,
  0x01, 0x00, 0x04, 0x00, 0x80, 0x06, 0x00, 0x40, 0x03, 0x00, 0x20, 0x01,
  0x00, 0x30, 0x00, 0x80, 0x10, 0x00, 0x60, 0x10, 0x00, 0x30, 0x10, 0x00,
  0x08, 0x30, 0x00, 0x04, 0x30, 0x00, 0x03, 0x30, 0x00, 0x00, 0xB0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x78, 0x00, 0x00, 0x64, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x40, 0xC0, 0x00, 0x40, 0x20, 0x0C, 0x60, 0x18, 0x04, 0x60, 0x04,
  0x02, 0x20, 0x01, 0x03, 0x30, 0x00, 0xC1, 0x10, 0x00, 0x21, 0x88, 0x00,
  0x08, 0x84, 0x00, 0x06, 0xC2, 0x00, 0x01, 0xC1, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x70, 0x20, 0x00, 0xC8, 0x18, 0x00, 0xC6, 0x07, 0x01, 0xC1, 0x80,
  0xFF, 0x80, 0x60, 0x6D, 0xA4, 0x96, 0x92, 0x00, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x18, 0x04, 0x07, 0x78, 0x21, 0xE0, 0x79, 0x78, 0x00, 0x7E,
  0x00, 0x00, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x88, 0x00, 0x08, 0x20, 0x00,
  0xC1, 0x80, 0x0C, 0x06, 0x00, 0xC0, 0x10, 0x0C, 0x00, 0xC0, 0xC0, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x42, 0x31, 0x88, 0xC4, 0x66, 0x00, 0xFF,
  0xFF, 0x80, 0x5B, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0xE1, 0xC0, 0x07, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x60, 0x00, 0x80,
  0x80, 0x01, 0x83, 0x00, 0x01, 0x04, 0x00, 0x02, 0x18, 0x00, 0x04, 0x20,
  0x00, 0x1C, 0xC0, 0x00, 0x79, 0x00, 0x01, 0xB2, 0x00, 0x06, 0x6C, 0x00,
  0x18, 0x98, 0x00, 0x61, 0x20, 0x01, 0x02, 0x40, 0x0C, 0x04, 0x80, 0x30,
  0x09, 0x00, 0xC0, 0x36, 0x03, 0x00, 0x6C, 0x0C, 0x00, 0x90, 0x30, 0x01,
  0x20, 0x80, 0x02, 0x42, 0x00, 0x0C, 0x98, 0x00, 0x11, 0x60, 0x00, 0x23,
  0x80, 0x00, 0xC6, 0x00, 0x01, 0x08, 0x00, 0x06, 0x10, 0x00, 0x08, 0x30,
  0x00, 0x30, 0x20, 0x00, 0x40, 0x60, 0x01, 0x00, 0x60, 0x0C, 0x00, 0x60,
  0x30, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x10, 0x03, 0x01, 0xD0, 0x71, 0x1C,
  0x3E, 0x03, 0x80, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x00,
  0x0F, 0xC0, 0x00, 0xF0, 0xE0, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x30,
  0x00, 0x60, 0xC0, 0x00, 0xC1, 0x00, 0x00, 0x86, 0x00, 0x01, 0x08, 0x00,
  0x02, 0x10, 0x00, 0x04, 0x40, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x3C,
  0x38, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x06, 0x01, 0x00, 0x02, 0x02, 0x00,
  0x01, 0x06, 0x00, 0x01, 0x04, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x08, 0x40, 0x00,
  0x08, 0x40, 0x00, 0x18, 0x60, 0x00, 0x30, 0x30, 0x00, 0x60, 0x18, 0x00,
  0xC0, 0x0C, 0x03, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x80, 0x00, 0x02, 0x40, 0x00,
  0x03, 0x20, 0x00, 0x03, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x08, 0x00,
  0x01, 0x04, 0x00, 0x01, 0x82, 0x00, 0x01, 0x81, 0x00, 0x01, 0x81, 0x80,
  0x01, 0x80, 0xC0, 0x00, 0x80, 0x40, 0x00, 0x80, 0x20, 0x00, 0xC0, 0x10,
  0x00, 0xC0, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x40, 0x02,
  0x00, 0x60, 0x01, 0x00, 0x60, 0x00, 0x80, 0x60, 0x00, 0x40, 0x60, 0x00,
  0x60, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x23, 0xFC, 0x00, 0x17,
  0x03, 0x80, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x08, 0x00, 0x02, 0x04, 0x00, 0x03, 0x02, 0x00, 0x01, 0x01, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x80, 0x20, 0x00, 0x80, 0x08, 0x01, 0xC0, 0x07, 0x01,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x41, 0xFE, 0x03, 0x3C, 0x0C, 0x09, 0x80,
  0x18, 0x2C, 0x00, 0x31, 0xC0, 0x00, 0x46, 0x00, 0x01, 0x98, 0x00, 0x02,
  0x40, 0x00, 0x09, 0x00, 0x00, 0x24, 0x00, 0x00, 0xB0, 0x00, 0x02, 0xC0,
  0x00, 0x0B, 0x00, 0x00, 0x2C, 0x00, 0x01, 0xB0, 0x00, 0x04, 0xC0, 0x00,
  0x11, 0x00, 0x00, 0xC4, 0x00, 0x06, 0x18, 0x00, 0x10, 0x30, 0x00, 0xC0,
  0x60, 0x06, 0x00, 0xC0, 0x60, 0x01, 0xFF, 0x00, 0x00, 0x40, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1E,
  0x1C, 0x00, 0x38, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x10,
  0x00, 0x08, 0x18, 0x00, 0x04, 0x08, 0x00, 0x02, 0x0C, 0x00, 0x01, 0x06,
  0x00, 0x00, 0x82, 0x00, 0x00, 0x41, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x20,
  0x20, 0x00, 0x30, 0x18, 0x00, 0x30, 0x06, 0x00, 0x30, 0x01, 0x80, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x01,
  0x00, 0xC0, 0x00, 0x40, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x08, 0x40, 0x00,
  0x04, 0x20, 0x00, 0x02, 0x30, 0x00, 0x01, 0x10, 0x00, 0x00, 0x88, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x43, 0x00, 0x00, 0x60, 0x80, 0x00, 0x60, 0x60,
  0x00, 0x60, 0x18, 0x00, 0x60, 0x07, 0x00, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x0F, 0x1C, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x40, 0x80,
  0x03, 0x0C, 0x00, 0x08, 0xC0, 0x00, 0x64, 0x00, 0x01, 0x60, 0x00, 0x0A,
  0x00, 0x00, 0x50, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xD0,
  0x00, 0x0C, 0x80, 0x00, 0xA2, 0x00, 0x09, 0x18, 0x01, 0x98, 0x60, 0x38,
  0x81, 0xFF, 0x04, 0x00, 0x80, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x04,
  0x1C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x38, 0x60, 0x00, 0x80, 0x70, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x06, 0x01,
  0x80, 0x40, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xE3,
  0x80, 0xC0, 0x30, 0x60, 0x06, 0x30, 0x00, 0x98, 0x00, 0x34, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x60, 0x18,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x06, 0x03, 0xF0,
  0x10, 0xC0, 0xE1, 0x81, 0x08, 0x18, 0x08, 0x11, 0x81, 0x00, 0x81, 0x10,
  0x30, 0x18, 0x13, 0x06, 0x01, 0x01, 0x20, 0x40, 0x10, 0x12, 0x04, 0x01,
  0x03, 0x60, 0xC0, 0x20, 0x34, 0x08, 0x02, 0x02, 0x40, 0x80, 0x20, 0x24,
  0x18, 0x06, 0x02, 0xC1, 0x00, 0x40, 0x6C, 0x10, 0x04, 0x04, 0x81, 0x00,
  0xC0, 0x48, 0x10, 0x0C, 0x0C, 0x81, 0x01, 0xC0, 0x88, 0x10, 0x3C, 0x18,
  0xC1, 0x06, 0xC3, 0x0C, 0x18, 0xC4, 0x60, 0xC0, 0xF8, 0x3C, 0x04, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x04, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x90, 0x00, 0x01, 0x90, 0x00, 0x01, 0x10, 0x00, 0x03, 0x10, 0x00,
  0x02, 0x10, 0x00, 0x06, 0x18, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x08, 0x00,
  0x08, 0x08, 0x00, 0x18, 0x08, 0x00, 0x10, 0x08, 0x00, 0x30, 0x08, 0x00,
  0x20, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x04, 0x00,
  0x80, 0x04, 0x01, 0x80, 0x04, 0x01, 0x00, 0x04, 0x03, 0x00, 0x06, 0x03,
  0xFF, 0xFE, 0x06, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x08,
  0x00, 0x02, 0x08, 0x00, 0x02, 0x10, 0x00, 0x03, 0x10, 0x00, 0x03, 0x20,
  0x00, 0x01, 0x20, 0x00, 0x01, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x06, 0x00, 0x38, 0x06, 0x00, 0x0C, 0x04,
  0x00, 0x06, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x08, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08,
  0x00, 0x06, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x10, 0x00, 0x30, 0x10,
  0x00, 0xC0, 0x1F, 0xFF, 0x00, 0x10, 0x03, 0xC0, 0x30, 0x00, 0x30, 0x30,
  0x00, 0x18, 0x20, 0x00, 0x08, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x20,
  0x00, 0x04, 0x60, 0x00, 0x04, 0x60, 0x00, 0x04, 0x40, 0x00, 0x0C, 0x40,
  0x00, 0x08, 0x40, 0x00, 0x18, 0x40, 0x00, 0x10, 0xC0, 0x00, 0x30, 0x80,
  0x00, 0x60, 0x80, 0x01, 0xC0, 0x80, 0x0F, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x38, 0x70, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x04, 0x03,
  0x00, 0x06, 0x06, 0x00, 0x02, 0x04, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x08,
  0x00, 0x01, 0x18, 0x00, 0x01, 0x10, 0x00, 0x01, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x08, 0x40,
  0x00, 0x18, 0x40, 0x00, 0x10, 0x40, 0x00, 0x30, 0x20, 0x00, 0x60, 0x30,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x0C, 0x07, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x40, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x80, 0x0E, 0x00,
  0x40, 0x01, 0x80, 0x20, 0x00, 0x60, 0x30, 0x00, 0x10, 0x18, 0x00, 0x04,
  0x08, 0x00, 0x02, 0x04, 0x00, 0x01, 0x82, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x21, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x08, 0x40, 0x00, 0x04, 0x20, 0x00,
  0x02, 0x10, 0x00, 0x01, 0x08, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x44, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x31, 0x00, 0x00, 0x10, 0x80, 0x00, 0x08, 0x40,
  0x00, 0x04, 0x60, 0x00, 0x06, 0x20, 0x00, 0x02, 0x10, 0x00, 0x03, 0x08,
  0x00, 0x01, 0x04, 0x00, 0x01, 0x86, 0x00, 0x00, 0x83, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0x20, 0x01, 0x80,
  0x30, 0x07, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC1, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x1C, 0x38, 0x00, 0x38, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x30, 0x00,
  0x20, 0x30, 0x00, 0x18, 0x10, 0x00, 0x04, 0x18, 0x00, 0x02, 0x18, 0x00,
  0x01, 0x08, 0x00, 0x00, 0x84, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0xFF, 0xE4, 0x00, 0x00, 0x32, 0x00, 0x00, 0x11, 0x00, 0x00, 0x08,
  0x80, 0x00, 0x04, 0x40, 0x00, 0x02, 0x20, 0x00, 0x03, 0x18, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x82, 0x00, 0x00, 0x41, 0x80, 0x00, 0x20, 0x40, 0x00,
  0x30, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x03, 0x00, 0xF0, 0x00, 0xFF,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x60, 0x40, 0x00, 0x08,
  0x18, 0x00, 0x01, 0x03, 0x00, 0x00, 0x20, 0x40, 0x00, 0x04, 0x08, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x30, 0x20, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x81,
  0x80, 0x00, 0x10, 0x20, 0x00, 0x02, 0x04, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x10, 0x10, 0x00, 0x02, 0x06, 0x00, 0x00, 0x40, 0x80, 0x00, 0x08, 0x10,
  0x00, 0x01, 0x03, 0xFF, 0xFF, 0xE0, 0x40, 0x00, 0x08, 0x08, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x20, 0x40, 0x00, 0x04, 0x08, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x30, 0x20, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x81, 0x80, 0x00, 0x10,
  0x20, 0x00, 0x02, 0x04, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x18, 0x10, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x08, 0x10, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x60, 0x40, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x20, 0x00, 0x06, 0x10, 0x00, 0x02, 0x08, 0x00, 0x01, 0x06, 0x00,
  0x01, 0x83, 0x00, 0x01, 0x80, 0x80, 0x00, 0x80, 0x60, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x06, 0x03, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x40, 0x00, 0x18, 0x08, 0x00, 0x06, 0x03, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x60, 0x08, 0x00, 0x18, 0x01, 0x00, 0x06, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x30, 0x06,
  0x00, 0x04, 0x01, 0x80, 0x00, 0x80, 0x60, 0x00, 0x10, 0x18, 0x00, 0x02,
  0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x02, 0x34, 0x00,
  0x00, 0x4C, 0xC0, 0x00, 0x0B, 0x08, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x70,
  0x18, 0x00, 0x0C, 0x01, 0x00, 0x01, 0x00, 0x30, 0x00, 0x20, 0x02, 0x00,
  0x04, 0x00, 0x60, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0x40, 0x04, 0x00,
  0x0C, 0x00, 0x80, 0x00, 0x80, 0x10, 0x00, 0x18, 0x02, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x10, 0x18, 0x00, 0x03, 0x02, 0x00, 0x00, 0x20, 0x40, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x03, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xE0, 0x78, 0x00,
  0x14, 0x09, 0x00, 0x06, 0x81, 0x20, 0x01, 0x90, 0x24, 0x00, 0x26, 0x04,
  0x80, 0x0C, 0xC1, 0x98, 0x01, 0x10, 0x31, 0x00, 0x62, 0x04, 0x20, 0x08,
  0x40, 0x84, 0x03, 0x08, 0x10, 0x80, 0xC3, 0x02, 0x18, 0x10, 0x60, 0xC1,
  0x06, 0x08, 0x18, 0x20, 0x81, 0x02, 0x04, 0x30, 0x20, 0x40, 0x84, 0x0C,
  0x08, 0x19, 0x81, 0x81, 0x01, 0x20, 0x20, 0x60, 0x28, 0x04, 0x0C, 0x07,
  0x00, 0x81, 0x00, 0xC0, 0x10, 0x20, 0x18, 0x06, 0x04, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x10, 0x30, 0x00, 0x02, 0x06, 0x00, 0x00, 0x40, 0x80, 0x00,
  0x08, 0x10, 0x00, 0x03, 0x02, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x08, 0x18,
  0x00, 0x01, 0x02, 0x00, 0x00, 0x20, 0x40, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x08, 0x1C, 0x00, 0x01, 0x03, 0x80, 0x00, 0x20,
  0x58, 0x00, 0x04, 0x09, 0x00, 0x01, 0x81, 0x20, 0x00, 0x20, 0x26, 0x00,
  0x04, 0x0C, 0x40, 0x00, 0x81, 0x88, 0x00, 0x10, 0x20, 0x80, 0x02, 0x04,
  0x10, 0x00, 0xC0, 0x83, 0x00, 0x10, 0x10, 0x20, 0x02, 0x06, 0x04, 0x00,
  0x40, 0x80, 0xC0, 0x08, 0x10, 0x08, 0x03, 0x02, 0x01, 0x00, 0x60, 0x40,
  0x10, 0x08, 0x08, 0x02, 0x01, 0x03, 0x00, 0x60, 0x20, 0x40, 0x04, 0x04,
  0x08, 0x00, 0x81, 0x81, 0x00, 0x08, 0x30, 0x20, 0x01, 0x04, 0x04, 0x00,
  0x20, 0x81, 0x80, 0x02, 0x10, 0x20, 0x00, 0x42, 0x04, 0x00, 0x0C, 0xC0,
  0x80, 0x00, 0x98, 0x10, 0x00, 0x12, 0x02, 0x00, 0x01, 0x40, 0xC0, 0x00,
  0x28, 0x10, 0x00, 0x05, 0x02, 0x00, 0x00, 0x60, 0x40, 0x00, 0x08, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x38, 0x70, 0x00, 0xE0, 0x18, 0x01, 0x80, 0x0C,
  0x03, 0x00, 0x04, 0x06, 0x00, 0x02, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x03,
  0x08, 0x00, 0x03, 0x18, 0x00, 0x01, 0x10, 0x00, 0x01, 0x30, 0x00, 0x01,
  0x20, 0x00, 0x01, 0x20, 0x00, 0x01, 0x20, 0x00, 0x01, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02,
  0x40, 0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x04,
  0x80, 0x00, 0x04, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18,
  0x40, 0x00, 0x10, 0x40, 0x00, 0x30, 0x40, 0x00, 0x60, 0x20, 0x00, 0x40,
  0x30, 0x00, 0x80, 0x10, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x20, 0x00, 0xE0, 0x08, 0x00,
  0x0C, 0x02, 0x00, 0x01, 0x01, 0x80, 0x00, 0x60, 0x60, 0x00, 0x08, 0x10,
  0x00, 0x02, 0x04, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x30, 0x40, 0x00, 0x0C,
  0x30, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x82, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x10, 0x20, 0x00, 0x0C, 0x08, 0x00, 0x06, 0x06, 0x00, 0x03, 0x01, 0x80,
  0x03, 0x80, 0x40, 0x07, 0x80, 0x1F, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x1C, 0x38, 0x00, 0x30, 0x07, 0x00, 0x30, 0x00, 0x80, 0x30, 0x00,
  0x20, 0x30, 0x00, 0x10, 0x30, 0x00, 0x04, 0x10, 0x00, 0x02, 0x18, 0x00,
  0x01, 0x08, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x64, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x06, 0x80, 0x00, 0x03, 0x40,
  0x00, 0x01, 0x60, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x09, 0x00, 0x00, 0x04,
  0x80, 0x00, 0x06, 0x40, 0x00, 0x02, 0x20, 0x00, 0x03, 0x10, 0x00, 0x01,
  0x08, 0x00, 0x01, 0x86, 0x00, 0x00, 0x81, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0xC0, 0x20, 0x00, 0xC0, 0x08, 0x00, 0xC0, 0x03, 0x01, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x02, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x06,
  0x04, 0x00, 0x02, 0x04, 0x00, 0x03, 0x04, 0x00, 0x01, 0x04, 0x00, 0x01,
  0x0C, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x08, 0x00, 0x03, 0x08, 0x00, 0x03,
  0x08, 0x00, 0x02, 0x08, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x08,
  0x10, 0x00, 0x30, 0x10, 0x00, 0x60, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x01, 0x00, 0x20, 0x01, 0x00, 0x20, 0x01, 0x80,
  0x20, 0x00, 0x80, 0x60, 0x00, 0x80, 0x60, 0x00, 0xC0, 0x40, 0x00, 0x40,
  0x40, 0x00, 0x60, 0x40, 0x00, 0x20, 0x40, 0x00, 0x20, 0xC0, 0x00, 0x30,
  0xC0, 0x00, 0x10, 0x80, 0x00, 0x18, 0x80, 0x00, 0x18, 0x00, 0x0F, 0xE0,
  0x00, 0x3E, 0x3C, 0x00, 0x30, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x60, 0x00,
  0x20, 0x20, 0x00, 0x18, 0x30, 0x00, 0x04, 0x10, 0x00, 0x02, 0x08, 0x00,
  0x01, 0x84, 0x00, 0x00, 0x82, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x20, 0x00, 0x01, 0x10, 0x00, 0x00,
  0x88, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x63, 0x00, 0x00, 0x20, 0x80, 0x00,
  0x20, 0x60, 0x00, 0x30, 0x18, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x08,
  0x30, 0x00, 0x02, 0x08, 0x00, 0x00, 0x82, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x18, 0x20, 0x00, 0x04, 0x18, 0x00, 0x01, 0x04, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x10, 0x40, 0x00, 0x0C, 0x10, 0x00, 0x03, 0x04, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x20, 0x80, 0x00, 0x08, 0x20, 0x00, 0x02, 0x08, 0x00, 0x01,
  0x82, 0x00, 0x00, 0x61, 0x80, 0x00, 0x10, 0x60, 0x00, 0x04, 0x10, 0x00,
  0x01, 0x04, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x30, 0x40, 0x00, 0x08, 0x30,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0x83, 0x00, 0x00, 0x60, 0x40, 0x00, 0x10,
  0x10, 0x00, 0x0C, 0x04, 0x00, 0x02, 0x01, 0x80, 0x01, 0x00, 0x20, 0x00,
  0xC0, 0x04, 0x00, 0xE0, 0x00, 0xC0, 0x60, 0x00, 0x1F, 0xF0, 0x00, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x02, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x04, 0xC0,
  0x00, 0x0C, 0x40, 0x00, 0x08, 0x40, 0x00, 0x18, 0x40, 0x00, 0x10, 0x40,
  0x00, 0x30, 0x60, 0x00, 0x20, 0x60, 0x00, 0x20, 0x20, 0x00, 0x60, 0x20,
  0x00, 0x40, 0x20, 0x00, 0xC0, 0x20, 0x00, 0x80, 0x20, 0x01, 0x80, 0x30,
  0x01, 0x00, 0x30, 0x03, 0x00, 0x10, 0x02, 0x00, 0x10, 0x06, 0x00, 0x10,
  0x04, 0x00, 0x10, 0x0C, 0x00, 0x18, 0x08, 0x00, 0x18, 0x18, 0x00, 0x08,
  0x10, 0x00, 0x08, 0x30, 0x00, 0x08, 0x20, 0x00, 0x08, 0x20, 0x00, 0x0C,
  0x40, 0x00, 0x0C, 0x40, 0x00, 0x04, 0xC0, 0x00, 0x04, 0x80, 0x00, 0x05,
  0x80, 0x00, 0x05, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x08, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x50, 0x03, 0x00, 0x28,
  0x03, 0x80, 0x14, 0x01, 0x40, 0x1A, 0x00, 0xA0, 0x09, 0x00, 0xD0, 0x04,
  0x80, 0x48, 0x06, 0x40, 0x24, 0x02, 0x20, 0x32, 0x01, 0x10, 0x11, 0x01,
  0x88, 0x08, 0x80, 0x84, 0x0C, 0x40, 0x42, 0x04, 0x20, 0x61, 0x06, 0x10,
  0x20, 0x83, 0x0C, 0x10, 0x41, 0x06, 0x08, 0x21, 0x83, 0x08, 0x10, 0x81,
  0x84, 0x08, 0x40, 0xC2, 0x04, 0x60, 0x63, 0x02, 0x20, 0x31, 0x01, 0x10,
  0x18, 0x80, 0x98, 0x0C, 0xC0, 0x48, 0x06, 0x40, 0x24, 0x01, 0x20, 0x16,
  0x00, 0xB0, 0x0A, 0x00, 0x50, 0x05, 0x00, 0x28, 0x03, 0x80, 0x1C, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x20, 0x01, 0x80,
  0x10, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x08, 0x03, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x40, 0x00, 0x60, 0x06,
  0x00, 0x01, 0x00, 0x60, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x20, 0x20, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x90, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x08, 0x40, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x40, 0x40, 0x00, 0x04,
  0x03, 0x00, 0x00, 0x60, 0x08, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x20, 0x03, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x04, 0x01, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x81, 0x80,
  0x00, 0x06, 0x00, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x04,
  0x40, 0x00, 0x0C, 0x60, 0x00, 0x08, 0x60, 0x00, 0x10, 0x20, 0x00, 0x30,
  0x30, 0x00, 0x60, 0x10, 0x00, 0x40, 0x10, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x08, 0x01, 0x00, 0x08, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x04, 0x04, 0x00,
  0x04, 0x08, 0x00, 0x06, 0x18, 0x00, 0x02, 0x10, 0x00, 0x02, 0x20, 0x00,
  0x03, 0x60, 0x00, 0x01, 0x40, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x43, 0xFF, 0xFF, 0xE0,
  0x01, 0xFC, 0x07, 0xF0, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0xC0, 0x60, 0x10, 0x08, 0x04, 0x03, 0x01, 0x80, 0x40, 0x20,
  0x10, 0x0C, 0x06, 0x01, 0x00, 0x80, 0x40, 0x30, 0x18, 0x04, 0x02, 0x01,
  0x00, 0xC0, 0x60, 0x10, 0x08, 0x06, 0x03, 0x00, 0x80, 0x40, 0x20, 0x18,
  0x0C, 0x02, 0x01, 0x00, 0x80, 0x60, 0x30, 0x08, 0x04, 0x02, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x05, 0x00, 0x06, 0xC0, 0x02, 0x20, 0x03, 0x10, 0x03, 0x08, 0x01,
  0x06, 0x01, 0x83, 0x00, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x30, 0x60, 0x18,
  0x60, 0x04, 0x20, 0x02, 0x30, 0x01, 0x10, 0x00, 0xD8, 0x00, 0x78, 0x00,
  0x10, 0xFF, 0xFF, 0xF0, 0xC2, 0x18, 0x41, 0x08, 0x20, 0x00, 0x1F, 0x80,
  0x03, 0xEF, 0x80, 0x38, 0x03, 0x01, 0x80, 0x06, 0x0C, 0x00, 0x08, 0x20,
  0x00, 0x31, 0x80, 0x00, 0x44, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xE0,
  0xE0, 0x00, 0x86, 0x00, 0x06, 0x30, 0x00, 0x19, 0x80, 0x00, 0x4C, 0x00,
  0x01, 0x20, 0x00, 0x04, 0x80, 0x00, 0x32, 0x00, 0x01, 0xC8, 0x00, 0x0E,
  0x30, 0x00, 0x68, 0x60, 0x03, 0x20, 0xC0, 0x70, 0x81, 0xFF, 0x02, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x07, 0xE0, 0x08,
  0x79, 0xC0, 0x27, 0x00, 0xC0, 0xB0, 0x01, 0x03, 0x80, 0x06, 0x1C, 0x00,
  0x08, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC4, 0x00, 0x01, 0x10, 0x00, 0x04,
  0x40, 0x00, 0x13, 0x00, 0x00, 0x4C, 0x00, 0x01, 0x20, 0x00, 0x0C, 0x80,
  0x00, 0x32, 0x00, 0x00, 0x88, 0x00, 0x02, 0x60, 0x00, 0x19, 0x00, 0x00,
  0x44, 0x00, 0x01, 0x10, 0x00, 0x0C, 0x40, 0x00, 0x61, 0x80, 0x01, 0x0E,
  0x00, 0x0C, 0x34, 0x00, 0xE0, 0x8C, 0x06, 0x02, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x07, 0x9E, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x60, 0xC0, 0x01,
  0x0C, 0x00, 0x0C, 0x40, 0x00, 0x24, 0x00, 0x01, 0x20, 0x00, 0x0B, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x48, 0x00, 0x02, 0x60, 0x00, 0x21, 0x00, 0x03, 0x0C,
  0x00, 0x30, 0x30, 0x03, 0x00, 0xC0, 0x70, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x7E, 0x04, 0x01, 0xF7,
  0x8C, 0x03, 0x00, 0xCC, 0x06, 0x00, 0x68, 0x0C, 0x00, 0x28, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x18, 0x20, 0x00, 0x18, 0x60, 0x00, 0x18, 0x40, 0x00,
  0x10, 0x40, 0x00, 0x10, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x30, 0x80, 0x00,
  0x30, 0x80, 0x00, 0x20, 0x80, 0x00, 0x20, 0x80, 0x00, 0x20, 0x80, 0x00,
  0x20, 0x80, 0x00, 0x60, 0x80, 0x00, 0x60, 0x80, 0x00, 0x40, 0xC0, 0x00,
  0x40, 0x40, 0x00, 0xC0, 0x40, 0x01, 0x40, 0x20, 0x06, 0xC0, 0x38, 0x1C,
  0xC0, 0x0F, 0xF0, 0x80, 0x00, 0x1F, 0x80, 0x00, 0xF3, 0xC0, 0x07, 0x00,
  0xC0, 0x18, 0x00, 0xC0, 0x60, 0x00, 0x81, 0x80, 0x01, 0x86, 0x00, 0x01,
  0x08, 0x00, 0x02, 0x30, 0x00, 0x06, 0x40, 0x00, 0x0D, 0x80, 0x00, 0x1A,
  0x00, 0x00, 0x27, 0xFF, 0xFF, 0xC8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x18, 0x18, 0x00, 0xC0, 0x1C, 0x07, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0x04, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x7D, 0xE3, 0x00, 0xC0, 0x33, 0x01, 0x80, 0x1A,
  0x03, 0x00, 0x0A, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x04, 0x10, 0x00, 0x04, 0x30, 0x00, 0x04,
  0x30, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x08,
  0x20, 0x00, 0x08, 0x20, 0x00, 0x08, 0x20, 0x00, 0x18, 0x20, 0x00, 0x18,
  0x20, 0x00, 0x10, 0x30, 0x00, 0x30, 0x10, 0x00, 0x30, 0x18, 0x00, 0x50,
  0x08, 0x01, 0x90, 0x06, 0x07, 0x30, 0x03, 0xFC, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x40, 0x01, 0x80, 0xC0, 0x01, 0x00, 0x60, 0x06, 0x00, 0x30, 0x0C, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x03, 0xF0, 0x08, 0x3C, 0xE0, 0x23, 0x80, 0x60, 0x98, 0x00, 0x86,
  0xC0, 0x03, 0x14, 0x00, 0x0C, 0x70, 0x00, 0x11, 0x80, 0x00, 0x44, 0x00,
  0x01, 0x10, 0x00, 0x04, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xC8, 0x00, 0x02,
  0x20, 0x00, 0x08, 0x80, 0x00, 0x26, 0x00, 0x00, 0x98, 0x00, 0x06, 0x60,
  0x00, 0x19, 0x00, 0x00, 0x44, 0x00, 0x01, 0x10, 0x00, 0x04, 0xC0, 0x00,
  0x13, 0x00, 0x00, 0xC8, 0x00, 0x03, 0x20, 0x00, 0x08, 0x80, 0x00, 0x22,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x80, 0x00, 0xC1, 0x00, 0x03, 0x02, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x18,
  0x01, 0x80, 0x20, 0x0C, 0x00, 0x40, 0x30, 0x00, 0x80, 0xC0, 0x01, 0x07,
  0x00, 0x06, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x11, 0xC0, 0x00, 0x2C, 0xC0,
  0x00, 0x70, 0x80, 0x00, 0xC1, 0x80, 0x03, 0x01, 0x80, 0x06, 0x01, 0x80,
  0x08, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x03, 0x00, 0x40, 0x02, 0x01,
  0x80, 0x06, 0x03, 0x00, 0x06, 0x04, 0x00, 0x04, 0x08, 0x00, 0x0C, 0x10,
  0x00, 0x0C, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x0F,
  0xFF, 0xFF, 0x00, 0x3E, 0x03, 0xC0, 0x27, 0x38, 0x7B, 0x81, 0x60, 0x66,
  0x06, 0x0E, 0x01, 0x40, 0x10, 0xE0, 0x0C, 0x00, 0x86, 0x00, 0x60, 0x04,
  0x30, 0x02, 0x00, 0x21, 0x00, 0x10, 0x01, 0x08, 0x00, 0x80, 0x08, 0x40,
  0x0C, 0x00, 0xC6, 0x00, 0x60, 0x04, 0x20, 0x02, 0x00, 0x21, 0x00, 0x10,
  0x01, 0x08, 0x00, 0x80, 0x08, 0x40, 0x04, 0x00, 0x46, 0x00, 0x60, 0x06,
  0x30, 0x02, 0x00, 0x21, 0x00, 0x10, 0x01, 0x08, 0x00, 0x80, 0x08, 0x40,
  0x04, 0x00, 0x42, 0x00, 0x20, 0x06, 0x30, 0x03, 0x00, 0x31, 0x00, 0x10,
  0x01, 0x08, 0x00, 0x80, 0x08, 0x40, 0x04, 0x00, 0x42, 0x00, 0x20, 0x02,
  0x30, 0x03, 0x00, 0x30, 0x00, 0x07, 0xE0, 0x08, 0x3C, 0xE0, 0x11, 0xC0,
  0x20, 0x26, 0x00, 0x20, 0xD0, 0x00, 0x41, 0x40, 0x00, 0xC3, 0x80, 0x00,
  0x86, 0x00, 0x01, 0x08, 0x00, 0x02, 0x30, 0x00, 0x04, 0x60, 0x00, 0x18,
  0xC0, 0x00, 0x31, 0x00, 0x00, 0x42, 0x00, 0x00, 0x84, 0x00, 0x01, 0x18,
  0x00, 0x02, 0x30, 0x00, 0x0C, 0x40, 0x00, 0x18, 0x80, 0x00, 0x21, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x8C, 0x00, 0x01, 0x18, 0x00, 0x06, 0x20, 0x00,
  0x0C, 0x40, 0x00, 0x10, 0x80, 0x00, 0x23, 0x00, 0x00, 0x40, 0x00, 0x1F,
  0x00, 0x01, 0xF7, 0xC0, 0x0E, 0x01, 0xC0, 0x30, 0x00, 0xC0, 0xC0, 0x00,
  0x81, 0x00, 0x01, 0x84, 0x00, 0x01, 0x18, 0x00, 0x02, 0x20, 0x00, 0x06,
  0xC0, 0x00, 0x0D, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x40, 0x00, 0x02, 0x80, 0x00, 0x05, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x24, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x08, 0x00,
  0x06, 0x18, 0x00, 0x18, 0x10, 0x00, 0x60, 0x30, 0x01, 0x80, 0x38, 0x0E,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0x07, 0xC0, 0x02, 0x1E, 0x70, 0x02, 0x70,
  0x18, 0x02, 0xC0, 0x04, 0x03, 0x80, 0x06, 0x07, 0x00, 0x02, 0x06, 0x00,
  0x02, 0x04, 0x00, 0x03, 0x04, 0x00, 0x03, 0x04, 0x00, 0x01, 0x04, 0x00,
  0x01, 0x0C, 0x00, 0x01, 0x08, 0x00, 0x03, 0x08, 0x00, 0x03, 0x08, 0x00,
  0x02, 0x08, 0x00, 0x02, 0x18, 0x00, 0x02, 0x18, 0x00, 0x06, 0x10, 0x00,
  0x04, 0x10, 0x00, 0x0C, 0x10, 0x00, 0x08, 0x10, 0x00, 0x18, 0x38, 0x00,
  0x10, 0x38, 0x00, 0x20, 0x24, 0x00, 0xC0, 0x23, 0x01, 0x80, 0x21, 0xFF,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0x9E,
  0x30, 0x30, 0x0C, 0xC1, 0x80, 0x1A, 0x0C, 0x00, 0x38, 0x60, 0x00, 0x63,
  0x00, 0x01, 0x88, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x44, 0x00,
  0x01, 0x30, 0x00, 0x04, 0xC0, 0x00, 0x12, 0x00, 0x00, 0xC8, 0x00, 0x02,
  0x20, 0x00, 0x08, 0x80, 0x00, 0x22, 0x00, 0x00, 0x88, 0x00, 0x06, 0x20,
  0x00, 0x18, 0x80, 0x00, 0x43, 0x00, 0x01, 0x04, 0x00, 0x0C, 0x18, 0x00,
  0x50, 0x20, 0x06, 0x40, 0xE0, 0x73, 0x00, 0xFF, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x04, 0x07, 0xF8, 0x40, 0xF8, 0x82, 0x18, 0x00, 0x13, 0x00, 0x00,
  0xB0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x07, 0xCF, 0x80, 0x70, 0x03, 0x03, 0x00, 0x06, 0x18,
  0x00, 0x08, 0x40, 0x00, 0x31, 0x00, 0x00, 0xC4, 0x00, 0x03, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x80, 0x00, 0x32, 0x00, 0x00,
  0xC8, 0x00, 0x02, 0x30, 0x00, 0x18, 0x60, 0x01, 0xC0, 0xE0, 0x1C, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0xFF, 0xFF,
  0xE0, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x40, 0x00, 0x31, 0x00, 0x00, 0xCC,
  0x00, 0x03, 0x30, 0x00, 0x08, 0x80, 0x00, 0x22, 0x00, 0x00, 0x88, 0x00,
  0x06, 0x20, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x01, 0x10, 0x00, 0x04,
  0x40, 0x00, 0x11, 0x00, 0x00, 0xC4, 0x00, 0x03, 0x30, 0x00, 0x08, 0xC0,
  0x00, 0x22, 0x00, 0x00, 0x88, 0x00, 0x06, 0x20, 0x00, 0x18, 0xC0, 0x00,
  0xE3, 0x00, 0x03, 0x04, 0x00, 0x14, 0x18, 0x01, 0x90, 0x30, 0x1C, 0x40,
  0x7F, 0xC3, 0x00, 0x80, 0x00, 0x07, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x22,
  0x00, 0x00, 0xC4, 0x00, 0x01, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x08, 0x10,
  0x00, 0x30, 0x20, 0x00, 0xC0, 0x60, 0x01, 0x00, 0xC0, 0x06, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x30, 0x03, 0x00, 0x40, 0x02, 0x01, 0x80, 0x04, 0x06,
  0x00, 0x0C, 0x08, 0x00, 0x18, 0x30, 0x00, 0x10, 0x40, 0x00, 0x21, 0x80,
  0x00, 0x62, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xB0, 0x00, 0x01, 0x40, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x80, 0x08, 0x00, 0xE0, 0x07, 0x00,
  0x28, 0x01, 0xC0, 0x1A, 0x00, 0x70, 0x04, 0x80, 0x2C, 0x03, 0x30, 0x0B,
  0x00, 0x8C, 0x06, 0x40, 0x23, 0x01, 0x10, 0x18, 0xC0, 0xC4, 0x04, 0x30,
  0x21, 0x03, 0x0C, 0x08, 0x40, 0x83, 0x06, 0x10, 0x20, 0xC1, 0x04, 0x18,
  0x10, 0xC1, 0x04, 0x04, 0x20, 0x43, 0x01, 0x08, 0x18, 0x80, 0x44, 0x06,
  0x20, 0x11, 0x01, 0x98, 0x04, 0xC0, 0x64, 0x01, 0x20, 0x0B, 0x00, 0x58,
  0x02, 0x80, 0x14, 0x00, 0xA0, 0x05, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x30, 0x04, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x80, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x03, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x24, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0x88,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x18, 0x00, 0x06, 0x01, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x02, 0x00, 0x06,
  0x00, 0x80, 0x00, 0x40, 0x20, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x60, 0x20, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x04, 0x00, 0x01, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x20, 0x00, 0x80, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x30, 0x01, 0x80, 0x00, 0x40, 0x04, 0x00,
  0x01, 0x00, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x08, 0x04, 0x00, 0x00,
  0x20, 0x30, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x04,
  0x30, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x04, 0x00, 0x02, 0x04, 0x08, 0x10, 0x20, 0xC1,
  0x82, 0x04, 0x08, 0x10, 0x60, 0xC1, 0x02, 0x04, 0x08, 0x10, 0x60, 0xC1,
  0x02, 0x04, 0x08, 0x30, 0x60, 0x81, 0x02, 0x04, 0x08, 0x30, 0x60, 0x81,
  0x02, 0x04, 0x18, 0x30, 0x40, 0x81, 0x02, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x10, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xDE,
  0x00, 0x0C, 0x40, 0x60, 0x01, 0x10, 0x06, 0x00, 0x26, 0x00, 0x60, 0x0C,
  0x80, 0x06, 0x03, 0x30, 0x00, 0x71, 0xC6, 0x00, 0x03, 0xE0,
};

const GFXglyph RobotoMono_ThinItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 8, 36, 29, 10, -36 },
  { 37, 9, 11, 29, 13, -38 },
  { 50, 29, 36, 29, 1, -36 },
  { 181, 24, 46, 29, 3, -41 },
  { 319, 24, 37, 29, 3, -36 },
  { 430, 25, 36, 29, 2, -36 },
  { 543, 3, 11, 29, 15, -38 },
  { 548, 15, 51, 29, 9, -40 },
  { 644, 15, 51, 29, 5, -40 },
  { 740, 21, 20, 29, 7, -36 },
  { 793, 24, 25, 29, 3, -29 },
  { 868, 5, 10, 29, 6, -4 },
  { 875, 17, 1, 29, 6, -17 },
  { 878, 3, 3, 29, 12, -3 },
  { 880, 23, 39, 29, 4, -36 },
  { 993, 23, 36, 29, 4, -36 },
  { 1097, 12, 36, 29, 8, -36 },
  { 1151, 23, 36, 29, 1, -36 },
  { 1255, 24, 36, 29, 1, -36 },
  { 1363, 25, 36, 29, 1, -36 },
  { 1476, 25, 36, 29, 4, -36 },
  { 1589, 22, 37, 29, 3, -36 },
  { 1691, 23, 36, 29, 6, -36 },
  { 1795, 25, 36, 29, 3, -36 },
  { 1908, 21, 36, 29, 5, -36 },
  { 2003, 7, 24, 29, 13, -24 },
  { 2024, 10, 30, 29, 10, -24 },
  { 2062, 22, 20, 29, 4, -26 },
  { 2117, 23, 11, 29, 3, -22 },
  { 2149, 22, 20, 29, 3, -26 },
  { 2204, 18, 36, 29, 8, -36 },
  { 2285, 28, 36, 29, 1, -36 },
  { 2411, 24, 36, 29, 0, -36 },
  { 2519, 24, 36, 29, 3, -36 },
  { 2627, 24, 37, 29, 3, -36 },
  { 2738, 25, 36, 29, 2, -36 },
  { 2851, 25, 36, 29, 3, -36 },
  { 2964, 26, 36, 29, 3, -36 },
  { 3081, 25, 37, 29, 3, -36 },
  { 3197, 27, 36, 29, 2, -36 },
  { 3319, 26, 36, 29, 2, -36 },
  { 3436, 25, 37, 29, 2, -36 },
  { 3552, 27, 36, 29, 3, -36 },
  { 3674, 20, 36, 29, 3, -36 },
  { 3764, 27, 36, 29, 2, -36 },
  { 3886, 27, 36, 29, 2, -36 },
  { 4008, 24, 36, 29, 3, -36 },
  { 4116, 26, 36, 29, 3, -36 },
  { 4233, 25, 42, 29, 3, -36 },
  { 4365, 24, 36, 29, 3, -36 },
  { 4473, 25, 36, 29, 3, -36 },
  { 4586, 24, 36, 29, 6, -36 },
  { 4694, 26, 36, 29, 3, -36 },
  { 4811, 24, 36, 29, 6, -36 },
  { 4919, 25, 36, 29, 6, -36 },
  { 5032, 29, 36, 29, 1, -36 },
  { 5163, 24, 36, 29, 6, -36 },
  { 5271, 26, 36, 29, 1, -36 },
  { 5388, 14, 49, 29, 8, -41 },
  { 5474, 9, 39, 29, 10, -36 },
  { 5518, 15, 49, 29, 7, -41 },
  { 5610, 17, 20, 29, 6, -36 },
  { 5653, 20, 1, 29, 2, 0 },
  { 5656, 5, 7, 29, 15, -37 },
  { 5661, 22, 28, 29, 3, -27 },
  { 5738, 22, 38, 29, 3, -38 },
  { 5843, 21, 27, 29, 4, -27 },
  { 5914, 24, 38, 29, 4, -38 },
  { 6028, 23, 27, 29, 3, -27 },
  { 6106, 23, 38, 29, 7, -38 },
  { 6216, 24, 38, 29, 2, -27 },
  { 6330, 22, 38, 29, 3, -38 },
  { 6435, 20, 36, 29, 3, -36 },
  { 6525, 23, 47, 29, 0, -36 },
  { 6661, 23, 38, 29, 4, -38 },
  { 6771, 20, 38, 29, 3, -38 },
  { 6866, 29, 27, 29, -1, -27 },
  { 6964, 23, 27, 29, 2, -27 },
  { 7042, 23, 27, 29, 3, -27 },
  { 7120, 24, 37, 29, 1, -27 },
  { 7231, 22, 37, 29, 4, -27 },
  { 7333, 21, 27, 29, 7, -27 },
  { 7404, 22, 27, 29, 4, -27 },
  { 7479, 19, 35, 29, 6, -34 },
  { 7563, 22, 26, 29, 4, -26 },
  { 7635, 23, 26, 29, 5, -26 },
  { 7710, 26, 26, 29, 4, -26 },
  { 7795, 27, 26, 29, 1, -26 },
  { 7883, 30, 37, 29, -1, -26 },
  { 8022, 26, 26, 29, 1, -26 },
  { 8107, 19, 50, 29, 8, -39 },
  { 8226, 7, 43, 29, 11, -36 },
  { 8264, 19, 50, 29, 4, -39 },
  { 8383, 27, 8, 29, 1, -19 },
};

const GFXfont RobotoMono_ThinItalic50pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic50pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic50pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _ROBOTOMONO_THINITALIC50PT7B_H_
