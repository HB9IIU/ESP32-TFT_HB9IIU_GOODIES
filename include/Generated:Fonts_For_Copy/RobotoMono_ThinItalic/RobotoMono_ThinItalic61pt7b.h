#ifndef _ROBOTOMONO_THINITALIC61PT7B_H_
#define _ROBOTOMONO_THINITALIC61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x70,
  0x38, 0x00, 0x30, 0x26, 0x04, 0xC1, 0x98, 0x33, 0x06, 0x40, 0xC8, 0x13,
  0x02, 0x60, 0xCC, 0x19, 0x03, 0x20, 0x4C, 0x08, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x08, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x60, 0x00, 0x01, 0x80, 0x08, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x04, 0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x04, 0x00, 0x60, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x04, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x04, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x20, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x20, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x20,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1C,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x38, 0x00, 0x18, 0x03, 0x80, 0x00,
  0x60, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x60,
  0x40, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x04, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x02, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x01, 0x80, 0x07, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x02,
  0x00, 0x21, 0x80, 0x10, 0x01, 0x88, 0x00, 0x80, 0x18, 0xC0, 0x04, 0x01,
  0x86, 0x00, 0x60, 0x18, 0x30, 0x03, 0x00, 0xC1, 0x00, 0x18, 0x0C, 0x08,
  0x00, 0x80, 0xC0, 0x40, 0x0C, 0x06, 0x02, 0x00, 0x60, 0x60, 0x18, 0x06,
  0x06, 0x00, 0xC0, 0x30, 0x20, 0x03, 0x07, 0x03, 0x00, 0x0E, 0xF0, 0x30,
  0x00, 0x3E, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0xC0, 0x7F, 0x00, 0x0C, 0x0E, 0x1C, 0x00, 0x60, 0x60, 0x60, 0x06, 0x06,
  0x01, 0x80, 0x60, 0x60, 0x0C, 0x03, 0x03, 0x00, 0x60, 0x30, 0x30, 0x03,
  0x03, 0x01, 0x80, 0x18, 0x10, 0x0C, 0x00, 0xC1, 0x80, 0x40, 0x06, 0x18,
  0x02, 0x00, 0x31, 0x80, 0x10, 0x01, 0x0C, 0x01, 0x80, 0x18, 0xC0, 0x04,
  0x00, 0xC4, 0x00, 0x20, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x06,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x40, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x0C,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x04, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x00, 0x8E, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0C,
  0x40, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x30, 0xC0, 0x18, 0x00, 0x86, 0x00, 0x30, 0x06, 0x30, 0x00, 0xC0,
  0x18, 0xC0, 0x01, 0x80, 0x66, 0x00, 0x02, 0x03, 0x18, 0x00, 0x0C, 0x0C,
  0x40, 0x00, 0x18, 0x61, 0x00, 0x00, 0x21, 0x8C, 0x00, 0x00, 0xCC, 0x30,
  0x00, 0x01, 0xB0, 0xC0, 0x00, 0x07, 0x81, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x78, 0x18, 0x00, 0x03, 0x60, 0x30, 0x00, 0x38, 0xC0, 0x60, 0x01,
  0xC1, 0x80, 0xF0, 0x3C, 0x06, 0x00, 0xFF, 0xC0, 0x0C, 0x00, 0x38, 0x00,
  0x00, 0x33, 0x22, 0x26, 0x66, 0x44, 0xCC, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x01, 0x00, 0x10,
  0x02, 0xE0, 0x08, 0x07, 0xBE, 0x0C, 0x1F, 0x03, 0xE6, 0x7C, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x01,
  0x8C, 0x00, 0x01, 0x86, 0x00, 0x01, 0x81, 0x80, 0x01, 0x80, 0x60, 0x01,
  0x80, 0x38, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x03, 0x01, 0x80, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x30, 0xC2, 0x08,
  0x61, 0x84, 0x31, 0x86, 0x30, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x6F, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0x80, 0x0E, 0x00, 0x04, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x80, 0x60, 0x00, 0x06, 0x02, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x68, 0x60, 0x00, 0x06, 0x43, 0x00, 0x00, 0xE2, 0x10, 0x00, 0x0C,
  0x11, 0x80, 0x00, 0xC0, 0x8C, 0x00, 0x0C, 0x0C, 0x60, 0x00, 0xC0, 0x63,
  0x00, 0x0C, 0x03, 0x10, 0x00, 0xC0, 0x18, 0x80, 0x1C, 0x00, 0x8C, 0x01,
  0x80, 0x04, 0x60, 0x18, 0x00, 0x63, 0x01, 0x80, 0x03, 0x10, 0x18, 0x00,
  0x18, 0x81, 0x80, 0x00, 0x84, 0x18, 0x00, 0x04, 0x23, 0x80, 0x00, 0x61,
  0x38, 0x00, 0x03, 0x0B, 0x00, 0x00, 0x10, 0x70, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x0C, 0x10, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x07, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x7C, 0x03,
  0x90, 0x3C, 0x21, 0xE0, 0x4F, 0x01, 0xB0, 0x03, 0x40, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x38, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x02, 0x06, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0x80, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x40, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0xC1, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x80, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x21, 0x80, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x0C,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0x78, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x06,
  0x80, 0x00, 0x00, 0x64, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x30, 0x20, 0x00, 0x03, 0x03, 0x00, 0x00, 0x38, 0x18, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x20, 0x00, 0x18, 0x01, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x0C, 0x00, 0x08, 0x00, 0xC0, 0x00,
  0xC0, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x01, 0x00,
  0x60, 0x00, 0x08, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x3F,
  0xE0, 0x00, 0x13, 0xE1, 0xE0, 0x00, 0xF8, 0x00, 0xC0, 0x03, 0x80, 0x01,
  0x80, 0x04, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x40, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x06, 0x00, 0x80, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x1C, 0x0F, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x04, 0x00, 0x18,
  0x3F, 0xF0, 0x04, 0x3C, 0x0F, 0x03, 0x38, 0x00, 0xE0, 0xD8, 0x00, 0x1C,
  0x2C, 0x00, 0x03, 0x1E, 0x00, 0x00, 0x67, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x02, 0x60, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x13, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00,
  0x70, 0x1C, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x30, 0x07, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x02, 0x00, 0x00, 0x08, 0x18, 0x00,
  0x00, 0x20, 0x60, 0x00, 0x00, 0x81, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00,
  0x18, 0x10, 0x00, 0x00, 0x60, 0x40, 0x00, 0x01, 0x01, 0x80, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x70, 0x03, 0x80, 0x07, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x01, 0x84, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x62, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x04, 0x20,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x0E, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x03, 0x00, 0x03, 0x01, 0x80, 0x00, 0x40, 0xC0, 0x00, 0x18,
  0x60, 0x00, 0x02, 0x18, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x32, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x01, 0x90, 0x00, 0x00,
  0x64, 0x00, 0x00, 0x39, 0x80, 0x00, 0x1E, 0x20, 0x00, 0x0D, 0x8C, 0x00,
  0x06, 0x41, 0x80, 0x07, 0x30, 0x30, 0x07, 0x8C, 0x07, 0xFF, 0x82, 0x00,
  0x7F, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x0F, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0xE0, 0x00, 0x70, 0x0F,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x10, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFC, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x70, 0x0E, 0x03, 0x80, 0x0C, 0x18,
  0x00, 0x18, 0xC0, 0x00, 0x62, 0x00, 0x00, 0x98, 0x00, 0x03, 0x40, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0x80, 0x78, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x03, 0xC0, 0x18, 0x0C, 0x01, 0xFE,
  0x01, 0x01, 0x80, 0x60, 0xE0, 0x20, 0x60, 0x18, 0x0C, 0x06, 0x18, 0x06,
  0x01, 0x80, 0xC3, 0x01, 0x80, 0x30, 0x18, 0x40, 0x60, 0x04, 0x02, 0x18,
  0x0C, 0x00, 0x80, 0x43, 0x03, 0x00, 0x30, 0x08, 0xC0, 0x60, 0x04, 0x01,
  0x18, 0x18, 0x00, 0x80, 0x62, 0x03, 0x00, 0x30, 0x0C, 0xC0, 0x40, 0x06,
  0x01, 0x98, 0x08, 0x00, 0x80, 0x23, 0x03, 0x00, 0x10, 0x04, 0x40, 0x60,
  0x06, 0x01, 0x88, 0x08, 0x00, 0xC0, 0x31, 0x01, 0x00, 0x30, 0x04, 0x60,
  0x20, 0x06, 0x01, 0x8C, 0x0C, 0x01, 0xC0, 0x31, 0x81, 0x80, 0x38, 0x04,
  0x30, 0x10, 0x0F, 0x01, 0x86, 0x02, 0x03, 0x60, 0x60, 0xC0, 0x40, 0xCC,
  0x0C, 0x08, 0x0C, 0x30, 0xC7, 0x01, 0x00, 0xFC, 0x1F, 0xC0, 0x30, 0x0E,
  0x00, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x30, 0x20, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x00, 0x00, 0xC0,
  0x04, 0x00, 0x03, 0x00, 0x10, 0x00, 0x18, 0x00, 0x60, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0x20,
  0x01, 0x80, 0x00, 0x80, 0x04, 0x00, 0x02, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x10, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x0C, 0x02, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x40, 0x40, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x61, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x09,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x06, 0x00, 0x3E, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x1C, 0x01,
  0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x20, 0x20, 0x00,
  0x00, 0x80, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x04, 0x00, 0x00, 0xE0,
  0x10, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x70, 0x03, 0x00, 0x07, 0x80, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x80, 0x00, 0x70, 0x02, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x06, 0x04, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x20,
  0x80, 0x00, 0x01, 0x82, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x70, 0x10, 0x00,
  0x03, 0x80, 0x40, 0x00, 0x38, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x60, 0x07, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18,
  0x10, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x82, 0x00, 0x00, 0x02, 0x18,
  0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x21, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x20, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x18, 0x10, 0x00, 0x00, 0x60, 0x40, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18,
  0x02, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x07, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x02, 0x00, 0x1E, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x04, 0x01, 0x00, 0x00, 0x0C, 0x02, 0x00,
  0x00, 0x08, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x20, 0x60, 0x00, 0x00, 0x40, 0x80, 0x00, 0x00, 0x81, 0x00, 0x00,
  0x01, 0x06, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00,
  0x08, 0x20, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x04,
  0x10, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x00, 0x83, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x08,
  0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x04, 0x00,
  0x00, 0x60, 0x08, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x38, 0x00, 0xC0, 0x01, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x02, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x60,
  0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x86, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x03, 0xFF, 0xF3, 0x00, 0x0F, 0xFF, 0x88, 0x00, 0x00, 0x02, 0x20, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x00, 0x62, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00,
  0x04, 0x20, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x43, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x81,
  0x80, 0x00, 0x02, 0x02, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xE0, 0x18,
  0x00, 0x07, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x0F, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x20, 0x10,
  0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x08,
  0x04, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xC0, 0x20, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00,
  0x02, 0x01, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x20, 0x10, 0x00,
  0x00, 0x30, 0x08, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x04, 0x03, 0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0x01, 0x00, 0x80,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x80, 0x80,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x80,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x08, 0x00, 0x03, 0x00, 0x04,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x07, 0x00, 0x00, 0x80, 0x07, 0x00, 0x00, 0x40, 0x07, 0x00, 0x00,
  0x20, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x01, 0x07, 0x00, 0x00, 0x01, 0x87, 0x80, 0x00, 0x00, 0xCE, 0x60, 0x00,
  0x00, 0x6E, 0x10, 0x00, 0x00, 0x2E, 0x0C, 0x00, 0x00, 0x1C, 0x03, 0x00,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x03, 0x00, 0x00, 0x80, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x03, 0x00, 0x08, 0x00, 0x01, 0x80, 0x04, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x60, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x78, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xD0, 0x09, 0x00,
  0x00, 0xC8, 0x04, 0x80, 0x00, 0x64, 0x06, 0x60, 0x00, 0x66, 0x03, 0x30,
  0x00, 0x33, 0x01, 0x98, 0x00, 0x31, 0x80, 0xC4, 0x00, 0x18, 0x80, 0x42,
  0x00, 0x18, 0x40, 0x21, 0x80, 0x18, 0x60, 0x30, 0xC0, 0x0C, 0x30, 0x18,
  0x60, 0x0C, 0x18, 0x0C, 0x10, 0x06, 0x0C, 0x04, 0x08, 0x06, 0x04, 0x02,
  0x06, 0x02, 0x02, 0x01, 0x03, 0x03, 0x03, 0x01, 0x81, 0x81, 0x01, 0x80,
  0xC0, 0x41, 0x80, 0xC0, 0x60, 0x21, 0x80, 0x60, 0x20, 0x18, 0xC0, 0x20,
  0x10, 0x0C, 0xC0, 0x10, 0x18, 0x06, 0x40, 0x18, 0x0C, 0x01, 0x60, 0x0C,
  0x06, 0x00, 0xA0, 0x06, 0x03, 0x00, 0x70, 0x02, 0x01, 0x00, 0x30, 0x01,
  0x00, 0x80, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00,
  0x08, 0x04, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x80, 0x40, 0x00,
  0x00, 0x40, 0x20, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x80, 0x70, 0x00, 0x00, 0x40,
  0x28, 0x00, 0x00, 0x20, 0x16, 0x00, 0x00, 0x30, 0x09, 0x00, 0x00, 0x18,
  0x0C, 0xC0, 0x00, 0x0C, 0x06, 0x20, 0x00, 0x04, 0x03, 0x10, 0x00, 0x02,
  0x01, 0x0C, 0x00, 0x01, 0x00, 0x82, 0x00, 0x01, 0x80, 0x41, 0x00, 0x00,
  0xC0, 0x60, 0xC0, 0x00, 0x60, 0x30, 0x20, 0x00, 0x20, 0x18, 0x18, 0x00,
  0x10, 0x08, 0x04, 0x00, 0x08, 0x04, 0x02, 0x00, 0x0C, 0x06, 0x01, 0x80,
  0x06, 0x03, 0x00, 0x40, 0x03, 0x01, 0x80, 0x20, 0x01, 0x00, 0x80, 0x18,
  0x00, 0x80, 0x40, 0x04, 0x00, 0xC0, 0x20, 0x03, 0x00, 0x60, 0x30, 0x00,
  0x80, 0x30, 0x18, 0x00, 0x40, 0x18, 0x0C, 0x00, 0x30, 0x08, 0x04, 0x00,
  0x08, 0x04, 0x02, 0x00, 0x06, 0x06, 0x01, 0x00, 0x03, 0x03, 0x01, 0x80,
  0x00, 0x81, 0x80, 0xC0, 0x00, 0x60, 0x80, 0x60, 0x00, 0x10, 0x40, 0x20,
  0x00, 0x08, 0x20, 0x10, 0x00, 0x06, 0x30, 0x08, 0x00, 0x01, 0x18, 0x0C,
  0x00, 0x00, 0xCC, 0x06, 0x00, 0x00, 0x64, 0x03, 0x00, 0x00, 0x12, 0x01,
  0x00, 0x00, 0x0D, 0x00, 0x80, 0x00, 0x03, 0x80, 0x40, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0x80,
  0x0E, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x00, 0x80, 0x60,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x06, 0x10, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x01, 0x30, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x09, 0x80,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x32, 0x00, 0x00,
  0x01, 0x10, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x86, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x60, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00, 0x20, 0x30,
  0x00, 0x03, 0x00, 0x80, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x07,
  0x80, 0x06, 0x00, 0x01, 0xC0, 0x08, 0x00, 0x01, 0xC0, 0x10, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x01, 0x80, 0x00, 0x03,
  0x02, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x08, 0x18,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x0C, 0x01, 0x00, 0x00, 0x70, 0x06, 0x00, 0x03, 0xC0, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x78, 0x07, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x10, 0x60,
  0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x0C, 0x80, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00,
  0x06, 0x40, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x26, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x20,
  0x80, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x1F, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x10, 0x04, 0x00, 0x00,
  0x60, 0x10, 0x00, 0x00, 0x80, 0x40, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x81, 0x80,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x06, 0x01, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x1C,
  0x00, 0xC0, 0x01, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x40, 0x00, 0x20, 0x01, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x18, 0x02, 0x00, 0x00,
  0x60, 0x08, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x03, 0x01, 0x80, 0x00, 0x04,
  0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x06, 0x02, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x08, 0x18,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x40, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x82,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00,
  0x20, 0x40, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x10,
  0x20, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x08, 0x10,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x01, 0x02, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x04, 0x08, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x01, 0x02, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x02, 0x03, 0x00, 0x00, 0x0C,
  0x02, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x00, 0x44, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x81, 0x00, 0x00, 0x0C,
  0x08, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x02, 0x00, 0x01, 0x80, 0x10, 0x00,
  0x08, 0x00, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x04, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x30, 0x00, 0x20, 0x01, 0x00, 0x01,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x18, 0x06, 0x00, 0x00, 0x40, 0x30, 0x00, 0x02, 0x03, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x00, 0x86, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0A, 0x00, 0x0C, 0x00, 0x14,
  0x00, 0x38, 0x00, 0x68, 0x00, 0x70, 0x00, 0x90, 0x00, 0xA0, 0x01, 0x20,
  0x03, 0x40, 0x06, 0x40, 0x06, 0x80, 0x08, 0x80, 0x09, 0x00, 0x11, 0x00,
  0x32, 0x00, 0x62, 0x00, 0x44, 0x00, 0xC4, 0x01, 0x8C, 0x01, 0x08, 0x03,
  0x18, 0x06, 0x10, 0x04, 0x30, 0x0C, 0x20, 0x18, 0x60, 0x10, 0x40, 0x30,
  0xC0, 0x60, 0x80, 0x41, 0x80, 0xC1, 0x01, 0x83, 0x01, 0x02, 0x03, 0x06,
  0x02, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30,
  0x20, 0x20, 0x40, 0x60, 0xC0, 0x41, 0x80, 0xC1, 0x80, 0x83, 0x01, 0x82,
  0x01, 0x04, 0x03, 0x0C, 0x02, 0x18, 0x06, 0x18, 0x04, 0x30, 0x0C, 0x20,
  0x08, 0x40, 0x08, 0xC0, 0x11, 0x80, 0x11, 0x80, 0x23, 0x00, 0x22, 0x00,
  0x4C, 0x00, 0x4C, 0x00, 0x98, 0x00, 0x98, 0x01, 0x30, 0x01, 0x20, 0x02,
  0xC0, 0x02, 0x40, 0x05, 0x80, 0x05, 0x80, 0x0B, 0x00, 0x0A, 0x00, 0x14,
  0x00, 0x14, 0x00, 0x38, 0x00, 0x38, 0x00, 0x60, 0x00, 0x70, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x02, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x60, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x04, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x80, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x02, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x02, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x18, 0x00, 0x18,
  0x01, 0x80, 0x00, 0xC0, 0x08, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x40, 0x40, 0x00, 0x02, 0x06, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x50, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x3F, 0xC0, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x04,
  0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18, 0x03, 0x00,
  0x60, 0x04, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18,
  0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00,
  0x80, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60,
  0x04, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18, 0x00,
  0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x0F, 0xF8, 0x00,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x01, 0xB0, 0x00, 0x13,
  0x00, 0x03, 0x10, 0x00, 0x61, 0x00, 0x06, 0x18, 0x00, 0xC1, 0x80, 0x0C,
  0x08, 0x01, 0x80, 0x80, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x0C, 0x06,
  0x00, 0x40, 0xC0, 0x06, 0x0C, 0x00, 0x61, 0x80, 0x06, 0x10, 0x00, 0x23,
  0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0xC0, 0x00, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE1, 0x83, 0x0C, 0x18, 0x60, 0xC1, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x0E, 0x00,
  0x1C, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3C,
  0x00, 0x04, 0x0F, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x86, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x84, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x1D, 0x06, 0x00, 0x03, 0x90, 0x30, 0x00, 0xE1, 0x01,
  0xC0, 0x7C, 0x30, 0x07, 0xFE, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x1F, 0x00, 0x02,
  0x0F, 0xFE, 0x00, 0x23, 0xC0, 0x70, 0x06, 0x70, 0x01, 0x80, 0x6C, 0x00,
  0x0C, 0x07, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x20, 0xC0, 0x00, 0x03, 0x08, 0x00, 0x00, 0x20, 0x80, 0x00, 0x02,
  0x18, 0x00, 0x00, 0x21, 0x80, 0x00, 0x02, 0x18, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x06, 0x10, 0x00, 0x00, 0x61, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x82, 0x00, 0x00, 0x18, 0x20,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x70, 0x00, 0x06, 0x07, 0x80, 0x00,
  0xC0, 0x6C, 0x00, 0x18, 0x04, 0xE0, 0x07, 0x00, 0x43, 0x81, 0xE0, 0x0C,
  0x1F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xE0, 0x38, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x18,
  0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x60, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x01, 0x98, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x18, 0x10, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x30,
  0x03, 0x00, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x1F, 0x00, 0xC0, 0x03, 0xFF, 0x82, 0x00, 0x1C,
  0x07, 0x08, 0x01, 0xC0, 0x06, 0x60, 0x0E, 0x00, 0x0D, 0x80, 0x30, 0x00,
  0x1E, 0x01, 0x80, 0x00, 0x78, 0x0C, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x03, 0x02, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00, 0x18, 0x10, 0x00,
  0x00, 0x40, 0xC0, 0x00, 0x01, 0x03, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x03, 0x01, 0x00, 0x00, 0x08,
  0x06, 0x00, 0x00, 0x20, 0x18, 0x00, 0x01, 0x80, 0x20, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0x78, 0x01, 0x00, 0x03, 0x60, 0x07, 0x00, 0x39, 0x00, 0x0E,
  0x03, 0x84, 0x00, 0x0F, 0xFC, 0x30, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xE0, 0x38, 0x00, 0x70, 0x01,
  0x80, 0x18, 0x00, 0x18, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x60,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x98, 0x00, 0x00, 0x12, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xDF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x30, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x07, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xC0, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0xC0, 0x0E, 0x03, 0x84, 0x01, 0xC0, 0x06, 0x60, 0x1C, 0x00, 0x1B, 0x00,
  0xC0, 0x00, 0x78, 0x0C, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x0C, 0x04, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x03, 0x02, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x06, 0x08, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01, 0x06,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x06, 0x08, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x01, 0x06, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00, 0x30, 0x20, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x08, 0x0C, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0xF0, 0x06, 0x00, 0x0D, 0x80, 0x38, 0x01, 0xC8, 0x00, 0xE0, 0x3C,
  0x40, 0x01, 0xFF, 0x86, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x10, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x03,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x0F, 0xC0, 0x02, 0x07, 0xFF, 0x00, 0x60, 0xE0, 0x38,
  0x06, 0x38, 0x00, 0xC0, 0x66, 0x00, 0x06, 0x04, 0xC0, 0x00, 0x60, 0x58,
  0x00, 0x02, 0x0F, 0x00, 0x00, 0x20, 0xE0, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x20, 0x80, 0x00, 0x02, 0x18,
  0x00, 0x00, 0x21, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x06, 0x10, 0x00, 0x00, 0x41, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x20, 0x00,
  0x00, 0x82, 0x00, 0x00, 0x08, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x01, 0x84, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x04, 0x08, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x1C, 0x06, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x18, 0x01, 0x80,
  0x03, 0x80, 0x0C, 0x00, 0x38, 0x00, 0x40, 0x03, 0x00, 0x02, 0x00, 0x30,
  0x00, 0x30, 0x07, 0x00, 0x01, 0x80, 0x70, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x40, 0xE0, 0x00, 0x02, 0x0E, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x8F,
  0x00, 0x00, 0x0D, 0xCC, 0x00, 0x00, 0x78, 0x60, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x60, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x03, 0x00, 0x80, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0x80, 0x1F, 0x00, 0x47, 0xFC, 0x0F, 0xF0, 0x09, 0xC0, 0xC7, 0x03, 0x03,
  0x60, 0x09, 0x80, 0x30, 0x78, 0x01, 0xE0, 0x06, 0x0E, 0x00, 0x38, 0x00,
  0x41, 0x80, 0x07, 0x00, 0x08, 0x30, 0x00, 0xC0, 0x01, 0x04, 0x00, 0x18,
  0x00, 0x21, 0x80, 0x03, 0x00, 0x04, 0x30, 0x00, 0x40, 0x01, 0x86, 0x00,
  0x08, 0x00, 0x30, 0x80, 0x03, 0x00, 0x06, 0x10, 0x00, 0x60, 0x00, 0x82,
  0x00, 0x0C, 0x00, 0x10, 0xC0, 0x01, 0x00, 0x06, 0x18, 0x00, 0x20, 0x00,
  0xC3, 0x00, 0x04, 0x00, 0x18, 0x40, 0x01, 0x80, 0x03, 0x08, 0x00, 0x30,
  0x00, 0x41, 0x00, 0x06, 0x00, 0x08, 0x60, 0x00, 0x80, 0x03, 0x0C, 0x00,
  0x10, 0x00, 0x61, 0x80, 0x02, 0x00, 0x0C, 0x20, 0x00, 0xC0, 0x01, 0x04,
  0x00, 0x18, 0x00, 0x21, 0x80, 0x03, 0x00, 0x04, 0x30, 0x00, 0x40, 0x01,
  0x86, 0x00, 0x08, 0x00, 0x30, 0x80, 0x01, 0x00, 0x06, 0x10, 0x00, 0x60,
  0x00, 0x82, 0x00, 0x0C, 0x00, 0x10, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x60, 0x7F, 0xF0, 0x06, 0x1E, 0x03, 0x80, 0x63, 0x80,
  0x0C, 0x06, 0x60, 0x00, 0x40, 0x4C, 0x00, 0x06, 0x05, 0x80, 0x00, 0x20,
  0xF0, 0x00, 0x02, 0x0E, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x20, 0xC0, 0x00, 0x02, 0x08, 0x00, 0x00, 0x21, 0x80, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x04, 0x10, 0x00, 0x00, 0x43, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x82, 0x00, 0x00, 0x08, 0x60,
  0x00, 0x00, 0x86, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x18, 0x40, 0x00, 0x01, 0x04, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x1E, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x00, 0x1C, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x04,
  0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x04, 0x60,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x09, 0x80, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x12, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x31, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0xF0, 0x3C, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x04, 0x1F, 0xF8, 0x00, 0x23, 0xC0, 0x70, 0x03, 0x38,
  0x00, 0xC0, 0x1B, 0x00, 0x02, 0x00, 0xF0, 0x00, 0x18, 0x07, 0x00, 0x00,
  0x40, 0x30, 0x00, 0x03, 0x03, 0x80, 0x00, 0x18, 0x18, 0x00, 0x00, 0x40,
  0xC0, 0x00, 0x02, 0x06, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x04, 0x18, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x20,
  0xC0, 0x00, 0x01, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x0C, 0x08, 0x00, 0x00, 0x60, 0x40, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x30, 0x38, 0x00, 0x03, 0x01, 0xE0, 0x00, 0x30, 0x0F, 0x00, 0x03, 0x00,
  0x4E, 0x00, 0x70, 0x02, 0x3C, 0x0F, 0x00, 0x30, 0x7F, 0xE0, 0x01, 0x80,
  0x70, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xFF, 0x83, 0x00, 0x70, 0x1C, 0x20, 0x1C, 0x00, 0x66, 0x03, 0x80, 0x03,
  0x60, 0x30, 0x00, 0x1E, 0x06, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x0C, 0x08,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x10, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x86,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x84, 0x00, 0x00, 0x18, 0x40, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x03, 0x04, 0x00, 0x00, 0x30, 0x40, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x20, 0x60, 0x00, 0x06, 0x02, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x1E,
  0x01, 0x80, 0x03, 0x60, 0x1C, 0x00, 0xE4, 0x00, 0xE0, 0x3C, 0x40, 0x03,
  0xFF, 0x04, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x80, 0xFF, 0xE0, 0x60, 0xF0, 0x00, 0x18, 0x70, 0x00, 0x06, 0x70,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0xF0, 0x07, 0x00, 0x18, 0x00, 0x18, 0x03,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x04, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x84, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x03, 0x03, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x1C, 0x00, 0xF0, 0x0F,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0xF0,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3C, 0x00, 0x08, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0x21, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0x86, 0x00,
  0x00, 0x10, 0x80, 0x00, 0x06, 0x10, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x43, 0x00, 0x00, 0x08, 0x40, 0x00,
  0x03, 0x08, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x21, 0x80, 0x00, 0x04, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x0E, 0x18, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x70, 0x30,
  0x00, 0x1A, 0x06, 0x00, 0x06, 0xC0, 0x60, 0x03, 0x98, 0x07, 0x03, 0xC3,
  0x00, 0x7F, 0xF0, 0x60, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x64, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x02, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x01, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x18, 0x01, 0x80, 0x01, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x04,
  0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x02, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x01, 0x18, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x36,
  0x00, 0x38, 0x00, 0x6C, 0x00, 0x58, 0x00, 0x98, 0x01, 0xB0, 0x03, 0x30,
  0x03, 0x60, 0x06, 0x60, 0x0C, 0xC0, 0x18, 0xC0, 0x19, 0x80, 0x31, 0x80,
  0x23, 0x00, 0x43, 0x00, 0xC6, 0x01, 0x86, 0x01, 0x0C, 0x03, 0x0C, 0x06,
  0x18, 0x04, 0x18, 0x0C, 0x10, 0x18, 0x30, 0x10, 0x20, 0x20, 0x60, 0x60,
  0x40, 0xC0, 0x40, 0x80, 0x81, 0x80, 0x83, 0x01, 0x02, 0x01, 0x06, 0x03,
  0x0C, 0x02, 0x18, 0x06, 0x18, 0x04, 0x30, 0x0C, 0x60, 0x08, 0x40, 0x18,
  0xC0, 0x11, 0x80, 0x31, 0x00, 0x32, 0x00, 0x66, 0x00, 0x6C, 0x00, 0xCC,
  0x00, 0xD8, 0x00, 0xB0, 0x01, 0xA0, 0x01, 0x60, 0x03, 0xC0, 0x02, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x0C, 0x1C, 0x00,
  0x00, 0x06, 0x38, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x01, 0xC0, 0x0C, 0x00, 0x03, 0x80, 0x06, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x08,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x40, 0xC0, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x02, 0x30,
  0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10,
  0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xC3, 0x01, 0xC0, 0x00, 0x63, 0x00, 0x70, 0x00, 0x23, 0x00,
  0x1C, 0x00, 0x31, 0x00, 0x07, 0x00, 0x31, 0x80, 0x01, 0xC0, 0x38, 0xC0,
  0x00, 0x70, 0x38, 0x40, 0x00, 0x0F, 0xF0, 0x40, 0x00, 0x01, 0xE0, 0x00,
};

const GFXglyph RobotoMono_ThinItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 9, 43, 36, 13, -43 },
  { 50, 11, 13, 36, 15, -46 },
  { 68, 35, 43, 36, 1, -43 },
  { 257, 29, 56, 36, 4, -50 },
  { 460, 29, 45, 36, 4, -44 },
  { 624, 30, 45, 36, 3, -44 },
  { 793, 4, 13, 36, 18, -46 },
  { 800, 18, 62, 36, 11, -48 },
  { 940, 18, 62, 36, 6, -48 },
  { 1080, 25, 23, 36, 9, -43 },
  { 1152, 29, 32, 36, 4, -36 },
  { 1268, 6, 13, 36, 8, -5 },
  { 1278, 21, 2, 36, 7, -21 },
  { 1284, 4, 3, 36, 14, -3 },
  { 1286, 28, 47, 36, 5, -43 },
  { 1451, 29, 45, 36, 4, -44 },
  { 1615, 15, 43, 36, 10, -43 },
  { 1696, 28, 44, 36, 2, -44 },
  { 1850, 29, 45, 36, 2, -44 },
  { 2014, 29, 43, 36, 2, -43 },
  { 2170, 30, 44, 36, 5, -43 },
  { 2335, 26, 45, 36, 4, -44 },
  { 2482, 27, 43, 36, 8, -43 },
  { 2628, 30, 45, 36, 4, -44 },
  { 2797, 26, 45, 36, 6, -44 },
  { 2944, 8, 29, 36, 16, -29 },
  { 2973, 12, 37, 36, 12, -29 },
  { 3029, 27, 24, 36, 5, -32 },
  { 3110, 28, 14, 36, 4, -27 },
  { 3159, 27, 24, 36, 4, -32 },
  { 3240, 22, 44, 36, 10, -44 },
  { 3361, 35, 44, 36, 1, -44 },
  { 3554, 30, 43, 36, 0, -43 },
  { 3716, 30, 43, 36, 3, -43 },
  { 3878, 30, 45, 36, 4, -44 },
  { 4047, 31, 43, 36, 3, -43 },
  { 4214, 32, 43, 36, 3, -43 },
  { 4386, 31, 43, 36, 4, -43 },
  { 4553, 30, 45, 36, 4, -44 },
  { 4722, 33, 43, 36, 2, -43 },
  { 4900, 31, 43, 36, 3, -43 },
  { 5067, 31, 44, 36, 2, -43 },
  { 5238, 33, 43, 36, 4, -43 },
  { 5416, 24, 43, 36, 4, -43 },
  { 5545, 33, 43, 36, 2, -43 },
  { 5723, 33, 43, 36, 2, -43 },
  { 5901, 29, 45, 36, 4, -44 },
  { 6065, 31, 43, 36, 4, -43 },
  { 6232, 31, 52, 36, 3, -44 },
  { 6434, 30, 43, 36, 3, -43 },
  { 6596, 31, 45, 36, 3, -44 },
  { 6771, 30, 43, 36, 7, -43 },
  { 6933, 31, 44, 36, 4, -43 },
  { 7104, 29, 43, 36, 7, -43 },
  { 7260, 31, 43, 36, 7, -43 },
  { 7427, 35, 43, 36, 1, -43 },
  { 7616, 29, 43, 36, 7, -43 },
  { 7772, 32, 43, 36, 1, -43 },
  { 7944, 17, 59, 36, 10, -50 },
  { 8070, 11, 47, 36, 13, -43 },
  { 8135, 18, 59, 36, 9, -50 },
  { 8268, 20, 23, 36, 8, -43 },
  { 8326, 25, 2, 36, 2, 0 },
  { 8333, 6, 8, 36, 18, -45 },
  { 8339, 28, 34, 36, 3, -33 },
  { 8458, 28, 47, 36, 3, -46 },
  { 8623, 27, 34, 36, 4, -33 },
  { 8738, 30, 47, 36, 4, -46 },
  { 8915, 27, 34, 36, 4, -33 },
  { 9030, 29, 46, 36, 8, -46 },
  { 9197, 29, 46, 36, 3, -33 },
  { 9364, 28, 46, 36, 3, -46 },
  { 9525, 24, 44, 36, 4, -44 },
  { 9657, 28, 57, 36, 0, -44 },
  { 9857, 29, 46, 36, 4, -46 },
  { 10024, 24, 46, 36, 4, -46 },
  { 10162, 35, 33, 36, -1, -33 },
  { 10307, 28, 33, 36, 3, -33 },
  { 10423, 29, 34, 36, 3, -33 },
  { 10547, 29, 45, 36, 1, -33 },
  { 10711, 28, 45, 36, 4, -33 },
  { 10869, 26, 33, 36, 8, -33 },
  { 10977, 28, 34, 36, 4, -33 },
  { 11096, 22, 42, 36, 8, -41 },
  { 11212, 27, 33, 36, 5, -32 },
  { 11324, 28, 32, 36, 6, -32 },
  { 11436, 31, 32, 36, 5, -32 },
  { 11560, 32, 32, 36, 2, -32 },
  { 11688, 36, 45, 36, -1, -32 },
  { 11891, 31, 32, 36, 1, -32 },
  { 12015, 23, 61, 36, 10, -48 },
  { 12191, 10, 51, 36, 13, -43 },
  { 12255, 24, 61, 36, 5, -48 },
  { 12438, 33, 10, 36, 1, -23 },
};

const GFXfont RobotoMono_ThinItalic61pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic61pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic61pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _ROBOTOMONO_THINITALIC61PT7B_H_
