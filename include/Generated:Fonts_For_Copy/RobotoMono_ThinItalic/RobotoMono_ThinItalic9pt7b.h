#ifndef _ROBOTOMONO_THINITALIC9PT7B_H_
#define _ROBOTOMONO_THINITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xF0, 0x2B, 0xD4, 0xAF, 0xD0, 0x69, 0x84, 0x39, 0xA4, 0xDE,
  0x47, 0xD7, 0x72, 0x88, 0xD9, 0x7C, 0xC0, 0x6A, 0xAA, 0x80, 0x44, 0x92,
  0x52, 0x80, 0xB6, 0xE0, 0x44, 0xF4, 0xC0, 0xE0, 0x80, 0x12, 0x24, 0x88,
  0x80, 0xF9, 0xBD, 0x9E, 0xE4, 0xA4, 0x80, 0x71, 0x12, 0x4F, 0x78, 0x4C,
  0x29, 0x78, 0x11, 0x95, 0x27, 0x88, 0x78, 0xE1, 0x9E, 0x7A, 0xDB, 0xC0,
  0xF2, 0x24, 0x48, 0xF9, 0x69, 0x9E, 0xF9, 0x9E, 0x2C, 0x40, 0x80, 0x40,
  0xA0, 0x34, 0xC2, 0xFE, 0x86, 0x78, 0xF1, 0x24, 0x00, 0x7D, 0xF7, 0xBB,
  0x78, 0x13, 0x57, 0x99, 0x7A, 0x5C, 0x98, 0xF8, 0xF9, 0x88, 0x9E, 0x7A,
  0x53, 0x18, 0xF8, 0x7A, 0x1C, 0x88, 0x78, 0xF8, 0xE8, 0x88, 0xF8, 0x8B,
  0x9E, 0x4A, 0x5F, 0x18, 0xC4, 0x39, 0x08, 0x42, 0x78, 0x08, 0x42, 0x19,
  0x78, 0x9A, 0xCC, 0xA9, 0x92, 0x49, 0xC0, 0x4A, 0xD7, 0x58, 0xC4, 0x4A,
  0x5B, 0x59, 0x48, 0xF9, 0x99, 0x9E, 0xF9, 0x9E, 0x88, 0x7A, 0x63, 0x18,
  0xB8, 0x40, 0xF9, 0x9E, 0xA9, 0x7A, 0x08, 0x38, 0xB8, 0xF4, 0x44, 0x44,
  0x99, 0x99, 0x9E, 0x99, 0xAA, 0xC4, 0xCE, 0xAD, 0x4A, 0x50, 0x49, 0x88,
  0x45, 0x44, 0x9A, 0x44, 0x44, 0x78, 0x88, 0x44, 0x78, 0x69, 0x25, 0x26,
  0xAA, 0x94, 0x24, 0x92, 0x96, 0x2E, 0x80, 0xF0, 0xC0, 0x32, 0x5D, 0x1F,
  0x00, 0x42, 0x1C, 0x94, 0xC7, 0xC0, 0x69, 0x88, 0xE0, 0x11, 0x79, 0x9A,
  0xE0, 0x69, 0xE8, 0xE0, 0x34, 0xF4, 0x44, 0x80, 0x3A, 0x63, 0x27, 0x0B,
  0x80, 0x42, 0x1C, 0x98, 0xC6, 0x40, 0x3D, 0x25, 0xC0, 0x13, 0x11, 0x22,
  0x2C, 0x88, 0x9E, 0x8C, 0xA0, 0x64, 0xA4, 0xB8, 0x7D, 0x6B, 0x5A, 0x80,
  0x72, 0x63, 0x19, 0x00, 0x32, 0x63, 0x17, 0x00, 0x75, 0x59, 0xF8, 0x80,
  0x79, 0x9A, 0xE2, 0x20, 0x78, 0x88, 0x80, 0x69, 0x61, 0xE0, 0x5D, 0x24,
  0xC0, 0x99, 0x99, 0xE0, 0x99, 0xAA, 0x40, 0xDD, 0xAA, 0xA0, 0x4A, 0x88,
  0xA9, 0x00, 0x8A, 0x54, 0xA2, 0x23, 0x00, 0x78, 0x88, 0x8F, 0x00, 0x12,
  0x24, 0x84, 0x44, 0x60, 0xFE, 0x44, 0x92, 0x92, 0x80, 0xF8,
};

const GFXglyph RobotoMono_ThinItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 2, 2, 5, 2, -7 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 4, 8, 5, 1, -7 },
  { 11, 4, 6, 5, 1, -6 },
  { 14, 5, 6, 5, 0, -6 },
  { 18, 1, 2, 5, 2, -7 },
  { 19, 2, 9, 5, 2, -7 },
  { 22, 3, 9, 5, 1, -7 },
  { 26, 4, 3, 5, 1, -6 },
  { 28, 4, 4, 5, 1, -5 },
  { 30, 1, 2, 5, 1, -1 },
  { 31, 3, 1, 5, 1, -3 },
  { 32, 1, 1, 5, 2, -1 },
  { 33, 4, 7, 5, 1, -6 },
  { 37, 4, 6, 5, 1, -6 },
  { 40, 3, 6, 5, 1, -6 },
  { 43, 4, 6, 5, 0, -6 },
  { 46, 5, 6, 5, 0, -6 },
  { 50, 5, 6, 5, 0, -6 },
  { 54, 4, 6, 5, 1, -6 },
  { 57, 3, 6, 5, 1, -6 },
  { 60, 4, 6, 5, 1, -6 },
  { 63, 4, 6, 5, 1, -6 },
  { 66, 4, 6, 5, 1, -6 },
  { 69, 2, 5, 5, 2, -5 },
  { 71, 2, 6, 5, 2, -5 },
  { 73, 4, 4, 5, 1, -5 },
  { 75, 4, 2, 5, 1, -4 },
  { 76, 4, 4, 5, 1, -5 },
  { 78, 4, 6, 5, 1, -6 },
  { 81, 5, 6, 5, 0, -6 },
  { 85, 4, 6, 5, 0, -6 },
  { 88, 5, 6, 5, 0, -6 },
  { 92, 4, 6, 5, 1, -6 },
  { 95, 5, 6, 5, 0, -6 },
  { 99, 5, 6, 5, 0, -6 },
  { 103, 4, 6, 5, 1, -6 },
  { 106, 4, 6, 5, 1, -6 },
  { 109, 5, 6, 5, 0, -6 },
  { 113, 5, 6, 5, 0, -6 },
  { 117, 5, 6, 5, 0, -6 },
  { 121, 4, 6, 5, 1, -6 },
  { 124, 3, 6, 5, 1, -6 },
  { 127, 5, 6, 5, 0, -6 },
  { 131, 5, 6, 5, 0, -6 },
  { 135, 4, 6, 5, 1, -6 },
  { 138, 4, 6, 5, 1, -6 },
  { 141, 5, 7, 5, 0, -6 },
  { 146, 4, 6, 5, 1, -6 },
  { 149, 5, 6, 5, 0, -6 },
  { 153, 4, 6, 5, 1, -6 },
  { 156, 4, 6, 5, 1, -6 },
  { 159, 4, 6, 5, 1, -6 },
  { 162, 5, 6, 5, 1, -6 },
  { 166, 5, 6, 5, 0, -6 },
  { 170, 4, 6, 5, 1, -6 },
  { 173, 5, 6, 5, 0, -6 },
  { 177, 3, 8, 5, 1, -7 },
  { 180, 2, 7, 5, 2, -6 },
  { 182, 3, 8, 5, 1, -7 },
  { 185, 3, 3, 5, 1, -6 },
  { 187, 4, 1, 5, 0, 0 },
  { 188, 1, 2, 5, 3, -7 },
  { 189, 5, 5, 5, 0, -5 },
  { 193, 5, 7, 5, 0, -7 },
  { 198, 4, 5, 5, 1, -5 },
  { 201, 4, 7, 5, 1, -7 },
  { 205, 4, 5, 5, 1, -5 },
  { 208, 4, 7, 5, 1, -7 },
  { 212, 5, 7, 5, 0, -5 },
  { 217, 5, 7, 5, 0, -7 },
  { 222, 3, 6, 5, 1, -6 },
  { 225, 4, 8, 5, 0, -6 },
  { 229, 4, 7, 5, 1, -7 },
  { 233, 3, 7, 5, 1, -7 },
  { 236, 5, 5, 5, 0, -5 },
  { 240, 5, 5, 5, 0, -5 },
  { 244, 5, 5, 5, 0, -5 },
  { 248, 4, 7, 5, 0, -5 },
  { 252, 4, 7, 5, 1, -5 },
  { 256, 4, 5, 5, 1, -5 },
  { 259, 4, 5, 5, 1, -5 },
  { 262, 3, 6, 5, 1, -6 },
  { 265, 4, 5, 5, 1, -5 },
  { 268, 4, 5, 5, 1, -5 },
  { 271, 4, 5, 5, 1, -5 },
  { 274, 5, 5, 5, 0, -5 },
  { 278, 5, 7, 5, 0, -5 },
  { 283, 5, 5, 5, 0, -5 },
  { 287, 4, 9, 5, 1, -7 },
  { 292, 1, 7, 5, 2, -6 },
  { 293, 3, 9, 5, 1, -7 },
  { 297, 5, 1, 5, 0, -3 },
};

const GFXfont RobotoMono_ThinItalic9pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic9pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _ROBOTOMONO_THINITALIC9PT7B_H_
