#ifndef _ROBOTOMONO_THINITALIC25PT7B_H_
#define _ROBOTOMONO_THINITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x12, 0x22, 0x22, 0x24, 0x40, 0x00, 0x0C, 0x4A, 0x53,
  0x29, 0x00, 0x00, 0x84, 0x02, 0x10, 0x04, 0x20, 0x08, 0x40, 0x21, 0x07,
  0xFF, 0xC0, 0x84, 0x02, 0x10, 0x04, 0x20, 0x08, 0x40, 0x21, 0x00, 0x42,
  0x0F, 0xFF, 0x82, 0x10, 0x04, 0x20, 0x10, 0x80, 0x21, 0x00, 0x42, 0x00,
  0x01, 0x00, 0x10, 0x07, 0xC1, 0x82, 0x20, 0x22, 0x01, 0x20, 0x12, 0x00,
  0x20, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x48, 0x04,
  0x80, 0x48, 0x04, 0x40, 0x83, 0x70, 0x08, 0x00, 0x80, 0x08, 0x00, 0x1C,
  0x01, 0x20, 0x10, 0x84, 0x84, 0x48, 0x44, 0x42, 0x21, 0x12, 0x0F, 0x20,
  0x02, 0x00, 0x10, 0x01, 0x1C, 0x11, 0x20, 0x90, 0x88, 0x84, 0x88, 0x2C,
  0x42, 0x01, 0x10, 0x0F, 0x00, 0x03, 0x80, 0xC4, 0x08, 0x41, 0x04, 0x10,
  0x41, 0x08, 0x09, 0x00, 0xA0, 0x0C, 0x01, 0x40, 0x22, 0x14, 0x11, 0x41,
  0x18, 0x0A, 0x80, 0x68, 0x04, 0x40, 0xA3, 0xF1, 0x55, 0x80, 0x01, 0x02,
  0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20,
  0x40, 0x80, 0x02, 0x00, 0x40, 0x10, 0x42, 0x17, 0x5C, 0x1C, 0x02, 0x80,
  0x90, 0x21, 0x08, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08,
  0x3F, 0xF8, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x25, 0x28,
  0xFF, 0x80, 0x80, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x00, 0x07, 0x83, 0x08, 0x80, 0x90,
  0x14, 0x02, 0x80, 0xD0, 0x2C, 0x09, 0x82, 0x30, 0x86, 0x20, 0xD8, 0x1C,
  0x05, 0x00, 0xA0, 0x24, 0x04, 0x41, 0x07, 0xC0, 0x04, 0x76, 0x61, 0x04,
  0x20, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x10, 0x80, 0x0F, 0x82,
  0x08, 0x80, 0x90, 0x14, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x1F, 0xF8, 0x07,
  0xC0, 0x82, 0x10, 0x22, 0x01, 0x40, 0x10, 0x01, 0x00, 0x20, 0x04, 0x0F,
  0x80, 0x18, 0x00, 0x40, 0x02, 0x00, 0x28, 0x02, 0x80, 0x48, 0x04, 0x40,
  0x83, 0xF0, 0x00, 0x20, 0x06, 0x00, 0xA0, 0x12, 0x02, 0x40, 0x24, 0x04,
  0x40, 0x84, 0x10, 0x42, 0x08, 0x20, 0x84, 0x08, 0xFF, 0xF0, 0x08, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x10, 0x0F, 0xF1, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x03, 0xF8, 0x20, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x28, 0x04, 0x80, 0x48, 0x08, 0x41, 0x83, 0xE0, 0x01, 0xE0, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x09, 0xE2, 0xC2, 0x60, 0x28, 0x05, 0x00, 0xA0,
  0x18, 0x03, 0x00, 0x50, 0x0A, 0x02, 0x20, 0x83, 0xE0, 0xFF, 0xE0, 0x04,
  0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x00, 0x03, 0xE0,
  0x60, 0x84, 0x02, 0x20, 0x12, 0x00, 0x90, 0x04, 0x40, 0x42, 0x04, 0x0F,
  0xC0, 0xC6, 0x08, 0x08, 0x80, 0x24, 0x01, 0x40, 0x0A, 0x00, 0x88, 0x04,
  0x40, 0x41, 0xFC, 0x00, 0x0F, 0x82, 0x08, 0x80, 0xA0, 0x14, 0x02, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x28, 0x0D, 0x02, 0x9F, 0xA0, 0x04, 0x01, 0x00,
  0x20, 0x08, 0x06, 0x0F, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x04, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x84, 0x22, 0x00, 0x00, 0x60, 0x30,
  0x18, 0x1C, 0x0C, 0x00, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x08, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x10, 0x00, 0x1E, 0x10,
  0x90, 0x30, 0x10, 0x08, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x02, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x04, 0x10, 0x30,
  0x10, 0x80, 0x21, 0x1E, 0x24, 0x44, 0x49, 0x08, 0xA2, 0x11, 0x48, 0x44,
  0x90, 0x8A, 0x21, 0x14, 0x44, 0x28, 0x88, 0x91, 0x2A, 0x11, 0x88, 0x20,
  0x00, 0x20, 0x40, 0x3F, 0x00, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x14, 0x01,
  0x40, 0x22, 0x02, 0x20, 0x42, 0x04, 0x20, 0x82, 0x08, 0x21, 0x02, 0x1F,
  0xE2, 0x01, 0x20, 0x14, 0x01, 0x40, 0x18, 0x01, 0x1F, 0xC1, 0x02, 0x10,
  0x11, 0x01, 0x20, 0x12, 0x01, 0x20, 0x12, 0x02, 0x3F, 0xC2, 0x04, 0x40,
  0x24, 0x01, 0x40, 0x14, 0x01, 0x40, 0x24, 0x02, 0x80, 0xCF, 0xF0, 0x07,
  0x81, 0x86, 0x20, 0x22, 0x01, 0x40, 0x14, 0x01, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x28, 0x04, 0x80, 0x48, 0x08, 0x41,
  0x03, 0xE0, 0x1F, 0x80, 0x83, 0x04, 0x04, 0x40, 0x22, 0x00, 0x90, 0x04,
  0x80, 0x24, 0x01, 0x20, 0x0A, 0x00, 0x50, 0x04, 0x80, 0x24, 0x01, 0x20,
  0x11, 0x00, 0x90, 0x08, 0x81, 0x87, 0xF0, 0x00, 0x1F, 0xF8, 0x80, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x3F, 0xE1, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x3F, 0xE1, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x00, 0x03, 0xC0, 0x61, 0x84,
  0x04, 0x20, 0x12, 0x00, 0x90, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x20, 0xFD, 0x00, 0x28, 0x01, 0x40, 0x11, 0x00, 0x88, 0x04, 0x20, 0x40,
  0xFC, 0x00, 0x10, 0x09, 0x00, 0x48, 0x02, 0x40, 0x12, 0x00, 0x90, 0x04,
  0x80, 0x48, 0x02, 0x7F, 0xF2, 0x00, 0x90, 0x04, 0x80, 0x24, 0x02, 0x40,
  0x12, 0x00, 0x90, 0x04, 0x80, 0x24, 0x02, 0x00, 0x1F, 0xF8, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x07,
  0xFE, 0x00, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x40,
  0x22, 0x01, 0x10, 0x10, 0x41, 0x01, 0xF0, 0x00, 0x10, 0x04, 0x40, 0x21,
  0x01, 0x04, 0x08, 0x10, 0x40, 0x82, 0x02, 0x10, 0x08, 0x80, 0x2C, 0x00,
  0xC8, 0x02, 0x20, 0x10, 0x40, 0x41, 0x01, 0x02, 0x04, 0x04, 0x10, 0x10,
  0x40, 0x22, 0x00, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x7F,
  0xC0, 0x10, 0x08, 0x80, 0x4A, 0x06, 0x50, 0x52, 0x82, 0x94, 0x24, 0xA1,
  0x24, 0x92, 0x44, 0x92, 0x28, 0x91, 0x84, 0x84, 0x24, 0x01, 0x20, 0x12,
  0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x00, 0x10, 0x08, 0x80, 0x4A, 0x02,
  0x50, 0x12, 0x80, 0x92, 0x04, 0x90, 0x48, 0x82, 0x42, 0x12, 0x10, 0x90,
  0x44, 0x82, 0x24, 0x12, 0x40, 0x52, 0x02, 0x90, 0x14, 0x80, 0x44, 0x02,
  0x00, 0x07, 0x81, 0x84, 0x20, 0x22, 0x02, 0x40, 0x14, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x48,
  0x08, 0x41, 0x03, 0xE0, 0x1F, 0xC2, 0x02, 0x20, 0x12, 0x01, 0x20, 0x12,
  0x01, 0x40, 0x14, 0x01, 0x40, 0x24, 0x0C, 0x7F, 0x04, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x03, 0xC0, 0x61, 0x84, 0x04,
  0x40, 0x12, 0x00, 0xA0, 0x05, 0x00, 0x28, 0x01, 0x40, 0x0C, 0x00, 0x60,
  0x05, 0x00, 0x28, 0x01, 0x40, 0x12, 0x00, 0x88, 0x08, 0x40, 0x81, 0xF8,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x1F, 0x80, 0x81, 0x04, 0x04, 0x20,
  0x11, 0x00, 0x90, 0x04, 0x80, 0x44, 0x02, 0x20, 0x21, 0x06, 0x0F, 0xC0,
  0x81, 0x04, 0x08, 0x20, 0x41, 0x01, 0x08, 0x08, 0x80, 0x24, 0x01, 0x00,
  0x07, 0xE0, 0x40, 0x84, 0x04, 0x40, 0x12, 0x00, 0x90, 0x00, 0x40, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x40, 0x01, 0x40, 0x0A, 0x00,
  0x48, 0x04, 0x40, 0x41, 0xFC, 0x00, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x14, 0x01,
  0x40, 0x14, 0x01, 0x40, 0x14, 0x01, 0x40, 0x28, 0x02, 0x80, 0x28, 0x02,
  0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x41, 0x03, 0xE0,
  0x80, 0x18, 0x02, 0x80, 0x28, 0x04, 0x80, 0x44, 0x04, 0x40, 0x84, 0x08,
  0x41, 0x04, 0x10, 0x42, 0x02, 0x20, 0x24, 0x02, 0x40, 0x28, 0x02, 0x80,
  0x30, 0x01, 0x00, 0x82, 0x0C, 0x30, 0xA1, 0x85, 0x0C, 0x28, 0xA2, 0x45,
  0x12, 0x28, 0x92, 0x48, 0x92, 0x45, 0x12, 0x28, 0x91, 0x45, 0x0C, 0x28,
  0x61, 0x43, 0x0C, 0x10, 0x60, 0x82, 0x04, 0x10, 0x00, 0x10, 0x02, 0x10,
  0x08, 0x20, 0x20, 0x20, 0x80, 0x41, 0x00, 0x44, 0x00, 0x90, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x0A, 0x00, 0x24, 0x00, 0x84, 0x01, 0x08, 0x04,
  0x08, 0x10, 0x10, 0x40, 0x11, 0x80, 0x20, 0x80, 0x18, 0x02, 0x40, 0x44,
  0x04, 0x40, 0x82, 0x10, 0x21, 0x02, 0x20, 0x14, 0x01, 0x40, 0x18, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x1F, 0xF8,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x07, 0xFE, 0x00, 0x1E, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20,
  0x78, 0x84, 0x20, 0x84, 0x21, 0x08, 0x21, 0x08, 0x42, 0x08, 0x42, 0x10,
  0x82, 0x10, 0x1E, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x70, 0x02,
  0x03, 0x02, 0x81, 0x41, 0x10, 0x88, 0x84, 0x82, 0x41, 0x40, 0x40, 0xFF,
  0xC0, 0xA9, 0x0F, 0xC1, 0x02, 0x20, 0x10, 0x01, 0x00, 0x20, 0x1E, 0x1E,
  0x22, 0x02, 0x40, 0x28, 0x02, 0x80, 0x44, 0x1C, 0x3E, 0x40, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x30, 0x2C, 0xC3, 0x02, 0x20, 0x22,
  0x01, 0x20, 0x12, 0x01, 0x40, 0x24, 0x02, 0x40, 0x24, 0x04, 0x40, 0x4A,
  0x08, 0x9F, 0x00, 0x1F, 0x84, 0x09, 0x00, 0xA0, 0x18, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x0A, 0x02, 0x20, 0x83, 0xE0, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x20, 0x62, 0x19, 0xA2, 0x06, 0x40, 0x44, 0x04,
  0x80, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x80, 0x84, 0x18,
  0x3E, 0x80, 0x1F, 0x84, 0x09, 0x00, 0xA0, 0x18, 0x03, 0xFF, 0xE0, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x43, 0xF0, 0x01, 0xF0, 0x20, 0x04,
  0x00, 0x80, 0x08, 0x00, 0x80, 0xFF, 0xC0, 0x80, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x00, 0x0F, 0xD1, 0x03, 0x20, 0x22, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24,
  0x02, 0x40, 0x24, 0x04, 0x40, 0x42, 0x0C, 0x1F, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x81, 0x07, 0xE0, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02,
  0x18, 0x26, 0x62, 0x82, 0x30, 0x12, 0x01, 0x20, 0x14, 0x02, 0x40, 0x24,
  0x02, 0x40, 0x24, 0x02, 0x40, 0x28, 0x04, 0x80, 0x40, 0x01, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x3F, 0xF0, 0x00, 0x20, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x20, 0x08, 0x3E, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x01, 0x20, 0x62, 0x08, 0x41, 0x04, 0x20, 0x4C, 0x05, 0x00, 0x68, 0x04,
  0x40, 0x82, 0x08, 0x20, 0x81, 0x08, 0x08, 0x80, 0xC0, 0x1F, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x0F, 0xFC, 0x3F, 0x7C, 0x86,
  0x14, 0x10, 0x50, 0x41, 0x41, 0x05, 0x04, 0x14, 0x10, 0x50, 0x82, 0x82,
  0x0A, 0x08, 0x28, 0x20, 0xA0, 0x82, 0x82, 0x08, 0x27, 0xC2, 0x82, 0x30,
  0x12, 0x01, 0x20, 0x14, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x40,
  0x28, 0x04, 0x80, 0x40, 0x0F, 0xC1, 0x02, 0x20, 0x14, 0x01, 0x40, 0x14,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x40, 0x44, 0x08, 0x1F, 0x00,
  0x17, 0xE1, 0x81, 0x10, 0x11, 0x01, 0x10, 0x12, 0x01, 0x20, 0x12, 0x01,
  0x20, 0x12, 0x02, 0x20, 0x27, 0x04, 0x4F, 0x84, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x1F, 0xA4, 0x0D, 0x01, 0x20, 0x28, 0x05, 0x00, 0xA0,
  0x14, 0x02, 0x80, 0x50, 0x12, 0x02, 0x20, 0xC3, 0xE8, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x20, 0x27, 0xE5, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x00, 0x1F, 0xC4,
  0x05, 0x00, 0xA0, 0x04, 0x00, 0x70, 0x01, 0xC0, 0x04, 0x00, 0x40, 0x0A,
  0x01, 0x40, 0x47, 0xF0, 0x04, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x1F, 0x00,
  0x40, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80,
  0x50, 0x0A, 0x02, 0x40, 0xC7, 0xE8, 0x80, 0x14, 0x02, 0x40, 0x24, 0x04,
  0x40, 0x82, 0x08, 0x21, 0x02, 0x10, 0x22, 0x01, 0x20, 0x14, 0x01, 0x80,
  0x08, 0x00, 0x82, 0x0C, 0x30, 0xA1, 0x85, 0x14, 0x28, 0xA2, 0x45, 0x12,
  0x49, 0x12, 0x48, 0xA2, 0x45, 0x0C, 0x30, 0x61, 0x82, 0x08, 0x10, 0x00,
  0x20, 0x18, 0x81, 0x02, 0x10, 0x11, 0x00, 0x50, 0x02, 0x80, 0x08, 0x00,
  0xA0, 0x09, 0x00, 0x84, 0x08, 0x20, 0x80, 0x88, 0x02, 0x00, 0x20, 0x06,
  0x40, 0x08, 0x40, 0x20, 0x80, 0x81, 0x01, 0x02, 0x04, 0x02, 0x08, 0x04,
  0x20, 0x08, 0x80, 0x09, 0x00, 0x14, 0x00, 0x30, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x01, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x80, 0xC0, 0x80, 0x80, 0x40,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x0E, 0x06, 0x00, 0x80, 0x40,
  0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x20, 0x0C, 0x00, 0x11,
  0x11, 0x11, 0x22, 0x22, 0x22, 0x24, 0x44, 0x44, 0x48, 0x80, 0x0C, 0x00,
  0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x10,
  0x03, 0x01, 0x80, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x04, 0x02, 0x03, 0x00, 0x7C, 0x0C, 0x10, 0x60, 0x4C, 0x01, 0x80,
};

const GFXglyph RobotoMono_ThinItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 4, 18, 15, 5, -18 },
  { 10, 5, 5, 15, 6, -19 },
  { 14, 15, 18, 15, 0, -18 },
  { 48, 12, 23, 15, 2, -20 },
  { 83, 13, 18, 15, 1, -18 },
  { 113, 12, 18, 15, 1, -18 },
  { 140, 2, 5, 15, 7, -19 },
  { 142, 8, 26, 15, 4, -20 },
  { 168, 8, 26, 15, 2, -20 },
  { 194, 11, 10, 15, 3, -18 },
  { 208, 11, 13, 15, 2, -15 },
  { 226, 3, 5, 15, 3, -2 },
  { 228, 9, 1, 15, 3, -9 },
  { 230, 1, 1, 15, 6, -1 },
  { 231, 11, 20, 15, 2, -18 },
  { 259, 11, 18, 15, 2, -18 },
  { 284, 6, 18, 15, 4, -18 },
  { 298, 11, 18, 15, 1, -18 },
  { 323, 12, 18, 15, 1, -18 },
  { 350, 12, 18, 15, 1, -18 },
  { 377, 12, 18, 15, 2, -18 },
  { 404, 11, 18, 15, 1, -18 },
  { 429, 11, 18, 15, 3, -18 },
  { 454, 13, 18, 15, 1, -18 },
  { 484, 11, 18, 15, 2, -18 },
  { 509, 4, 12, 15, 6, -12 },
  { 515, 5, 15, 15, 5, -12 },
  { 525, 11, 10, 15, 2, -13 },
  { 539, 11, 6, 15, 2, -11 },
  { 548, 11, 10, 15, 2, -13 },
  { 562, 9, 18, 15, 4, -18 },
  { 583, 15, 18, 15, 0, -18 },
  { 617, 12, 18, 15, 0, -18 },
  { 644, 12, 18, 15, 1, -18 },
  { 671, 12, 18, 15, 2, -18 },
  { 698, 13, 18, 15, 1, -18 },
  { 728, 13, 18, 15, 1, -18 },
  { 758, 13, 18, 15, 1, -18 },
  { 788, 13, 18, 15, 1, -18 },
  { 818, 13, 18, 15, 1, -18 },
  { 848, 13, 18, 15, 1, -18 },
  { 878, 13, 18, 15, 1, -18 },
  { 908, 14, 18, 15, 1, -18 },
  { 940, 9, 18, 15, 2, -18 },
  { 961, 13, 18, 15, 1, -18 },
  { 991, 13, 18, 15, 1, -18 },
  { 1021, 12, 18, 15, 2, -18 },
  { 1048, 12, 18, 15, 2, -18 },
  { 1075, 13, 21, 15, 1, -18 },
  { 1110, 13, 18, 15, 1, -18 },
  { 1140, 13, 18, 15, 1, -18 },
  { 1170, 12, 18, 15, 3, -18 },
  { 1197, 12, 18, 15, 2, -18 },
  { 1224, 12, 18, 15, 3, -18 },
  { 1251, 13, 18, 15, 3, -18 },
  { 1281, 15, 18, 15, 0, -18 },
  { 1315, 12, 18, 15, 3, -18 },
  { 1342, 13, 18, 15, 1, -18 },
  { 1372, 7, 24, 15, 4, -20 },
  { 1393, 5, 20, 15, 5, -18 },
  { 1406, 7, 24, 15, 4, -20 },
  { 1427, 9, 10, 15, 3, -18 },
  { 1439, 10, 1, 15, 1, 0 },
  { 1441, 2, 4, 15, 8, -19 },
  { 1442, 12, 13, 15, 1, -13 },
  { 1462, 12, 19, 15, 1, -19 },
  { 1491, 11, 13, 15, 2, -13 },
  { 1509, 12, 19, 15, 2, -19 },
  { 1538, 11, 13, 15, 2, -13 },
  { 1556, 12, 19, 15, 3, -19 },
  { 1585, 12, 18, 15, 1, -13 },
  { 1612, 12, 19, 15, 1, -19 },
  { 1641, 10, 18, 15, 2, -18 },
  { 1664, 11, 23, 15, 0, -18 },
  { 1696, 12, 19, 15, 2, -19 },
  { 1725, 10, 19, 15, 2, -19 },
  { 1749, 14, 13, 15, 0, -13 },
  { 1772, 12, 13, 15, 1, -13 },
  { 1792, 12, 13, 15, 1, -13 },
  { 1812, 12, 18, 15, 0, -13 },
  { 1839, 11, 18, 15, 2, -13 },
  { 1864, 11, 13, 15, 3, -13 },
  { 1882, 11, 13, 15, 2, -13 },
  { 1900, 9, 17, 15, 3, -17 },
  { 1920, 11, 13, 15, 2, -13 },
  { 1938, 12, 13, 15, 2, -13 },
  { 1958, 13, 13, 15, 2, -13 },
  { 1980, 13, 13, 15, 1, -13 },
  { 2002, 15, 18, 15, 0, -13 },
  { 2036, 13, 13, 15, 0, -13 },
  { 2058, 9, 25, 15, 4, -20 },
  { 2087, 4, 21, 15, 5, -18 },
  { 2098, 10, 24, 15, 2, -19 },
  { 2128, 13, 4, 15, 1, -9 },
};

const GFXfont RobotoMono_ThinItalic25pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic25pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _ROBOTOMONO_THINITALIC25PT7B_H_
