#ifndef _ROBOTOMONO_THINITALIC47PT7B_H_
#define _ROBOTOMONO_THINITALIC47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x04, 0x18, 0x30, 0x40, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x40,
  0x81, 0x06, 0x08, 0x10, 0x20, 0x41, 0x83, 0x04, 0x08, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x61, 0x61, 0x41, 0x43, 0x43, 0x42,
  0xC2, 0x82, 0x86, 0x00, 0x02, 0x01, 0x80, 0x00, 0xC0, 0x20, 0x00, 0x10,
  0x0C, 0x00, 0x02, 0x01, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x10, 0x0C, 0x00,
  0x02, 0x01, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x10, 0x0C, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0xC0, 0x20, 0x00, 0x10, 0x0C, 0x00, 0x06, 0x01, 0x00, 0x00,
  0x80, 0x60, 0x00, 0x10, 0x08, 0x00, 0x06, 0x01, 0x00, 0x00, 0x80, 0x60,
  0x00, 0x10, 0x08, 0x00, 0x06, 0x01, 0x00, 0x00, 0x80, 0x60, 0x00, 0x10,
  0x08, 0x00, 0x06, 0x01, 0x00, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0,
  0x06, 0x01, 0x00, 0x00, 0x80, 0x60, 0x00, 0x10, 0x08, 0x00, 0x06, 0x01,
  0x00, 0x00, 0x80, 0x60, 0x00, 0x10, 0x08, 0x00, 0x06, 0x01, 0x00, 0x00,
  0x80, 0x40, 0x00, 0x30, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x1C,
  0x00, 0x30, 0x04, 0x00, 0x80, 0x0C, 0x02, 0x00, 0x08, 0x0C, 0x00, 0x08,
  0x10, 0x00, 0x10, 0x60, 0x00, 0x20, 0x80, 0x00, 0x41, 0x00, 0x00, 0x82,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x04,
  0x20, 0x00, 0x18, 0x40, 0x00, 0x20, 0xC0, 0x00, 0xC0, 0x80, 0x03, 0x01,
  0x80, 0x0C, 0x01, 0xC0, 0x70, 0x00, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x39, 0x80, 0x00, 0xC1, 0x00, 0x01, 0x03, 0x00, 0x04, 0x02,
  0x01, 0x88, 0x04, 0x02, 0x30, 0x08, 0x08, 0x40, 0x10, 0x30, 0x80, 0x60,
  0x41, 0x00, 0x81, 0x02, 0x01, 0x06, 0x04, 0x06, 0x18, 0x0C, 0x08, 0x20,
  0x08, 0x20, 0xC0, 0x1F, 0x83, 0x00, 0x0E, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x02, 0x07, 0x80, 0x0C, 0x39, 0x80,
  0x30, 0xC0, 0x80, 0x41, 0x01, 0x01, 0x86, 0x02, 0x06, 0x08, 0x04, 0x08,
  0x10, 0x08, 0x20, 0x20, 0x10, 0xC0, 0xC0, 0x21, 0x01, 0x00, 0x44, 0x03,
  0x01, 0x98, 0x06, 0x02, 0x00, 0x04, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x73, 0x80, 0x01, 0x81, 0x00, 0x06, 0x03,
  0x00, 0x18, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x30,
  0x03, 0x00, 0x40, 0x02, 0x01, 0x80, 0x04, 0x06, 0x00, 0x08, 0x18, 0x00,
  0x18, 0x60, 0x00, 0x13, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x40, 0x00, 0x18, 0x40, 0x00, 0x60, 0xC0, 0x11, 0x80,
  0x80, 0x22, 0x00, 0x80, 0xC8, 0x01, 0x81, 0x30, 0x01, 0x02, 0x40, 0x03,
  0x0C, 0x80, 0x03, 0x11, 0x00, 0x02, 0x62, 0x00, 0x07, 0x84, 0x00, 0x06,
  0x08, 0x00, 0x0C, 0x18, 0x00, 0x3C, 0x18, 0x01, 0x88, 0x18, 0x0E, 0x08,
  0x1F, 0xF0, 0x18, 0x6D, 0x24, 0xB4, 0x80, 0x00, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x78, 0x10, 0x39,
  0xC2, 0x38, 0x07, 0xFC, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x90, 0x00,
  0x63, 0x00, 0x18, 0x20, 0x06, 0x02, 0x01, 0x80, 0x60, 0x60, 0x06, 0x08,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x84, 0x21, 0x18, 0x8C, 0xC4, 0x00, 0xFF, 0xFF, 0x5F, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x01, 0xC3, 0x80, 0x0C, 0x03, 0x00, 0x40, 0x04, 0x02, 0x00, 0x08, 0x18,
  0x00, 0x20, 0x40, 0x00, 0xC2, 0x00, 0x01, 0x08, 0x00, 0x04, 0x40, 0x00,
  0x71, 0x00, 0x03, 0x4C, 0x00, 0x19, 0x20, 0x00, 0xC4, 0x80, 0x06, 0x12,
  0x00, 0x20, 0xC8, 0x01, 0x03, 0x60, 0x08, 0x09, 0x80, 0xC0, 0x24, 0x06,
  0x00, 0x90, 0x30, 0x02, 0x41, 0x80, 0x19, 0x0C, 0x00, 0x44, 0x40, 0x01,
  0x32, 0x00, 0x04, 0xF0, 0x00, 0x31, 0x80, 0x00, 0x84, 0x00, 0x06, 0x10,
  0x00, 0x10, 0x40, 0x00, 0xC1, 0x80, 0x02, 0x02, 0x00, 0x10, 0x0C, 0x00,
  0x80, 0x18, 0x0C, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x30, 0x1D, 0x07, 0x31,
  0xC3, 0x60, 0x28, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x00, 0x1F, 0x80,
  0x01, 0xE7, 0x80, 0x1C, 0x03, 0x00, 0xC0, 0x06, 0x02, 0x00, 0x08, 0x10,
  0x00, 0x30, 0xC0, 0x00, 0xC2, 0x00, 0x01, 0x18, 0x00, 0x04, 0x40, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x71,
  0xE0, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x30, 0x00, 0x40, 0xC0, 0x00,
  0x81, 0x00, 0x01, 0x86, 0x00, 0x03, 0x08, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x23, 0x00, 0x00,
  0x46, 0x00, 0x00, 0x84, 0x00, 0x02, 0x0C, 0x00, 0x0C, 0x08, 0x00, 0x30,
  0x18, 0x00, 0xC0, 0x1C, 0x07, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x40, 0x00, 0x09, 0x80,
  0x00, 0x32, 0x00, 0x00, 0xC4, 0x00, 0x03, 0x08, 0x00, 0x04, 0x10, 0x00,
  0x10, 0x60, 0x00, 0x40, 0xC0, 0x01, 0x81, 0x00, 0x06, 0x02, 0x00, 0x18,
  0x04, 0x00, 0x20, 0x08, 0x00, 0x80, 0x30, 0x03, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x30, 0x01, 0x00, 0xC0, 0x02, 0x01, 0x00, 0x04, 0x04, 0x00, 0x18,
  0x18, 0x00, 0x20, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFE, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x8F, 0xC0, 0x03, 0x70, 0x60,
  0x07, 0x00, 0x20, 0x08, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x21, 0x80, 0x00, 0xC3, 0x00,
  0x01, 0x02, 0x00, 0x06, 0x04, 0x00, 0x08, 0x0C, 0x00, 0x20, 0x0C, 0x00,
  0x80, 0x0C, 0x06, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x7E, 0x02, 0x3E, 0x38, 0x26, 0x00, 0xC6, 0x80, 0x04, 0x50,
  0x00, 0x26, 0x00, 0x02, 0x40, 0x00, 0x34, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x28, 0x00, 0x02,
  0x80, 0x00, 0x2C, 0x00, 0x04, 0x40, 0x00, 0xC4, 0x00, 0x08, 0x20, 0x01,
  0x83, 0x00, 0x30, 0x18, 0x0C, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0xF1, 0xC0, 0x03, 0x00, 0x60, 0x08, 0x00, 0x40, 0x20,
  0x00, 0x40, 0x80, 0x00, 0x83, 0x00, 0x01, 0x84, 0x00, 0x03, 0x08, 0x00,
  0x06, 0x10, 0x00, 0x0C, 0x20, 0x00, 0x10, 0x40, 0x00, 0x60, 0x80, 0x00,
  0x81, 0x80, 0x02, 0x01, 0x80, 0x08, 0x01, 0x80, 0x60, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x18, 0x03, 0x00, 0xC0, 0x03, 0x03, 0x00, 0x03, 0x04,
  0x00, 0x02, 0x10, 0x00, 0x06, 0x20, 0x00, 0x04, 0x80, 0x00, 0x09, 0x00,
  0x00, 0x32, 0x00, 0x00, 0x44, 0x00, 0x00, 0x88, 0x00, 0x03, 0x18, 0x00,
  0x0C, 0x10, 0x00, 0x30, 0x10, 0x00, 0xC0, 0x18, 0x07, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x3C, 0x70, 0x06, 0x01, 0x80, 0xC0, 0x0C, 0x18,
  0x00, 0x63, 0x00, 0x02, 0x20, 0x00, 0x26, 0x00, 0x02, 0x40, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x02,
  0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x6C, 0x00, 0x06, 0x40, 0x00,
  0xE6, 0x00, 0x34, 0x30, 0x06, 0x41, 0x81, 0xC4, 0x0F, 0xF0, 0x80, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x07,
  0xE0, 0x00, 0x04, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x43, 0x8E, 0x00, 0x00, 0x80, 0xC0, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10,
  0x18, 0x08, 0x08, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x10, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0xF0, 0x07, 0x8E, 0x06, 0x01, 0x86, 0x00,
  0x66, 0x00, 0x12, 0x00, 0x0B, 0x00, 0x05, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0xE0, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x08, 0x03, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x10, 0x30, 0x1E, 0x02, 0x0C, 0x0F, 0xE0, 0x41,
  0x03, 0x06, 0x08, 0x60, 0xC0, 0x41, 0x08, 0x10, 0x10, 0x23, 0x04, 0x02,
  0x04, 0x40, 0x80, 0x40, 0x88, 0x20, 0x18, 0x13, 0x04, 0x02, 0x02, 0x41,
  0x80, 0x40, 0x48, 0x20, 0x08, 0x19, 0x04, 0x03, 0x02, 0x60, 0x80, 0x40,
  0x48, 0x30, 0x18, 0x19, 0x06, 0x03, 0x02, 0x20, 0x80, 0xE0, 0x44, 0x10,
  0x18, 0x18, 0x83, 0x05, 0x02, 0x10, 0x21, 0x10, 0x83, 0x07, 0xC3, 0xE0,
  0x20, 0x30, 0x30, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x04, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0B, 0x00,
  0x00, 0x32, 0x00, 0x00, 0x44, 0x00, 0x01, 0x88, 0x00, 0x02, 0x10, 0x00,
  0x0C, 0x20, 0x00, 0x10, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x80, 0x80, 0x03,
  0x01, 0x00, 0x04, 0x02, 0x00, 0x18, 0x04, 0x00, 0x20, 0x08, 0x00, 0xC0,
  0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x20, 0x08, 0x00, 0x40, 0x30, 0x00,
  0x80, 0x40, 0x01, 0x01, 0xFF, 0xFE, 0x02, 0x00, 0x06, 0x0C, 0x00, 0x0C,
  0x10, 0x00, 0x08, 0x20, 0x00, 0x10, 0x80, 0x00, 0x21, 0x00, 0x00, 0x44,
  0x00, 0x00, 0x88, 0x00, 0x01, 0xA0, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x03,
  0xFF, 0xE0, 0x04, 0x00, 0x60, 0x08, 0x00, 0x20, 0x10, 0x00, 0x20, 0x60,
  0x00, 0x60, 0x80, 0x00, 0x41, 0x00, 0x00, 0x82, 0x00, 0x01, 0x04, 0x00,
  0x02, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x10, 0x40, 0x00, 0x60, 0x80, 0x01,
  0x81, 0x00, 0x06, 0x02, 0x00, 0x30, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x20, 0x00, 0xC0, 0x40, 0x00, 0x40, 0x80, 0x00, 0x41, 0x00, 0x00, 0x86,
  0x00, 0x01, 0x88, 0x00, 0x03, 0x10, 0x00, 0x06, 0x20, 0x00, 0x08, 0x40,
  0x00, 0x10, 0x80, 0x00, 0x63, 0x00, 0x00, 0x84, 0x00, 0x03, 0x08, 0x00,
  0x0C, 0x10, 0x00, 0x70, 0x20, 0x03, 0x80, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0xF3, 0xC0, 0x03, 0x00, 0xC0, 0x08, 0x00, 0xC0, 0x20, 0x00,
  0x80, 0x80, 0x00, 0x83, 0x00, 0x01, 0x04, 0x00, 0x02, 0x10, 0x00, 0x06,
  0x20, 0x00, 0x0C, 0xC0, 0x00, 0x09, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x04, 0x80, 0x00, 0x11, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x86, 0x00, 0x03, 0x04, 0x00, 0x04, 0x08, 0x00, 0x18,
  0x08, 0x00, 0x60, 0x18, 0x01, 0x80, 0x18, 0x0E, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x02, 0x00, 0x70, 0x06, 0x00, 0x18, 0x04, 0x00, 0x08,
  0x04, 0x00, 0x04, 0x04, 0x00, 0x06, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x02,
  0x0C, 0x00, 0x03, 0x08, 0x00, 0x03, 0x08, 0x00, 0x01, 0x08, 0x00, 0x01,
  0x08, 0x00, 0x01, 0x18, 0x00, 0x03, 0x10, 0x00, 0x03, 0x10, 0x00, 0x02,
  0x10, 0x00, 0x02, 0x10, 0x00, 0x02, 0x10, 0x00, 0x02, 0x30, 0x00, 0x06,
  0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x08,
  0x20, 0x00, 0x18, 0x60, 0x00, 0x10, 0x40, 0x00, 0x20, 0x40, 0x00, 0x60,
  0x40, 0x00, 0xC0, 0x40, 0x01, 0x80, 0xC0, 0x07, 0x00, 0xC0, 0x3C, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF1, 0xC0, 0x03, 0x00, 0xC0, 0x18,
  0x00, 0xC0, 0x60, 0x00, 0xC0, 0x80, 0x00, 0x83, 0x00, 0x01, 0x0C, 0x00,
  0x03, 0x10, 0x00, 0x02, 0x60, 0x00, 0x04, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0xFF, 0xC8,
  0x00, 0x00, 0x90, 0x00, 0x01, 0x20, 0x00, 0x06, 0x40, 0x00, 0x08, 0x80,
  0x00, 0x11, 0x00, 0x00, 0x22, 0x00, 0x00, 0x46, 0x00, 0x00, 0x84, 0x00,
  0x03, 0x0C, 0x00, 0x04, 0x08, 0x00, 0x18, 0x18, 0x00, 0x60, 0x1C, 0x03,
  0x80, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x01, 0x82, 0x00,
  0x00, 0xC1, 0x00, 0x00, 0x40, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x10, 0x60,
  0x00, 0x08, 0x20, 0x00, 0x0C, 0x10, 0x00, 0x04, 0x08, 0x00, 0x02, 0x04,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x82, 0x00, 0x00, 0x41, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x20, 0x40, 0x00, 0x10, 0x3F, 0xFF, 0xF8, 0x30, 0x00, 0x04,
  0x10, 0x00, 0x02, 0x08, 0x00, 0x03, 0x04, 0x00, 0x01, 0x02, 0x00, 0x00,
  0x81, 0x00, 0x00, 0x41, 0x80, 0x00, 0x20, 0x80, 0x00, 0x10, 0x40, 0x00,
  0x18, 0x20, 0x00, 0x08, 0x10, 0x00, 0x04, 0x08, 0x00, 0x02, 0x0C, 0x00,
  0x01, 0x04, 0x00, 0x01, 0x82, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x40, 0x80,
  0x00, 0x20, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x20, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x80, 0x00, 0x20, 0x80, 0x00, 0x20,
  0x80, 0x00, 0x40, 0x80, 0x00, 0xC0, 0x40, 0x00, 0x80, 0x40, 0x01, 0x00,
  0x20, 0x07, 0x00, 0x18, 0x0C, 0x00, 0x0F, 0xF8, 0x00, 0x06, 0x00, 0x01,
  0xC1, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x60, 0x10, 0x00, 0x20, 0x04, 0x00,
  0x10, 0x03, 0x00, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x20, 0x06, 0x00, 0x08,
  0x03, 0x00, 0x02, 0x01, 0x80, 0x00, 0x80, 0xC0, 0x00, 0x60, 0x60, 0x00,
  0x10, 0x30, 0x00, 0x04, 0x18, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x47, 0x00,
  0x00, 0x13, 0x60, 0x00, 0x0D, 0x08, 0x00, 0x02, 0x81, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x20, 0x08, 0x00, 0x08, 0x03, 0x00, 0x02, 0x00, 0x40, 0x01,
  0x80, 0x08, 0x00, 0x40, 0x03, 0x00, 0x10, 0x00, 0x40, 0x04, 0x00, 0x18,
  0x01, 0x00, 0x02, 0x00, 0x40, 0x00, 0x40, 0x30, 0x00, 0x18, 0x08, 0x00,
  0x02, 0x02, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x01, 0x83, 0x80, 0x01, 0xC1, 0x40,
  0x00, 0xA0, 0xA0, 0x00, 0xF0, 0x50, 0x00, 0xD0, 0x28, 0x00, 0x48, 0x36,
  0x00, 0x64, 0x11, 0x00, 0x22, 0x08, 0x80, 0x33, 0x04, 0x40, 0x11, 0x02,
  0x20, 0x10, 0x83, 0x18, 0x18, 0x41, 0x84, 0x08, 0x20, 0x82, 0x0C, 0x10,
  0x41, 0x04, 0x18, 0x20, 0x86, 0x08, 0x10, 0x62, 0x04, 0x18, 0x12, 0x02,
  0x0C, 0x09, 0x01, 0x04, 0x05, 0x01, 0x82, 0x03, 0x80, 0xC1, 0x01, 0x80,
  0x40, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x08, 0x20, 0x00,
  0x0C, 0x10, 0x00, 0x06, 0x08, 0x00, 0x02, 0x04, 0x00, 0x01, 0x06, 0x00,
  0x00, 0x82, 0x00, 0x00, 0x41, 0x00, 0x00, 0x60, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0x81, 0xC0, 0x00, 0x40, 0xA0, 0x00,
  0x20, 0x50, 0x00, 0x10, 0x64, 0x00, 0x08, 0x22, 0x00, 0x0C, 0x11, 0x00,
  0x04, 0x08, 0x40, 0x02, 0x04, 0x20, 0x01, 0x06, 0x18, 0x00, 0x82, 0x04,
  0x00, 0x41, 0x02, 0x00, 0x60, 0x80, 0x80, 0x20, 0x40, 0x40, 0x10, 0x20,
  0x20, 0x08, 0x30, 0x08, 0x04, 0x10, 0x04, 0x02, 0x08, 0x03, 0x03, 0x04,
  0x00, 0x81, 0x02, 0x00, 0x40, 0x81, 0x00, 0x10, 0x41, 0x80, 0x08, 0x20,
  0x80, 0x04, 0x30, 0x40, 0x01, 0x18, 0x20, 0x00, 0x88, 0x10, 0x00, 0x64,
  0x08, 0x00, 0x12, 0x0C, 0x00, 0x09, 0x04, 0x00, 0x03, 0x82, 0x00, 0x01,
  0xC1, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x20, 0x00, 0x00, 0x1F, 0x80, 0x01,
  0xE7, 0x80, 0x0C, 0x03, 0x00, 0xC0, 0x04, 0x02, 0x00, 0x08, 0x10, 0x00,
  0x20, 0xC0, 0x00, 0x42, 0x00, 0x01, 0x10, 0x00, 0x04, 0x40, 0x00, 0x13,
  0x00, 0x00, 0x48, 0x00, 0x01, 0x20, 0x00, 0x05, 0x80, 0x00, 0x14, 0x00,
  0x00, 0x50, 0x00, 0x01, 0x40, 0x00, 0x05, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x02, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x28, 0x00, 0x01, 0xA0,
  0x00, 0x04, 0x80, 0x00, 0x12, 0x00, 0x00, 0xC8, 0x00, 0x02, 0x30, 0x00,
  0x18, 0x40, 0x00, 0xC1, 0x00, 0x02, 0x02, 0x00, 0x10, 0x0C, 0x00, 0x80,
  0x18, 0x0C, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x06, 0x00, 0x18,
  0x06, 0x00, 0x0C, 0x04, 0x00, 0x06, 0x04, 0x00, 0x02, 0x04, 0x00, 0x03,
  0x04, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x03,
  0x08, 0x00, 0x03, 0x08, 0x00, 0x02, 0x08, 0x00, 0x06, 0x18, 0x00, 0x04,
  0x10, 0x00, 0x08, 0x10, 0x00, 0x18, 0x10, 0x00, 0x60, 0x10, 0x03, 0xC0,
  0x1F, 0xFE, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x3C, 0x70, 0x00, 0xE0, 0x18, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x04,
  0x06, 0x00, 0x02, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x01,
  0x18, 0x00, 0x01, 0x10, 0x00, 0x01, 0x30, 0x00, 0x01, 0x20, 0x00, 0x01,
  0x20, 0x00, 0x01, 0x20, 0x00, 0x01, 0x60, 0x00, 0x01, 0x60, 0x00, 0x03,
  0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02,
  0x40, 0x00, 0x06, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x04, 0x40, 0x00, 0x0C,
  0x40, 0x00, 0x08, 0x40, 0x00, 0x18, 0x40, 0x00, 0x10, 0x60, 0x00, 0x30,
  0x20, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x0C, 0x07, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x07, 0xFF, 0xC0,
  0x08, 0x00, 0xE0, 0x10, 0x00, 0x60, 0x20, 0x00, 0x40, 0x40, 0x00, 0xC1,
  0x80, 0x00, 0x82, 0x00, 0x01, 0x04, 0x00, 0x02, 0x08, 0x00, 0x04, 0x10,
  0x00, 0x08, 0x20, 0x00, 0x10, 0xC0, 0x00, 0x61, 0x00, 0x00, 0x82, 0x00,
  0x03, 0x04, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x10, 0x00, 0xC0, 0x7F, 0xFE,
  0x00, 0xFF, 0xF0, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x08, 0x00, 0xC0, 0x30, 0x00, 0x80, 0x40, 0x01, 0x00, 0x80, 0x03, 0x01,
  0x00, 0x02, 0x02, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x10, 0x00, 0x08, 0x20,
  0x00, 0x18, 0x40, 0x00, 0x10, 0x80, 0x00, 0x30, 0x00, 0x1F, 0x80, 0x00,
  0xF1, 0xC0, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x40, 0x40, 0x00, 0xC1, 0x80,
  0x00, 0x82, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x10, 0x00, 0x02, 0x20, 0x00,
  0x04, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x19, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x44, 0x00, 0x00, 0x88, 0x00, 0x03, 0x18, 0x00, 0x04, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x60, 0x18, 0x07, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x01, 0x08, 0x00, 0x03, 0x08,
  0x00, 0x02, 0x08, 0x00, 0x02, 0x18, 0x00, 0x02, 0x10, 0x00, 0x02, 0x10,
  0x00, 0x06, 0x10, 0x00, 0x06, 0x10, 0x00, 0x04, 0x10, 0x00, 0x04, 0x30,
  0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x08, 0x20,
  0x00, 0x08, 0x20, 0x00, 0x08, 0x60, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40,
  0x00, 0x18, 0x40, 0x00, 0x10, 0x40, 0x00, 0x10, 0x40, 0x00, 0x10, 0xC0,
  0x00, 0x10, 0x80, 0x00, 0x30, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x20, 0xC0,
  0x00, 0x60, 0x40, 0x00, 0x40, 0x40, 0x00, 0x80, 0x20, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x18, 0x0C, 0x00, 0x0F, 0xF8, 0x00, 0xC0, 0x00, 0x06, 0x80,
  0x00, 0x09, 0x00, 0x00, 0x32, 0x00, 0x00, 0x44, 0x00, 0x01, 0x8C, 0x00,
  0x02, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x10, 0x20, 0x00, 0x60, 0x40, 0x00,
  0x80, 0x80, 0x03, 0x01, 0x80, 0x04, 0x03, 0x00, 0x08, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x30, 0x08, 0x00,
  0x60, 0x10, 0x00, 0x40, 0x60, 0x00, 0x80, 0x80, 0x01, 0x03, 0x00, 0x02,
  0x04, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x20, 0x00, 0x08, 0xC0, 0x00, 0x11,
  0x00, 0x00, 0x26, 0x00, 0x00, 0x48, 0x00, 0x00, 0xB0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x03, 0x80, 0x18, 0x02, 0x80, 0x38, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28,
  0x04, 0x80, 0x68, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x80, 0x88,
  0x08, 0x80, 0x88, 0x08, 0x81, 0x88, 0x18, 0x81, 0x08, 0x10, 0x81, 0x08,
  0x10, 0x83, 0x08, 0x30, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x86, 0x08,
  0x60, 0x84, 0x08, 0x40, 0x84, 0x0C, 0x40, 0x8C, 0x0C, 0x40, 0x88, 0x0C,
  0x80, 0x88, 0x0C, 0x80, 0x98, 0x0C, 0x80, 0x90, 0x0D, 0x00, 0x90, 0x0D,
  0x00, 0xB0, 0x0D, 0x00, 0xA0, 0x07, 0x00, 0xA0, 0x06, 0x00, 0xE0, 0x06,
  0x00, 0xC0, 0x06, 0x00, 0xC0, 0x04, 0x00, 0xC0, 0x04, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x18, 0x04, 0x00, 0x06, 0x00, 0x80, 0x00, 0x80,
  0x08, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x02, 0x00,
  0xC0, 0x00, 0x60, 0x10, 0x00, 0x04, 0x04, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x08, 0x60, 0x00, 0x01, 0x88, 0x00, 0x00, 0x12, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0x18, 0x80, 0x00, 0x06, 0x10, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x20, 0x20, 0x00, 0x08, 0x06, 0x00, 0x03, 0x00, 0x40, 0x00, 0xC0,
  0x0C, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x18, 0x01, 0x80, 0x01, 0x00,
  0x60, 0x00, 0x30, 0x08, 0x00, 0x02, 0x02, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x04, 0x00, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x21, 0x00,
  0x00, 0x82, 0x00, 0x03, 0x06, 0x00, 0x04, 0x04, 0x00, 0x10, 0x08, 0x00,
  0x60, 0x18, 0x01, 0x80, 0x10, 0x02, 0x00, 0x20, 0x0C, 0x00, 0x20, 0x30,
  0x00, 0x40, 0x40, 0x00, 0x81, 0x00, 0x00, 0x86, 0x00, 0x01, 0x08, 0x00,
  0x02, 0x20, 0x00, 0x02, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0xFE, 0x00, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x40, 0x40, 0x60,
  0x60, 0x20, 0x20, 0x20, 0x30, 0x30, 0x10, 0x10, 0x10, 0x18, 0x18, 0x08,
  0x08, 0x08, 0x0C, 0x0C, 0x04, 0x04, 0x04, 0x06, 0x06, 0x02, 0x02, 0x02,
  0x03, 0x03, 0x01, 0x01, 0x01, 0xFC, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0xFE, 0x00, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x50, 0x00, 0xD8, 0x00, 0x88, 0x01, 0x08, 0x03,
  0x08, 0x02, 0x08, 0x06, 0x0C, 0x04, 0x04, 0x0C, 0x04, 0x08, 0x04, 0x10,
  0x06, 0x30, 0x02, 0x20, 0x02, 0x60, 0x02, 0x40, 0x03, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0xC2, 0x18, 0x41, 0x0C, 0x00, 0x7F, 0x80, 0x0C, 0x06, 0x01,
  0x80, 0x08, 0x18, 0x00, 0x60, 0x80, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x01,
  0xFF, 0xE0, 0x7E, 0x03, 0x0E, 0x00, 0x10, 0xC0, 0x00, 0x8C, 0x00, 0x04,
  0xC0, 0x00, 0x24, 0x00, 0x03, 0x20, 0x00, 0x19, 0x00, 0x01, 0x88, 0x00,
  0x1C, 0x40, 0x01, 0xA3, 0x00, 0x19, 0x0C, 0x03, 0x08, 0x1F, 0xE0, 0x40,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x1F, 0xC0, 0x13, 0x81, 0x81, 0xB0, 0x06, 0x0B, 0x00,
  0x10, 0x60, 0x00, 0xC3, 0x00, 0x02, 0x10, 0x00, 0x10, 0x80, 0x00, 0x8C,
  0x00, 0x04, 0x60, 0x00, 0x32, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00,
  0x44, 0x00, 0x02, 0x60, 0x00, 0x32, 0x00, 0x01, 0x90, 0x00, 0x08, 0x80,
  0x00, 0xC4, 0x00, 0x04, 0x20, 0x00, 0x63, 0x00, 0x02, 0x14, 0x00, 0x20,
  0xB0, 0x03, 0x04, 0xC0, 0x60, 0x21, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x0E,
  0x06, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x60, 0xC0, 0x01, 0x0C, 0x00, 0x08,
  0x40, 0x00, 0x66, 0x00, 0x03, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x01, 0x10, 0x00, 0x18, 0x80, 0x00,
  0x86, 0x00, 0x0C, 0x10, 0x00, 0xC0, 0xC0, 0x0C, 0x03, 0x01, 0xC0, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x03, 0xFC, 0x20, 0x0C, 0x0C,
  0x40, 0x30, 0x04, 0x80, 0x80, 0x07, 0x02, 0x00, 0x0E, 0x0C, 0x00, 0x08,
  0x10, 0x00, 0x10, 0x60, 0x00, 0x20, 0x80, 0x00, 0x43, 0x00, 0x01, 0x84,
  0x00, 0x03, 0x08, 0x00, 0x04, 0x10, 0x00, 0x08, 0x20, 0x00, 0x10, 0xC0,
  0x00, 0x21, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x02, 0x04, 0x00,
  0x04, 0x08, 0x00, 0x08, 0x10, 0x00, 0x30, 0x10, 0x00, 0xE0, 0x30, 0x06,
  0x80, 0x30, 0x19, 0x00, 0x3F, 0xC2, 0x00, 0x00, 0x7F, 0x80, 0x0E, 0x06,
  0x00, 0xC0, 0x18, 0x0C, 0x00, 0x60, 0xC0, 0x01, 0x0C, 0x00, 0x0C, 0x40,
  0x00, 0x24, 0x00, 0x01, 0x20, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x02,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x20, 0x40, 0x06, 0x01, 0x80, 0xE0, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFA, 0x00, 0x0F, 0xF8, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFE, 0x08,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x84,
  0x03, 0x03, 0x10, 0x18, 0x02, 0x40, 0x80, 0x07, 0x04, 0x00, 0x1C, 0x30,
  0x00, 0x20, 0x80, 0x00, 0x86, 0x00, 0x02, 0x10, 0x00, 0x08, 0xC0, 0x00,
  0x62, 0x00, 0x01, 0x88, 0x00, 0x04, 0x20, 0x00, 0x10, 0x80, 0x00, 0x46,
  0x00, 0x01, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x30, 0x80, 0x00, 0x82, 0x00,
  0x02, 0x08, 0x00, 0x18, 0x20, 0x00, 0x60, 0x40, 0x03, 0x81, 0x80, 0x16,
  0x03, 0x01, 0x90, 0x07, 0xF8, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x08, 0x00, 0x30, 0x10, 0x01,
  0x80, 0x60, 0x0C, 0x00, 0x60, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x41, 0xFC, 0x03, 0x1C, 0x0C, 0x08, 0xC0, 0x10, 0x24, 0x00,
  0x20, 0xA0, 0x00, 0x83, 0x00, 0x02, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x31,
  0x80, 0x00, 0x84, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x21, 0x00,
  0x00, 0x8C, 0x00, 0x06, 0x20, 0x00, 0x10, 0x80, 0x00, 0x42, 0x00, 0x01,
  0x08, 0x00, 0x04, 0x60, 0x00, 0x11, 0x80, 0x00, 0xC4, 0x00, 0x02, 0x10,
  0x00, 0x08, 0x40, 0x00, 0x21, 0x00, 0x00, 0x8C, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x08, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x20,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0xC3, 0x00,
  0x06, 0x08, 0x00, 0x60, 0x20, 0x03, 0x00, 0x80, 0x18, 0x02, 0x00, 0xC0,
  0x08, 0x0C, 0x00, 0x60, 0x60, 0x01, 0x03, 0x00, 0x04, 0x30, 0x00, 0x11,
  0x80, 0x00, 0x4E, 0x00, 0x03, 0x6C, 0x00, 0x0E, 0x18, 0x00, 0x30, 0x20,
  0x00, 0x80, 0x40, 0x02, 0x01, 0x80, 0x08, 0x03, 0x00, 0x60, 0x04, 0x01,
  0x80, 0x18, 0x04, 0x00, 0x30, 0x10, 0x00, 0x40, 0x40, 0x01, 0x81, 0x00,
  0x03, 0x0C, 0x00, 0x06, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x03, 0xFF, 0xFF, 0x80, 0x09, 0xFC, 0x1F, 0x81, 0x60, 0xCC, 0x18,
  0x58, 0x0B, 0x01, 0x0E, 0x01, 0xC0, 0x21, 0x80, 0x30, 0x04, 0x20, 0x04,
  0x00, 0x84, 0x00, 0x80, 0x10, 0x80, 0x10, 0x02, 0x30, 0x02, 0x00, 0x44,
  0x00, 0xC0, 0x08, 0x80, 0x10, 0x03, 0x10, 0x02, 0x00, 0x42, 0x00, 0x40,
  0x08, 0x40, 0x08, 0x01, 0x10, 0x01, 0x00, 0x22, 0x00, 0x60, 0x04, 0x40,
  0x08, 0x01, 0x88, 0x01, 0x00, 0x21, 0x00, 0x20, 0x04, 0x60, 0x04, 0x00,
  0x88, 0x01, 0x80, 0x11, 0x00, 0x20, 0x02, 0x20, 0x04, 0x00, 0xC4, 0x00,
  0x80, 0x10, 0x80, 0x10, 0x02, 0x00, 0x04, 0x1F, 0xC0, 0x31, 0xC0, 0xC0,
  0x8C, 0x01, 0x02, 0x40, 0x02, 0x0A, 0x00, 0x08, 0x30, 0x00, 0x20, 0xC0,
  0x00, 0x86, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x21, 0x00, 0x00,
  0x84, 0x00, 0x02, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x62, 0x00, 0x01, 0x08,
  0x00, 0x04, 0x20, 0x00, 0x10, 0x80, 0x00, 0x46, 0x00, 0x03, 0x18, 0x00,
  0x0C, 0x40, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x02, 0x10, 0x00, 0x08,
  0xC0, 0x00, 0x60, 0x00, 0x7F, 0x00, 0x0C, 0x0E, 0x01, 0x80, 0x18, 0x18,
  0x00, 0x61, 0x80, 0x01, 0x08, 0x00, 0x0C, 0x80, 0x00, 0x2C, 0x00, 0x01,
  0x40, 0x00, 0x0A, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x02, 0x80, 0x00, 0x14,
  0x00, 0x01, 0xA0, 0x00, 0x09, 0x80, 0x00, 0x84, 0x00, 0x0C, 0x30, 0x00,
  0xC0, 0xC0, 0x0C, 0x03, 0x01, 0xC0, 0x0F, 0xF8, 0x00, 0x02, 0x1F, 0xC0,
  0x09, 0xC1, 0xC0, 0x6C, 0x01, 0x81, 0x60, 0x02, 0x07, 0x00, 0x0C, 0x18,
  0x00, 0x10, 0x40, 0x00, 0x41, 0x00, 0x01, 0x0C, 0x00, 0x04, 0x20, 0x00,
  0x10, 0x80, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x04, 0x60, 0x00, 0x11,
  0x80, 0x00, 0xC4, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x61, 0x00,
  0x01, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x20, 0xE0, 0x01, 0x02, 0xC0, 0x08,
  0x09, 0x80, 0xC0, 0x21, 0xFE, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x08, 0x0C, 0x0C, 0x40, 0xC0, 0x12, 0x08, 0x00, 0x70, 0x80, 0x03, 0x8C,
  0x00, 0x08, 0x40, 0x00, 0x46, 0x00, 0x02, 0x20, 0x00, 0x13, 0x00, 0x00,
  0x90, 0x00, 0x0C, 0x80, 0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x13, 0x00,
  0x00, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x62, 0x00, 0x02, 0x10, 0x00, 0x10,
  0x80, 0x00, 0x84, 0x00, 0x0C, 0x10, 0x00, 0xE0, 0xC0, 0x0A, 0x03, 0x01,
  0x90, 0x0F, 0xF0, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x04, 0x0F, 0xF0, 0xC3, 0x80, 0x08,
  0xC0, 0x00, 0x98, 0x00, 0x0A, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x1C, 0x07, 0x01, 0x80, 0x0C, 0x18, 0x00, 0x30, 0x80, 0x00, 0x8C, 0x00,
  0x04, 0x40, 0x00, 0x22, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x09, 0x80,
  0x00, 0x44, 0x00, 0x06, 0x20, 0x00, 0x20, 0x80, 0x03, 0x03, 0x00, 0xE0,
  0x0F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x01, 0xFF, 0xFF, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0xF8, 0x10,
  0x00, 0x19, 0x80, 0x00, 0x8C, 0x00, 0x04, 0x40, 0x00, 0x22, 0x00, 0x01,
  0x10, 0x00, 0x18, 0x80, 0x00, 0xCC, 0x00, 0x04, 0x40, 0x00, 0x22, 0x00,
  0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0xC4, 0x00, 0x04, 0x60, 0x00, 0x22,
  0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x06, 0x20, 0x00,
  0x21, 0x00, 0x03, 0x08, 0x00, 0x18, 0x60, 0x01, 0x41, 0x00, 0x32, 0x06,
  0x07, 0x30, 0x1F, 0xE1, 0x00, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x98, 0x00, 0x06, 0x60, 0x00, 0x30, 0x80, 0x00, 0x82, 0x00, 0x06,
  0x0C, 0x00, 0x10, 0x10, 0x00, 0xC0, 0x40, 0x02, 0x01, 0x00, 0x10, 0x06,
  0x00, 0xC0, 0x08, 0x02, 0x00, 0x20, 0x18, 0x00, 0x80, 0x40, 0x03, 0x03,
  0x00, 0x04, 0x08, 0x00, 0x10, 0x40, 0x00, 0x63, 0x00, 0x01, 0x88, 0x00,
  0x02, 0x60, 0x00, 0x09, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x10, 0x03, 0x80, 0x10, 0x02, 0x80, 0x30, 0x02, 0x80,
  0x38, 0x06, 0x80, 0x78, 0x04, 0x80, 0x58, 0x04, 0x80, 0x58, 0x08, 0x80,
  0x88, 0x08, 0x80, 0x88, 0x18, 0x81, 0x88, 0x10, 0x81, 0x08, 0x10, 0x83,
  0x08, 0x20, 0xC2, 0x08, 0x20, 0xC2, 0x08, 0x60, 0xC4, 0x08, 0x40, 0xC4,
  0x08, 0x40, 0xCC, 0x0C, 0xC0, 0xC8, 0x0C, 0x80, 0x48, 0x0D, 0x80, 0x50,
  0x05, 0x00, 0x50, 0x05, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x04, 0x00, 0x01, 0x83, 0x00, 0x01, 0x80,
  0xC0, 0x01, 0x80, 0x20, 0x01, 0x80, 0x18, 0x01, 0x80, 0x04, 0x01, 0x80,
  0x03, 0x01, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x21, 0x80, 0x00, 0x19, 0x80,
  0x00, 0x06, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xC1, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0xC0, 0x20, 0x00, 0xC0, 0x08, 0x00, 0xC0, 0x06, 0x00, 0xC0,
  0x01, 0x00, 0xC0, 0x00, 0xC0, 0x40, 0x00, 0x30, 0xC0, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x20,
  0x00, 0x04, 0x02, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x08, 0x01, 0x00, 0x01,
  0x00, 0x10, 0x00, 0x30, 0x01, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x80, 0x04, 0x00, 0x08, 0x00, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x04, 0x01,
  0x00, 0x00, 0x40, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x40, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x20, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x13,
  0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x16, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x02, 0x04, 0x08, 0x10, 0x60, 0x81, 0x02, 0x04,
  0x08, 0x30, 0x60, 0x81, 0x02, 0x04, 0x08, 0x30, 0x40, 0x81, 0x02, 0x04,
  0x18, 0x30, 0x40, 0x81, 0x02, 0x0C, 0x18, 0x20, 0x40, 0x81, 0x02, 0x0C,
  0x10, 0x20, 0x00, 0x01, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x4C, 0x0C, 0x00, 0x64, 0x03,
  0x00, 0x24, 0x00, 0xC0, 0x32, 0x00, 0x30, 0x33, 0x00, 0x0F, 0x70, 0x00,
  0x01, 0xE0,
};

const GFXglyph RobotoMono_ThinItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 7, 33, 28, 10, -33 },
  { 30, 8, 9, 28, 12, -35 },
  { 39, 27, 33, 28, 1, -33 },
  { 151, 23, 43, 28, 3, -38 },
  { 275, 23, 34, 28, 3, -34 },
  { 373, 23, 34, 28, 2, -34 },
  { 471, 3, 9, 28, 14, -35 },
  { 475, 14, 48, 28, 8, -37 },
  { 559, 14, 48, 28, 4, -37 },
  { 643, 19, 18, 28, 7, -33 },
  { 686, 22, 25, 28, 3, -28 },
  { 755, 5, 10, 28, 6, -4 },
  { 762, 16, 1, 28, 6, -16 },
  { 764, 3, 3, 28, 11, -3 },
  { 766, 21, 36, 28, 4, -33 },
  { 861, 22, 34, 28, 3, -34 },
  { 955, 12, 33, 28, 7, -33 },
  { 1005, 22, 34, 28, 1, -34 },
  { 1099, 23, 34, 28, 1, -34 },
  { 1197, 23, 33, 28, 1, -33 },
  { 1292, 23, 33, 28, 4, -33 },
  { 1387, 20, 34, 28, 3, -34 },
  { 1472, 21, 33, 28, 6, -33 },
  { 1559, 23, 34, 28, 3, -34 },
  { 1657, 20, 34, 28, 5, -34 },
  { 1742, 6, 23, 28, 12, -23 },
  { 1760, 9, 29, 28, 9, -23 },
  { 1793, 21, 19, 28, 4, -25 },
  { 1843, 22, 11, 28, 3, -21 },
  { 1874, 21, 19, 28, 3, -25 },
  { 1924, 17, 34, 28, 8, -34 },
  { 1997, 27, 34, 28, 1, -34 },
  { 2112, 23, 33, 28, 0, -33 },
  { 2207, 23, 33, 28, 2, -33 },
  { 2302, 23, 34, 28, 3, -34 },
  { 2400, 24, 33, 28, 2, -33 },
  { 2499, 25, 33, 28, 2, -33 },
  { 2603, 24, 33, 28, 3, -33 },
  { 2702, 23, 35, 28, 3, -34 },
  { 2803, 25, 33, 28, 2, -33 },
  { 2907, 24, 33, 28, 2, -33 },
  { 3006, 24, 33, 28, 2, -33 },
  { 3105, 26, 33, 28, 3, -33 },
  { 3213, 19, 33, 28, 3, -33 },
  { 3292, 25, 33, 28, 2, -33 },
  { 3396, 25, 33, 28, 2, -33 },
  { 3500, 22, 34, 28, 3, -34 },
  { 3594, 24, 33, 28, 3, -33 },
  { 3693, 24, 40, 28, 2, -34 },
  { 3813, 23, 33, 28, 3, -33 },
  { 3908, 23, 34, 28, 3, -34 },
  { 4006, 22, 33, 28, 6, -33 },
  { 4097, 24, 33, 28, 3, -33 },
  { 4196, 23, 33, 28, 5, -33 },
  { 4291, 24, 33, 28, 5, -33 },
  { 4390, 27, 33, 28, 1, -33 },
  { 4502, 23, 33, 28, 5, -33 },
  { 4597, 25, 33, 28, 1, -33 },
  { 4701, 14, 45, 28, 7, -38 },
  { 4780, 8, 36, 28, 10, -33 },
  { 4816, 14, 45, 28, 7, -38 },
  { 4895, 16, 18, 28, 6, -33 },
  { 4931, 19, 1, 28, 2, 0 },
  { 4934, 5, 6, 28, 14, -35 },
  { 4938, 21, 25, 28, 3, -25 },
  { 5004, 21, 35, 28, 3, -35 },
  { 5096, 21, 25, 28, 3, -25 },
  { 5162, 23, 35, 28, 3, -35 },
  { 5263, 21, 25, 28, 3, -25 },
  { 5329, 23, 36, 28, 6, -36 },
  { 5433, 22, 35, 28, 2, -25 },
  { 5530, 22, 35, 28, 2, -35 },
  { 5627, 19, 34, 28, 3, -34 },
  { 5708, 21, 44, 28, 0, -34 },
  { 5824, 22, 35, 28, 3, -35 },
  { 5921, 19, 35, 28, 3, -35 },
  { 6005, 27, 25, 28, 0, -25 },
  { 6090, 22, 25, 28, 2, -25 },
  { 6159, 21, 25, 28, 3, -25 },
  { 6225, 22, 35, 28, 1, -25 },
  { 6322, 21, 35, 28, 3, -25 },
  { 6414, 20, 25, 28, 6, -25 },
  { 6477, 21, 25, 28, 3, -25 },
  { 6543, 17, 32, 28, 6, -32 },
  { 6611, 21, 25, 28, 4, -25 },
  { 6677, 22, 25, 28, 4, -25 },
  { 6746, 24, 25, 28, 4, -25 },
  { 6821, 25, 25, 28, 1, -25 },
  { 6900, 28, 35, 28, -1, -25 },
  { 7023, 24, 25, 28, 1, -25 },
  { 7098, 18, 47, 28, 7, -37 },
  { 7204, 7, 39, 28, 10, -33 },
  { 7239, 18, 47, 28, 4, -37 },
  { 7345, 25, 8, 28, 1, -18 },
};

const GFXfont RobotoMono_ThinItalic47pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic47pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic47pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _ROBOTOMONO_THINITALIC47PT7B_H_
