#ifndef _NOTOSANS_ITALIC42PT7B_H_
#define _NOTOSANS_ITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x18, 0x00, 0x78, 0xF7, 0x8F, 0x70,
  0xF7, 0x0E, 0xF0, 0xEF, 0x0E, 0xE1, 0xCE, 0x1C, 0xE1, 0xCC, 0x1C, 0xC1,
  0x80, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00,
  0x70, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x1C,
  0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x0F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0xE0,
  0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81,
  0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xF1, 0x86,
  0x0F, 0x1C, 0x00, 0x78, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xF1,
  0x80, 0x07, 0x9C, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xEF, 0x80, 0x07, 0x3C, 0x00, 0x30,
  0xE0, 0x01, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE3, 0xC4, 0x07, 0x3E, 0x3E,
  0x37, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0xE0, 0x7F, 0x80, 0x0E, 0x07, 0x9E, 0x00, 0xE0, 0x78, 0x70, 0x0F, 0x03,
  0x83, 0x80, 0x70, 0x3C, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x70, 0x0E, 0x07,
  0x07, 0x80, 0x70, 0x38, 0x38, 0x03, 0x81, 0xC3, 0x80, 0x38, 0x1E, 0x3C,
  0x01, 0xC0, 0xE3, 0xC0, 0x0E, 0x07, 0x1C, 0xFE, 0x70, 0x79, 0xCF, 0xF9,
  0xC3, 0x9E, 0xFB, 0xCF, 0x79, 0xE7, 0x0F, 0x7F, 0xCE, 0x78, 0x39, 0xF8,
  0xE3, 0x81, 0xC0, 0x0F, 0x1C, 0x0E, 0x00, 0x71, 0xC0, 0xF0, 0x07, 0x0E,
  0x07, 0x00, 0x70, 0x70, 0x38, 0x07, 0x83, 0x81, 0xC0, 0x38, 0x1C, 0x0E,
  0x03, 0x80, 0xE0, 0xE0, 0x38, 0x07, 0x07, 0x03, 0xC0, 0x38, 0x70, 0x1C,
  0x01, 0xE7, 0x81, 0xC0, 0x07, 0xF8, 0x1C, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0x81, 0xE0, 0x01,
  0xC0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x01, 0xE0,
  0x03, 0xC0, 0xF0, 0x00, 0x70, 0x7C, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0xBE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0x3E, 0x03, 0xCF, 0x87, 0x80, 0xE3, 0xC0, 0xF0, 0x79,
  0xE0, 0x1E, 0x3C, 0x70, 0x07, 0x8F, 0x3C, 0x00, 0xF7, 0x8F, 0x00, 0x1F,
  0xC3, 0xC0, 0x07, 0xE0, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0xFE, 0x07, 0xC0,
  0x7F, 0xC0, 0xFF, 0xFE, 0xF8, 0x3F, 0xFE, 0x1E, 0x03, 0xFE, 0x03, 0xC0,
  0x7B, 0xDC, 0xEF, 0x7B, 0x9C, 0xE6, 0x30, 0x00, 0x38, 0x03, 0x80, 0x38,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xC0,
  0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x40, 0x70, 0x07, 0x07, 0x00,
  0x7C, 0x70, 0x0F, 0xF6, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xF0, 0x3F, 0x01, 0x07, 0x30, 0x00, 0xF3, 0x80, 0x1E, 0x38, 0x03, 0xC1,
  0xC0, 0x18, 0x1C, 0x00, 0x81, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x0F,
  0x87, 0x87, 0xC3, 0xC1, 0xE1, 0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x00, 0x7F,
  0xEF, 0xFB, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x30, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7C,
  0x1E, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x07, 0x3C,
  0x00, 0x73, 0xC0, 0x07, 0x3C, 0x00, 0x73, 0x80, 0x07, 0x78, 0x00, 0xF7,
  0x80, 0x0F, 0x78, 0x00, 0xF7, 0x00, 0x0F, 0x70, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x03,
  0xC7, 0x00, 0x7C, 0x78, 0x07, 0x87, 0x80, 0xF0, 0x3C, 0x1F, 0x03, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x78, 0x0F, 0x81, 0xFC, 0x1F,
  0xE3, 0xFF, 0x3F, 0x73, 0xE3, 0x8E, 0x3C, 0x41, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0xF0, 0x1F, 0x01, 0x80, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x01,
  0xFF, 0xFC, 0x0F, 0x01, 0xF0, 0x20, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC4,
  0x00, 0x3E, 0x38, 0x03, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xF7, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0x3C,
  0x00, 0x1C, 0x70, 0x00, 0x78, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0x87, 0x80,
  0x1E, 0x0E, 0x00, 0x78, 0x1C, 0x01, 0xE0, 0x78, 0x03, 0x80, 0xF0, 0x0F,
  0x01, 0xE0, 0x3C, 0x03, 0x80, 0xF0, 0x07, 0x03, 0xC0, 0x1E, 0x17, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x84, 0x00, 0x7C,
  0x30, 0x07, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x87, 0x80, 0x79, 0xFE, 0x07, 0x7F, 0xF0, 0xFF, 0x0F,
  0x8F, 0xC0, 0x7C, 0xF8, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCE, 0x00,
  0x3C, 0xE0, 0x03, 0xCE, 0x00, 0x3C, 0xE0, 0x03, 0x8F, 0x00, 0x78, 0xF0,
  0x07, 0x8F, 0x00, 0xF0, 0x78, 0x1F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x80, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0x81, 0xE0, 0x78, 0x07, 0x87, 0x80,
  0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x70, 0x78, 0x07, 0x81,
  0xE0, 0x78, 0x0F, 0x87, 0xC0, 0x3E, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x01, 0xFF, 0xC0, 0x1F, 0x0F, 0x01, 0xF0, 0x3C, 0x1E, 0x00, 0xF0, 0xF0,
  0x07, 0x8F, 0x00, 0x1C, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x38,
  0xF0, 0x03, 0xC7, 0xC0, 0x3E, 0x1F, 0x03, 0xE0, 0xFF, 0xFE, 0x03, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0,
  0xF8, 0x3E, 0x1F, 0x01, 0xE1, 0xE0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F,
  0x3C, 0x00, 0xF3, 0x80, 0x0F, 0x38, 0x00, 0xF3, 0x80, 0x0F, 0x38, 0x01,
  0xF3, 0xC0, 0x1F, 0x3C, 0x03, 0xE1, 0xF0, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF,
  0x9E, 0x03, 0xE1, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x80, 0x7C, 0x0F,
  0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0x0F, 0x1F, 0x1F, 0x1F,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0xF8, 0xF8, 0xF8, 0xF0, 0x60, 0x01, 0xE0, 0x3C, 0x0F, 0x81,
  0xF0, 0x3E, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0x81, 0xE0,
  0x3C, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x38, 0x1F, 0x20, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x20,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x1E, 0x0E, 0x00,
  0xF8, 0x07, 0x0E, 0x01, 0xFF, 0x83, 0x8F, 0x03, 0xFF, 0xC1, 0xC7, 0x03,
  0xC0, 0xE0, 0xE7, 0x83, 0xC0, 0xF0, 0x7B, 0x81, 0xC0, 0x70, 0x3D, 0xC1,
  0xC0, 0x38, 0x1C, 0xE0, 0xE0, 0x1C, 0x0E, 0xF0, 0xF0, 0x1E, 0x07, 0x70,
  0x70, 0x0E, 0x03, 0xB8, 0x38, 0x07, 0x03, 0xDC, 0x1C, 0x07, 0x81, 0xCE,
  0x0E, 0x03, 0xC1, 0xE7, 0x07, 0x83, 0xE0, 0xE3, 0xC3, 0xC3, 0xF9, 0xF0,
  0xE0, 0xFF, 0x9F, 0xF0, 0x70, 0x3F, 0x8F, 0xE0, 0x3C, 0x02, 0x00, 0x80,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x10, 0x00, 0x3F, 0x80, 0x78, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x78,
  0x38, 0x00, 0x70, 0x3C, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xE0,
  0x3C, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x0F, 0x00, 0x1C, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0xF8, 0x00,
  0x0E, 0xF0, 0x00, 0x0F, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x3C, 0x07, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0xC1, 0xC0, 0x07,
  0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0,
  0x70, 0x03, 0xC1, 0xE0, 0x3F, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x1C, 0x03, 0xE0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0,
  0x03, 0xC3, 0x80, 0x07, 0x87, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00,
  0x78, 0x78, 0x00, 0xF0, 0xE0, 0x03, 0xE3, 0xC0, 0x3F, 0x87, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0x0C, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xF0,
  0x3F, 0x80, 0x78, 0x07, 0xE0, 0x3C, 0x00, 0xF0, 0x1C, 0x00, 0x3C, 0x1E,
  0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1,
  0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1E,
  0x3C, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03,
  0xC7, 0x80, 0x03, 0xC3, 0x80, 0x01, 0xE1, 0xC0, 0x01, 0xF1, 0xE0, 0x01,
  0xF0, 0xF0, 0x01, 0xF0, 0x78, 0x01, 0xF8, 0x38, 0x03, 0xF8, 0x3C, 0x0F,
  0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x81, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F,
  0x01, 0xE0, 0x7E, 0x00, 0x10, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x0F, 0xF9,
  0xE0, 0x0F, 0xFC, 0xF0, 0x07, 0xFE, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07,
  0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0x70, 0x7C, 0x00, 0x78, 0x1F, 0x00, 0x3C, 0x0F, 0xC0,
  0x3E, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x78, 0x00, 0x38, 0x0E, 0x00, 0x0F, 0x03, 0xC0, 0x01,
  0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xE0, 0x38,
  0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E,
  0x07, 0x00, 0x03, 0x81, 0xE0, 0x00, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x0E, 0x07, 0x80, 0x03, 0xC0,
  0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xC0, 0x70, 0x00,
  0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0E,
  0x00, 0x07, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0x80,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x07, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0x1F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x81, 0xC0, 0x0F, 0x80, 0xE0,
  0x0F, 0x80, 0xF0, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x1C,
  0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x0F, 0x07, 0x80, 0x07, 0x87, 0x80, 0x03,
  0xC7, 0x80, 0x01, 0xC7, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xF7, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x1E, 0x00,
  0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0x81, 0xE0, 0x01, 0xC0, 0x78,
  0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03,
  0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x07, 0x80,
  0x0F, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x77, 0x00, 0x07, 0xF8, 0x3B,
  0x80, 0x03, 0xB8, 0x1D, 0xC0, 0x03, 0xFC, 0x1E, 0xE0, 0x01, 0xDE, 0x0F,
  0x70, 0x01, 0xEF, 0x07, 0xB8, 0x00, 0xE7, 0x83, 0x9E, 0x00, 0xE3, 0x81,
  0xCF, 0x00, 0xF3, 0xC1, 0xE3, 0x80, 0x71, 0xE0, 0xF1, 0xC0, 0x78, 0xF0,
  0x78, 0xE0, 0x38, 0x70, 0x38, 0x70, 0x3C, 0x38, 0x1C, 0x38, 0x1C, 0x3C,
  0x1E, 0x1C, 0x1E, 0x1E, 0x0F, 0x0F, 0x0E, 0x0F, 0x07, 0x07, 0x8E, 0x07,
  0x03, 0x81, 0xC7, 0x07, 0x83, 0xC0, 0xE7, 0x03, 0xC1, 0xE0, 0x77, 0x81,
  0xE0, 0xF0, 0x3B, 0x80, 0xF0, 0x70, 0x1F, 0xC0, 0x70, 0x38, 0x0F, 0xC0,
  0x78, 0x3C, 0x07, 0xE0, 0x3C, 0x1E, 0x03, 0xE0, 0x1E, 0x0F, 0x00, 0xF0,
  0x0F, 0x07, 0x00, 0x70, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x3E, 0x00,
  0x0F, 0x07, 0xE0, 0x00, 0xE0, 0x7E, 0x00, 0x0E, 0x07, 0xF0, 0x01, 0xE0,
  0x7F, 0x00, 0x1E, 0x07, 0x70, 0x01, 0xE0, 0xF7, 0x80, 0x1C, 0x0F, 0x38,
  0x01, 0xC0, 0xE3, 0xC0, 0x3C, 0x0E, 0x3C, 0x03, 0xC0, 0xE1, 0xC0, 0x38,
  0x1E, 0x1E, 0x03, 0x81, 0xE1, 0xE0, 0x78, 0x1C, 0x0E, 0x07, 0x81, 0xC0,
  0xF0, 0x78, 0x1C, 0x07, 0x07, 0x03, 0xC0, 0x78, 0x70, 0x3C, 0x07, 0x8F,
  0x03, 0x80, 0x38, 0xF0, 0x38, 0x03, 0xCF, 0x07, 0x80, 0x3C, 0xE0, 0x78,
  0x01, 0xCE, 0x07, 0x80, 0x1F, 0xE0, 0x70, 0x00, 0xFE, 0x07, 0x00, 0x0F,
  0xE0, 0xF0, 0x00, 0xFC, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x7C, 0x0E,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x03, 0xE1, 0xF0,
  0x00, 0x78, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x3C,
  0x00, 0x03, 0xCF, 0x80, 0x01, 0xF1, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x7C,
  0x0F, 0x80, 0x3F, 0x03, 0xF0, 0x3F, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x01, 0xE0, 0x7E, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xF0, 0x70, 0x03,
  0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3,
  0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x07, 0xC1, 0xE0, 0x7F, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x03, 0xE1,
  0xF0, 0x00, 0x78, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x0F,
  0x3C, 0x00, 0x03, 0xCF, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF8, 0x7C, 0x00,
  0x7C, 0x0F, 0x80, 0x3F, 0x03, 0xF0, 0x3F, 0x80, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x01, 0xE0, 0xFE, 0x07, 0x80, 0x78, 0x1E, 0x00, 0xF0, 0x70, 0x03,
  0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3,
  0x80, 0x1E, 0x1E, 0x00, 0xF8, 0x78, 0x07, 0xC1, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xC1, 0xE0, 0x0F, 0x03, 0x80,
  0x38, 0x0F, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0x78,
  0x07, 0x81, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x01,
  0xE3, 0xC0, 0x07, 0x80, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x0F, 0x80, 0xE0, 0xF8, 0x01, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x84, 0x00, 0x7C,
  0x38, 0x0F, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0xF0, 0xF0, 0x00, 0x38, 0x3C, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x87, 0x80,
  0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1C, 0x1E, 0x00, 0x0F, 0x07,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x3C, 0x00, 0x1E,
  0x0F, 0x00, 0x07, 0x83, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00,
  0x1C, 0x1E, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0xF0,
  0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0,
  0x78, 0x00, 0xF0, 0x1E, 0x00, 0x7C, 0x07, 0xE0, 0x7E, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00,
  0x1E, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0xF0, 0x70, 0x01, 0xE0, 0xF0, 0x07,
  0x81, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0,
  0x1E, 0x07, 0x80, 0x1C, 0x0F, 0x00, 0x38, 0x3C, 0x00, 0x70, 0x78, 0x00,
  0xE1, 0xE0, 0x01, 0xC3, 0xC0, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F,
  0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xF7, 0x00, 0x1F, 0x00, 0x1E, 0x70, 0x01, 0xF0, 0x01,
  0xC7, 0x00, 0x3F, 0x00, 0x3C, 0x70, 0x03, 0xF0, 0x03, 0xC7, 0x00, 0x3F,
  0x00, 0x78, 0x70, 0x07, 0x70, 0x07, 0x87, 0x00, 0x77, 0x00, 0xF0, 0x70,
  0x0F, 0x70, 0x0F, 0x07, 0x00, 0xE7, 0x01, 0xE0, 0x78, 0x1E, 0x70, 0x1E,
  0x07, 0x81, 0xC7, 0x01, 0xC0, 0x78, 0x3C, 0x78, 0x3C, 0x07, 0x83, 0x87,
  0x83, 0xC0, 0x78, 0x78, 0x78, 0x78, 0x07, 0x87, 0x07, 0x87, 0x80, 0x78,
  0xF0, 0x38, 0xF0, 0x07, 0x8E, 0x03, 0x8F, 0x00, 0x79, 0xE0, 0x38, 0xE0,
  0x07, 0x9C, 0x03, 0x9E, 0x00, 0x79, 0xC0, 0x39, 0xC0, 0x07, 0xBC, 0x03,
  0xBC, 0x00, 0x7B, 0x80, 0x3B, 0x80, 0x07, 0xF8, 0x03, 0xB8, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x01, 0xF0, 0x1E, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0x78, 0x3C, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x1D, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x3C, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78,
  0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x03, 0xC0, 0x07, 0x80, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0x9C, 0x00, 0x7C, 0xE0, 0x03, 0xC7, 0x80, 0x3C,
  0x3C, 0x03, 0xE0, 0xE0, 0x1E, 0x07, 0x01, 0xE0, 0x3C, 0x1E, 0x01, 0xE0,
  0xF0, 0x07, 0x0F, 0x00, 0x38, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x78, 0x00,
  0x3B, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xE1, 0xC3, 0x87, 0x0F, 0x1E, 0x3C, 0x38, 0x70, 0xE1, 0xC3,
  0xC7, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xF1, 0xE1, 0xC3, 0x87, 0x0E, 0x1E,
  0x3C, 0x78, 0x70, 0xE1, 0xC0, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xB8, 0x00, 0x3B, 0xC0, 0x07, 0x1C,
  0x00, 0x71, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xF0, 0x1E, 0x07, 0x01, 0xC0,
  0x78, 0x1C, 0x03, 0x83, 0x80, 0x1C, 0x38, 0x01, 0xC7, 0x00, 0x0E, 0x70,
  0x00, 0xEE, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF0, 0xF1, 0xE1, 0xE1, 0xC1, 0xC1, 0x80, 0x00, 0xF8, 0x38,
  0x1F, 0xF1, 0xC1, 0xFF, 0xDE, 0x1F, 0x8E, 0xE1, 0xF0, 0x3F, 0x0F, 0x00,
  0xF8, 0xF0, 0x07, 0xC7, 0x80, 0x3E, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E,
  0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x01, 0xE3, 0xC0, 0x0F,
  0x1E, 0x00, 0xF8, 0xF0, 0x07, 0xC7, 0x80, 0x7C, 0x3C, 0x07, 0xE0, 0xF0,
  0x77, 0x07, 0xFF, 0x38, 0x1F, 0xF1, 0xC0, 0x7F, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x3C,
  0x01, 0xC7, 0xF8, 0x0E, 0x7F, 0xE0, 0xF7, 0x9F, 0x07, 0xF0, 0x3C, 0x3F,
  0x01, 0xE1, 0xF0, 0x0F, 0x1F, 0x00, 0x78, 0xF8, 0x03, 0xC7, 0x80, 0x1E,
  0x3C, 0x00, 0xF1, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80,
  0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x9F, 0x00, 0x78, 0xF8, 0x07, 0x87,
  0xE0, 0x7C, 0x3B, 0xFF, 0xC3, 0xCF, 0xFC, 0x1C, 0x3F, 0x80, 0x00, 0x7E,
  0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xF8, 0x71, 0xF0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x01, 0xF0, 0xF0, 0x0F, 0xF9, 0xE0, 0x3F, 0xFB, 0xC0, 0xFC, 0x77,
  0x03, 0xE0, 0x3E, 0x07, 0x80, 0x7C, 0x1E, 0x00, 0xF8, 0x3C, 0x00, 0xF0,
  0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x0F, 0x00, 0x1E, 0x1E,
  0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x07, 0xC1, 0xE0,
  0x0F, 0x83, 0xC0, 0x3E, 0x07, 0x80, 0xFC, 0x07, 0x83, 0xB8, 0x0F, 0xFE,
  0x70, 0x0F, 0xF9, 0xE0, 0x0F, 0xE3, 0x80, 0x00, 0xFC, 0x00, 0xFF, 0xC0,
  0x7F, 0xF8, 0x3E, 0x1E, 0x1F, 0x03, 0xC7, 0x80, 0xF3, 0xC0, 0x3C, 0xE0,
  0x0E, 0x78, 0x07, 0x9E, 0x07, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xE0,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x18, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x1C, 0x07, 0xFC, 0x70, 0x3F,
  0xF9, 0xC1, 0xF8, 0xFF, 0x0F, 0x80, 0xF8, 0x3C, 0x03, 0xE1, 0xE0, 0x0F,
  0x87, 0x80, 0x3E, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x1E,
  0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00,
  0xF8, 0x78, 0x03, 0xE1, 0xE0, 0x1F, 0x07, 0x80, 0xFC, 0x0F, 0x07, 0x70,
  0x3F, 0xFB, 0xC0, 0x7F, 0xCF, 0x00, 0xFE, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x80, 0x1F,
  0x03, 0x80, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x3E, 0x01, 0xC7, 0xF8, 0x0E, 0x7F, 0xE0, 0xF7, 0x8F, 0x87, 0xF0,
  0x3C, 0x3F, 0x01, 0xE1, 0xF0, 0x0F, 0x1F, 0x00, 0x78, 0xF8, 0x03, 0xC7,
  0x80, 0x1C, 0x3C, 0x01, 0xE1, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03,
  0xC7, 0x80, 0x1C, 0x38, 0x01, 0xE1, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0,
  0x03, 0xC7, 0x80, 0x1C, 0x38, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0x80, 0x00, 0x00, 0x00, 0x07, 0x81,
  0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x70,
  0x3C, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x03, 0xC1, 0xC0, 0x3C, 0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x07,
  0x83, 0xC0, 0x3C, 0x3C, 0x01, 0xC3, 0xC0, 0x1E, 0x3C, 0x00, 0xF3, 0xC0,
  0x07, 0x3C, 0x00, 0x3B, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xF9,
  0xE0, 0x07, 0x8F, 0x00, 0x38, 0x3C, 0x01, 0xC1, 0xE0, 0x1E, 0x07, 0x80,
  0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x38, 0x07, 0x83, 0xC0, 0x1E, 0x1E, 0x00,
  0xF0, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0x07, 0x07, 0x80,
  0x7C, 0x03, 0x8F, 0xF0, 0x7F, 0x81, 0xCF, 0xF8, 0xFF, 0xE1, 0xEE, 0x3E,
  0xF1, 0xF0, 0xFC, 0x0F, 0x70, 0x78, 0x7C, 0x03, 0xE0, 0x1C, 0x3E, 0x01,
  0xF0, 0x0E, 0x3E, 0x01, 0xF0, 0x07, 0x1E, 0x00, 0xF8, 0x07, 0x8F, 0x00,
  0x78, 0x03, 0xC7, 0x80, 0x3C, 0x01, 0xE3, 0x80, 0x1C, 0x00, 0xE3, 0xC0,
  0x1E, 0x00, 0x71, 0xE0, 0x0F, 0x00, 0x78, 0xF0, 0x07, 0x80, 0x3C, 0x70,
  0x03, 0xC0, 0x1E, 0x38, 0x01, 0xC0, 0x0E, 0x3C, 0x01, 0xE0, 0x0F, 0x1E,
  0x00, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0x03, 0xC7, 0x00, 0x38, 0x01, 0xE7,
  0x80, 0x1C, 0x00, 0xE3, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x0F, 0xC0, 0x38,
  0xFF, 0x83, 0xDF, 0xFC, 0x1E, 0xF1, 0xF0, 0xFE, 0x07, 0x87, 0xE0, 0x3C,
  0x3E, 0x01, 0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80,
  0x3C, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7,
  0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x07,
  0x87, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0x80, 0xFC, 0x7C, 0x1F, 0x03, 0xE3, 0xE0, 0x1E,
  0x3C, 0x00, 0xE7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00,
  0x1C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0x78, 0x07, 0x87, 0xC1, 0xF0, 0x3F,
  0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x01, 0xC1, 0xE0, 0x03, 0x8F,
  0xF0, 0x07, 0x3F, 0xF0, 0x1E, 0xF3, 0xE0, 0x3F, 0x81, 0xE0, 0x7E, 0x03,
  0xC0, 0xF8, 0x07, 0x83, 0xE0, 0x0F, 0x07, 0xC0, 0x1E, 0x0F, 0x00, 0x3C,
  0x1E, 0x00, 0x78, 0x38, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3,
  0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x7C, 0x3E, 0x00, 0xF0, 0x7C,
  0x03, 0xC0, 0xFC, 0x0F, 0x81, 0xDF, 0xFE, 0x03, 0x9F, 0xF8, 0x0F, 0x1F,
  0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x38, 0x1F, 0xF1, 0xC1,
  0xFF, 0xCE, 0x1F, 0x8F, 0xE1, 0xF0, 0x3F, 0x0F, 0x00, 0xF8, 0xF0, 0x07,
  0xC7, 0x80, 0x3E, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x79, 0xE0,
  0x03, 0xCF, 0x00, 0x1E, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0xF8,
  0xF0, 0x07, 0xC7, 0x80, 0x7C, 0x3C, 0x07, 0xE0, 0xF0, 0x77, 0x07, 0xFF,
  0x78, 0x1F, 0xF3, 0xC0, 0x7F, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x07, 0x0F, 0x83,
  0x8F, 0xC1, 0xCF, 0xE1, 0xEF, 0xA0, 0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x01, 0xFC,
  0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xF0, 0xF1, 0xE0, 0x08, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x98, 0x07, 0xCF, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0x80, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0,
  0x1E, 0x00, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x00, 0x0E, 0x00, 0x78,
  0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xE1, 0xE0, 0x07, 0x0E, 0x00,
  0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xE1, 0xE0, 0x07, 0x0E,
  0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x01, 0xE1, 0xC0, 0x0F,
  0x0E, 0x00, 0x78, 0xF0, 0x07, 0xC7, 0x80, 0x7C, 0x3C, 0x07, 0xE1, 0xF0,
  0x77, 0x07, 0xFF, 0x38, 0x3F, 0xF3, 0xC0, 0xFF, 0x1C, 0x00, 0xF0, 0x00,
  0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x03, 0x87, 0x00,
  0x78, 0x70, 0x0F, 0x07, 0x00, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x3C, 0x07, 0x83, 0xC0, 0x78, 0x78, 0x03, 0x87, 0x80, 0x38, 0xF0, 0x03,
  0x8F, 0x00, 0x39, 0xE0, 0x03, 0x9C, 0x00, 0x3B, 0xC0, 0x03, 0xB8, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x3F,
  0xC0, 0x1E, 0x00, 0xFF, 0x00, 0xF8, 0x07, 0x9C, 0x03, 0xE0, 0x1E, 0x70,
  0x1F, 0x80, 0xF1, 0xC0, 0x7E, 0x03, 0xC7, 0x03, 0xB8, 0x1E, 0x1C, 0x0E,
  0xE0, 0x78, 0x70, 0x73, 0x83, 0xC1, 0xC1, 0xCF, 0x0F, 0x07, 0x0F, 0x3C,
  0x38, 0x1C, 0x38, 0xF1, 0xE0, 0x71, 0xE1, 0xC7, 0x01, 0xC7, 0x07, 0x3C,
  0x07, 0x3C, 0x1C, 0xF0, 0x1C, 0xE0, 0x77, 0x80, 0x73, 0x81, 0xDE, 0x01,
  0xDC, 0x07, 0x70, 0x07, 0x70, 0x1F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x7E,
  0x01, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x1E, 0x07, 0x00, 0x7C, 0x0F, 0x00, 0xF0, 0x0E, 0x03, 0xC0, 0x1E,
  0x0F, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0x77,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xF7, 0x80, 0x03, 0xC7, 0x00,
  0x0F, 0x0F, 0x00, 0x3C, 0x0E, 0x00, 0xF8, 0x1E, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0x3C, 0x3E, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x01,
  0xE0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x07, 0x80, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x78, 0x00,
  0x78, 0x1E, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xE1, 0xE0,
  0x00, 0x38, 0x78, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F,
  0xFF, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF,
  0x80, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x07, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x7F,
  0x80, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x17, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xE8, 0x00, 0xF8,
};

const GFXglyph NotoSans_Italic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 11, 31, 11, 1, -30 },
  { 44, 12, 11, 16, 5, -30 },
  { 61, 26, 30, 27, 1, -30 },
  { 159, 21, 34, 23, 1, -32 },
  { 249, 29, 30, 34, 3, -30 },
  { 358, 26, 30, 28, 1, -30 },
  { 456, 5, 11, 9, 5, -30 },
  { 463, 13, 37, 12, 2, -30 },
  { 524, 13, 37, 12, -3, -30 },
  { 585, 20, 19, 23, 4, -32 },
  { 633, 20, 20, 24, 3, -25 },
  { 683, 9, 10, 11, -2, -5 },
  { 695, 11, 3, 13, 1, -13 },
  { 700, 5, 6, 11, 1, -5 },
  { 704, 21, 30, 15, -2, -30 },
  { 783, 20, 30, 23, 2, -30 },
  { 858, 13, 30, 23, 6, -30 },
  { 907, 22, 30, 23, 0, -30 },
  { 990, 21, 30, 23, 1, -30 },
  { 1069, 23, 30, 23, 0, -30 },
  { 1156, 21, 30, 23, 2, -30 },
  { 1235, 20, 30, 23, 3, -30 },
  { 1310, 21, 30, 23, 3, -30 },
  { 1389, 21, 30, 23, 2, -30 },
  { 1468, 20, 30, 23, 2, -30 },
  { 1543, 8, 24, 11, 1, -23 },
  { 1567, 11, 28, 11, -2, -23 },
  { 1606, 20, 21, 24, 3, -26 },
  { 1659, 19, 11, 24, 3, -20 },
  { 1686, 20, 21, 24, 3, -26 },
  { 1739, 16, 31, 18, 3, -30 },
  { 1801, 33, 34, 36, 2, -30 },
  { 1942, 24, 30, 24, -2, -30 },
  { 2032, 23, 30, 25, 2, -30 },
  { 2119, 24, 30, 25, 3, -30 },
  { 2209, 25, 30, 28, 2, -30 },
  { 2303, 21, 30, 22, 2, -30 },
  { 2382, 21, 30, 20, 2, -30 },
  { 2461, 25, 30, 28, 3, -30 },
  { 2555, 27, 30, 29, 2, -30 },
  { 2657, 17, 30, 14, -1, -30 },
  { 2721, 19, 38, 11, -7, -30 },
  { 2812, 25, 30, 24, 2, -30 },
  { 2906, 16, 30, 20, 2, -30 },
  { 2966, 33, 30, 35, 2, -30 },
  { 3090, 28, 30, 30, 2, -30 },
  { 3195, 26, 30, 30, 3, -30 },
  { 3293, 22, 30, 24, 2, -30 },
  { 3376, 26, 37, 30, 3, -30 },
  { 3497, 22, 30, 24, 2, -30 },
  { 3580, 21, 30, 21, 1, -30 },
  { 3659, 21, 30, 21, 4, -30 },
  { 3738, 26, 30, 28, 3, -30 },
  { 3836, 23, 30, 23, 4, -30 },
  { 3923, 36, 30, 36, 4, -30 },
  { 4058, 28, 30, 22, -2, -30 },
  { 4163, 21, 30, 21, 4, -30 },
  { 4242, 24, 30, 22, 0, -30 },
  { 4332, 16, 37, 12, 0, -30 },
  { 4406, 7, 30, 15, 5, -30 },
  { 4433, 16, 37, 12, -3, -30 },
  { 4507, 20, 19, 24, 2, -30 },
  { 4555, 17, 3, 17, -4, 4 },
  { 4562, 7, 7, 12, 6, -32 },
  { 4569, 21, 23, 24, 2, -23 },
  { 4630, 21, 32, 24, 1, -32 },
  { 4714, 17, 23, 19, 2, -23 },
  { 4763, 23, 32, 24, 2, -32 },
  { 4855, 18, 23, 21, 2, -23 },
  { 4907, 24, 42, 13, -5, -32 },
  { 5033, 22, 33, 24, 1, -23 },
  { 5124, 21, 32, 24, 1, -32 },
  { 5208, 10, 31, 11, 1, -31 },
  { 5247, 16, 41, 11, -5, -31 },
  { 5329, 21, 32, 21, 1, -32 },
  { 5413, 11, 32, 11, 1, -32 },
  { 5457, 33, 23, 37, 1, -23 },
  { 5552, 21, 23, 24, 1, -23 },
  { 5613, 20, 23, 24, 2, -23 },
  { 5671, 23, 33, 24, -1, -23 },
  { 5766, 21, 33, 24, 2, -23 },
  { 5853, 17, 23, 17, 1, -23 },
  { 5902, 17, 23, 18, 0, -23 },
  { 5951, 13, 28, 14, 2, -28 },
  { 5997, 21, 23, 24, 2, -23 },
  { 6058, 20, 23, 20, 2, -23 },
  { 6116, 30, 23, 30, 2, -23 },
  { 6203, 23, 23, 20, -2, -23 },
  { 6270, 26, 33, 20, -4, -23 },
  { 6378, 19, 23, 19, -1, -23 },
  { 6433, 17, 37, 15, 0, -30 },
  { 6512, 3, 42, 23, 11, -32 },
  { 6528, 16, 37, 15, -2, -30 },
  { 6602, 20, 6, 24, 3, -18 },
};

const GFXfont NotoSans_Italic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic42pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_ITALIC42PT7B_H_
