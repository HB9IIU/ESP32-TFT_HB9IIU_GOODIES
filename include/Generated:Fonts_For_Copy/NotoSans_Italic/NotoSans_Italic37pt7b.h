#ifndef _NOTOSANS_ITALIC37PT7B_H_
#define _NOTOSANS_ITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x0F,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x10, 0x00, 0x78, 0xEE, 0x3D, 0xC7,
  0x38, 0xE6, 0x1C, 0xC3, 0xB8, 0x67, 0x0C, 0xC3, 0x80, 0x00, 0x38, 0x38,
  0x00, 0x60, 0x60, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x06, 0x06, 0x00,
  0x1C, 0x1C, 0x00, 0x38, 0x38, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFC, 0x07, 0x07, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x38, 0x00, 0x70,
  0x70, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF0, 0x18, 0x18, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0x81, 0x80,
  0x03, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x30, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x01, 0xFC, 0x03, 0xFF, 0xC1,
  0xFF, 0xF0, 0xF3, 0x8C, 0x38, 0xC0, 0x1E, 0x30, 0x07, 0x0C, 0x01, 0xE7,
  0x00, 0x39, 0xC0, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0xDE, 0x00, 0x33, 0xC0, 0x0C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00,
  0x63, 0xCC, 0x19, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x01, 0x0F,
  0xE0, 0x07, 0x0F, 0xF8, 0x07, 0x07, 0x1C, 0x03, 0x87, 0x06, 0x03, 0x83,
  0x83, 0x03, 0x81, 0x81, 0x83, 0x81, 0xC1, 0xC1, 0xC0, 0xE0, 0xE1, 0xC0,
  0x70, 0x71, 0xC0, 0x38, 0x39, 0xC0, 0x1C, 0x38, 0xE7, 0xCE, 0x1C, 0xE7,
  0xF7, 0x1C, 0xE7, 0x3D, 0xFE, 0xE7, 0x0E, 0xFE, 0x73, 0x87, 0x1C, 0x73,
  0x83, 0x80, 0x71, 0xC1, 0xC0, 0x70, 0xE0, 0xE0, 0x38, 0x60, 0x60, 0x38,
  0x30, 0x30, 0x38, 0x18, 0x38, 0x18, 0x0C, 0x1C, 0x1C, 0x06, 0x1C, 0x1C,
  0x03, 0x9E, 0x1C, 0x01, 0xFE, 0x1C, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1E, 0x1E, 0x00, 0x38, 0x1C, 0x00,
  0xF0, 0x38, 0x01, 0xE0, 0x70, 0x03, 0xC0, 0xE0, 0x03, 0x83, 0xC0, 0x07,
  0x0F, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xDC, 0x03, 0x9F, 0x3C, 0x0E, 0x38, 0x3C, 0x1C, 0xE0, 0x38,
  0x73, 0xC0, 0x79, 0xE7, 0x00, 0x7F, 0x8E, 0x00, 0x7E, 0x1C, 0x00, 0x78,
  0x3C, 0x01, 0xF0, 0x3C, 0x07, 0xF0, 0x7C, 0x7E, 0xF0, 0x7F, 0xF9, 0xE0,
  0x7F, 0xC1, 0xE0, 0x7B, 0x9C, 0xE6, 0x33, 0x9C, 0xC0, 0x00, 0x78, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x38, 0x07, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x06, 0x0C, 0x07,
  0xC6, 0x03, 0xFB, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0x83, 0xE3, 0xC3, 0xB0,
  0x03, 0x9C, 0x03, 0xC6, 0x03, 0xC3, 0x80, 0xC1, 0xC0, 0x20, 0xF0, 0x00,
  0x20, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x0F, 0x1E, 0x1E, 0x1C, 0x38, 0x38, 0x70,
  0x70, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x40, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7F,
  0x80, 0x7F, 0xF0, 0x3E, 0x1E, 0x0F, 0x03, 0x87, 0x80, 0xE1, 0xC0, 0x3C,
  0xF0, 0x0F, 0x38, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3D, 0xC0, 0x0F, 0x70,
  0x03, 0xDC, 0x00, 0xEF, 0x00, 0x3B, 0xC0, 0x0E, 0xE0, 0x07, 0xB8, 0x01,
  0xEE, 0x00, 0x73, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0x87, 0x01, 0xE1,
  0xE0, 0xF0, 0x7E, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xE0, 0x7C,
  0x3F, 0x9F, 0xFF, 0xDC, 0xF3, 0x98, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7C, 0x3E, 0x03, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0xFF, 0xF8,
  0x3C, 0x1F, 0x04, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0x7F, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF2, 0x00, 0x78, 0xF8,
  0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xC0, 0x01, 0xDC, 0x00, 0x39, 0xC0,
  0x07, 0x1C, 0x00, 0xE3, 0xC0, 0x1E, 0x38, 0x03, 0xC3, 0x80, 0x38, 0x38,
  0x07, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0x70, 0x78, 0x07,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x03,
  0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0x00, 0xF7, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x30, 0x07, 0x87, 0xC7, 0xF0, 0xFF, 0xF8, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xF0, 0x1F, 0xFC, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0x82, 0x01, 0xE7, 0xF0, 0x77, 0xFE, 0x1F, 0x87, 0xC7, 0xC0, 0x71, 0xE0,
  0x1C, 0xF0, 0x07, 0x3C, 0x01, 0xEF, 0x00, 0x73, 0xC0, 0x1C, 0xF0, 0x07,
  0x3C, 0x03, 0xC7, 0x00, 0xE1, 0xE0, 0x78, 0x3E, 0x7C, 0x0F, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3E, 0x1F, 0x0F, 0x03,
  0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x03, 0xC3, 0x80, 0xE0,
  0xF0, 0xF0, 0x1E, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xF0,
  0x78, 0x78, 0x0E, 0x3C, 0x03, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07,
  0x38, 0x03, 0xCE, 0x00, 0xF3, 0xC0, 0x78, 0x7C, 0x7E, 0x0F, 0xFE, 0x01,
  0xFF, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xE1, 0xE1, 0xC0,
  0x79, 0xE0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x78, 0x03, 0xB8, 0x01, 0xDC,
  0x00, 0xEF, 0x00, 0xF7, 0x80, 0x79, 0xE0, 0x7C, 0xFD, 0xFE, 0x3F, 0xEE,
  0x0F, 0xE7, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xE0, 0x01, 0xF0, 0xF7, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x00,
  0x1E, 0x3C, 0x78, 0xF0, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF1, 0xE3, 0xC7, 0x84, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x01,
  0x80, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01, 0xE0, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x60, 0x00, 0x20, 0x00, 0x00, 0x07,
  0x80, 0xFF, 0xC7, 0xFF, 0x9C, 0x1E, 0x40, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x7C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x10, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x3C,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x71, 0xC0, 0x7F, 0x07, 0x38, 0x1F, 0xF8, 0x73, 0x03, 0xC3, 0x83, 0x70,
  0x70, 0x38, 0x37, 0x0E, 0x07, 0x03, 0xE0, 0xE0, 0x70, 0x3E, 0x1C, 0x07,
  0x07, 0xE1, 0xC0, 0x70, 0x7E, 0x1C, 0x0E, 0x07, 0xE1, 0xC0, 0xE0, 0x6E,
  0x1C, 0x1E, 0x0E, 0xE1, 0xC1, 0xE1, 0xCE, 0x1E, 0x77, 0x3C, 0xE0, 0xFE,
  0x7F, 0x87, 0x07, 0xC3, 0xE0, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x80, 0x0F, 0x80, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0E, 0xE0, 0x00, 0xF3,
  0x80, 0x07, 0x1C, 0x00, 0x78, 0xE0, 0x03, 0x87, 0x00, 0x3C, 0x38, 0x01,
  0xC1, 0xC0, 0x1E, 0x0E, 0x00, 0xE0, 0x70, 0x0F, 0x03, 0xC0, 0x7F, 0xFE,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0x80, 0x1C, 0x3C, 0x00, 0xE1, 0xC0,
  0x07, 0x1E, 0x00, 0x38, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x70, 0x00, 0x3F,
  0x80, 0x01, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0x0F, 0xE0, 0xF0,
  0x1E, 0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x0E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E,
  0x00, 0xE1, 0xC0, 0x1E, 0x1C, 0x07, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x03,
  0xFF, 0xF0, 0x38, 0x07, 0x83, 0x80, 0x3C, 0x38, 0x03, 0xC7, 0x80, 0x1C,
  0x70, 0x01, 0xC7, 0x00, 0x3C, 0x70, 0x03, 0xCF, 0x00, 0x78, 0xF0, 0x0F,
  0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x0F,
  0xFF, 0x03, 0xFF, 0xF0, 0x7E, 0x07, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x10, 0x3F, 0xFF, 0x01, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xF1, 0xFE,
  0x03, 0xC0, 0x7C, 0x0E, 0x00, 0xF0, 0x38, 0x01, 0xE0, 0xE0, 0x03, 0x87,
  0x80, 0x0E, 0x1E, 0x00, 0x38, 0x70, 0x00, 0xF1, 0xC0, 0x03, 0xC7, 0x00,
  0x0E, 0x3C, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x07, 0x8E, 0x00, 0x1E,
  0x38, 0x00, 0x79, 0xE0, 0x03, 0xC7, 0x00, 0x0F, 0x1C, 0x00, 0x78, 0x70,
  0x03, 0xC3, 0xC0, 0x1F, 0x0F, 0x03, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF,
  0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFF, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xF8, 0x1E, 0x0F, 0x80, 0x08, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x3F, 0xCE, 0x01,
  0xFF, 0x38, 0x07, 0xFC, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E,
  0x38, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x07, 0x80, 0x1C, 0x1F,
  0x00, 0x70, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xE0,
  0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x0F, 0x00, 0x1E, 0x1E, 0x00,
  0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0xF0,
  0xF0, 0x01, 0xE1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x1E,
  0x00, 0x3C, 0x3C, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0,
  0x07, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x7F,
  0xC1, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x07, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0x00, 0x7C,
  0x1C, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x0E, 0x07, 0x80, 0x38,
  0x3C, 0x00, 0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x1C, 0x78, 0x00, 0x73, 0xC0,
  0x01, 0xDE, 0x00, 0x07, 0x78, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03,
  0xC7, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x78, 0x01, 0xE0, 0xE0, 0x07, 0x03,
  0xC0, 0x1C, 0x07, 0x00, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0,
  0x38, 0x03, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x1E, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x3F, 0xFF, 0xFF, 0xFB, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x0F,
  0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x07, 0xE0,
  0x03, 0xF8, 0x1D, 0x80, 0x0E, 0xE0, 0x77, 0x00, 0x73, 0x83, 0x9C, 0x01,
  0xDE, 0x0E, 0x70, 0x0E, 0x70, 0x39, 0xC0, 0x39, 0xC0, 0xE7, 0x01, 0xC7,
  0x03, 0x9C, 0x07, 0x3C, 0x1C, 0x70, 0x38, 0xF0, 0x70, 0xC0, 0xE3, 0x81,
  0xC3, 0x07, 0x0E, 0x07, 0x0E, 0x38, 0x38, 0x3C, 0x38, 0xE1, 0xE0, 0xE0,
  0xE7, 0x07, 0x83, 0x83, 0x9C, 0x1C, 0x0E, 0x0E, 0xE0, 0x70, 0x38, 0x3B,
  0x81, 0xC1, 0xE0, 0x7C, 0x0F, 0x07, 0x01, 0xF0, 0x38, 0x1C, 0x07, 0x80,
  0xE0, 0x70, 0x1E, 0x03, 0x83, 0xC0, 0x70, 0x1E, 0x00, 0x03, 0xC0, 0x03,
  0x81, 0xE0, 0x01, 0xC1, 0xF8, 0x00, 0xE0, 0xFC, 0x00, 0xF0, 0x7E, 0x00,
  0x70, 0x3B, 0x80, 0x38, 0x1D, 0xC0, 0x1C, 0x1C, 0xF0, 0x0E, 0x0E, 0x38,
  0x0E, 0x07, 0x1C, 0x07, 0x03, 0x8F, 0x03, 0x81, 0xC3, 0x81, 0xC1, 0xC1,
  0xC1, 0xE0, 0xE0, 0x70, 0xE0, 0x70, 0x38, 0x70, 0x38, 0x1C, 0x38, 0x3C,
  0x07, 0x1C, 0x1C, 0x03, 0x9E, 0x0E, 0x01, 0xEE, 0x07, 0x00, 0x77, 0x03,
  0x80, 0x3B, 0x83, 0xC0, 0x0F, 0xC1, 0xC0, 0x07, 0xE0, 0xE0, 0x03, 0xE0,
  0x70, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x3E, 0x0F, 0x80, 0xF0, 0x07, 0x83, 0xC0, 0x07,
  0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x78, 0x00, 0x1C, 0xF0, 0x00, 0x39,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8,
  0x00, 0x07, 0x70, 0x00, 0x1E, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7B, 0x80,
  0x01, 0xE7, 0x00, 0x03, 0xCF, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x78, 0x3E, 0x03, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x3C, 0x7F, 0x07, 0x81, 0xE0, 0xE0,
  0x1E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0xF0, 0x07, 0x1E, 0x01, 0xE3, 0x80,
  0x3C, 0x70, 0x0F, 0x0E, 0x03, 0xE3, 0xC1, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF,
  0x01, 0xFE, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x3E, 0x0F, 0x80, 0xF0, 0x07, 0x83, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x1E,
  0x00, 0x0E, 0x78, 0x00, 0x1C, 0xF0, 0x00, 0x39, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00,
  0x1E, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7B, 0x80, 0x01, 0xE7, 0x00, 0x03,
  0xCF, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x3E, 0x03, 0xE0,
  0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x3C, 0x7F, 0x07, 0x80, 0xF0,
  0xE0, 0x1E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0xF0, 0x07, 0x1E, 0x01, 0xE3,
  0x80, 0x3C, 0x70, 0x0F, 0x0E, 0x03, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F,
  0xFE, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x0F, 0x07, 0x81, 0xC0, 0x70, 0x38,
  0x0E, 0x07, 0x01, 0xE1, 0xE0, 0x1C, 0x3C, 0x03, 0xC7, 0x00, 0x78, 0xE0,
  0x07, 0x1C, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x3E,
  0x0E, 0x0F, 0x00, 0x87, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE2, 0x00, 0xF8, 0xFF, 0xFC,
  0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x1C, 0x78, 0x00,
  0x71, 0xC0, 0x01, 0xC7, 0x00, 0x0F, 0x1C, 0x00, 0x38, 0xF0, 0x00, 0xE3,
  0xC0, 0x03, 0x8E, 0x00, 0x1E, 0x38, 0x00, 0x78, 0xE0, 0x01, 0xC7, 0x80,
  0x07, 0x1E, 0x00, 0x1C, 0x70, 0x00, 0xF1, 0xC0, 0x03, 0xC7, 0x00, 0x0E,
  0x3C, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x07, 0x8E, 0x00, 0x1C, 0x38,
  0x00, 0x70, 0xE0, 0x03, 0xC3, 0xC0, 0x1E, 0x07, 0x80, 0xF8, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xF0, 0x00, 0x7B, 0x80, 0x07,
  0x9C, 0x00, 0x38, 0xE0, 0x03, 0xC7, 0x00, 0x1C, 0x38, 0x01, 0xE1, 0xC0,
  0x0E, 0x0E, 0x00, 0xF0, 0x78, 0x07, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0x80,
  0x70, 0x3C, 0x03, 0x83, 0xC0, 0x1C, 0x1C, 0x00, 0xE1, 0xE0, 0x07, 0x0E,
  0x00, 0x38, 0xF0, 0x01, 0xC7, 0x00, 0x0F, 0x78, 0x00, 0x3B, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x1F, 0xC0, 0x0F, 0x00, 0x3B,
  0x80, 0x3E, 0x00, 0xF7, 0x00, 0x7C, 0x01, 0xCE, 0x01, 0xD8, 0x07, 0x9C,
  0x03, 0xB0, 0x0E, 0x38, 0x0E, 0x60, 0x3C, 0x70, 0x1C, 0xC0, 0x70, 0xF0,
  0x39, 0xC0, 0xE1, 0xE0, 0xE3, 0x83, 0x83, 0xC1, 0xC7, 0x07, 0x07, 0x87,
  0x0E, 0x1C, 0x07, 0x0E, 0x1C, 0x38, 0x0E, 0x38, 0x38, 0xF0, 0x1C, 0x70,
  0x71, 0xC0, 0x39, 0xC0, 0xE7, 0x80, 0x73, 0x81, 0xCE, 0x00, 0xEE, 0x03,
  0x9C, 0x01, 0xDC, 0x07, 0x70, 0x03, 0xB0, 0x0E, 0xE0, 0x07, 0xE0, 0x1D,
  0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x78, 0x01, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x0F,
  0x80, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x07,
  0x80, 0x07, 0x87, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xE3, 0x80, 0x00, 0x3B,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xEE, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0x70, 0x00,
  0xF0, 0x3C, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x78, 0x00, 0xE0, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xEE, 0x00, 0x79,
  0xC0, 0x0E, 0x3C, 0x03, 0xC3, 0x80, 0xF0, 0x70, 0x1C, 0x0E, 0x07, 0x81,
  0xE1, 0xE0, 0x1C, 0x38, 0x03, 0x8E, 0x00, 0x73, 0xC0, 0x07, 0x70, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x38, 0x00,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xE1, 0xC3, 0x83, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x07, 0x0E,
  0x1C, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x3B, 0x00, 0x06, 0x70, 0x01,
  0xC6, 0x00, 0x38, 0xE0, 0x0E, 0x0C, 0x01, 0xC1, 0xC0, 0x70, 0x18, 0x0E,
  0x03, 0x81, 0x80, 0x30, 0x70, 0x07, 0x0C, 0x00, 0x63, 0x80, 0x0E, 0xF0,
  0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF1, 0xE3, 0x87, 0x1C,
  0x30, 0x03, 0xF0, 0xC1, 0xFE, 0x70, 0xFF, 0xDC, 0x78, 0x3F, 0x3C, 0x07,
  0x8E, 0x01, 0xE7, 0x80, 0x79, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xCE,
  0x00, 0x73, 0x80, 0x3C, 0xE0, 0x0F, 0x38, 0x03, 0xCE, 0x01, 0xE3, 0x80,
  0xF8, 0xF0, 0x7E, 0x1E, 0x7B, 0x87, 0xFC, 0xC0, 0xFC, 0x30, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x3F, 0x01, 0xCF, 0xF0, 0x3B, 0xFF,
  0x07, 0xE1, 0xE1, 0xF0, 0x1C, 0x3E, 0x03, 0xC7, 0x80, 0x78, 0xE0, 0x0F,
  0x3C, 0x01, 0xE7, 0x80, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x3C,
  0xF0, 0x07, 0x1E, 0x01, 0xE3, 0xC0, 0x38, 0x7C, 0x0F, 0x0D, 0xE7, 0xC3,
  0x9F, 0xF0, 0x71, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0,
  0x08, 0xF8, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x03, 0xF1, 0xC0, 0x7F, 0x9C, 0x0F, 0xFD, 0xC1, 0xE0,
  0xFC, 0x3C, 0x07, 0x83, 0x80, 0x78, 0x78, 0x07, 0x87, 0x00, 0x78, 0xF0,
  0x07, 0x8F, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x0E,
  0x00, 0xF0, 0xE0, 0x1E, 0x0E, 0x03, 0xE0, 0xF0, 0x7E, 0x07, 0x9E, 0xE0,
  0x7F, 0xCC, 0x03, 0xF1, 0xC0, 0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xF8, 0xF0,
  0x73, 0xC0, 0xE7, 0x01, 0xDC, 0x03, 0xB8, 0x1E, 0xF1, 0xFD, 0xFF, 0xE3,
  0xFF, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0,
  0x08, 0xFC, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0x30, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x60, 0x7F, 0x9C, 0x1F, 0xFB, 0x87,
  0x83, 0xF1, 0xE0, 0x3C, 0x38, 0x07, 0x8F, 0x00, 0xF1, 0xC0, 0x1E, 0x78,
  0x03, 0xCF, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x03, 0xC7, 0x00, 0x78, 0xE0,
  0x0F, 0x1C, 0x03, 0xC3, 0x80, 0xF8, 0x78, 0x3F, 0x07, 0x9E, 0xE0, 0xFF,
  0xB8, 0x0F, 0xC7, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x18, 0x0F, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xF8,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x3F, 0x03, 0x9F, 0xE0,
  0xEF, 0xFC, 0x3F, 0x07, 0x1F, 0x01, 0xC7, 0xC0, 0x71, 0xE0, 0x1C, 0x70,
  0x07, 0x3C, 0x01, 0xCF, 0x00, 0xF3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03,
  0x9E, 0x01, 0xE7, 0x00, 0x79, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xCF,
  0x00, 0xF3, 0x80, 0x38, 0x03, 0x83, 0xC1, 0xE0, 0x60, 0x00, 0x00, 0x00,
  0x1E, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x1C,
  0x0E, 0x07, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F,
  0x01, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0E, 0x03, 0xC3, 0x81, 0xE0, 0xE0, 0xF0, 0x78, 0x78, 0x1E, 0x3C,
  0x07, 0x1E, 0x01, 0xCF, 0x00, 0x77, 0x80, 0x3B, 0xC0, 0x0F, 0xF0, 0x03,
  0xFE, 0x00, 0xF3, 0x80, 0x38, 0xF0, 0x1E, 0x1C, 0x07, 0x07, 0x81, 0xC0,
  0xE0, 0x70, 0x3C, 0x1C, 0x0F, 0x0F, 0x01, 0xE3, 0x80, 0x78, 0x03, 0x81,
  0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x03, 0x81, 0xC1,
  0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xC0,
  0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x00, 0x0E, 0x3F, 0x03, 0xE0, 0x73, 0xFC,
  0x7F, 0x83, 0xBF, 0xE7, 0xFE, 0x1F, 0x07, 0x70, 0x71, 0xF0, 0x3F, 0x03,
  0x8F, 0x01, 0xF0, 0x1C, 0x78, 0x0F, 0x00, 0xE3, 0x80, 0x78, 0x07, 0x3C,
  0x03, 0x80, 0x39, 0xE0, 0x1C, 0x03, 0xCE, 0x00, 0xE0, 0x1C, 0x70, 0x0F,
  0x00, 0xE3, 0x80, 0x70, 0x07, 0x3C, 0x03, 0x80, 0x79, 0xC0, 0x1C, 0x03,
  0xCE, 0x01, 0xE0, 0x1C, 0x70, 0x0F, 0x00, 0xE3, 0x80, 0x70, 0x07, 0x3C,
  0x03, 0x80, 0x79, 0xC0, 0x1C, 0x03, 0x80, 0x0E, 0x3F, 0x03, 0x9F, 0xF0,
  0xEF, 0xFC, 0x7F, 0x07, 0x1F, 0x81, 0xC7, 0xC0, 0x71, 0xE0, 0x1C, 0x70,
  0x07, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0x80, 0x3C, 0xE0, 0x0E, 0x78, 0x03,
  0x9E, 0x01, 0xE7, 0x80, 0x79, 0xC0, 0x1C, 0x70, 0x07, 0x3C, 0x03, 0xCF,
  0x00, 0xF3, 0x80, 0x3C, 0x03, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xC1,
  0xE3, 0xC0, 0x7B, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0xF0, 0x03, 0xF0,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x3D,
  0xE0, 0x3C, 0x70, 0x3C, 0x3F, 0x7E, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x03,
  0x8F, 0xC0, 0x1C, 0xFF, 0x00, 0xEF, 0xFC, 0x07, 0xE1, 0xE0, 0x7C, 0x07,
  0x03, 0xE0, 0x3C, 0x1E, 0x01, 0xE0, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78,
  0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x0F, 0x0F, 0x00, 0x70,
  0x78, 0x07, 0x83, 0xC0, 0x38, 0x1F, 0x03, 0xC0, 0xFE, 0x7C, 0x0F, 0x7F,
  0xC0, 0x71, 0xFC, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0xC1, 0xFE, 0x70, 0xFF, 0xDC, 0x78,
  0x3F, 0x3C, 0x07, 0x8E, 0x01, 0xE7, 0x80, 0x79, 0xC0, 0x1E, 0xF0, 0x07,
  0xBC, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x3C, 0xE0, 0x0F, 0x38, 0x07, 0xCE,
  0x01, 0xE3, 0x80, 0xF8, 0xF0, 0x7E, 0x1E, 0x7B, 0x87, 0xFD, 0xC0, 0xFC,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x0E, 0x3E,
  0x1C, 0xFC, 0x3B, 0xF0, 0x7E, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x00,
  0x03, 0xF8, 0x1F, 0xFC, 0x7F, 0xF8, 0xF0, 0x21, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x80, 0x79, 0xE3, 0xF3, 0xFF, 0xC3,
  0xFE, 0x00, 0x06, 0x00, 0xC0, 0x38, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80,
  0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE2, 0x1F, 0xC1, 0xF8, 0x1C,
  0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0xF0, 0x0F, 0x38, 0x03, 0x8E, 0x00,
  0xE3, 0x80, 0x39, 0xE0, 0x0E, 0x78, 0x07, 0x9C, 0x01, 0xC7, 0x00, 0x71,
  0xC0, 0x1C, 0xF0, 0x0F, 0x3C, 0x03, 0xCE, 0x01, 0xE3, 0x80, 0xF8, 0xF0,
  0x7E, 0x3E, 0x7B, 0x87, 0xFC, 0xC0, 0xFC, 0x70, 0xE0, 0x07, 0xF0, 0x03,
  0xB8, 0x03, 0xDC, 0x01, 0xCE, 0x01, 0xE7, 0x80, 0xE1, 0xC0, 0xF0, 0xE0,
  0x70, 0x70, 0x78, 0x38, 0x38, 0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x1C, 0x03,
  0x8E, 0x01, 0xCE, 0x00, 0x67, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x00, 0xE0, 0x1E, 0x01, 0xF8, 0x07, 0x80, 0xFE, 0x03, 0xE0,
  0x3B, 0x80, 0xF8, 0x1E, 0xE0, 0x7E, 0x07, 0x38, 0x1B, 0x83, 0xCE, 0x0E,
  0xE0, 0xE3, 0xC3, 0xB8, 0x78, 0xF1, 0xCE, 0x1C, 0x3C, 0x71, 0x87, 0x07,
  0x38, 0x63, 0x81, 0xCE, 0x18, 0xE0, 0x77, 0x06, 0x70, 0x1D, 0xC1, 0x9C,
  0x07, 0x60, 0x6F, 0x01, 0xF8, 0x1B, 0x80, 0x6C, 0x06, 0xE0, 0x1F, 0x01,
  0xF0, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x1E, 0x00, 0x0E, 0x00, 0xF0, 0x70,
  0x1E, 0x07, 0x03, 0xC0, 0x78, 0x78, 0x03, 0x87, 0x00, 0x38, 0xE0, 0x01,
  0xDE, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xB8, 0x00, 0x7B, 0x80, 0x0F, 0x3C, 0x01, 0xE1, 0xC0,
  0x1C, 0x1E, 0x03, 0x80, 0xE0, 0x78, 0x0F, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0x3C, 0x1C, 0x00, 0xE0, 0x70, 0x07, 0x81, 0xC0, 0x1C, 0x07, 0x80, 0xF0,
  0x0E, 0x03, 0x80, 0x38, 0x1E, 0x00, 0xE0, 0x70, 0x03, 0x83, 0xC0, 0x0E,
  0x0E, 0x00, 0x38, 0x70, 0x00, 0xF1, 0xC0, 0x01, 0xCE, 0x00, 0x07, 0x38,
  0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0x1F, 0xFF,
  0x80, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x78, 0x01, 0xE0, 0x1F, 0x80, 0x3C, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xF0, 0x03, 0xE0, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x03, 0xF0, 0x0F, 0x80, 0x38, 0x00, 0x7F, 0x00, 0xFF, 0xF1, 0xF0,
  0xFF, 0xF0, 0x1F, 0xE0,
};

const GFXglyph NotoSans_Italic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 9, 27, 10, 1, -26 },
  { 32, 11, 9, 15, 4, -26 },
  { 45, 23, 26, 24, 1, -26 },
  { 120, 18, 30, 20, 1, -28 },
  { 188, 25, 27, 30, 3, -27 },
  { 273, 23, 27, 25, 1, -27 },
  { 351, 5, 9, 8, 4, -26 },
  { 357, 13, 32, 11, 1, -26 },
  { 409, 12, 32, 11, -3, -26 },
  { 457, 17, 17, 20, 4, -28 },
  { 494, 17, 18, 21, 3, -22 },
  { 533, 8, 9, 9, -2, -4 },
  { 542, 9, 3, 12, 1, -11 },
  { 546, 4, 5, 9, 1, -4 },
  { 549, 18, 26, 13, -2, -26 },
  { 608, 18, 27, 20, 2, -27 },
  { 669, 11, 26, 20, 5, -26 },
  { 705, 20, 27, 20, 0, -27 },
  { 773, 18, 27, 20, 1, -27 },
  { 834, 20, 26, 20, 0, -26 },
  { 899, 19, 26, 20, 1, -26 },
  { 961, 18, 27, 20, 2, -27 },
  { 1022, 18, 26, 20, 3, -26 },
  { 1081, 18, 27, 20, 2, -27 },
  { 1142, 17, 27, 20, 2, -27 },
  { 1200, 7, 21, 9, 1, -20 },
  { 1219, 10, 25, 9, -2, -20 },
  { 1251, 17, 19, 21, 3, -23 },
  { 1292, 17, 10, 21, 3, -18 },
  { 1314, 17, 19, 21, 3, -23 },
  { 1355, 14, 28, 16, 3, -27 },
  { 1404, 28, 29, 31, 2, -26 },
  { 1506, 21, 26, 21, -2, -26 },
  { 1575, 20, 26, 22, 2, -26 },
  { 1640, 20, 27, 22, 3, -27 },
  { 1708, 22, 26, 25, 2, -26 },
  { 1780, 19, 26, 19, 2, -26 },
  { 1842, 19, 26, 18, 2, -26 },
  { 1904, 22, 27, 25, 3, -27 },
  { 1979, 23, 26, 25, 2, -26 },
  { 2054, 15, 26, 12, -1, -26 },
  { 2103, 16, 33, 10, -6, -26 },
  { 2169, 22, 26, 21, 2, -26 },
  { 2241, 14, 26, 18, 2, -26 },
  { 2287, 30, 26, 31, 1, -26 },
  { 2385, 25, 26, 26, 1, -26 },
  { 2467, 23, 27, 27, 3, -27 },
  { 2545, 19, 26, 21, 2, -26 },
  { 2607, 23, 33, 27, 3, -27 },
  { 2702, 19, 26, 21, 2, -26 },
  { 2764, 18, 27, 19, 1, -27 },
  { 2825, 19, 26, 19, 3, -26 },
  { 2887, 22, 26, 25, 3, -26 },
  { 2959, 21, 26, 20, 3, -26 },
  { 3028, 31, 26, 32, 4, -26 },
  { 3129, 25, 26, 20, -2, -26 },
  { 3211, 19, 26, 19, 3, -26 },
  { 3273, 21, 26, 20, 0, -26 },
  { 3342, 14, 32, 11, 0, -26 },
  { 3398, 7, 26, 13, 4, -26 },
  { 3421, 14, 32, 11, -3, -26 },
  { 3477, 19, 17, 21, 1, -27 },
  { 3518, 15, 3, 15, -3, 3 },
  { 3524, 6, 6, 10, 5, -28 },
  { 3529, 18, 20, 21, 2, -20 },
  { 3574, 19, 28, 21, 1, -28 },
  { 3641, 15, 20, 17, 2, -20 },
  { 3679, 20, 28, 21, 2, -28 },
  { 3749, 15, 20, 18, 2, -20 },
  { 3787, 20, 37, 12, -4, -28 },
  { 3880, 19, 29, 21, 1, -20 },
  { 3949, 18, 28, 21, 1, -28 },
  { 4012, 9, 27, 10, 1, -27 },
  { 4043, 15, 36, 10, -5, -27 },
  { 4111, 18, 28, 18, 1, -28 },
  { 4174, 9, 28, 10, 1, -28 },
  { 4206, 29, 20, 32, 1, -20 },
  { 4279, 18, 20, 21, 1, -20 },
  { 4324, 17, 20, 21, 2, -20 },
  { 4367, 21, 29, 21, -1, -20 },
  { 4444, 18, 29, 21, 2, -20 },
  { 4510, 15, 20, 15, 1, -20 },
  { 4548, 15, 20, 16, 0, -20 },
  { 4586, 11, 24, 12, 2, -24 },
  { 4619, 18, 20, 21, 2, -20 },
  { 4664, 17, 20, 17, 2, -20 },
  { 4707, 26, 20, 27, 2, -20 },
  { 4772, 20, 20, 18, -1, -20 },
  { 4822, 22, 29, 17, -3, -20 },
  { 4902, 17, 20, 16, -1, -20 },
  { 4945, 15, 32, 13, 0, -26 },
  { 5005, 2, 37, 20, 10, -28 },
  { 5015, 14, 32, 13, -1, -26 },
  { 5071, 17, 4, 21, 3, -15 },
};

const GFXfont NotoSans_Italic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic37pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_ITALIC37PT7B_H_
