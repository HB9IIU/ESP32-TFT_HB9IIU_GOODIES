#ifndef _NOTOSANS_ITALIC28PT7B_H_
#define _NOTOSANS_ITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x38, 0x70, 0xE1, 0xC3, 0x06, 0x1C, 0x38, 0x60, 0xC1, 0x87,
  0x0C, 0x00, 0x00, 0x01, 0xC3, 0x87, 0x00, 0x73, 0xB1, 0x99, 0xCC, 0xEC,
  0x66, 0x33, 0x18, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x61, 0x80,
  0x30, 0xC0, 0x18, 0x60, 0xFF, 0xFE, 0xFF, 0xFF, 0x06, 0x18, 0x03, 0x0C,
  0x03, 0x0C, 0x01, 0x86, 0x0F, 0xFF, 0xF7, 0xFF, 0xF8, 0x61, 0x80, 0x30,
  0xC0, 0x18, 0x60, 0x18, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x3F, 0x03, 0xFF, 0x1F, 0x98, 0x66, 0x03, 0x98, 0x0E, 0x60,
  0x39, 0x80, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x09, 0xC0, 0x63,
  0x01, 0x9C, 0x86, 0x73, 0xDF, 0x8F, 0xFC, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x1F, 0x00, 0xC7, 0xE0, 0x31, 0xC6, 0x0C, 0x30, 0xC3,
  0x86, 0x18, 0x61, 0xC3, 0x18, 0x30, 0xC6, 0x06, 0x19, 0xC0, 0xC3, 0x37,
  0xD8, 0xCD, 0xFD, 0xFB, 0x31, 0xBE, 0xEC, 0x30, 0x19, 0x86, 0x06, 0x30,
  0xC1, 0x86, 0x18, 0x70, 0xC7, 0x0C, 0x18, 0xC3, 0x03, 0x18, 0xC0, 0x7E,
  0x38, 0x07, 0x80, 0x03, 0xF0, 0x03, 0xFC, 0x03, 0x87, 0x01, 0x83, 0x80,
  0xC1, 0xC0, 0x60, 0xC0, 0x38, 0xE0, 0x1D, 0xE0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0xE0, 0x0E, 0x38, 0x76, 0x0C, 0x37, 0x07, 0x3B, 0x01, 0xF9, 0x80,
  0x78, 0xE0, 0x38, 0x70, 0x7E, 0x1F, 0xFB, 0x87, 0xF0, 0xE0, 0x76, 0x66,
  0xCC, 0xC0, 0x01, 0x81, 0x81, 0x81, 0xC1, 0xC0, 0xC0, 0xE0, 0x60, 0x70,
  0x38, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x38, 0x1C,
  0x06, 0x03, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x1C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x06,
  0x03, 0x03, 0x83, 0x81, 0x81, 0xC1, 0xC1, 0xC0, 0x03, 0x80, 0x18, 0x00,
  0xC1, 0xC6, 0x0F, 0xA0, 0x1F, 0xFC, 0x1F, 0xE1, 0xE0, 0x3B, 0x03, 0x8C,
  0x18, 0x60, 0x43, 0x80, 0x10, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x83, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x39, 0xCC, 0xE6, 0x63, 0x00, 0xFF, 0xFF,
  0xF0, 0xFF, 0x80, 0x00, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xC0,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x00,
  0x07, 0xE0, 0x7F, 0x87, 0x1C, 0x70, 0x77, 0x03, 0xB8, 0x1D, 0x80, 0xFC,
  0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x6C, 0x03, 0x60, 0x3B, 0x01,
  0xD8, 0x1C, 0xE0, 0xE7, 0x0E, 0x1F, 0xE0, 0x7E, 0x00, 0x07, 0x0F, 0x3F,
  0x7F, 0xE6, 0x46, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x18,
  0x18, 0x38, 0x38, 0x30, 0x30, 0x03, 0xF8, 0x1F, 0xF8, 0x38, 0x70, 0x40,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0xFF, 0xE7, 0xFF, 0xC0, 0x07, 0xF0, 0x7F, 0xE1, 0x83,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x01, 0xE0, 0x3E,
  0x00, 0xFC, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x1C, 0x00,
  0x72, 0x03, 0x8F, 0xFC, 0x3F, 0xE0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0x03, 0x60, 0x0E, 0xC0, 0x3B, 0x80, 0xE6, 0x03, 0x8C, 0x06, 0x18, 0x18,
  0x70, 0x60, 0xE1, 0xC1, 0x87, 0x03, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0xFC, 0x3F, 0xF0,
  0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x3F, 0xC0,
  0xFF, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C,
  0x00, 0x72, 0x03, 0x8F, 0xFC, 0x1F, 0xE0, 0x01, 0xF8, 0x3F, 0xC3, 0x80,
  0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x20, 0x6F, 0xE7, 0xEF, 0x3C,
  0x1D, 0xC0, 0xEC, 0x03, 0x60, 0x3B, 0x01, 0xD8, 0x0E, 0xE0, 0xE7, 0x0E,
  0x1F, 0xF0, 0x7E, 0x00, 0x7F, 0xFD, 0xFF, 0xE0, 0x01, 0x80, 0x0C, 0x00,
  0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0x03, 0xF0, 0x3F, 0xE0, 0xE1, 0xC7, 0x03, 0x1C, 0x0C,
  0x70, 0x31, 0xC1, 0xC3, 0x8E, 0x07, 0xF0, 0x1F, 0x01, 0xFE, 0x0E, 0x1C,
  0x70, 0x31, 0x80, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x31, 0xC1, 0xC7, 0xFE,
  0x07, 0xF0, 0x07, 0xE0, 0x3F, 0xC1, 0xC3, 0x8E, 0x06, 0x30, 0x1C, 0xC0,
  0x77, 0x01, 0xDC, 0x07, 0x70, 0x38, 0xC0, 0xE3, 0xDD, 0x87, 0xEE, 0x06,
  0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x0F, 0xF8, 0x3F,
  0x80, 0x39, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x73, 0x80, 0x0E,
  0x1C, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x86, 0x1C,
  0x30, 0x61, 0x83, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x1C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0x80, 0x04, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x01, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x0E,
  0x00, 0x40, 0x00, 0x3F, 0x8F, 0xF9, 0x87, 0x00, 0x70, 0x0E, 0x01, 0xC0,
  0x30, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x0C, 0x03, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF,
  0x80, 0x3C, 0x07, 0x01, 0x80, 0x0E, 0x0C, 0x00, 0x18, 0x60, 0x20, 0x73,
  0x07, 0xF8, 0xCC, 0x38, 0xC3, 0x61, 0x83, 0x0D, 0x8E, 0x0C, 0x36, 0x30,
  0x70, 0xD8, 0xC1, 0x83, 0xE3, 0x06, 0x1B, 0x8C, 0x38, 0x66, 0x31, 0xE3,
  0x18, 0xFD, 0xFC, 0x61, 0xE3, 0xC1, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F,
  0x00, 0x40, 0x1F, 0x0F, 0x00, 0x1F, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x6C, 0x00, 0xEE, 0x00,
  0xCE, 0x01, 0xCE, 0x01, 0x86, 0x03, 0x86, 0x03, 0x06, 0x07, 0x06, 0x0F,
  0xFE, 0x0F, 0xFF, 0x1C, 0x07, 0x1C, 0x07, 0x38, 0x07, 0x30, 0x03, 0x70,
  0x03, 0xE0, 0x03, 0x0F, 0xF8, 0x1F, 0xF8, 0x30, 0x78, 0x60, 0x31, 0xC0,
  0x63, 0x80, 0xC7, 0x01, 0x8C, 0x07, 0x18, 0xFC, 0x7F, 0xC0, 0xFF, 0xE1,
  0x80, 0xE3, 0x01, 0xC6, 0x01, 0x9C, 0x03, 0x38, 0x0E, 0x60, 0x1C, 0xC0,
  0xF3, 0xFF, 0xC7, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xFF, 0x0F, 0x02, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x78, 0x10, 0x3F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xFE, 0x03, 0x07, 0x81, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x1C, 0x70, 0x0E,
  0x30, 0x07, 0x18, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE6, 0x00, 0x63, 0x00,
  0x71, 0x80, 0x39, 0xC0, 0x38, 0xE0, 0x3C, 0x60, 0x3C, 0x30, 0xFC, 0x3F,
  0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x30, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x00, 0x01, 0xFF, 0x83, 0xFF,
  0x83, 0xC0, 0xC3, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x70, 0x3F, 0xB8, 0x1F, 0x9C, 0x0F, 0xCE, 0x00, 0xE7,
  0x00, 0x73, 0x80, 0x31, 0xC0, 0x18, 0x70, 0x0C, 0x3C, 0x0E, 0x0F, 0xFF,
  0x01, 0xFF, 0x00, 0x0E, 0x00, 0xC3, 0x80, 0x70, 0xC0, 0x1C, 0x30, 0x06,
  0x1C, 0x01, 0x87, 0x00, 0x61, 0xC0, 0x38, 0x60, 0x0E, 0x1F, 0xFF, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF0, 0xC0, 0x1C, 0x30, 0x07, 0x0C, 0x01, 0x87, 0x00,
  0x61, 0xC0, 0x38, 0x60, 0x0E, 0x18, 0x03, 0x0E, 0x00, 0xC3, 0x80, 0x70,
  0x07, 0xF0, 0xFE, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x1C, 0x01, 0xC0, 0x7E, 0x0F, 0xF0, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x0E, 0x0F, 0xC0, 0xF8, 0x00, 0x0E, 0x03, 0x87, 0x03,
  0x83, 0x03, 0x81, 0x83, 0x81, 0xC3, 0x80, 0xE3, 0x80, 0x63, 0x80, 0x33,
  0x80, 0x1B, 0x80, 0x1F, 0xC0, 0x0F, 0x60, 0x07, 0x38, 0x03, 0x0C, 0x01,
  0x87, 0x01, 0xC3, 0x80, 0xE0, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x38, 0x0E,
  0x1C, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03,
  0x80, 0x60, 0x0C, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x1E, 0x1E, 0x00,
  0x78, 0x3C, 0x01, 0xF0, 0x78, 0x03, 0x61, 0xF0, 0x0F, 0xC3, 0x70, 0x1B,
  0x86, 0x60, 0x76, 0x0C, 0xC0, 0xCC, 0x19, 0x83, 0x38, 0x73, 0x06, 0x70,
  0xC6, 0x18, 0xC1, 0x8C, 0x31, 0x83, 0x18, 0xC3, 0x0E, 0x33, 0x8E, 0x1C,
  0x76, 0x1C, 0x30, 0x7C, 0x30, 0x60, 0xF0, 0x60, 0xC1, 0xE1, 0xC3, 0x83,
  0x83, 0x87, 0x06, 0x07, 0x00, 0x0E, 0x00, 0xE1, 0xE0, 0x1C, 0x3C, 0x03,
  0x07, 0x80, 0x61, 0xF8, 0x0C, 0x33, 0x03, 0x86, 0x60, 0x70, 0xCE, 0x0C,
  0x18, 0xC1, 0x87, 0x1C, 0x30, 0xC3, 0x8E, 0x18, 0x31, 0xC3, 0x07, 0x30,
  0xE0, 0x66, 0x1C, 0x0C, 0xC3, 0x01, 0xF8, 0x60, 0x1E, 0x0C, 0x03, 0xC3,
  0x80, 0x78, 0x70, 0x07, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0x83, 0xC3,
  0x80, 0xF3, 0x80, 0x39, 0x80, 0x1D, 0xC0, 0x06, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3B, 0x80,
  0x1D, 0xC0, 0x1C, 0x70, 0x1E, 0x3C, 0x1E, 0x0F, 0xFE, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x1F, 0xF8, 0x30, 0x70, 0x60, 0x71, 0xC0, 0xE3, 0x81, 0xC7,
  0x03, 0x8C, 0x07, 0x18, 0x1C, 0x70, 0x78, 0xFF, 0xE1, 0xFF, 0x03, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0x83, 0xC3, 0x80, 0xF3, 0x80,
  0x39, 0x80, 0x1D, 0xC0, 0x06, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1B, 0x80, 0x1D, 0xC0, 0x1C,
  0x70, 0x1E, 0x3C, 0x1E, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0xF0, 0x1F, 0xF8,
  0x30, 0x70, 0x60, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8C, 0x07, 0x18,
  0x1C, 0x71, 0xF0, 0xFF, 0xC1, 0xFE, 0x03, 0x0C, 0x06, 0x1C, 0x1C, 0x18,
  0x38, 0x38, 0x60, 0x70, 0xC0, 0x63, 0x80, 0xE7, 0x01, 0xC0, 0x07, 0xFC,
  0x3F, 0xE1, 0xC1, 0x8E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x18, 0x00, 0xE2, 0x07, 0x8F, 0xFC, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC1, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0x8C, 0x01, 0xC6, 0x00,
  0xE7, 0x00, 0x73, 0x80, 0x31, 0x80, 0x18, 0xC0, 0x1C, 0x60, 0x0E, 0x70,
  0x06, 0x38, 0x03, 0x18, 0x01, 0x8C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x63,
  0x80, 0x31, 0xC0, 0x38, 0xE0, 0x38, 0x38, 0x3C, 0x1F, 0xFC, 0x03, 0xF8,
  0x00, 0xC0, 0x0F, 0x80, 0x3B, 0x00, 0x76, 0x01, 0xCC, 0x03, 0x9C, 0x0E,
  0x38, 0x1C, 0x70, 0x70, 0x60, 0xE0, 0xC3, 0x81, 0x86, 0x03, 0x1C, 0x06,
  0x30, 0x0C, 0xE0, 0x19, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0xC0, 0x38, 0x07, 0xC0, 0x70, 0x1F, 0x81, 0xE0, 0x37,
  0x03, 0xC0, 0xEE, 0x0F, 0x81, 0x9C, 0x1B, 0x07, 0x38, 0x76, 0x0C, 0x70,
  0xCC, 0x38, 0xE3, 0x98, 0x71, 0xC6, 0x30, 0xC3, 0x9C, 0x63, 0x87, 0x30,
  0xC6, 0x06, 0x61, 0xDC, 0x0D, 0x83, 0xB0, 0x1B, 0x03, 0x60, 0x3C, 0x07,
  0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70,
  0x00, 0x0E, 0x01, 0xC1, 0x80, 0xE0, 0x70, 0x70, 0x1C, 0x18, 0x03, 0x0C,
  0x00, 0xE7, 0x00, 0x1B, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x07, 0x70, 0x01, 0x9C, 0x00, 0xC3, 0x00, 0x70,
  0xE0, 0x38, 0x38, 0x1C, 0x06, 0x06, 0x01, 0xC3, 0x80, 0x70, 0xC0, 0x1F,
  0x00, 0xEE, 0x07, 0x38, 0x18, 0x60, 0xE1, 0x87, 0x07, 0x18, 0x0C, 0xE0,
  0x37, 0x00, 0xD8, 0x03, 0xE0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0x0F,
  0xFF, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xFF, 0xF8, 0xFF,
  0xF0, 0x07, 0xC1, 0xF0, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18,
  0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06,
  0x01, 0x80, 0x60, 0x38, 0x0F, 0xC3, 0xE0, 0xC6, 0x38, 0xC6, 0x31, 0x8C,
  0x73, 0x8C, 0x63, 0x18, 0xC7, 0x38, 0xC6, 0x30, 0x07, 0xE0, 0xF8, 0x03,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00,
  0xC0, 0x18, 0x3F, 0x07, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x78, 0x03, 0x60,
  0x0C, 0xC0, 0x63, 0x01, 0x86, 0x0E, 0x18, 0x30, 0x31, 0xC0, 0xC6, 0x01,
  0x98, 0x06, 0xC0, 0x0C, 0xFF, 0xF0, 0xE3, 0x8C, 0x30, 0x07, 0xCC, 0x7F,
  0xB1, 0xC3, 0xCE, 0x0F, 0x70, 0x19, 0xC0, 0x66, 0x01, 0x98, 0x0E, 0xE0,
  0x3B, 0x80, 0xCE, 0x07, 0x38, 0x3C, 0x71, 0xB1, 0xFD, 0xC3, 0xE6, 0x00,
  0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x9F,
  0x06, 0xFE, 0x3E, 0x18, 0xF0, 0x73, 0x81, 0xCE, 0x07, 0x30, 0x1D, 0xC0,
  0x77, 0x01, 0x9C, 0x0E, 0x60, 0x39, 0xC1, 0xCF, 0x0F, 0x37, 0xF8, 0xCF,
  0x80, 0x07, 0xF0, 0xFF, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x43, 0xFC, 0x1F, 0xC0,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x07, 0xCC, 0x1F, 0xEC, 0x1C, 0x3C, 0x38, 0x3C, 0x70, 0x18, 0x70, 0x18,
  0x60, 0x18, 0x60, 0x38, 0xE0, 0x38, 0xE0, 0x30, 0xE0, 0x70, 0xE0, 0xF0,
  0x61, 0xF0, 0x7F, 0x70, 0x3E, 0x60, 0x07, 0xE0, 0xFF, 0x1C, 0x73, 0x83,
  0x70, 0x77, 0x0E, 0x6F, 0xE7, 0xF8, 0xF0, 0x0E, 0x00, 0xE0, 0x06, 0x00,
  0x70, 0x47, 0xFC, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0xFE, 0x07, 0xFC, 0x01, 0x80, 0x03, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x1C, 0x01, 0x70, 0x03, 0xE0, 0x07, 0x00, 0x00, 0x07, 0xCC,
  0x7F, 0xB1, 0xC3, 0xCE, 0x0F, 0x70, 0x19, 0xC0, 0x66, 0x03, 0x98, 0x0E,
  0xE0, 0x3B, 0x80, 0xCE, 0x07, 0x38, 0x3C, 0x71, 0xF1, 0xFD, 0xC3, 0xE6,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x88, 0x1C, 0x31, 0xE0, 0xFF, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x9F, 0x06, 0xFE, 0x3E, 0x1C, 0xF0, 0x73, 0x81, 0xCE, 0x06, 0x30, 0x19,
  0xC0, 0xE7, 0x03, 0x98, 0x0E, 0x60, 0x31, 0x80, 0xCE, 0x07, 0x38, 0x1C,
  0xC0, 0x60, 0x04, 0x1C, 0x30, 0x40, 0x00, 0x06, 0x0C, 0x38, 0x70, 0xC1,
  0x83, 0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x87, 0x0C, 0x00, 0x00, 0x20, 0x07,
  0x00, 0x60, 0x04, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30,
  0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x09, 0xC0,
  0xF8, 0x07, 0x00, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0x83, 0xC6, 0x1C, 0x38, 0xE0, 0xE7, 0x03, 0x38, 0x0D, 0xC0,
  0x3E, 0x01, 0xFC, 0x07, 0xB0, 0x18, 0xE0, 0x61, 0x83, 0x87, 0x0E, 0x1C,
  0x38, 0x38, 0xC0, 0xE0, 0x0E, 0x18, 0x30, 0xE1, 0xC3, 0x86, 0x0C, 0x38,
  0x70, 0xC1, 0x83, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x87, 0x0C, 0x00, 0x19,
  0xF0, 0xF8, 0x6F, 0xEF, 0xF3, 0xE3, 0xB1, 0xCF, 0x07, 0x87, 0x38, 0x1C,
  0x1C, 0xE0, 0xE0, 0x73, 0x03, 0x81, 0xDC, 0x0E, 0x06, 0x70, 0x30, 0x19,
  0x80, 0xC0, 0xE6, 0x07, 0x03, 0x98, 0x1C, 0x0C, 0xE0, 0x60, 0x33, 0x81,
  0x80, 0xCC, 0x0E, 0x07, 0x00, 0x19, 0xF8, 0x6F, 0xE3, 0xE1, 0xCF, 0x07,
  0x38, 0x1C, 0xE0, 0x77, 0x01, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xE6, 0x03,
  0x38, 0x0C, 0xE0, 0x73, 0x81, 0xCC, 0x07, 0x00, 0x07, 0xE0, 0xFF, 0x87,
  0x0E, 0x70, 0x37, 0x01, 0xB8, 0x0D, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01,
  0xF8, 0x0C, 0xC0, 0xE7, 0x0E, 0x1F, 0xE0, 0x7E, 0x00, 0x06, 0x7C, 0x06,
  0xFE, 0x0F, 0x86, 0x0F, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0C, 0x07, 0x1C,
  0x07, 0x1C, 0x06, 0x1C, 0x0E, 0x18, 0x0E, 0x1C, 0x1C, 0x3C, 0x3C, 0x37,
  0xF8, 0x33, 0xE0, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0x07, 0xCC, 0x7F, 0xB1, 0xC3, 0xCE, 0x0F,
  0x70, 0x19, 0xC0, 0x66, 0x03, 0x98, 0x0E, 0xE0, 0x3B, 0x80, 0xCE, 0x07,
  0x38, 0x3C, 0x61, 0xF1, 0xFD, 0xC3, 0xE6, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x19, 0xE3, 0x7C, 0xF8,
  0x1E, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30,
  0x0E, 0x01, 0xC0, 0x30, 0x00, 0x0F, 0xF1, 0xFE, 0x38, 0x23, 0x00, 0x30,
  0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x81,
  0xCF, 0xF8, 0x7F, 0x00, 0x0C, 0x06, 0x07, 0x0F, 0xFF, 0xF9, 0xC0, 0xE0,
  0x70, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x7E, 0x1F,
  0x00, 0x30, 0x1B, 0x80, 0xDC, 0x0E, 0xE0, 0x76, 0x03, 0x30, 0x1B, 0x80,
  0xDC, 0x0E, 0xC0, 0x76, 0x03, 0x30, 0x39, 0x83, 0xCC, 0x3E, 0x7F, 0x71,
  0xF3, 0x00, 0xE0, 0x3B, 0x01, 0xD8, 0x1C, 0xC0, 0xE6, 0x0E, 0x30, 0x61,
  0x87, 0x0E, 0x30, 0x73, 0x83, 0x98, 0x0D, 0xC0, 0x6C, 0x03, 0xE0, 0x1E,
  0x00, 0xF0, 0x00, 0xC0, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0x83, 0x61, 0xB0,
  0xEC, 0x36, 0x19, 0x8E, 0xC7, 0x31, 0x98, 0xC6, 0x73, 0x38, 0xCC, 0x66,
  0x19, 0x8C, 0xC3, 0x61, 0xB0, 0x6C, 0x36, 0x0F, 0x07, 0xC1, 0xE0, 0xF0,
  0x38, 0x1E, 0x00, 0x1C, 0x0E, 0x18, 0x38, 0x38, 0xE0, 0x31, 0x80, 0x76,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0xC0, 0x0D, 0x80, 0x33, 0x00,
  0xE7, 0x03, 0x86, 0x0E, 0x0E, 0x38, 0x0C, 0x00, 0x0E, 0x03, 0x83, 0x01,
  0xC1, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0xE0, 0x38, 0x60, 0x1C, 0x70, 0x0E,
  0x30, 0x03, 0x38, 0x01, 0x98, 0x00, 0xDC, 0x00, 0x6C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x13, 0xC0, 0x0F, 0xC0, 0x03, 0x00, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x60,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0x60, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0xE0, 0x3C, 0x0E, 0x01, 0x80,
  0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x00,
  0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60,
  0x0F, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x01,
  0xF0, 0x0E, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0xF0, 0x1C, 0x0F, 0x81, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30,
  0x0E, 0x01, 0x80, 0x30, 0x3E, 0x07, 0x80, 0x38, 0x0F, 0xF8, 0x7B, 0xFF,
  0x03, 0xE0,
};

const GFXglyph NotoSans_Italic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 20, 7, 1, -20 },
  { 19, 9, 7, 11, 3, -20 },
  { 27, 17, 20, 18, 1, -20 },
  { 70, 14, 23, 15, 1, -21 },
  { 111, 19, 20, 22, 2, -20 },
  { 159, 17, 20, 19, 1, -20 },
  { 202, 4, 7, 6, 3, -20 },
  { 206, 9, 24, 8, 1, -20 },
  { 233, 9, 24, 8, -2, -20 },
  { 260, 13, 13, 15, 3, -21 },
  { 282, 13, 14, 16, 2, -17 },
  { 305, 5, 7, 7, -1, -3 },
  { 310, 7, 3, 9, 1, -9 },
  { 313, 3, 3, 7, 1, -3 },
  { 315, 13, 20, 10, -1, -20 },
  { 348, 13, 20, 15, 2, -20 },
  { 381, 8, 20, 15, 4, -20 },
  { 401, 15, 20, 15, 0, -20 },
  { 439, 14, 20, 15, 1, -20 },
  { 474, 15, 20, 15, 0, -20 },
  { 512, 14, 20, 15, 1, -20 },
  { 547, 13, 20, 15, 2, -20 },
  { 580, 14, 20, 15, 2, -20 },
  { 615, 14, 20, 15, 1, -20 },
  { 650, 14, 20, 15, 1, -20 },
  { 685, 5, 15, 7, 1, -15 },
  { 695, 7, 19, 7, -1, -15 },
  { 712, 13, 14, 16, 2, -17 },
  { 735, 13, 8, 16, 2, -14 },
  { 748, 13, 14, 16, 2, -17 },
  { 771, 11, 20, 12, 2, -20 },
  { 799, 22, 23, 24, 1, -20 },
  { 863, 16, 20, 16, -2, -20 },
  { 903, 15, 20, 17, 1, -20 },
  { 941, 16, 20, 16, 2, -20 },
  { 981, 17, 20, 19, 1, -20 },
  { 1024, 15, 20, 14, 1, -20 },
  { 1062, 15, 20, 13, 1, -20 },
  { 1100, 17, 20, 19, 2, -20 },
  { 1143, 18, 20, 19, 1, -20 },
  { 1188, 12, 20, 9, -1, -20 },
  { 1218, 12, 25, 8, -4, -20 },
  { 1256, 17, 20, 16, 1, -20 },
  { 1299, 11, 20, 13, 1, -20 },
  { 1327, 23, 20, 24, 1, -20 },
  { 1385, 19, 20, 20, 1, -20 },
  { 1433, 17, 20, 20, 2, -20 },
  { 1476, 15, 20, 16, 1, -20 },
  { 1514, 17, 25, 20, 2, -20 },
  { 1568, 15, 20, 16, 1, -20 },
  { 1606, 14, 20, 14, 1, -20 },
  { 1641, 13, 20, 14, 3, -20 },
  { 1674, 17, 20, 19, 2, -20 },
  { 1717, 15, 20, 15, 3, -20 },
  { 1755, 23, 20, 24, 3, -20 },
  { 1813, 18, 20, 15, -1, -20 },
  { 1858, 14, 20, 14, 3, -20 },
  { 1893, 16, 20, 15, 0, -20 },
  { 1933, 10, 24, 8, 0, -20 },
  { 1963, 5, 20, 10, 3, -20 },
  { 1976, 11, 24, 8, -2, -20 },
  { 2009, 14, 13, 16, 1, -20 },
  { 2032, 12, 1, 11, -3, 3 },
  { 2034, 5, 4, 8, 4, -21 },
  { 2037, 14, 15, 16, 1, -15 },
  { 2064, 14, 21, 16, 1, -21 },
  { 2101, 12, 15, 13, 1, -15 },
  { 2124, 16, 21, 16, 1, -21 },
  { 2166, 12, 15, 14, 1, -15 },
  { 2189, 15, 28, 9, -3, -21 },
  { 2242, 14, 22, 16, 1, -15 },
  { 2281, 14, 21, 16, 1, -21 },
  { 2318, 7, 21, 7, 1, -21 },
  { 2337, 12, 28, 7, -4, -21 },
  { 2379, 14, 21, 14, 1, -21 },
  { 2416, 7, 21, 7, 1, -21 },
  { 2435, 22, 15, 25, 1, -15 },
  { 2477, 14, 15, 16, 1, -15 },
  { 2504, 13, 15, 16, 1, -15 },
  { 2529, 16, 22, 16, -1, -15 },
  { 2573, 14, 22, 16, 1, -15 },
  { 2612, 11, 15, 11, 1, -15 },
  { 2633, 12, 15, 12, 0, -15 },
  { 2656, 9, 18, 9, 1, -18 },
  { 2677, 13, 15, 16, 2, -15 },
  { 2702, 13, 15, 13, 1, -15 },
  { 2727, 19, 15, 20, 2, -15 },
  { 2763, 15, 15, 14, -1, -15 },
  { 2792, 17, 22, 13, -3, -15 },
  { 2839, 12, 15, 12, 0, -15 },
  { 2862, 11, 24, 10, 0, -20 },
  { 2895, 2, 28, 15, 7, -21 },
  { 2902, 11, 24, 10, -1, -20 },
  { 2935, 13, 4, 16, 2, -12 },
};

const GFXfont NotoSans_Italic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic28pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_ITALIC28PT7B_H_
