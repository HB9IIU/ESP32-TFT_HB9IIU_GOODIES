#ifndef _NOTOSANS_ITALIC70PT7B_H_
#define _NOTOSANS_ITALIC70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xC0, 0x00, 0x3F, 0x83, 0xF9, 0xF8,
  0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE7, 0xF0, 0x7F, 0x3F, 0x03, 0xF1,
  0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01,
  0xF0, 0xF0, 0x0F, 0x8F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1E,
  0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xCF, 0x8F, 0xC0,
  0x0F, 0xE1, 0xF0, 0x38, 0x03, 0xF8, 0x3E, 0x01, 0x00, 0x7E, 0x07, 0x80,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x7E, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x01, 0xF8, 0x1E, 0x00, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0x7F, 0x1F, 0x00, 0x00,
  0x0F, 0xFB, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x0F, 0xBF, 0xC0, 0x00, 0x01, 0xE3, 0xFC, 0x00, 0x00, 0x3C, 0x1F, 0x80,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0xF0, 0x3F, 0x00, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0xFC, 0x10, 0x00, 0xF8, 0x3F, 0x03, 0x80,
  0x1E, 0x0F, 0xE0, 0x7E, 0x07, 0xC7, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x01, 0xF8,
  0x7E, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x7C, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0xE0,
  0x3E, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0x07, 0xC0, 0x0F, 0x83,
  0xF0, 0x00, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x78, 0x1F, 0x00, 0x7C, 0x1F,
  0x07, 0xFC, 0x3E, 0x01, 0xF8, 0x7E, 0x3F, 0xFC, 0x7C, 0x03, 0xE1, 0xF8,
  0xFF, 0xFC, 0xF8, 0x0F, 0xC3, 0xE3, 0xFF, 0xFD, 0xF0, 0x3F, 0x0F, 0x8F,
  0xE1, 0xFB, 0xF0, 0xFE, 0x3F, 0x1F, 0x81, 0xF3, 0xFF, 0xF8, 0xFC, 0x7E,
  0x03, 0xF7, 0xFF, 0xE1, 0xF0, 0xF8, 0x03, 0xE7, 0xFF, 0x87, 0xC3, 0xF0,
  0x07, 0xC7, 0xFC, 0x1F, 0x87, 0xC0, 0x0F, 0x81, 0xC0, 0x7E, 0x0F, 0x80,
  0x1F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0x80,
  0x1F, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0xFC, 0x01,
  0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x0F,
  0x80, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0x00,
  0x00, 0x7E, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xE3, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x7F, 0x00, 0x03, 0xF0, 0x7F, 0xC7, 0xF0, 0x00, 0xFE, 0x1F,
  0xE0, 0x7F, 0x00, 0x1F, 0x87, 0xF8, 0x07, 0xE0, 0x03, 0xF1, 0xFC, 0x00,
  0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0, 0x00, 0xFE,
  0x07, 0xE1, 0xF8, 0x00, 0x1F, 0xC1, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x7F,
  0x0F, 0xE0, 0x00, 0x1F, 0xDF, 0xC1, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x3F,
  0x00, 0x00, 0x3F, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xFC, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0x81, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC,
  0x7C, 0x3E, 0x1F, 0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x20, 0x01, 0xF0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x7F, 0x01, 0xF0, 0x00,
  0x7F, 0xC1, 0xE0, 0x00, 0xFF, 0xF1, 0xE0, 0x00, 0x7F, 0xFD, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xE7, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0x00, 0x7C, 0xF0, 0x00, 0x00, 0xFC, 0xF0, 0x00, 0x01, 0xF8, 0xF8, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xE0, 0x7C, 0x00,
  0x3F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x0F, 0x00, 0x3F, 0x00,
  0x07, 0x00, 0x3F, 0x00, 0x02, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0x80,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x00,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xE7,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xC0, 0x3F, 0x1F, 0xDF,
  0xEF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFE, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x7F,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFD,
  0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F,
  0xBF, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x01,
  0xFD, 0xF8, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0x80,
  0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF,
  0x7C, 0x3F, 0xF7, 0xE3, 0xFF, 0x3F, 0x3F, 0xE1, 0xF8, 0xFE, 0x1F, 0xC3,
  0xC0, 0xFC, 0x1C, 0x07, 0xE0, 0x80, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x1C, 0x00, 0x07, 0xF8, 0x00, 0x40,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x03, 0xE0, 0x00, 0xFE, 0x00,
  0x70, 0x00, 0x0F, 0xC0, 0x04, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x40, 0x00, 0x01, 0xFC,
  0x0E, 0x00, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0xF8, 0x00, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x7F, 0xF8, 0x00,
  0x20, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x02, 0x00, 0x00, 0x1F, 0xC0, 0x60, 0x00, 0x0F, 0xF8, 0x0F, 0x80,
  0x07, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xFF, 0x80, 0x07,
  0xE1, 0xFF, 0xF0, 0x03, 0xF9, 0xFF, 0xFF, 0x00, 0xFC, 0xFF, 0xFF, 0xC0,
  0x3F, 0x7F, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x07, 0xFF, 0x00, 0x1F,
  0xC1, 0xFF, 0x00, 0x03, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x1F, 0xE0, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0x7E, 0x3F, 0x80, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x07, 0xE3, 0xF8,
  0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x3F, 0x0F,
  0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xFC,
  0x1F, 0x80, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFA, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x01, 0xFC, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x7F,
  0x8F, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x3F,
  0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0xFC,
  0x3F, 0x80, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00,
  0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x80,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x1F, 0xF0, 0x0F,
  0xFF, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x01,
  0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x7F, 0x1F, 0x80,
  0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFE, 0x0F, 0xC0, 0x00, 0xFF,
  0x83, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0xFE,
  0xFC, 0x03, 0xFF, 0xFF, 0xBF, 0x00, 0x7F, 0xFF, 0x8F, 0xC0, 0x0F, 0xFF,
  0xC7, 0xE0, 0x00, 0xFF, 0xC1, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x38, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x10, 0x01, 0xF8, 0x07,
  0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xF8,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0xFF, 0x01, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x1E, 0x00, 0x00, 0x01,
  0x00, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xE0, 0x0F, 0xF0, 0xE0, 0x00,
  0xFE, 0x10, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x3E, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0xF8, 0x7E, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xE1, 0xF0, 0x03, 0xFE, 0x07,
  0xE0, 0x0F, 0x8F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFC, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xF7, 0xE0,
  0x1F, 0x80, 0x07, 0xC0, 0x0F, 0xDF, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3E,
  0x7C, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFB, 0xF0, 0x0F, 0x80, 0x03, 0xE0,
  0x03, 0xEF, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x0F, 0xBE, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x3E, 0xF8, 0x07, 0xC0, 0x01, 0xF8, 0x01, 0xFB, 0xE0, 0x1F,
  0x00, 0x07, 0xC0, 0x07, 0xCF, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0x1F, 0x3E,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x03,
  0xE3, 0xE0, 0x1F, 0x00, 0x1F, 0xC0, 0x1F, 0x8F, 0x80, 0x7C, 0x00, 0xFF,
  0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x03, 0xFC, 0x03, 0xF0, 0xF8, 0x07, 0xE0,
  0x1F, 0xF0, 0x1F, 0x83, 0xE0, 0x1F, 0xC1, 0xF7, 0xE0, 0xFE, 0x0F, 0xC0,
  0x3F, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x80,
  0x7C, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x07, 0xE0, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFC,
  0x07, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x00, 0xFF,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00,
  0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x7E, 0x01, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0x80,
  0x00, 0x7F, 0xC0, 0x7E, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x00, 0x0C, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x40, 0x01,
  0xFF, 0xC0, 0x0F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xC0, 0x7F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x1F,
  0xC0, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xFC,
  0x07, 0xE0, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xC0, 0x00,
  0x3F, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x7E, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x1E, 0x00, 0x7F, 0xC0, 0x00,
  0x02, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0xFF, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0x9F, 0xC0, 0x00,
  0x7F, 0xFF, 0x8F, 0xE0, 0x00, 0x3F, 0xFF, 0xC7, 0xF0, 0x00, 0x1F, 0xFF,
  0xE3, 0xF8, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0xFC,
  0x01, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x01,
  0x83, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0x00, 0xFD,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFB, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x7D, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0xFD,
  0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0xF9, 0xF8, 0x00, 0x00, 0xF9, 0xFC, 0x00, 0xF9, 0xF8, 0x00, 0x01,
  0xF9, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF1, 0xF8, 0x01, 0xF8, 0xF8,
  0x00, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xE1, 0xF8, 0x01,
  0xF8, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xC3,
  0xF0, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00,
  0x1F, 0x83, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x03, 0xF0,
  0x7C, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xE0,
  0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x7C,
  0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xC0, 0x7C,
  0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3E, 0x03, 0xF0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3E, 0x07,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80,
  0x3E, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3F, 0x80,
  0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F, 0xF0,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x7C, 0x00,
  0x1F, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xF0, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xE0, 0x07, 0xEF, 0xC0, 0x00, 0x1F,
  0x80, 0x0F, 0x8F, 0xC0, 0x00, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8,
  0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0xFE, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x80,
  0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0x00,
  0x07, 0xE7, 0xE0, 0x07, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x0F, 0xC0, 0x00,
  0x1F, 0x9F, 0x80, 0x1F, 0x80, 0x00, 0x1F, 0xBE, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00, 0x01, 0xFB,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0x81, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x01,
  0xFE, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x7E, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00,
  0xFE, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x0F, 0xF8, 0x07, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0xC0,
  0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x83, 0xFF, 0xF0, 0x01,
  0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xF0, 0x07, 0xFC, 0x00, 0x0C, 0x00, 0xFE,
  0x00, 0x00, 0x80, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x40, 0x00, 0x03, 0xFC, 0x0E,
  0x00, 0x01, 0xFF, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x00,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x3F,
  0x80, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x81,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0xFC,
  0x00, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x00, 0xFE, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x01,
  0xF3, 0xF8, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x07, 0xCF, 0xC0,
  0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x1F, 0x9F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xE3, 0xF0, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x8F,
  0xC0, 0x07, 0xF0, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xF8,
  0x0F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x01, 0xF0, 0x07, 0xE0, 0x03,
  0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x07, 0xC0,
  0x3F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0xF8, 0x0F,
  0xC0, 0x1F, 0x01, 0xF8, 0x00, 0x1F, 0x81, 0xF0, 0x03, 0xE0, 0x7F, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x0F,
  0x81, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xC3, 0xF0,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x7C, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0xFE, 0x7E, 0x00,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x83,
  0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x1F, 0x80, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0x80,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0x3E, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x1F, 0x3F, 0x00,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x3E, 0x7E, 0x00,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0xFC, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0x7C, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x01,
  0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x03,
  0xFE, 0x01, 0xF0, 0x00, 0xFF, 0xF0, 0x3E, 0x00, 0x3F, 0xFF, 0xC3, 0xE0,
  0x07, 0xFF, 0xFE, 0x3E, 0x00, 0xFF, 0xFF, 0xE7, 0xE0, 0x1F, 0xF8, 0x3F,
  0x7C, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0x80, 0x07, 0xFC, 0x07, 0xF0,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xFC, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xE0, 0x00, 0xFF,
  0x80, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0x80,
  0xFD, 0xF8, 0x03, 0xFF, 0x7F, 0x9F, 0x00, 0x3F, 0xFF, 0xF1, 0xF0, 0x01,
  0xFF, 0xFE, 0x1F, 0x00, 0x0F, 0xFF, 0xC1, 0xF0, 0x00, 0x3F, 0xF0, 0x1F,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x3F, 0xC0, 0x00, 0xFC, 0x1F, 0xFE, 0x00, 0x3F, 0x8F, 0xFF,
  0xE0, 0x07, 0xE3, 0xFF, 0xFE, 0x00, 0xFC, 0xFF, 0xFF, 0xC0, 0x1F, 0xBF,
  0x03, 0xFC, 0x03, 0xEF, 0x80, 0x3F, 0x80, 0xFF, 0xE0, 0x03, 0xF0, 0x1F,
  0xF8, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0xFC,
  0x0F, 0xF0, 0x00, 0x1F, 0x83, 0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00,
  0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x7F, 0x00,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x01, 0xFC, 0x3F,
  0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x03, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0,
  0x7C, 0xFE, 0x7F, 0xF0, 0x0F, 0x8F, 0xFF, 0xFC, 0x03, 0xF1, 0xFF, 0xFF,
  0x00, 0x7C, 0x1F, 0xFF, 0xC0, 0x0F, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xC0,
  0x78, 0x0F, 0xF8, 0x00, 0x40, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x20, 0x3F,
  0xC0, 0x07, 0x00, 0xFF, 0xE7, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFF, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x07, 0xE0,
  0x00, 0x7F, 0xFF, 0x8F, 0xC0, 0x01, 0xFF, 0xFF, 0x9F, 0x80, 0x07, 0xFF,
  0xFF, 0x3F, 0x00, 0x1F, 0xF0, 0x3F, 0x7C, 0x00, 0x7F, 0x80, 0x1F, 0xF8,
  0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x07,
  0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x0F,
  0xFE, 0x00, 0x3F, 0xC0, 0x7E, 0xFC, 0x00, 0x3F, 0xF7, 0xF9, 0xF0, 0x00,
  0x7F, 0xFF, 0xE3, 0xE0, 0x00, 0x7F, 0xFF, 0x87, 0xC0, 0x00, 0x7F, 0xFC,
  0x0F, 0x80, 0x00, 0x3F, 0xF0, 0x3F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x0F, 0xE0,
  0x3F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFC, 0x3F,
  0x80, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFF, 0x0F, 0xC0, 0x0F,
  0xF8, 0x7F, 0x07, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x20, 0x3F, 0xC0, 0x07, 0x80, 0x7F, 0xF3, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x02,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0x8F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0xF8, 0x00, 0x3F, 0xFE, 0x0F,
  0x80, 0x07, 0xFF, 0xF8, 0x7C, 0x00, 0x7F, 0xFF, 0xE3, 0xE0, 0x07, 0xFF,
  0xFF, 0x3F, 0x00, 0x7F, 0xC0, 0xFD, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0x80,
  0x7F, 0x80, 0x07, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0x80, 0x00,
  0xFF, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x07, 0xFC,
  0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0xFC, 0x00,
  0x3F, 0xF0, 0x07, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x7E, 0xFC, 0x00,
  0xFF, 0xDF, 0xE7, 0xC0, 0x07, 0xFF, 0xFE, 0x7E, 0x00, 0x1F, 0xFF, 0xE3,
  0xF0, 0x00, 0x7F, 0xFC, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0xFC, 0x00, 0x00,
  0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x10, 0x00, 0x07, 0xF0, 0x00, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x3F, 0xC0, 0x00, 0xFC, 0x1F, 0xFE, 0x00, 0x3F, 0x0F, 0xFF,
  0xE0, 0x07, 0xE3, 0xFF, 0xFE, 0x00, 0xFC, 0xFF, 0xFF, 0xE0, 0x1F, 0xBF,
  0x83, 0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0x80, 0xFF, 0xE0, 0x03, 0xF0, 0x1F,
  0xF8, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x01, 0xFC,
  0x0F, 0xF0, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00,
  0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x00,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8,
  0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x04,
  0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x0C, 0x3F, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x0F, 0xF0, 0x07, 0xE0,
  0x03, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x03,
  0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x00,
  0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x0F, 0xC7,
  0xF0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x0F,
  0xDF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xBF, 0x80, 0x00, 0x3F, 0xC3, 0xF0,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x0F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x3F, 0xF8, 0x01,
  0xFF, 0xE0, 0x07, 0xE1, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xC7, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0x1F, 0x9F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x3E,
  0x7E, 0x0F, 0xF3, 0xF8, 0x3F, 0xC0, 0x7D, 0xF0, 0x0F, 0xE7, 0xC0, 0x3F,
  0x81, 0xFF, 0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x7E, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFC, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8,
  0x0F, 0xFC, 0x00, 0x3F, 0x07, 0xFF, 0xE0, 0x07, 0xE1, 0xFF, 0xFE, 0x00,
  0xFC, 0x7F, 0xFF, 0xC0, 0x1F, 0x9F, 0xFF, 0xFC, 0x03, 0xF7, 0xF0, 0x7F,
  0x80, 0xFF, 0xF8, 0x07, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0x03, 0xFF, 0x00,
  0x0F, 0xE0, 0x7F, 0xC0, 0x01, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0x83, 0xFE,
  0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0,
  0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x3F,
  0x8F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x7F, 0x80, 0x00, 0x1F, 0x03, 0xFF, 0xC0,
  0x00, 0x7E, 0x1F, 0xFF, 0xC0, 0x00, 0xFC, 0x7F, 0xFF, 0xC0, 0x01, 0xF9,
  0xFF, 0xFF, 0x80, 0x03, 0xE7, 0xE0, 0x7F, 0x80, 0x07, 0xDF, 0x00, 0x7F,
  0x00, 0x1F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x7F,
  0xC0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0x03,
  0xF0, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x00,
  0x1F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xDF, 0xCF, 0xFE, 0x00,
  0x1F, 0x9F, 0xFF, 0xF8, 0x00, 0x3F, 0x3F, 0xFF, 0xE0, 0x00, 0xFC, 0x3F,
  0xFF, 0x80, 0x01, 0xF8, 0x1F, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x01, 0xF0,
  0x00, 0xFF, 0xF8, 0x3E, 0x00, 0x3F, 0xFF, 0xC3, 0xE0, 0x07, 0xFF, 0xFE,
  0x3E, 0x00, 0xFF, 0xFF, 0xE7, 0xE0, 0x1F, 0xF0, 0x3F, 0x7C, 0x03, 0xFC,
  0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0xC0,
  0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x7F,
  0xC0, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xE0, 0x00, 0xFF, 0x80, 0x7E, 0x00,
  0x1F, 0xF8, 0x07, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0xFD, 0xF8, 0x03,
  0xFF, 0x7F, 0x9F, 0x00, 0x3F, 0xFF, 0xF3, 0xF0, 0x01, 0xFF, 0xFE, 0x3F,
  0x00, 0x0F, 0xFF, 0x83, 0xF0, 0x00, 0x3F, 0xF0, 0x3F, 0x00, 0x00, 0x78,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0xF0, 0x0F, 0x83, 0xFF, 0x01, 0xF8,
  0x7F, 0xF0, 0x1F, 0x8F, 0xFE, 0x01, 0xF9, 0xFF, 0xE0, 0x1F, 0x3F, 0xC6,
  0x01, 0xF7, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFE,
  0x01, 0xF8, 0x1F, 0xE0, 0x01, 0x80, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x18, 0x00, 0x07, 0xF0,
  0xF0, 0x00, 0xFF, 0x07, 0xFC, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x3C, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0xC0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x3F,
  0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03,
  0xF8, 0x1F, 0x80, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x7E, 0x00,
  0x03, 0xFC, 0x0F, 0xC0, 0x00, 0xFF, 0x81, 0xF8, 0x00, 0x3F, 0xE0, 0x3F,
  0x00, 0x0F, 0xFC, 0x07, 0xF0, 0x03, 0xFF, 0x80, 0xFE, 0x01, 0xFB, 0xF0,
  0x0F, 0xF9, 0xFE, 0x7C, 0x01, 0xFF, 0xFF, 0x8F, 0x80, 0x1F, 0xFF, 0xE1,
  0xF0, 0x01, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0xFC, 0x0F, 0xC0, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xDF,
  0x80, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xFC,
  0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xE0, 0x1F,
  0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0xF8,
  0xFC, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x1F,
  0x7E, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xDF, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xF9, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x7D, 0xF0, 0x01, 0xFC, 0x7E,
  0x00, 0x3E, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x7C, 0x00, 0xFE, 0x1F,
  0x80, 0x1F, 0x3E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x9F, 0x00, 0x7F, 0x03,
  0xE0, 0x0F, 0x8F, 0x80, 0x3F, 0x01, 0xF0, 0x0F, 0xC7, 0xC0, 0x1F, 0x80,
  0xF8, 0x07, 0xC3, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE1, 0xF8, 0x0F, 0xC0,
  0x3E, 0x03, 0xE0, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x7E, 0x07, 0xE0,
  0x0F, 0xC1, 0xF0, 0x1F, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x0F, 0x83, 0xF0,
  0x03, 0xF0, 0xFC, 0x07, 0xC3, 0xF8, 0x01, 0xF8, 0x7C, 0x03, 0xE1, 0xF8,
  0x00, 0xFC, 0x7E, 0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x3E, 0x00, 0xF8, 0xFC,
  0x00, 0x3F, 0x3F, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x9F, 0x00, 0x3E, 0x7E,
  0x00, 0x0F, 0xCF, 0x80, 0x1F, 0x3F, 0x00, 0x07, 0xEF, 0x80, 0x0F, 0x9F,
  0x00, 0x03, 0xE7, 0xC0, 0x07, 0xDF, 0x80, 0x01, 0xF7, 0xC0, 0x03, 0xEF,
  0x80, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0xFE,
  0x00, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x00, 0x7D, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x18, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x9F,
  0xFF, 0x80, 0x00, 0xDF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF9,
  0x00, 0x00, 0xFF, 0xF8, 0x80, 0x00, 0x07, 0xE0, 0x00,
};

const GFXglyph NotoSans_Italic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 18, 51, 18, 1, -50 },
  { 116, 21, 18, 27, 8, -50 },
  { 164, 44, 50, 45, 2, -50 },
  { 439, 35, 57, 39, 2, -53 },
  { 689, 47, 52, 56, 6, -51 },
  { 995, 43, 52, 47, 2, -51 },
  { 1275, 9, 18, 15, 8, -50 },
  { 1296, 23, 61, 20, 3, -50 },
  { 1472, 22, 61, 20, -5, -50 },
  { 1640, 32, 32, 39, 7, -53 },
  { 1768, 33, 34, 40, 5, -42 },
  { 1909, 14, 17, 18, -3, -8 },
  { 1939, 18, 6, 22, 2, -22 },
  { 1953, 9, 9, 18, 1, -8 },
  { 1964, 34, 50, 25, -3, -50 },
  { 2177, 33, 52, 39, 4, -51 },
  { 2392, 21, 50, 39, 10, -50 },
  { 2524, 37, 51, 39, 0, -51 },
  { 2760, 35, 52, 39, 2, -51 },
  { 2988, 38, 50, 39, 0, -50 },
  { 3226, 35, 51, 39, 3, -50 },
  { 3450, 34, 52, 39, 4, -51 },
  { 3671, 33, 50, 39, 6, -50 },
  { 3878, 35, 52, 39, 3, -51 },
  { 4106, 34, 52, 39, 3, -51 },
  { 4327, 15, 40, 18, 1, -39 },
  { 4402, 19, 48, 18, -3, -39 },
  { 4516, 33, 35, 40, 5, -43 },
  { 4661, 32, 19, 40, 5, -34 },
  { 4737, 33, 35, 40, 5, -43 },
  { 4882, 27, 52, 30, 5, -51 },
  { 5058, 54, 56, 59, 4, -50 },
  { 5436, 40, 50, 39, -4, -50 },
  { 5686, 38, 50, 42, 3, -50 },
  { 5924, 39, 52, 41, 5, -51 },
  { 6178, 42, 50, 47, 3, -50 },
  { 6441, 36, 50, 36, 3, -50 },
  { 6666, 36, 50, 33, 3, -50 },
  { 6891, 41, 52, 47, 5, -51 },
  { 7158, 45, 50, 48, 3, -50 },
  { 7440, 28, 50, 23, -1, -50 },
  { 7615, 31, 63, 19, -11, -50 },
  { 7860, 43, 50, 39, 3, -50 },
  { 8129, 26, 50, 33, 3, -50 },
  { 8292, 56, 50, 59, 3, -50 },
  { 8642, 47, 50, 49, 3, -50 },
  { 8936, 43, 52, 50, 5, -51 },
  { 9216, 37, 50, 40, 3, -50 },
  { 9448, 43, 63, 50, 5, -51 },
  { 9787, 37, 50, 40, 3, -50 },
  { 10019, 35, 52, 35, 1, -51 },
  { 10247, 35, 50, 35, 6, -50 },
  { 10466, 42, 51, 47, 6, -50 },
  { 10734, 39, 50, 39, 6, -50 },
  { 10978, 59, 50, 60, 7, -50 },
  { 11347, 47, 50, 37, -4, -50 },
  { 11641, 36, 50, 36, 6, -50 },
  { 11866, 41, 50, 37, -1, -50 },
  { 12123, 27, 61, 20, -1, -50 },
  { 12329, 13, 50, 25, 8, -50 },
  { 12411, 26, 61, 20, -5, -50 },
  { 12610, 34, 31, 40, 3, -50 },
  { 12742, 28, 5, 28, -6, 6 },
  { 12760, 12, 12, 19, 10, -54 },
  { 12778, 36, 39, 40, 3, -38 },
  { 12954, 35, 54, 41, 2, -53 },
  { 13191, 29, 39, 32, 3, -38 },
  { 13333, 39, 54, 41, 3, -53 },
  { 13597, 30, 39, 35, 3, -38 },
  { 13744, 39, 71, 22, -8, -54 },
  { 14091, 37, 55, 41, 2, -38 },
  { 14346, 35, 53, 41, 2, -53 },
  { 14578, 17, 52, 18, 2, -52 },
  { 14689, 28, 69, 18, -9, -52 },
  { 14931, 35, 53, 35, 2, -53 },
  { 15163, 17, 53, 18, 2, -53 },
  { 15276, 55, 38, 61, 2, -38 },
  { 15538, 35, 38, 41, 2, -38 },
  { 15705, 33, 39, 39, 3, -38 },
  { 15866, 39, 55, 41, -2, -38 },
  { 16135, 36, 55, 41, 3, -38 },
  { 16383, 28, 38, 28, 2, -38 },
  { 16516, 29, 39, 30, 0, -38 },
  { 16658, 22, 47, 23, 3, -46 },
  { 16788, 35, 39, 41, 4, -38 },
  { 16959, 33, 38, 33, 3, -38 },
  { 17116, 49, 38, 51, 4, -38 },
  { 17349, 39, 38, 34, -3, -38 },
  { 17535, 43, 55, 33, -7, -38 },
  { 17831, 32, 38, 31, -1, -38 },
  { 17983, 27, 61, 25, 1, -50 },
  { 18189, 5, 70, 39, 18, -53 },
  { 18233, 27, 61, 25, -3, -50 },
  { 18439, 33, 9, 40, 5, -29 },
};

const GFXfont NotoSans_Italic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic70pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_ITALIC70PT7B_H_
