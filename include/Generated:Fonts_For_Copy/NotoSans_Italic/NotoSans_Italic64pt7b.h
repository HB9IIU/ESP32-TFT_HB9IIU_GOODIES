#ifndef _NOTOSANS_ITALIC64PT7B_H_
#define _NOTOSANS_ITALIC64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x03, 0xF0, 0x00, 0xF0, 0x00, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F,
  0x9F, 0x03, 0xE3, 0xE0, 0x7C, 0xFC, 0x0F, 0x9F, 0x83, 0xF3, 0xE0, 0x7C,
  0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF1,
  0xF0, 0x3E, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x00, 0x00, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x7C, 0x3C,
  0x01, 0xF8, 0x78, 0x04, 0x03, 0xF0, 0x78, 0x00, 0x03, 0xE0, 0x78, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x03, 0xF1, 0xF0, 0x00,
  0x03, 0xF9, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xDF, 0xE0,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x07, 0x83, 0xF0,
  0x00, 0x07, 0x83, 0xF0, 0x00, 0x07, 0x83, 0xF0, 0x00, 0x0F, 0x03, 0xF0,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x07, 0xE0, 0x80, 0x0F, 0x07, 0xE0,
  0xE0, 0x1F, 0x1F, 0xC0, 0xFC, 0x1E, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0x80, 0x3F, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0xFF, 0x00, 0x00, 0x7C,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xC0, 0x3F,
  0x03, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x07, 0xC0,
  0x07, 0x80, 0x1E, 0x01, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x7C, 0x00, 0x3E,
  0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x03,
  0xE0, 0xF8, 0x00, 0x1F, 0x00, 0x78, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x07,
  0xC3, 0xF8, 0x7C, 0x03, 0xE1, 0xF1, 0xFF, 0xCF, 0x80, 0x78, 0x7C, 0x7F,
  0xFD, 0xF0, 0x1F, 0x1F, 0x1F, 0xFF, 0xBE, 0x07, 0xC3, 0xE3, 0xF1, 0xFB,
  0xE1, 0xF8, 0xF8, 0xF8, 0x1F, 0x7F, 0xFE, 0x3E, 0x3E, 0x03, 0xE7, 0xFF,
  0x8F, 0x87, 0xC0, 0x3C, 0x7F, 0xE1, 0xF1, 0xF0, 0x07, 0x87, 0xF0, 0x7C,
  0x3E, 0x00, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x1E, 0x00, 0x07, 0xC0, 0xF0,
  0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x1F,
  0x00, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x78, 0x00,
  0x7C, 0x03, 0xC0, 0x0F, 0x00, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x0F, 0x00, 0x3E, 0x00, 0x3C,
  0x03, 0xE0, 0x0F, 0x80, 0x07, 0x80, 0x78, 0x03, 0xE0, 0x00, 0xF8, 0x1F,
  0x00, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xFF, 0xF8, 0x07,
  0xC0, 0x00, 0x3F, 0xFE, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x7E, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x1F,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xF0, 0x00, 0x00, 0x3E, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFD, 0xF8, 0x00, 0x3E, 0x1F,
  0xE1, 0xF8, 0x00, 0xFC, 0x7F, 0x83, 0xF8, 0x01, 0xF0, 0xFC, 0x03, 0xF0,
  0x07, 0xE3, 0xF0, 0x03, 0xF0, 0x0F, 0x8F, 0xC0, 0x07, 0xF0, 0x3F, 0x1F,
  0x80, 0x07, 0xE0, 0xFC, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0xFC, 0x00, 0x0F,
  0xE7, 0xE1, 0xF8, 0x00, 0x0F, 0xFF, 0x83, 0xF0, 0x00, 0x0F, 0xFE, 0x07,
  0xE0, 0x00, 0x0F, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0x03, 0xFF, 0x80,
  0x7F, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0xBF, 0x00, 0xFF, 0xFF,
  0xFE, 0x3F, 0x00, 0xFF, 0xFF, 0xF0, 0x7F, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0x78,
  0xF8, 0xF0, 0xF0, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0xF8, 0x00, 0x78, 0x07, 0x80, 0x07,
  0xF0, 0x3C, 0x00, 0x3F, 0xE1, 0xE0, 0x01, 0xFF, 0xCF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xBF, 0xF8, 0x03, 0xFC, 0x01, 0xC0, 0x3C, 0xF0, 0x00,
  0x07, 0xE7, 0x80, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x7F,
  0x07, 0xC0, 0x07, 0xF0, 0x3E, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xF0, 0x07,
  0xC0, 0x03, 0x80, 0x3E, 0x00, 0x08, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0,
  0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0x0E, 0x3F, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0x7E,
  0x3C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xDF, 0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFC, 0x3F, 0x80,
  0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0xFC, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0xFC,
  0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x3F,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7E, 0x07, 0xE0,
  0x03, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x00, 0xFF, 0x0F,
  0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x81,
  0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xEF, 0xDF, 0xF1, 0xF1, 0xFC, 0x3E, 0x3E,
  0x0F, 0xC3, 0x81, 0xF8, 0x40, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x1F,
  0xE0, 0x03, 0xC0, 0x03, 0xF8, 0x00, 0x60, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0x7F, 0xE0,
  0x07, 0xF0, 0x07, 0xF8, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x40, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC1, 0x80, 0x00, 0x1F, 0xC0,
  0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3E, 0xF0, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x07, 0xE7, 0xC0,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x7E, 0x3E,
  0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x3E, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xEF, 0xF8,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0xC0, 0x00, 0x1F,
  0xE0, 0xF0, 0x00, 0x3F, 0xC0, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF7,
  0xC0, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0xFC, 0x3F, 0xF8, 0x01, 0xF9, 0xFF, 0xF8, 0x03, 0xE7,
  0xFF, 0xF8, 0x0F, 0xDF, 0xFF, 0xF8, 0x1F, 0xFC, 0x07, 0xF8, 0x3F, 0xE0,
  0x07, 0xF0, 0x7F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x07, 0xE3, 0xF8, 0x00,
  0x0F, 0xC7, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0,
  0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x83, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x07,
  0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x0F, 0xE0, 0x3F,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0x9F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F,
  0x1F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x03, 0xF1, 0xF0,
  0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x01, 0xFC, 0x7E, 0x00,
  0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0xC3, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF7, 0xE0, 0x3F, 0xFF, 0x9F, 0x80, 0x7F, 0xFC, 0x7C,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x80, 0x03, 0xFC,
  0x03, 0xE0, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x03, 0xF0, 0x3F,
  0x81, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0x80, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3E, 0x00, 0xFE, 0x18,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x17, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x81,
  0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x7F, 0xFF, 0x80, 0xF8,
  0x3E, 0x00, 0x3F, 0xFF, 0xE0, 0x3E, 0x0F, 0x80, 0x3F, 0xFF, 0xF8, 0x07,
  0x87, 0xC0, 0x1F, 0xC0, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0xE0, 0x1F, 0x00,
  0x7C, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x3E, 0x01, 0xF0, 0x01, 0xF0,
  0x07, 0xCF, 0x00, 0xFC, 0x00, 0x78, 0x01, 0xF7, 0xC0, 0x3E, 0x00, 0x3E,
  0x00, 0x79, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x1E, 0x7C, 0x07, 0xC0, 0x03,
  0xE0, 0x0F, 0x9F, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE7, 0x80, 0x78, 0x00,
  0x7C, 0x00, 0xFB, 0xE0, 0x3E, 0x00, 0x1F, 0x00, 0x3E, 0xF8, 0x0F, 0x80,
  0x0F, 0xC0, 0x1F, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xCF, 0x80, 0xF8,
  0x00, 0xF8, 0x03, 0xE3, 0xE0, 0x3E, 0x00, 0x7E, 0x00, 0xF8, 0xF8, 0x0F,
  0x80, 0x3F, 0x80, 0x7C, 0x1E, 0x01, 0xF0, 0x1F, 0xE0, 0x3F, 0x07, 0xC0,
  0x7E, 0x0F, 0x7C, 0x1F, 0x81, 0xF0, 0x1F, 0xFF, 0xCF, 0xFF, 0xC0, 0x7C,
  0x03, 0xFF, 0xE3, 0xFF, 0xE0, 0x1F, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x03,
  0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0xF7, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0x7E,
  0xF8, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x01, 0xF1, 0xF8, 0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x7C, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x3F,
  0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x00, 0x7C, 0x7E, 0x00,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xF8,
  0x03, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x07, 0xC0, 0x00, 0xFE, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xFC, 0x03,
  0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x07, 0xC0,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0x80,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x7C, 0x00, 0x1F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x07,
  0x80, 0x3F, 0xE0, 0x00, 0x20, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xE0, 0x01, 0xFF, 0xE7,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xF0, 0x0F, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0x3E, 0x00,
  0x07, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0xFE, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x00,
  0xFE, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x00, 0x7F, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x00, 0xFF, 0x01, 0xF8, 0x00, 0x07, 0xF8,
  0x07, 0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x7C, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0x80, 0x0F, 0xC0, 0x0F, 0xF8, 0x00, 0x07, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFE,
  0x3F, 0x00, 0x03, 0xFF, 0xF8, 0xFC, 0x00, 0x0F, 0xFF, 0xE3, 0xF0, 0x00,
  0x3F, 0xFF, 0x0F, 0xC0, 0x01, 0xFF, 0xFC, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x00,
  0x7E, 0x00, 0x3F, 0xFE, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x80, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x00, 0x7C, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x80,
  0x00, 0x1F, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x00, 0x07, 0xC3, 0xF8, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x00, 0x3F,
  0x3F, 0x80, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00, 0xFB, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xE3, 0xF0, 0x00, 0x00, 0x3F, 0x83, 0xE0,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x01, 0xF7, 0xC0, 0x00,
  0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x00, 0x00, 0xFD, 0xF0, 0x07, 0xCF, 0x00,
  0x00, 0x1F, 0x7E, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x1F, 0x3E,
  0x00, 0x00, 0xF9, 0xF0, 0x07, 0xE7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0xFC,
  0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF8, 0x03,
  0xE3, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x87, 0xC0,
  0x1F, 0x87, 0x80, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x00, 0x7C, 0x3F,
  0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x0F, 0x83, 0xE0, 0x03, 0xE0,
  0xFC, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x1F,
  0x03, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x3E, 0x00,
  0xF8, 0x1F, 0x80, 0x3E, 0x03, 0xC0, 0x3E, 0x03, 0xF0, 0x0F, 0xC0, 0x7C,
  0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x80, 0x3E, 0x01,
  0xF0, 0x7E, 0x03, 0xF0, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7E, 0x00, 0xF8,
  0x07, 0xC3, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x07,
  0xE0, 0x1F, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xE3, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x3C, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xDF, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x1F, 0xF8, 0x01,
  0xF8, 0x03, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7F, 0xC0,
  0x07, 0xE0, 0x0F, 0x80, 0x0F, 0xF0, 0x00, 0xF8, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0xF8, 0x00,
  0x00, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xE0, 0x07, 0xFE, 0x00, 0x00, 0x7C, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x80,
  0x3E, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0x00, 0xF9,
  0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x3F, 0x00, 0x01, 0xF0, 0x07, 0xE3, 0xE0,
  0x00, 0x7E, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x01,
  0xF0, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0xC0,
  0x1F, 0x81, 0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x00, 0x7C,
  0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x03, 0xE0,
  0x0F, 0xC0, 0x07, 0xC0, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x3E,
  0x00, 0x0F, 0x83, 0xE0, 0x07, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0xF8, 0x00,
  0x3F, 0x0F, 0x80, 0x3F, 0x00, 0x03, 0xE3, 0xF0, 0x07, 0xE0, 0x00, 0x7E,
  0x7E, 0x00, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x1F, 0x00, 0x00, 0xF9, 0xF0,
  0x03, 0xE0, 0x00, 0x1F, 0xBE, 0x00, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x1F,
  0x80, 0x00, 0x3F, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x7C, 0x00,
  0x00, 0x7F, 0xC0, 0x0F, 0x80, 0x00, 0x0F, 0xF8, 0x03, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x00, 0x03, 0xF8,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x0F, 0xE3, 0xF0,
  0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x3F, 0xF8, 0x03, 0xF0,
  0x01, 0xFC, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0,
  0x3F, 0x00, 0x0F, 0xF0, 0x1F, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x0F, 0xE3, 0xF0,
  0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x3F, 0xF8, 0x03, 0xF0,
  0x01, 0xFC, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F,
  0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xE0,
  0x3E, 0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x01,
  0xF8, 0x03, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xF0, 0x3E, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xC0,
  0x00, 0x1F, 0x87, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x3E, 0x01, 0xFE, 0x00, 0x04, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x80, 0x00, 0x1F, 0xC0, 0xF0,
  0x00, 0x7F, 0x80, 0xFF, 0x8F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x1F, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x00, 0x7F, 0xF3, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x1F,
  0x00, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x7E,
  0x0F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0xFC, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x1F, 0x80, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x01,
  0xF0, 0x3F, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xF8,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFB, 0xE0, 0x00,
  0xFC, 0x3F, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3F,
  0x3E, 0x00, 0x1F, 0x03, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF8, 0x1F, 0x80,
  0x0F, 0x8F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x03,
  0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7E,
  0x00, 0xF8, 0x03, 0xE0, 0x78, 0x03, 0xF0, 0x07, 0xC0, 0x3E, 0x03, 0xC0,
  0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x01, 0xF0, 0x1F, 0x80,
  0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0xFC, 0x00, 0x7C, 0x0F,
  0xC0, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x7E, 0x00, 0x1F,
  0x07, 0xE0, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3F, 0x00,
  0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x8F, 0x80, 0x07,
  0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xE7, 0xC0,
  0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x3E, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x00, 0x03, 0xE3, 0xF0, 0x00,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7E, 0x7C, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xFC, 0x7E, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xF0, 0x3F, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0xC0, 0x1F, 0x00,
  0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0,
  0x1F, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E, 0xF8, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3C, 0x7C, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x0F, 0x80,
  0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x1F, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF0,
  0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x0F, 0x00, 0x7F, 0xFE, 0x1F, 0x00, 0xFF, 0xFF, 0x1F, 0x01,
  0xFF, 0xFF, 0xBE, 0x03, 0xFC, 0x0F, 0xBE, 0x07, 0xF8, 0x03, 0xFE, 0x07,
  0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x1F,
  0x80, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x3F, 0xE0, 0x7E,
  0x00, 0x7F, 0xC0, 0x7E, 0x01, 0xF7, 0xC0, 0x7F, 0x83, 0xE7, 0xC0, 0x3F,
  0xFF, 0xC7, 0xC0, 0x3F, 0xFF, 0x87, 0x80, 0x1F, 0xFF, 0x07, 0x80, 0x07,
  0xFC, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x7F, 0xF0, 0x01,
  0xF0, 0xFF, 0xF8, 0x03, 0xF1, 0xFF, 0xFC, 0x03, 0xF7, 0xFF, 0xFC, 0x03,
  0xE7, 0xC0, 0xFE, 0x03, 0xEF, 0x00, 0x7E, 0x03, 0xFE, 0x00, 0x7E, 0x07,
  0xFC, 0x00, 0x3F, 0x07, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F,
  0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F,
  0x80, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0x7F,
  0xC0, 0x1F, 0xE0, 0x7D, 0xF0, 0x7F, 0xC0, 0x79, 0xFF, 0xFF, 0x80, 0xF8,
  0xFF, 0xFF, 0x00, 0xF8, 0x7F, 0xFC, 0x00, 0xF0, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFC, 0x07, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x18, 0x0F, 0xF0, 0x1F, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00,
  0xFF, 0xE1, 0xF8, 0x00, 0x7F, 0xFE, 0x3F, 0x00, 0x1F, 0xFF, 0xE7, 0xE0,
  0x07, 0xFF, 0xFE, 0xF8, 0x01, 0xFE, 0x03, 0xDF, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x1F, 0xC0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x0F, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0xFF, 0x00,
  0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0x80, 0x07, 0xFC, 0x01, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0x00, 0xFB, 0xE0, 0x07, 0xF8, 0x3E, 0x7C, 0x00, 0x7F, 0xFF,
  0x8F, 0x80, 0x0F, 0xFF, 0xE1, 0xE0, 0x00, 0xFF, 0xF8, 0x7C, 0x00, 0x07,
  0xFC, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x07, 0xF8, 0x1F, 0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x03,
  0xE3, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0xE3, 0xF1,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x20, 0xFF, 0x00,
  0x1C, 0x0F, 0xF8, 0x1F, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x67, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x03, 0xC0, 0x0F,
  0xFF, 0xC3, 0xE0, 0x0F, 0xFF, 0xF1, 0xF0, 0x0F, 0xFF, 0xFD, 0xF0, 0x0F,
  0xF0, 0x1E, 0xF8, 0x0F, 0xF0, 0x07, 0xFC, 0x0F, 0xE0, 0x01, 0xFE, 0x07,
  0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x07,
  0xF8, 0x1F, 0x80, 0x03, 0xFC, 0x0F, 0xC0, 0x03, 0xFE, 0x03, 0xF0, 0x03,
  0xFE, 0x01, 0xF8, 0x07, 0xDF, 0x00, 0xFF, 0x07, 0xDF, 0x80, 0x3F, 0xFF,
  0xCF, 0xC0, 0x1F, 0xFF, 0xC7, 0xC0, 0x07, 0xFF, 0xC3, 0xE0, 0x00, 0xFF,
  0x83, 0xF0, 0x00, 0x0E, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x10,
  0x00, 0x0F, 0xC0, 0x0E, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0xF8, 0x3F, 0xF8, 0x01, 0xF0, 0xFF, 0xF8, 0x07,
  0xE3, 0xFF, 0xF8, 0x0F, 0xCF, 0xFF, 0xF8, 0x1F, 0x3E, 0x07, 0xF0, 0x3E,
  0xF0, 0x07, 0xE0, 0x7F, 0xC0, 0x07, 0xC1, 0xFF, 0x00, 0x0F, 0x83, 0xFC,
  0x00, 0x1F, 0x07, 0xF0, 0x00, 0x3E, 0x0F, 0xE0, 0x00, 0x7C, 0x1F, 0x80,
  0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E,
  0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x63, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0x01, 0xF0,
  0x00, 0xFE, 0x01, 0xF0, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF0,
  0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xE0, 0x1F, 0xC0, 0x03, 0xE0,
  0x3F, 0x80, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x07, 0xC1,
  0xFC, 0x00, 0x07, 0xC3, 0xF8, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x0F, 0xCF,
  0xE0, 0x00, 0x0F, 0x9F, 0xC0, 0x00, 0x0F, 0xBF, 0x80, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xF7,
  0xE0, 0x00, 0x1F, 0xE7, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x7C,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F,
  0x8F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xE7, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0,
  0xFB, 0xF0, 0x7F, 0x3F, 0x07, 0xF0, 0x3E, 0xF0, 0x0F, 0xDF, 0x00, 0xFC,
  0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7C, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0xE0, 0x01,
  0xF0, 0x7F, 0xF8, 0x03, 0xF1, 0xFF, 0xFC, 0x03, 0xF3, 0xFF, 0xFC, 0x03,
  0xE7, 0xFF, 0xFE, 0x03, 0xEF, 0xE0, 0xFE, 0x03, 0xFF, 0x80, 0x7E, 0x07,
  0xFE, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x3F, 0x07, 0xF8, 0x00, 0x3F, 0x07,
  0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x1F,
  0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0,
  0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01,
  0xF8, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0,
  0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC1, 0xFF, 0xC0, 0x00, 0xF8, 0x7F, 0xFC, 0x00, 0x3E, 0x1F, 0xFF, 0xC0,
  0x07, 0xCF, 0xFF, 0xF8, 0x00, 0xF9, 0xF0, 0x3F, 0x80, 0x1F, 0x78, 0x03,
  0xF0, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x1F, 0xE0,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00,
  0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x00, 0xFC, 0x07, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x07, 0xE0,
  0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xEF, 0x83, 0xFE, 0x00, 0x7D, 0xFF,
  0xFF, 0x80, 0x1F, 0x9F, 0xFF, 0xE0, 0x03, 0xF1, 0xFF, 0xF0, 0x00, 0x7E,
  0x0F, 0xFC, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x0F, 0x00, 0x7F, 0xFE, 0x1F, 0x00, 0xFF, 0xFF,
  0x1F, 0x01, 0xFF, 0xFF, 0xBE, 0x03, 0xFC, 0x07, 0xBE, 0x07, 0xF8, 0x03,
  0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x01,
  0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x3F,
  0xE0, 0x7E, 0x00, 0x7F, 0xC0, 0x7E, 0x01, 0xF7, 0xC0, 0x7F, 0x83, 0xEF,
  0xC0, 0x3F, 0xFF, 0xCF, 0xC0, 0x3F, 0xFF, 0x8F, 0x80, 0x1F, 0xFF, 0x0F,
  0x80, 0x07, 0xFC, 0x1F, 0x80, 0x00, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0xF8, 0x3F, 0xC0,
  0x7C, 0x7F, 0xE0, 0x7C, 0x7F, 0xF0, 0x3E, 0x7F, 0xF8, 0x1F, 0x3F, 0x04,
  0x0F, 0xBC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1,
  0xFE, 0x01, 0xE0, 0x7E, 0x00, 0x08, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x80, 0x00, 0x7E, 0x38, 0x00, 0x3F, 0x0F, 0xC0, 0x3F, 0xC3,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x40, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC,
  0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x7E, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x0F,
  0xE0, 0xF8, 0x00, 0x3F, 0xC1, 0xF0, 0x00, 0x7F, 0x83, 0xE0, 0x01, 0xFF,
  0x07, 0xE0, 0x07, 0xFC, 0x0F, 0xC0, 0x3E, 0xF8, 0x1F, 0xC1, 0xF9, 0xF0,
  0x3F, 0xFF, 0xE3, 0xE0, 0x3F, 0xFF, 0x87, 0x80, 0x3F, 0xFE, 0x1F, 0x00,
  0x3F, 0xF0, 0x3E, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0xFC, 0x7C,
  0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xFC, 0x1F, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x03,
  0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x3E, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x07, 0xDF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3D, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xCF, 0x80, 0x07, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x7F, 0xC0,
  0x07, 0xE3, 0xE0, 0x03, 0xDE, 0x00, 0x3F, 0x1F, 0x00, 0x3E, 0xF0, 0x03,
  0xF0, 0xF8, 0x01, 0xE7, 0x80, 0x1F, 0x87, 0xC0, 0x1F, 0x3E, 0x01, 0xF8,
  0x3E, 0x00, 0xF9, 0xF0, 0x0F, 0xC1, 0xF0, 0x0F, 0x8F, 0x80, 0xFC, 0x0F,
  0x80, 0x7C, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xC3, 0xE0, 0x3E, 0x03, 0xF0,
  0x3E, 0x1F, 0x03, 0xF0, 0x1F, 0x83, 0xE0, 0xF8, 0x1F, 0x00, 0xFC, 0x1F,
  0x07, 0xC1, 0xF8, 0x07, 0xE0, 0xF0, 0x3E, 0x0F, 0x80, 0x3F, 0x0F, 0x81,
  0xF0, 0xFC, 0x01, 0xF8, 0x78, 0x0F, 0x87, 0xE0, 0x07, 0xC7, 0xC0, 0x7C,
  0x3E, 0x00, 0x3E, 0x3E, 0x03, 0xE3, 0xF0, 0x01, 0xF3, 0xE0, 0x1F, 0x1F,
  0x00, 0x0F, 0x9F, 0x00, 0x79, 0xF8, 0x00, 0x7D, 0xF0, 0x03, 0xCF, 0x80,
  0x03, 0xEF, 0x80, 0x1E, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0xF7, 0xC0, 0x00,
  0xFF, 0xC0, 0x07, 0xBE, 0x00, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0x00, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x0F, 0xE0, 0x00, 0x7C, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x00, 0x3E, 0x3F, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x07, 0xF1, 0xF0,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x03, 0xE1, 0xF8,
  0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x08, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x02, 0x3F, 0xFC, 0x00, 0x0C, 0xFF,
  0xFE, 0x00, 0x3B, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xB8, 0x00, 0xFF, 0xFE, 0x60, 0x00, 0x3F, 0xF8, 0x80, 0x00,
  0x03, 0x00,
};

const GFXglyph NotoSans_Italic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 17, 47, 17, 1, -46 },
  { 101, 19, 17, 25, 7, -46 },
  { 142, 40, 46, 41, 2, -46 },
  { 372, 32, 53, 35, 2, -49 },
  { 584, 43, 47, 51, 5, -46 },
  { 837, 39, 47, 43, 2, -46 },
  { 1067, 8, 17, 14, 7, -46 },
  { 1084, 20, 56, 19, 3, -46 },
  { 1224, 21, 56, 19, -5, -46 },
  { 1371, 29, 30, 35, 7, -49 },
  { 1480, 31, 31, 37, 4, -38 },
  { 1601, 13, 15, 16, -3, -7 },
  { 1626, 16, 5, 20, 2, -20 },
  { 1636, 8, 9, 16, 1, -8 },
  { 1645, 31, 46, 23, -3, -46 },
  { 1824, 30, 47, 35, 4, -46 },
  { 2001, 19, 46, 35, 9, -46 },
  { 2111, 34, 46, 35, 0, -46 },
  { 2307, 33, 47, 35, 1, -46 },
  { 2501, 34, 46, 35, 0, -46 },
  { 2697, 32, 47, 35, 2, -46 },
  { 2885, 31, 47, 35, 4, -46 },
  { 3068, 31, 46, 35, 5, -46 },
  { 3247, 32, 47, 35, 3, -46 },
  { 3435, 30, 47, 35, 3, -46 },
  { 3612, 13, 36, 16, 1, -35 },
  { 3671, 17, 43, 16, -3, -35 },
  { 3763, 31, 32, 37, 4, -39 },
  { 3887, 29, 17, 37, 5, -31 },
  { 3949, 31, 32, 37, 4, -39 },
  { 4073, 24, 47, 28, 5, -46 },
  { 4214, 50, 52, 54, 3, -46 },
  { 4539, 37, 46, 36, -4, -46 },
  { 4752, 35, 46, 38, 3, -46 },
  { 4954, 35, 47, 38, 5, -46 },
  { 5160, 38, 46, 43, 3, -46 },
  { 5379, 32, 46, 33, 3, -46 },
  { 5563, 32, 46, 31, 3, -46 },
  { 5747, 38, 47, 43, 5, -46 },
  { 5971, 41, 46, 44, 3, -46 },
  { 6207, 25, 46, 21, -1, -46 },
  { 6351, 28, 58, 17, -10, -46 },
  { 6554, 39, 46, 36, 3, -46 },
  { 6779, 24, 46, 31, 3, -46 },
  { 6917, 51, 46, 54, 3, -46 },
  { 7211, 43, 46, 45, 3, -46 },
  { 7459, 39, 47, 46, 5, -46 },
  { 7689, 33, 46, 36, 3, -46 },
  { 7879, 39, 57, 46, 5, -46 },
  { 8157, 33, 46, 37, 3, -46 },
  { 8347, 32, 47, 32, 1, -46 },
  { 8535, 32, 46, 32, 6, -46 },
  { 8719, 39, 47, 43, 5, -46 },
  { 8949, 35, 46, 35, 6, -46 },
  { 9151, 53, 46, 55, 7, -46 },
  { 9456, 42, 46, 34, -3, -46 },
  { 9698, 32, 46, 33, 6, -46 },
  { 9882, 38, 46, 34, -1, -46 },
  { 10101, 25, 56, 19, -1, -46 },
  { 10276, 12, 46, 23, 7, -46 },
  { 10345, 25, 56, 19, -5, -46 },
  { 10520, 32, 29, 37, 2, -46 },
  { 10636, 26, 4, 25, -6, 6 },
  { 10649, 11, 10, 18, 9, -49 },
  { 10663, 32, 36, 36, 3, -35 },
  { 10807, 32, 50, 37, 2, -49 },
  { 11007, 27, 36, 29, 3, -35 },
  { 11129, 35, 50, 37, 3, -49 },
  { 11348, 27, 36, 32, 3, -35 },
  { 11470, 35, 64, 20, -7, -49 },
  { 11750, 33, 50, 37, 2, -35 },
  { 11957, 31, 49, 37, 2, -49 },
  { 12147, 15, 47, 17, 2, -47 },
  { 12236, 25, 62, 17, -8, -47 },
  { 12430, 32, 49, 32, 2, -49 },
  { 12626, 16, 49, 17, 2, -49 },
  { 12724, 50, 35, 56, 2, -35 },
  { 12943, 32, 35, 37, 2, -35 },
  { 13083, 30, 36, 36, 3, -35 },
  { 13218, 35, 50, 37, -1, -35 },
  { 13437, 32, 50, 37, 3, -35 },
  { 13637, 25, 35, 25, 2, -35 },
  { 13747, 26, 36, 28, 0, -35 },
  { 13864, 20, 43, 21, 3, -42 },
  { 13972, 31, 35, 37, 4, -34 },
  { 14108, 30, 34, 30, 3, -34 },
  { 14236, 45, 34, 46, 4, -34 },
  { 14428, 35, 34, 31, -2, -34 },
  { 14577, 39, 49, 30, -6, -34 },
  { 14816, 29, 34, 28, -1, -34 },
  { 14940, 25, 56, 22, 1, -46 },
  { 15115, 4, 64, 35, 17, -49 },
  { 15147, 24, 56, 22, -2, -46 },
  { 15315, 31, 9, 37, 4, -27 },
};

const GFXfont NotoSans_Italic64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic64pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_ITALIC64PT7B_H_
