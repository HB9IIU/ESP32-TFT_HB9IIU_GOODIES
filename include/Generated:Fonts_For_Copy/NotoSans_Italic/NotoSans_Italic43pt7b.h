#ifndef _NOTOSANS_ITALIC43PT7B_H_
#define _NOTOSANS_ITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0x00, 0x78, 0x7B, 0xC7,
  0x9E, 0x3C, 0xE1, 0xE7, 0x0F, 0x78, 0x73, 0xC3, 0x9C, 0x1C, 0xE1, 0xC7,
  0x0E, 0x30, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x70,
  0x1C, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x78, 0x1C, 0x00,
  0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x03, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0x0E, 0x03, 0x80, 0x01,
  0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xF0,
  0x00, 0x38, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1E, 0x00,
  0x07, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x03,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFB, 0x9E, 0x07, 0x8E,
  0x10, 0x3C, 0x38, 0x00, 0xF1, 0xC0, 0x03, 0xC7, 0x00, 0x0F, 0x1C, 0x00,
  0x3C, 0x70, 0x00, 0x79, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x73, 0xE0, 0x01, 0xC7,
  0x80, 0x07, 0x1E, 0x00, 0x1C, 0x78, 0x00, 0xE1, 0xE0, 0x03, 0x87, 0x0C,
  0x0E, 0x3C, 0x3F, 0x3F, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x7F, 0x80, 0x07, 0x07, 0xFE,
  0x00, 0x70, 0x38, 0x70, 0x07, 0x83, 0xC3, 0xC0, 0x38, 0x1C, 0x0E, 0x03,
  0x81, 0xE0, 0x70, 0x38, 0x0E, 0x07, 0x83, 0xC0, 0x70, 0x38, 0x1C, 0x03,
  0x81, 0xC1, 0xC0, 0x1C, 0x0E, 0x1C, 0x01, 0xE0, 0x71, 0xE0, 0x0F, 0x07,
  0x0E, 0x3C, 0x78, 0x38, 0xE7, 0xF9, 0xC3, 0xCE, 0x7F, 0xEE, 0x1C, 0xF3,
  0xC7, 0x7F, 0xC7, 0x3C, 0x39, 0xFC, 0x71, 0xC1, 0xC7, 0xC7, 0x9E, 0x0E,
  0x00, 0x78, 0xE0, 0x70, 0x03, 0x87, 0x03, 0x80, 0x38, 0x38, 0x1C, 0x03,
  0xC3, 0xC0, 0xE0, 0x3C, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x70, 0x1C, 0x07,
  0x03, 0x81, 0xE0, 0x38, 0x3C, 0x1E, 0x01, 0xE1, 0xC0, 0xE0, 0x07, 0xBC,
  0x0E, 0x00, 0x3F, 0xE0, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x1E, 0x07,
  0x80, 0x03, 0x80, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x01, 0xC0, 0x03,
  0xC0, 0x78, 0x00, 0x38, 0x1F, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF3, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xFC, 0x01, 0xE3, 0xE3, 0xC0, 0x78, 0xF8, 0x3C, 0x0F,
  0x3E, 0x07, 0xC3, 0xC7, 0x80, 0x78, 0x78, 0xE0, 0x07, 0x9E, 0x3C, 0x00,
  0xFF, 0x87, 0x80, 0x0F, 0xE0, 0xF0, 0x00, 0xFC, 0x1E, 0x00, 0x1F, 0x01,
  0xE0, 0x07, 0xF0, 0x3E, 0x03, 0xFE, 0x03, 0xFF, 0xF9, 0xE0, 0x3F, 0xFC,
  0x3E, 0x03, 0xFF, 0x03, 0xE0, 0x7B, 0xDE, 0xE7, 0x7B, 0xDC, 0xE7, 0x30,
  0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x06, 0x03, 0x80, 0x78, 0x30, 0x0F, 0xE7, 0x00, 0x3F, 0xF0,
  0x10, 0x7F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0x0F, 0x03, 0xB8, 0x00, 0x73,
  0x80, 0x0F, 0x3C, 0x01, 0xE1, 0xC0, 0x3C, 0x1C, 0x01, 0x81, 0xE0, 0x08,
  0x0F, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x87, 0x87,
  0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x70, 0x38, 0x38, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xB0, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0x7F,
  0xF8, 0x07, 0xC3, 0xE0, 0x7C, 0x0F, 0x07, 0xC0, 0x78, 0x3C, 0x01, 0xE3,
  0xC0, 0x0F, 0x1E, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00,
  0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78,
  0x00, 0xF3, 0x80, 0x07, 0x9C, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x1E,
  0x78, 0x00, 0xF3, 0xC0, 0x07, 0x8E, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0,
  0x3C, 0x1E, 0x03, 0xE0, 0x78, 0x3E, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x78, 0x07, 0xC0, 0xFE, 0x0F, 0xE1, 0xFF, 0x1F,
  0xFB, 0xF3, 0xCF, 0x1E, 0x60, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x1F, 0x87, 0xE0, 0x18, 0x03, 0xC0, 0x20, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xF0, 0x7E, 0x03,
  0x00, 0x78, 0x08, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x88,
  0x00, 0x7C, 0x38, 0x03, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xEE, 0x00, 0x07,
  0x9C, 0x00, 0x1E, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xC0, 0x03, 0xC3,
  0x80, 0x0F, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x70,
  0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x81, 0xE0, 0x0F, 0x07,
  0x80, 0x1C, 0x0F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xEF, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xC3, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x20, 0x01, 0xE1, 0xC0, 0x3F, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x1F, 0x81, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0xFE, 0x07, 0xBF, 0xF0, 0x77, 0xFF, 0x8F, 0xE0, 0x7C, 0xFC, 0x03,
  0xCF, 0x80, 0x3C, 0xF0, 0x01, 0xCF, 0x00, 0x1E, 0xF0, 0x01, 0xCE, 0x00,
  0x1C, 0xE0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x78, 0xF8,
  0x0F, 0x87, 0xC1, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xC3, 0xF0, 0x78, 0x07, 0x83,
  0xC0, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x38, 0x03,
  0xC1, 0xE0, 0x3C, 0x0F, 0x03, 0xE0, 0x3C, 0x7E, 0x00, 0xFF, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x00, 0xF8, 0x7C, 0x0F, 0x00, 0xF0,
  0xF0, 0x07, 0x87, 0x80, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00,
  0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x1F, 0x3E, 0x00, 0xF0, 0xF8, 0x1F, 0x87,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x1F,
  0xFC, 0x07, 0xFF, 0xE0, 0xFC, 0x3E, 0x0F, 0x01, 0xF1, 0xE0, 0x0F, 0x1E,
  0x00, 0xF3, 0xC0, 0x07, 0x3C, 0x00, 0x73, 0xC0, 0x07, 0x3C, 0x00, 0x73,
  0x80, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x01, 0xF3, 0xE0, 0x3F,
  0x1F, 0xFE, 0xF0, 0xFF, 0xEE, 0x07, 0xF9, 0xE0, 0x1E, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x08, 0x07, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF,
  0xC0, 0x00, 0x06, 0x07, 0x87, 0xE3, 0xF1, 0xF0, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x60, 0x00, 0x00, 0xC0, 0x1E, 0x03, 0xF0,
  0x3F, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x00,
  0xFC, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xFE,
  0x1F, 0xFF, 0x87, 0x83, 0xE2, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0x80, 0x03,
  0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x07, 0x8F, 0x00, 0xFF, 0x81, 0xC7, 0x01, 0xFF,
  0xE0, 0xE7, 0x81, 0xF9, 0xF0, 0x73, 0x81, 0xE0, 0x70, 0x3B, 0xC1, 0xE0,
  0x38, 0x1D, 0xC0, 0xE0, 0x1C, 0x0E, 0xE0, 0xF0, 0x1E, 0x07, 0x70, 0x70,
  0x0E, 0x03, 0xF8, 0x38, 0x07, 0x01, 0xFC, 0x3C, 0x07, 0x81, 0xFE, 0x1E,
  0x03, 0xC0, 0xEF, 0x0F, 0x01, 0xC0, 0x77, 0x87, 0x81, 0xE0, 0x73, 0xC3,
  0xC1, 0xF0, 0x78, 0xE0, 0xF3, 0xDC, 0x78, 0x70, 0x7F, 0xCF, 0xF8, 0x38,
  0x1F, 0xC3, 0xF8, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x04, 0x00,
  0x0F, 0xC0, 0x1E, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xB8, 0x00,
  0x07, 0xB8, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x38, 0x00, 0x1E, 0x38, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x3C, 0x00,
  0xF0, 0x3C, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x1C, 0x01, 0xE0, 0x1C, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0x80, 0x1E, 0x0F,
  0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x0E, 0x3C,
  0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x78, 0x03, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0,
  0x0F, 0x07, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x01,
  0xE0, 0xF0, 0x0F, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x38, 0x03, 0xE0, 0xF0, 0x03, 0xE1, 0xE0, 0x03, 0xC3,
  0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78,
  0x00, 0x78, 0xF0, 0x01, 0xF1, 0xE0, 0x07, 0xC7, 0x80, 0x7F, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFC, 0x3E, 0x03, 0xF0, 0x02, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x78, 0x07, 0xE0, 0x3C, 0x00, 0xF8,
  0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1F, 0x07, 0x00, 0x07, 0x87, 0x80, 0x03,
  0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8E, 0x00,
  0x03, 0xCF, 0x00, 0x03, 0xE7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0,
  0x00, 0xF8, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x7C, 0x3C,
  0x00, 0xFC, 0x1E, 0x01, 0xFC, 0x1E, 0x07, 0xFC, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xF8, 0x7E, 0x03,
  0xF0, 0x01, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x0F, 0xFC, 0xF0, 0x03, 0xFF, 0x3C, 0x01, 0xFF, 0x8F, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x8F, 0x80, 0x03,
  0xC3, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x03, 0xE0,
  0x03, 0x80, 0xFE, 0x01, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x70, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x03, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x03, 0xC0,
  0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0,
  0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x38, 0x00,
  0x1E, 0x0F, 0x00, 0x03, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x00,
  0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x03,
  0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x43, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0x3C, 0x01,
  0xF0, 0x0E, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x3E, 0x00, 0x78,
  0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0x07, 0xC0, 0x03, 0xC3, 0xE0, 0x00,
  0xF1, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x0E, 0x7C, 0x00, 0x07, 0xBE, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xBC, 0x00, 0x07, 0xCF,
  0x00, 0x03, 0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F,
  0x03, 0xC0, 0x03, 0x80, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x01,
  0xE0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xFC, 0x0F,
  0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xDC, 0x00, 0x0E, 0xE0,
  0x77, 0x00, 0x07, 0xF8, 0x1D, 0xC0, 0x03, 0xDE, 0x0F, 0x78, 0x00, 0xE7,
  0x83, 0xDE, 0x00, 0x79, 0xC0, 0xF3, 0x80, 0x1C, 0xF0, 0x38, 0xE0, 0x0F,
  0x3C, 0x0E, 0x38, 0x03, 0x8F, 0x07, 0x8E, 0x01, 0xE3, 0xC1, 0xE3, 0x80,
  0x70, 0xE0, 0x78, 0xE0, 0x3C, 0x78, 0x1C, 0x3C, 0x0E, 0x1E, 0x07, 0x0F,
  0x07, 0x87, 0x83, 0xC1, 0xC3, 0xC1, 0xE0, 0xF0, 0x70, 0xE0, 0xF0, 0x3C,
  0x1C, 0x78, 0x3C, 0x0E, 0x07, 0x1C, 0x0F, 0x03, 0x81, 0xCF, 0x03, 0xC1,
  0xE0, 0x73, 0x80, 0xE0, 0x78, 0x1D, 0xE0, 0x78, 0x1E, 0x07, 0xF0, 0x1E,
  0x07, 0x00, 0xFC, 0x07, 0x83, 0xC0, 0x3E, 0x01, 0xE0, 0xF0, 0x0F, 0x80,
  0x70, 0x3C, 0x03, 0xC0, 0x3C, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x1F, 0x00, 0x03, 0x80, 0xF8, 0x00, 0x3C, 0x07, 0xC0, 0x01,
  0xE0, 0x7F, 0x00, 0x0F, 0x03, 0xF8, 0x00, 0x78, 0x1D, 0xE0, 0x03, 0x80,
  0xEF, 0x00, 0x3C, 0x0F, 0x38, 0x01, 0xE0, 0x79, 0xE0, 0x0F, 0x03, 0xCF,
  0x00, 0x70, 0x1C, 0x38, 0x03, 0x80, 0xE1, 0xE0, 0x3C, 0x0F, 0x0F, 0x01,
  0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x70, 0x1C, 0x07, 0x07, 0x80,
  0xE0, 0x3C, 0x3C, 0x0F, 0x01, 0xE1, 0xE0, 0x78, 0x07, 0x0F, 0x03, 0xC0,
  0x3C, 0x70, 0x1C, 0x01, 0xE7, 0x80, 0xE0, 0x07, 0xBC, 0x0F, 0x00, 0x3D,
  0xE0, 0x78, 0x00, 0xEF, 0x03, 0xC0, 0x07, 0xF0, 0x1C, 0x00, 0x3F, 0x81,
  0xE0, 0x00, 0xFC, 0x0F, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x3E, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x03,
  0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x7C, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0,
  0x00, 0x07, 0xDE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0xF8,
  0x78, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x1F, 0xC0,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x07,
  0x80, 0x7C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x00,
  0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x7C,
  0x78, 0x01, 0xE1, 0xE0, 0x1F, 0x87, 0x83, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF8,
  0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x03, 0xC0,
  0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x7C,
  0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00,
  0x07, 0xDE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x78, 0x78,
  0x00, 0x1E, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x1F, 0xC0, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0x80,
  0x7C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x00, 0x3C,
  0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0E, 0x00, 0x7C, 0x78,
  0x03, 0xE1, 0xE0, 0x3F, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8,
  0x03, 0xC1, 0xE0, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03,
  0x80, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x0F, 0x07, 0x80,
  0x3C, 0x3C, 0x00, 0xF8, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xE1, 0xF0,
  0x78, 0x01, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x20, 0x03, 0xE1,
  0xC0, 0x3F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0,
  0x00, 0x3C, 0x1E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C,
  0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1C, 0x1E, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x78, 0x3C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x0F, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x1F,
  0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0x70, 0x00, 0x78,
  0x70, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0,
  0x78, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x0F, 0x00, 0x38, 0x0F, 0x00, 0x38, 0x1E, 0x00, 0x38, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x70, 0x00,
  0x3C, 0xF0, 0x00, 0x3C, 0xE0, 0x00, 0x1D, 0xE0, 0x00, 0x1D, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0xE0, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0x00, 0x1E,
  0xE0, 0x01, 0xF0, 0x03, 0xEE, 0x00, 0x3F, 0x00, 0x3C, 0xF0, 0x03, 0xF0,
  0x03, 0xCF, 0x00, 0x77, 0x00, 0x78, 0xF0, 0x07, 0x70, 0x07, 0x8F, 0x00,
  0xF7, 0x00, 0xF0, 0xF0, 0x0E, 0x70, 0x0F, 0x0F, 0x01, 0xE7, 0x01, 0xE0,
  0xF0, 0x1C, 0x70, 0x1E, 0x0F, 0x03, 0xC7, 0x01, 0xC0, 0xF0, 0x38, 0x70,
  0x3C, 0x0F, 0x07, 0x87, 0x03, 0xC0, 0xF0, 0x70, 0x70, 0x78, 0x0F, 0x0F,
  0x07, 0x07, 0x80, 0xF0, 0xF0, 0x70, 0xF0, 0x0F, 0x0E, 0x07, 0x0F, 0x00,
  0xF1, 0xE0, 0x70, 0xE0, 0x0F, 0x1C, 0x07, 0x1E, 0x00, 0xF3, 0xC0, 0x71,
  0xC0, 0x0F, 0x38, 0x07, 0xBC, 0x00, 0x77, 0x80, 0x7B, 0x80, 0x07, 0x70,
  0x07, 0xB8, 0x00, 0x77, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x1E, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1C,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0xF0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0x38, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xE7, 0x00, 0x0F, 0x1E, 0x00, 0x7C, 0x78,
  0x01, 0xE1, 0xE0, 0x0F, 0x03, 0x80, 0x7C, 0x0E, 0x01, 0xE0, 0x3C, 0x0F,
  0x00, 0xF0, 0x7C, 0x01, 0xC1, 0xE0, 0x07, 0x0F, 0x00, 0x1E, 0x3C, 0x00,
  0x79, 0xE0, 0x00, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xE0, 0xE0, 0xE0, 0xF0, 0xF0,
  0xF0, 0x70, 0x70, 0x70, 0x70, 0x78, 0x78, 0x78, 0x38, 0x38, 0x38, 0x38,
  0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1E, 0x1E, 0x1E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0F, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80,
  0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xCE, 0x00, 0x0E, 0x70,
  0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x3C,
  0x07, 0x01, 0xC0, 0x38, 0x1E, 0x00, 0xE0, 0xE0, 0x07, 0x0F, 0x00, 0x1C,
  0x70, 0x00, 0xE3, 0x80, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0x70, 0x7F,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0xF0, 0xF1, 0xE1, 0xE1, 0xC1, 0xC1,
  0x80, 0x01, 0xFE, 0x1C, 0x0F, 0xFC, 0xE0, 0x7F, 0xFB, 0x83, 0xE0, 0xFE,
  0x1F, 0x01, 0xF8, 0xF8, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x78,
  0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0E, 0x3C, 0x00, 0x78, 0xF0, 0x01,
  0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x3E, 0x3C, 0x00, 0xF0, 0xF0, 0x07, 0xC3,
  0xC0, 0x3F, 0x0F, 0x01, 0xFC, 0x1E, 0x0E, 0xF0, 0x7F, 0xFB, 0x80, 0xFF,
  0x8E, 0x01, 0xFC, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0xFE, 0x01,
  0xC7, 0xFC, 0x07, 0x7F, 0xF8, 0x3F, 0xC1, 0xE0, 0xFC, 0x07, 0x83, 0xE0,
  0x0F, 0x0F, 0x80, 0x3C, 0x7C, 0x00, 0xF1, 0xF0, 0x03, 0xC7, 0x80, 0x0F,
  0x1E, 0x00, 0x3C, 0x70, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C,
  0x00, 0x78, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x1F, 0x00, 0x78, 0x7E, 0x03,
  0xE1, 0xD8, 0x1F, 0x07, 0x7F, 0xF8, 0x1C, 0xFF, 0xC0, 0xE1, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF8, 0x3E, 0x02, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x18, 0x3F, 0xFE, 0x07,
  0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x01, 0xFE,
  0x3C, 0x03, 0xFF, 0x38, 0x07, 0xFF, 0xB8, 0x0F, 0x83, 0xF8, 0x1F, 0x01,
  0xF8, 0x3E, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0x78, 0x00,
  0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01,
  0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xC0, 0xF0, 0x07,
  0xC0, 0xF0, 0x0F, 0xC0, 0xF0, 0x1F, 0xC0, 0x78, 0x3B, 0x80, 0x7F, 0xF3,
  0x80, 0x3F, 0xE3, 0x80, 0x1F, 0xC3, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0xE0,
  0x7F, 0xFC, 0x3E, 0x0F, 0x1E, 0x03, 0xCF, 0x80, 0xF3, 0xC0, 0x3D, 0xE0,
  0x0F, 0x78, 0x0F, 0x9E, 0x0F, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xC0,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x18, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xE2, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x0E, 0x03,
  0xFF, 0x38, 0x0F, 0xFF, 0x70, 0x3E, 0x0F, 0xE0, 0xF8, 0x0F, 0xC3, 0xE0,
  0x0F, 0x87, 0x80, 0x1E, 0x1F, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00,
  0xF0, 0xF0, 0x01, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E,
  0x1E, 0x00, 0x7C, 0x3C, 0x00, 0xF0, 0x78, 0x03, 0xE0, 0xF0, 0x0F, 0xC1,
  0xE0, 0x3F, 0x81, 0xE0, 0xEE, 0x03, 0xFF, 0x9C, 0x03, 0xFE, 0x78, 0x03,
  0xF8, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x08, 0x00, 0xF0, 0x1C, 0x07, 0xC0, 0x3F, 0xFF,
  0x80, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE3, 0xF8,
  0x0E, 0x3F, 0xE0, 0x77, 0xFF, 0x87, 0xF8, 0x3C, 0x3F, 0x01, 0xE1, 0xF0,
  0x07, 0x0F, 0x80, 0x38, 0xF8, 0x03, 0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xF1,
  0xE0, 0x07, 0x8E, 0x00, 0x38, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00,
  0xF1, 0xE0, 0x07, 0x8E, 0x00, 0x38, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C,
  0x00, 0xF1, 0xE0, 0x07, 0x8E, 0x00, 0x38, 0xF0, 0x03, 0xC0, 0x00, 0xC0,
  0x38, 0x0F, 0x81, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x10, 0x78, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0,
  0x3C, 0x0F, 0x00, 0xF0, 0x78, 0x03, 0xC3, 0xC0, 0x0E, 0x1E, 0x00, 0x78,
  0xF0, 0x01, 0xE7, 0x80, 0x07, 0xBC, 0x00, 0x1D, 0xF0, 0x00, 0x7F, 0xC0,
  0x03, 0xF7, 0x80, 0x0F, 0x9E, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03,
  0x81, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0xC0, 0x01, 0xE0, 0x3C, 0x07, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1C, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x0F, 0xE0, 0x7F, 0x01, 0xCF, 0xFC,
  0x3F, 0xE0, 0x77, 0xFF, 0x3F, 0xFC, 0x3F, 0xC3, 0xCE, 0x0F, 0x0F, 0xC0,
  0x7F, 0x03, 0xC3, 0xE0, 0x1F, 0x80, 0xF0, 0xF8, 0x07, 0xC0, 0x3C, 0x7C,
  0x01, 0xE0, 0x0F, 0x1F, 0x00, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x00, 0xF1,
  0xE0, 0x0F, 0x00, 0x38, 0x70, 0x03, 0xC0, 0x1E, 0x3C, 0x00, 0xF0, 0x07,
  0x8F, 0x00, 0x38, 0x01, 0xE3, 0xC0, 0x1E, 0x00, 0x78, 0xF0, 0x07, 0x80,
  0x1C, 0x38, 0x01, 0xE0, 0x0F, 0x1E, 0x00, 0x78, 0x03, 0xC7, 0x80, 0x1C,
  0x00, 0xF1, 0xE0, 0x0F, 0x00, 0x3C, 0x78, 0x03, 0xC0, 0x1E, 0x1C, 0x00,
  0xF0, 0x07, 0x8F, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x01, 0x80, 0x1C, 0x3F,
  0xC0, 0x73, 0xFF, 0x83, 0xDF, 0xFE, 0x0F, 0xF0, 0x78, 0x3F, 0x81, 0xF0,
  0xFC, 0x03, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x78, 0x7C, 0x01, 0xE1, 0xE0,
  0x07, 0x87, 0x80, 0x1E, 0x3E, 0x00, 0xF8, 0xF0, 0x03, 0xC3, 0xC0, 0x0F,
  0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0xC7, 0x80, 0x1E, 0x1E,
  0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x3C, 0x00,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xF8, 0x3E, 0x1E,
  0x01, 0xE3, 0xE0, 0x0F, 0x3C, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7,
  0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0x78, 0x07,
  0x87, 0xC0, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x01,
  0xC3, 0xF8, 0x01, 0xC7, 0xFC, 0x01, 0xDF, 0xFE, 0x03, 0xFC, 0x1E, 0x03,
  0xF0, 0x1E, 0x03, 0xE0, 0x0F, 0x03, 0xE0, 0x0F, 0x07, 0xC0, 0x0F, 0x07,
  0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x00, 0x1E, 0x0F,
  0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3C, 0x0F,
  0x00, 0x3C, 0x1F, 0x00, 0x78, 0x1F, 0x80, 0xF8, 0x1D, 0x81, 0xF0, 0x1D,
  0xFF, 0xE0, 0x1C, 0xFF, 0xC0, 0x3C, 0x7F, 0x80, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x1C, 0x0F, 0xFC, 0xE0, 0x7F, 0xFB, 0x83, 0xE0,
  0xFE, 0x1F, 0x01, 0xF8, 0xF8, 0x03, 0xC3, 0xC0, 0x0F, 0x1F, 0x00, 0x3C,
  0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0E, 0x3C, 0x00, 0x78, 0xF0,
  0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x3E, 0x3C, 0x00, 0xF0, 0xF0, 0x07,
  0xC3, 0xC0, 0x3F, 0x0F, 0x01, 0xFC, 0x1E, 0x0E, 0xF0, 0x7F, 0xF3, 0x80,
  0xFF, 0x9E, 0x01, 0xFC, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x07, 0x0F, 0x83,
  0x9F, 0xC1, 0xDF, 0xE1, 0xFE, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x03, 0xFF,
  0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x7C, 0x06, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC8, 0x01, 0xE3, 0x00, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x07,
  0xFF, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFE, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xFF, 0x07,
  0xFC, 0x0F, 0xF0, 0x0F, 0x00, 0x3C, 0x78, 0x00, 0xE1, 0xE0, 0x07, 0x87,
  0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xC3, 0xC0, 0x0F, 0x0F, 0x00,
  0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0x80, 0x0E, 0x1E, 0x00, 0x78,
  0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x1C, 0x00, 0xF0, 0xF0,
  0x07, 0xC3, 0xC0, 0x3F, 0x0F, 0x01, 0xFC, 0x1E, 0x0E, 0xF0, 0x7F, 0xF3,
  0x81, 0xFF, 0x8E, 0x01, 0xFC, 0x38, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x1E,
  0xF0, 0x01, 0xEF, 0x00, 0x3C, 0x70, 0x03, 0xC7, 0x00, 0x78, 0x78, 0x07,
  0x87, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x07, 0x83,
  0xC0, 0x38, 0x78, 0x03, 0x87, 0x80, 0x38, 0xF0, 0x03, 0x8F, 0x00, 0x39,
  0xE0, 0x03, 0x9E, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0xE0, 0x0F, 0x80,
  0x79, 0xC0, 0x3F, 0x00, 0xF3, 0x80, 0x7E, 0x03, 0xC7, 0x01, 0xDC, 0x07,
  0x8E, 0x03, 0xB8, 0x1E, 0x1C, 0x0F, 0x70, 0x3C, 0x38, 0x1C, 0xE0, 0xF0,
  0x70, 0x79, 0xC1, 0xE0, 0xE0, 0xE3, 0x87, 0x81, 0xC3, 0xC7, 0x0F, 0x03,
  0x87, 0x0E, 0x1C, 0x07, 0x9E, 0x1C, 0x78, 0x0F, 0x38, 0x38, 0xE0, 0x1E,
  0x70, 0x73, 0xC0, 0x3D, 0xC0, 0xE7, 0x80, 0x73, 0x81, 0xCE, 0x00, 0xEE,
  0x03, 0xBC, 0x01, 0xDC, 0x07, 0x70, 0x03, 0xB8, 0x0F, 0xE0, 0x07, 0xE0,
  0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x1F, 0x03, 0xC0, 0x3E, 0x01, 0xC0, 0x3C, 0x01, 0xE0, 0x78, 0x01,
  0xE0, 0xF0, 0x00, 0xF1, 0xE0, 0x00, 0xF3, 0xC0, 0x00, 0x73, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xE7, 0x00, 0x03,
  0xC7, 0x80, 0x07, 0x87, 0x80, 0x0F, 0x03, 0xC0, 0x1F, 0x03, 0xC0, 0x3E,
  0x01, 0xE0, 0x3C, 0x01, 0xE0, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0,
  0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x07, 0x00, 0x3C, 0x01, 0xC0, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x01, 0xE0,
  0x3C, 0x00, 0x78, 0x1E, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0xE1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x77, 0x80, 0x00, 0x1D, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0x80,
  0x0B, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x0F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xC0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x17, 0xFE, 0x03, 0xFF, 0xFE,
  0xFE, 0x1F, 0xFF, 0x80, 0x3F, 0xE8, 0x00, 0x38,
};

const GFXglyph NotoSans_Italic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 11, 32, 11, 1, -31 },
  { 45, 13, 11, 17, 5, -31 },
  { 63, 27, 31, 28, 1, -31 },
  { 168, 22, 36, 24, 1, -33 },
  { 267, 29, 31, 34, 3, -31 },
  { 380, 27, 31, 29, 1, -31 },
  { 485, 5, 11, 9, 5, -31 },
  { 492, 14, 38, 12, 2, -31 },
  { 559, 14, 38, 12, -3, -31 },
  { 626, 20, 20, 24, 4, -33 },
  { 676, 20, 21, 25, 3, -26 },
  { 729, 9, 11, 11, -2, -5 },
  { 742, 11, 3, 13, 1, -13 },
  { 747, 5, 6, 11, 1, -5 },
  { 751, 21, 31, 15, -2, -31 },
  { 833, 21, 31, 24, 2, -31 },
  { 915, 13, 31, 24, 6, -31 },
  { 966, 23, 31, 24, 0, -31 },
  { 1056, 22, 31, 24, 1, -31 },
  { 1142, 23, 31, 24, 0, -31 },
  { 1232, 21, 31, 24, 2, -31 },
  { 1314, 20, 31, 24, 3, -31 },
  { 1392, 21, 31, 24, 3, -31 },
  { 1474, 21, 31, 24, 2, -31 },
  { 1556, 20, 31, 24, 2, -31 },
  { 1634, 9, 25, 11, 1, -24 },
  { 1663, 12, 30, 11, -2, -24 },
  { 1708, 20, 21, 25, 3, -26 },
  { 1761, 20, 12, 25, 3, -21 },
  { 1791, 20, 21, 25, 3, -26 },
  { 1844, 17, 32, 18, 3, -31 },
  { 1912, 33, 35, 36, 2, -31 },
  { 2057, 24, 31, 24, -2, -31 },
  { 2150, 23, 31, 26, 2, -31 },
  { 2240, 24, 31, 25, 3, -31 },
  { 2333, 25, 31, 29, 2, -31 },
  { 2430, 22, 31, 22, 2, -31 },
  { 2516, 22, 31, 21, 2, -31 },
  { 2602, 26, 31, 29, 3, -31 },
  { 2703, 27, 31, 29, 2, -31 },
  { 2808, 17, 31, 14, -1, -31 },
  { 2874, 19, 39, 12, -7, -31 },
  { 2967, 26, 31, 24, 2, -31 },
  { 3068, 16, 31, 21, 2, -31 },
  { 3130, 34, 31, 36, 2, -31 },
  { 3262, 29, 31, 30, 2, -31 },
  { 3375, 27, 31, 31, 3, -31 },
  { 3480, 22, 31, 24, 2, -31 },
  { 3566, 27, 38, 31, 3, -31 },
  { 3695, 22, 31, 25, 2, -31 },
  { 3781, 21, 31, 22, 1, -31 },
  { 3863, 21, 31, 22, 4, -31 },
  { 3945, 27, 31, 29, 3, -31 },
  { 4050, 24, 31, 24, 4, -31 },
  { 4143, 36, 31, 37, 5, -31 },
  { 4283, 28, 31, 23, -2, -31 },
  { 4392, 22, 31, 22, 4, -31 },
  { 4478, 25, 31, 23, 0, -31 },
  { 4575, 16, 38, 12, 0, -31 },
  { 4651, 8, 31, 15, 5, -31 },
  { 4682, 16, 38, 12, -3, -31 },
  { 4758, 21, 20, 25, 2, -31 },
  { 4811, 18, 3, 17, -4, 4 },
  { 4818, 7, 7, 12, 6, -33 },
  { 4825, 22, 23, 24, 2, -23 },
  { 4889, 22, 33, 25, 1, -33 },
  { 4980, 18, 23, 19, 2, -23 },
  { 5032, 24, 33, 25, 2, -33 },
  { 5131, 18, 23, 21, 2, -23 },
  { 5183, 24, 43, 14, -5, -33 },
  { 5312, 23, 33, 25, 1, -23 },
  { 5407, 21, 33, 25, 1, -33 },
  { 5494, 11, 32, 11, 1, -32 },
  { 5538, 17, 42, 11, -5, -32 },
  { 5628, 22, 33, 21, 1, -33 },
  { 5719, 11, 33, 11, 1, -33 },
  { 5765, 34, 23, 38, 1, -23 },
  { 5863, 22, 24, 25, 1, -24 },
  { 5929, 20, 23, 24, 2, -23 },
  { 5987, 24, 33, 25, -1, -23 },
  { 6086, 22, 33, 25, 2, -23 },
  { 6177, 17, 23, 17, 1, -23 },
  { 6226, 18, 23, 19, 0, -23 },
  { 6278, 14, 28, 14, 2, -28 },
  { 6327, 22, 23, 25, 2, -23 },
  { 6391, 20, 23, 20, 2, -23 },
  { 6449, 31, 23, 31, 2, -23 },
  { 6539, 24, 23, 21, -2, -23 },
  { 6608, 26, 33, 20, -4, -23 },
  { 6716, 20, 23, 19, -1, -23 },
  { 6774, 17, 38, 15, 0, -31 },
  { 6855, 3, 43, 24, 11, -33 },
  { 6872, 17, 38, 15, -2, -31 },
  { 6953, 20, 6, 25, 3, -18 },
};

const GFXfont NotoSans_Italic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic43pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_ITALIC43PT7B_H_
