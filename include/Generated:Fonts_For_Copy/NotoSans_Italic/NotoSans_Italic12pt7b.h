#ifndef _NOTOSANS_ITALIC12PT7B_H_
#define _NOTOSANS_ITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xB4, 0x90, 0xC0, 0x55, 0xAA, 0x0A, 0x12, 0x12, 0x7F, 0x24,
  0x24, 0xFA, 0x48, 0x48, 0x08, 0xF7, 0x1C, 0x30, 0x61, 0x7E, 0x20, 0x80,
  0x61, 0x92, 0x94, 0xA8, 0xAF, 0x55, 0x29, 0x49, 0xC6, 0x18, 0x24, 0x24,
  0x2C, 0x30, 0x4B, 0x8A, 0xC4, 0x7A, 0x5A, 0x13, 0x24, 0x44, 0x48, 0x44,
  0x40, 0x21, 0x11, 0x11, 0x12, 0x24, 0x80, 0x13, 0x43, 0xD4, 0x50, 0x21,
  0x3E, 0x42, 0x10, 0x6A, 0x00, 0xE0, 0xC0, 0x04, 0x10, 0x82, 0x10, 0x82,
  0x10, 0xC0, 0x32, 0x73, 0x18, 0xC6, 0x32, 0xF0, 0x2E, 0x94, 0x92, 0xC0,
  0x18, 0x90, 0x41, 0x08, 0x42, 0x10, 0xFC, 0x18, 0x90, 0x41, 0x38, 0x20,
  0x42, 0xF8, 0x04, 0x31, 0x4D, 0x29, 0x2F, 0xC2, 0x18, 0x3C, 0x82, 0x08,
  0x78, 0x10, 0x43, 0xF8, 0x1C, 0x84, 0x20, 0xFA, 0x28, 0xA6, 0xF0, 0xFC,
  0x20, 0x84, 0x10, 0x86, 0x10, 0x80, 0x31, 0x24, 0xD2, 0x72, 0x68, 0xA2,
  0xF0, 0x32, 0x63, 0x19, 0xB4, 0x62, 0xE0, 0x2C, 0x00, 0x30, 0x13, 0x00,
  0x02, 0x44, 0x80, 0x09, 0xB0, 0xC1, 0x84, 0xF8, 0x3E, 0xC1, 0x82, 0x3E,
  0x40, 0x69, 0x11, 0x24, 0x80, 0x80, 0x0C, 0x19, 0x90, 0x33, 0xDA, 0x4D,
  0x26, 0xB5, 0x6C, 0x80, 0x3E, 0x00, 0x04, 0x18, 0x30, 0xA1, 0x27, 0xC8,
  0xA1, 0xC2, 0x38, 0x4C, 0x89, 0x17, 0xC8, 0x91, 0xA2, 0xF8, 0x1E, 0x49,
  0x04, 0x08, 0x10, 0x20, 0x60, 0x78, 0x38, 0x26, 0x22, 0x23, 0x63, 0x42,
  0x42, 0x44, 0xF8, 0x3E, 0x40, 0x81, 0x07, 0xC8, 0x10, 0x20, 0xF8, 0x3E,
  0x40, 0x81, 0x07, 0xC8, 0x10, 0x20, 0xC0, 0x1C, 0x45, 0x04, 0x08, 0xF0,
  0xA1, 0x62, 0x7C, 0x21, 0x21, 0x21, 0x21, 0x7E, 0x42, 0x42, 0x42, 0xC4,
  0x79, 0x08, 0x42, 0x31, 0x08, 0xE0, 0x08, 0x42, 0x11, 0x88, 0x42, 0x11,
  0x38, 0x23, 0x26, 0x24, 0x28, 0x70, 0x48, 0x48, 0x48, 0xC4, 0x21, 0x08,
  0x46, 0x21, 0x08, 0xF8, 0x30, 0xCC, 0x33, 0x14, 0xC6, 0x52, 0x94, 0xA4,
  0xC9, 0x32, 0xC9, 0x00, 0x20, 0x98, 0x8C, 0x45, 0x24, 0x92, 0x51, 0x18,
  0x8C, 0xC6, 0x00, 0x18, 0xCD, 0x0C, 0x18, 0x30, 0x60, 0xE2, 0x78, 0x38,
  0x4C, 0x89, 0x16, 0x4F, 0x10, 0x20, 0xC0, 0x18, 0xCD, 0x0C, 0x18, 0x30,
  0x60, 0xE2, 0x78, 0x30, 0x30, 0x38, 0x4C, 0x89, 0x16, 0xCB, 0x12, 0x26,
  0xC4, 0x18, 0x94, 0x18, 0x30, 0x20, 0x82, 0xF0, 0xFC, 0xC2, 0x08, 0x20,
  0x84, 0x10, 0x40, 0x42, 0x85, 0x0A, 0x18, 0x50, 0xA1, 0x46, 0x78, 0x83,
  0x0A, 0x34, 0x45, 0x8A, 0x1C, 0x30, 0x40, 0x84, 0x63, 0x18, 0xCA, 0x52,
  0x95, 0x39, 0x46, 0x51, 0x18, 0x46, 0x00, 0x21, 0x12, 0x12, 0x0C, 0x08,
  0x18, 0x24, 0x24, 0xC6, 0x86, 0x24, 0x94, 0x61, 0x84, 0x10, 0x40, 0x3E,
  0x0C, 0x10, 0x41, 0x04, 0x18, 0x20, 0xF8, 0x32, 0x24, 0x44, 0x44, 0x88,
  0xC0, 0x91, 0x24, 0x92, 0x60, 0x38, 0x84, 0x21, 0x08, 0x84, 0x21, 0x38,
  0x10, 0xC2, 0x92, 0x47, 0x10, 0xF8, 0x90, 0x25, 0x68, 0xA2, 0x8A, 0x6F,
  0x00, 0x20, 0x82, 0x8D, 0x65, 0x14, 0x53, 0xB8, 0x32, 0x61, 0x08, 0x43,
  0xC0, 0x04, 0x12, 0x56, 0x8A, 0x28, 0xA6, 0xF0, 0x22, 0xE7, 0xE8, 0x43,
  0xC0, 0x0C, 0x41, 0x8C, 0x30, 0x82, 0x08, 0x21, 0x04, 0x30, 0x12, 0x59,
  0x12, 0x24, 0x49, 0x9E, 0x04, 0x89, 0xE0, 0x20, 0x82, 0x95, 0x65, 0x14,
  0x51, 0x88, 0x24, 0x14, 0x92, 0x80, 0x08, 0x40, 0x11, 0x08, 0x42, 0x21,
  0x09, 0x80, 0x20, 0x82, 0x5A, 0x51, 0xC5, 0x16, 0x88, 0x24, 0xB4, 0x92,
  0x80, 0x28, 0x95, 0xD6, 0x45, 0x11, 0x44, 0x92, 0x28, 0x88, 0x09, 0xD6,
  0x51, 0x45, 0x1C, 0x80, 0x22, 0xE3, 0x18, 0xCF, 0xC0, 0x29, 0x56, 0x51,
  0x45, 0x3B, 0xA0, 0x82, 0x00, 0x25, 0x68, 0xA2, 0x8A, 0x6F, 0x04, 0x10,
  0x40, 0x2A, 0x98, 0x84, 0x22, 0x00, 0x32, 0x50, 0xC1, 0x0B, 0xC0, 0x5D,
  0x49, 0x26, 0xCE, 0x28, 0xA2, 0x9B, 0xC0, 0x8C, 0xAD, 0x4E, 0x60, 0x91,
  0xAA, 0xAA, 0xCC, 0xCC, 0x88, 0x4C, 0xC3, 0x0C, 0x52, 0x20, 0x22, 0x48,
  0x91, 0x43, 0x06, 0x08, 0x10, 0xC0, 0x78, 0x88, 0xC4, 0x78, 0x08, 0x88,
  0x42, 0x61, 0x08, 0x42, 0x18, 0xFF, 0xF0, 0x42, 0x22, 0x23, 0x24, 0x44,
  0x80, 0xEC, 0xC0,
};

const GFXglyph NotoSans_Italic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 4, 4, 5, 1, -9 },
  { 7, 8, 9, 8, 0, -9 },
  { 16, 6, 10, 7, 0, -9 },
  { 24, 8, 9, 10, 1, -9 },
  { 33, 8, 9, 8, 0, -9 },
  { 42, 2, 4, 3, 1, -9 },
  { 43, 4, 11, 3, 0, -9 },
  { 49, 4, 11, 3, -1, -9 },
  { 55, 6, 5, 7, 1, -9 },
  { 59, 5, 6, 7, 1, -7 },
  { 63, 3, 3, 3, -1, -1 },
  { 65, 3, 1, 4, 0, -4 },
  { 66, 2, 1, 3, 0, -1 },
  { 67, 6, 9, 4, -1, -9 },
  { 74, 5, 9, 7, 1, -9 },
  { 80, 3, 9, 7, 2, -9 },
  { 84, 6, 9, 7, 0, -9 },
  { 91, 6, 9, 7, 0, -9 },
  { 98, 6, 9, 7, 0, -9 },
  { 105, 6, 9, 7, 0, -9 },
  { 112, 6, 9, 7, 1, -9 },
  { 119, 6, 9, 7, 1, -9 },
  { 126, 6, 9, 7, 1, -9 },
  { 133, 5, 9, 7, 1, -9 },
  { 139, 3, 7, 3, 0, -7 },
  { 142, 4, 9, 3, -1, -7 },
  { 147, 5, 6, 7, 1, -7 },
  { 151, 5, 3, 7, 1, -6 },
  { 153, 5, 6, 7, 1, -7 },
  { 157, 4, 9, 5, 1, -9 },
  { 162, 9, 10, 10, 1, -9 },
  { 174, 7, 9, 7, -1, -9 },
  { 182, 7, 9, 7, 0, -9 },
  { 190, 7, 9, 7, 1, -9 },
  { 198, 8, 9, 8, 0, -9 },
  { 207, 7, 9, 6, 0, -9 },
  { 215, 7, 9, 6, 0, -9 },
  { 223, 7, 9, 8, 1, -9 },
  { 231, 8, 9, 8, 0, -9 },
  { 240, 5, 9, 4, 0, -9 },
  { 246, 5, 11, 3, -2, -9 },
  { 253, 8, 9, 7, 0, -9 },
  { 262, 5, 9, 6, 0, -9 },
  { 268, 10, 9, 10, 0, -9 },
  { 280, 9, 9, 8, 0, -9 },
  { 291, 7, 9, 9, 1, -9 },
  { 299, 7, 9, 7, 0, -9 },
  { 307, 7, 11, 9, 1, -9 },
  { 317, 7, 9, 7, 0, -9 },
  { 325, 6, 9, 6, 0, -9 },
  { 332, 6, 9, 6, 1, -9 },
  { 339, 7, 9, 8, 1, -9 },
  { 347, 7, 9, 7, 1, -9 },
  { 355, 10, 9, 10, 1, -9 },
  { 367, 8, 9, 6, -1, -9 },
  { 376, 6, 9, 6, 1, -9 },
  { 383, 7, 9, 6, 0, -9 },
  { 391, 4, 11, 3, 0, -9 },
  { 397, 3, 9, 4, 1, -9 },
  { 401, 5, 11, 3, -1, -9 },
  { 408, 6, 6, 7, 0, -9 },
  { 413, 5, 1, 5, -1, 1 },
  { 414, 2, 2, 3, 2, -9 },
  { 415, 6, 7, 7, 1, -7 },
  { 421, 6, 9, 7, 0, -9 },
  { 428, 5, 7, 5, 1, -7 },
  { 433, 6, 9, 7, 1, -9 },
  { 440, 5, 7, 6, 1, -7 },
  { 445, 6, 12, 4, -1, -9 },
  { 454, 7, 10, 7, 0, -7 },
  { 463, 6, 9, 7, 0, -9 },
  { 470, 3, 9, 3, 0, -9 },
  { 474, 5, 12, 3, -2, -9 },
  { 482, 6, 9, 6, 0, -9 },
  { 489, 3, 9, 3, 0, -9 },
  { 493, 10, 7, 11, 0, -7 },
  { 502, 6, 7, 7, 0, -7 },
  { 508, 5, 7, 7, 1, -7 },
  { 513, 6, 10, 7, 0, -7 },
  { 521, 6, 10, 7, 1, -7 },
  { 529, 5, 7, 5, 0, -7 },
  { 534, 5, 7, 5, 0, -7 },
  { 539, 3, 8, 4, 1, -8 },
  { 542, 6, 6, 7, 1, -6 },
  { 547, 5, 6, 6, 1, -6 },
  { 551, 8, 6, 9, 1, -6 },
  { 557, 6, 6, 6, 0, -6 },
  { 562, 7, 9, 6, -1, -6 },
  { 570, 5, 6, 5, 0, -6 },
  { 574, 5, 11, 4, 0, -9 },
  { 581, 1, 12, 7, 3, -9 },
  { 583, 4, 11, 4, 0, -9 },
  { 589, 5, 2, 7, 1, -5 },
};

const GFXfont NotoSans_Italic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic12pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_ITALIC12PT7B_H_
