#ifndef _NOTOSANS_ITALIC9PT7B_H_
#define _NOTOSANS_ITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x20, 0xB8, 0x29, 0xF2, 0xBE, 0x51, 0x40, 0x13, 0xD8, 0xC3,
  0x59, 0x88, 0x42, 0xAB, 0x3B, 0xB5, 0x59, 0x80, 0x10, 0xA5, 0x88, 0x56,
  0x67, 0x80, 0xC0, 0x29, 0x49, 0x30, 0x24, 0x92, 0x70, 0x2A, 0x5A, 0x4F,
  0x44, 0xC0, 0xE0, 0x80, 0x12, 0x44, 0x88, 0x69, 0x99, 0x9A, 0xE0, 0xE5,
  0x24, 0x80, 0x32, 0x42, 0x22, 0x23, 0xC0, 0x32, 0x42, 0x61, 0x0B, 0xC0,
  0x19, 0x95, 0x2F, 0x88, 0x7A, 0x1C, 0x21, 0x78, 0x34, 0x8E, 0x9A, 0xE0,
  0xF2, 0x24, 0x48, 0x32, 0x52, 0x65, 0x49, 0xC0, 0x32, 0x52, 0x93, 0x0B,
  0x80, 0x40, 0x80, 0x40, 0xA0, 0x3C, 0x43, 0xFF, 0xC3, 0x68, 0x54, 0xA8,
  0x20, 0x3E, 0xB6, 0x9D, 0x5B, 0x68, 0x0E, 0x00, 0x18, 0x62, 0x8E, 0x47,
  0x10, 0x7A, 0x5C, 0x94, 0xF8, 0x32, 0x61, 0x08, 0x43, 0xC0, 0x79, 0x14,
  0x51, 0x4B, 0xC0, 0x7A, 0x1C, 0x84, 0x78, 0x7A, 0x1C, 0x84, 0x40, 0x32,
  0x61, 0x2A, 0xCB, 0xC0, 0x65, 0x17, 0xD2, 0x4A, 0x20, 0x69, 0x25, 0x80,
  0x32, 0x22, 0x24, 0x48, 0x6D, 0x46, 0x14, 0x52, 0x60, 0x64, 0x44, 0x4F,
  0x23, 0x66, 0x66, 0x6A, 0x52, 0x94, 0x25, 0x95, 0x55, 0x4A, 0x20, 0x32,
  0x63, 0x18, 0xC7, 0xC0, 0x7A, 0x56, 0xC4, 0x40, 0x32, 0x63, 0x18, 0xC7,
  0xC4, 0x10, 0x7A, 0x52, 0xE5, 0x4C, 0x32, 0x50, 0xC1, 0x0B, 0x80, 0xF4,
  0x44, 0x48, 0x8C, 0x63, 0x29, 0x70, 0x9C, 0xA9, 0x4C, 0x60, 0x93, 0x66,
  0xD6, 0xAC, 0x91, 0x00, 0x49, 0x88, 0xC5, 0x48, 0x9A, 0xC4, 0x48, 0x78,
  0x88, 0x84, 0x78, 0x69, 0x29, 0x30, 0xAA, 0x50, 0x32, 0x22, 0x22, 0xC0,
  0x22, 0x95, 0x10, 0xF0, 0x90, 0x3A, 0x63, 0x27, 0x00, 0x22, 0x1C, 0x94,
  0xCB, 0xC0, 0x34, 0x88, 0x60, 0x08, 0x4E, 0x98, 0xC9, 0xC0, 0x35, 0x68,
  0x70, 0x19, 0x1C, 0x42, 0x11, 0x08, 0xC0, 0x3A, 0x63, 0x27, 0x0B, 0x80,
  0x22, 0x1C, 0x94, 0xCA, 0x40, 0x45, 0x68, 0x20, 0x92, 0x92, 0xC0, 0x22,
  0x16, 0xC6, 0x52, 0x40, 0x29, 0x25, 0x20, 0x76, 0x95, 0x4C, 0x99, 0x20,
  0x7A, 0x53, 0x29, 0x00, 0x32, 0x63, 0x27, 0x00, 0x72, 0x53, 0x2F, 0x42,
  0x00, 0x3A, 0x63, 0x27, 0x08, 0x40, 0x74, 0x48, 0x80, 0x74, 0x62, 0xE0,
  0x5D, 0x28, 0x80, 0x4A, 0x53, 0x27, 0x00, 0x8C, 0x98, 0xC4, 0x00, 0xA7,
  0xAE, 0xAC, 0x90, 0x5A, 0x88, 0xC9, 0x00, 0x44, 0xA3, 0x0C, 0x20, 0x8C,
  0x00, 0x72, 0x44, 0xE0, 0x32, 0x48, 0x44, 0x40, 0xFF, 0x80, 0x65, 0x14,
  0xA0, 0xF0,
};

const GFXglyph NotoSans_Italic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 3, 2, 4, 1, -6 },
  { 4, 6, 6, 6, 0, -6 },
  { 9, 5, 8, 5, 0, -7 },
  { 14, 6, 7, 7, 1, -7 },
  { 20, 6, 7, 6, 0, -7 },
  { 26, 1, 2, 2, 1, -6 },
  { 27, 3, 7, 3, 0, -6 },
  { 30, 3, 7, 3, -1, -6 },
  { 33, 4, 4, 5, 1, -7 },
  { 35, 4, 4, 5, 1, -5 },
  { 37, 1, 2, 2, 0, -1 },
  { 38, 3, 1, 3, 0, -3 },
  { 39, 1, 1, 2, 0, -1 },
  { 40, 4, 6, 3, 0, -6 },
  { 43, 4, 7, 5, 1, -7 },
  { 47, 3, 6, 5, 1, -6 },
  { 50, 5, 7, 5, 0, -7 },
  { 55, 5, 7, 5, 0, -7 },
  { 60, 5, 6, 5, 0, -6 },
  { 64, 5, 6, 5, 0, -6 },
  { 68, 4, 7, 5, 1, -7 },
  { 72, 4, 6, 5, 1, -6 },
  { 75, 5, 7, 5, 0, -7 },
  { 80, 5, 7, 5, 0, -7 },
  { 85, 2, 5, 2, 0, -5 },
  { 87, 2, 6, 2, 0, -5 },
  { 89, 4, 4, 5, 1, -5 },
  { 91, 4, 2, 5, 1, -4 },
  { 92, 4, 4, 5, 1, -5 },
  { 94, 3, 7, 4, 1, -7 },
  { 97, 7, 7, 8, 0, -6 },
  { 104, 6, 6, 5, -1, -6 },
  { 109, 5, 6, 5, 0, -6 },
  { 113, 5, 7, 5, 1, -7 },
  { 118, 6, 6, 6, 0, -6 },
  { 123, 5, 6, 5, 0, -6 },
  { 127, 5, 6, 4, 0, -6 },
  { 131, 5, 7, 6, 1, -7 },
  { 136, 6, 6, 6, 0, -6 },
  { 141, 3, 6, 3, 0, -6 },
  { 144, 4, 8, 2, -1, -6 },
  { 148, 6, 6, 5, 0, -6 },
  { 153, 4, 6, 4, 0, -6 },
  { 156, 8, 6, 8, 0, -6 },
  { 162, 6, 6, 6, 0, -6 },
  { 167, 5, 7, 6, 1, -7 },
  { 172, 5, 6, 5, 0, -6 },
  { 176, 5, 9, 6, 1, -7 },
  { 182, 5, 6, 5, 0, -6 },
  { 186, 5, 7, 5, 0, -7 },
  { 191, 4, 6, 5, 1, -6 },
  { 194, 5, 6, 6, 1, -6 },
  { 198, 5, 6, 5, 1, -6 },
  { 202, 7, 6, 8, 1, -6 },
  { 208, 5, 6, 5, 0, -6 },
  { 212, 4, 6, 5, 1, -6 },
  { 215, 5, 6, 5, 0, -6 },
  { 219, 3, 7, 3, 0, -6 },
  { 222, 2, 6, 3, 1, -6 },
  { 224, 4, 7, 3, -1, -6 },
  { 228, 5, 4, 5, 0, -6 },
  { 231, 4, 1, 4, -1, 1 },
  { 232, 2, 2, 3, 1, -7 },
  { 233, 5, 5, 5, 0, -5 },
  { 237, 5, 7, 5, 0, -7 },
  { 242, 4, 5, 4, 0, -5 },
  { 245, 5, 7, 5, 0, -7 },
  { 250, 4, 5, 4, 0, -5 },
  { 253, 5, 9, 3, -1, -7 },
  { 259, 5, 7, 5, 0, -5 },
  { 264, 5, 7, 5, 0, -7 },
  { 269, 2, 7, 2, 0, -7 },
  { 271, 3, 9, 2, -1, -7 },
  { 275, 5, 7, 4, 0, -7 },
  { 280, 3, 7, 2, 0, -7 },
  { 283, 7, 5, 8, 0, -5 },
  { 288, 5, 5, 5, 0, -5 },
  { 292, 5, 5, 5, 0, -5 },
  { 296, 5, 7, 5, 0, -5 },
  { 301, 5, 7, 5, 0, -5 },
  { 306, 4, 5, 4, 0, -5 },
  { 309, 4, 5, 4, 0, -5 },
  { 312, 3, 6, 3, 0, -6 },
  { 315, 5, 5, 5, 0, -5 },
  { 319, 5, 5, 4, 0, -5 },
  { 323, 6, 5, 7, 1, -5 },
  { 327, 5, 5, 4, 0, -5 },
  { 331, 6, 7, 4, -1, -5 },
  { 337, 4, 5, 4, 0, -5 },
  { 340, 4, 7, 3, 0, -6 },
  { 344, 1, 9, 5, 2, -7 },
  { 346, 3, 7, 3, 0, -6 },
  { 349, 4, 1, 5, 1, -4 },
};

const GFXfont NotoSans_Italic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic9pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_ITALIC9PT7B_H_
