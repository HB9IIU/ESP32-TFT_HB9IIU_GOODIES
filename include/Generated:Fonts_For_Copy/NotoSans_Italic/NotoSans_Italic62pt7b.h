#ifndef _NOTOSANS_ITALIC62PT7B_H_
#define _NOTOSANS_ITALIC62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x3F, 0x0F, 0xE7, 0xC1, 0xF8,
  0xF8, 0x3F, 0x3F, 0x07, 0xC7, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3,
  0xE0, 0x78, 0x78, 0x1F, 0x0F, 0x03, 0xE3, 0xE0, 0x78, 0x78, 0x0F, 0x0F,
  0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x07, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xF1, 0xE1, 0xE0, 0x1F, 0x83, 0xC0, 0xC0, 0x3F, 0x0F, 0x00, 0x00, 0x7C,
  0x1E, 0x00, 0x01, 0xF8, 0x3C, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x0F, 0xC3, 0xC0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x1F, 0x8F,
  0x00, 0x00, 0x3F, 0x9E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x79, 0xFC,
  0x00, 0x00, 0xF1, 0xF8, 0x00, 0x01, 0xE1, 0xF8, 0x00, 0x07, 0x83, 0xF0,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0x1E, 0x0F, 0xC0, 0x00, 0x3C, 0x1F, 0x80,
  0x00, 0xF8, 0x3E, 0x00, 0x01, 0xE0, 0xFC, 0x18, 0x03, 0xC3, 0xF0, 0x3E,
  0x07, 0x9F, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0x80, 0x7F, 0xF8, 0x00, 0x03, 0xC0, 0x1F, 0xFF, 0x00, 0x01, 0xF0, 0x0F,
  0xC7, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x3E,
  0x00, 0x1E, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x01,
  0xE0, 0x0F, 0x80, 0x7C, 0x00, 0x78, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x00,
  0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x3C, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x03,
  0xE0, 0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x00, 0x3C, 0x01, 0xF0, 0xF8, 0x00,
  0x0F, 0x00, 0x78, 0x3E, 0x1F, 0xC3, 0xC0, 0x3E, 0x1F, 0x1F, 0xF8, 0xF8,
  0x0F, 0x8F, 0x8F, 0xFF, 0x3E, 0x07, 0xC7, 0xC7, 0xFF, 0xEF, 0x83, 0xE1,
  0xF3, 0xF0, 0xF9, 0xF1, 0xF8, 0xF8, 0xF8, 0x1F, 0x7F, 0xFC, 0x7C, 0x7C,
  0x07, 0xCF, 0xFE, 0x3E, 0x1F, 0x01, 0xF1, 0xFF, 0x0F, 0x8F, 0x80, 0x7C,
  0x3F, 0x07, 0xC3, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0xF0, 0x07, 0xC0, 0x01,
  0xF0, 0x3C, 0x01, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x78, 0x00, 0x3E, 0x07,
  0xC0, 0x1E, 0x00, 0x1F, 0x01, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x78, 0x03,
  0xE0, 0x03, 0xE0, 0x1E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x07, 0xC0, 0x1F, 0x00,
  0x1E, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x01, 0xF0,
  0x7C, 0x01, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x7C, 0x00, 0x01, 0xFF, 0xC0, 0x3E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xF7, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x3F, 0x80, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x3E, 0x1F, 0xE0,
  0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF9,
  0xF8, 0x00, 0xFC, 0x3F, 0x87, 0xE0, 0x03, 0xE1, 0xFC, 0x0F, 0xC0, 0x1F,
  0x8F, 0xC0, 0x1F, 0x80, 0x7C, 0x3E, 0x00, 0x7E, 0x03, 0xF1, 0xF8, 0x00,
  0xFC, 0x0F, 0x87, 0xC0, 0x01, 0xF8, 0x7E, 0x3F, 0x00, 0x07, 0xF3, 0xF0,
  0xF8, 0x00, 0x0F, 0xDF, 0x83, 0xE0, 0x00, 0x1F, 0xFC, 0x0F, 0x80, 0x00,
  0x3F, 0xF0, 0x3E, 0x00, 0x00, 0xFF, 0x80, 0xFC, 0x00, 0x01, 0xFC, 0x03,
  0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xC0, 0x07,
  0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xBF, 0x00, 0xFF, 0xFF, 0xFC, 0x7E, 0x01,
  0xFF, 0xFF, 0xC1, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xF0, 0x03, 0xFF, 0xE0,
  0x07, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x7E, 0x7E,
  0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x80, 0x0F,
  0x00, 0x07, 0x00, 0x78, 0x00, 0x7E, 0x03, 0x80, 0x03, 0xFC, 0x3C, 0x00,
  0x3F, 0xF9, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xF7, 0xFF, 0x00, 0x7F,
  0x80, 0x38, 0x07, 0xDE, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0x7E, 0x1E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0xFE, 0x07, 0xC0, 0x03,
  0xE0, 0x1F, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x30, 0x07, 0xE0, 0x00, 0x80,
  0x1F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0x81, 0xFC,
  0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x04, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7E, 0x38, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xC0, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x7C, 0xFC, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3F, 0x7E, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xBE, 0x00,
  0x00, 0xFD, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x3F,
  0x80, 0x3F, 0x83, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x07, 0xFB, 0xE3, 0xFE, 0x7C, 0xFF, 0x9F, 0x9F, 0xC3, 0xE1, 0xF0,
  0x7C, 0x18, 0x0F, 0x82, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x01, 0xF0, 0x01,
  0xFC, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x20, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFE,
  0x01, 0xFE, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x60, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x43, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0xC0, 0x00,
  0x0F, 0xE0, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x9F, 0x00,
  0x00, 0x1F, 0x9F, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x1F, 0x87, 0xC0,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0xFC, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7C, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x10, 0x00, 0x03, 0xF8, 0x38,
  0x00, 0x1F, 0xE0, 0x7E, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0x80, 0x20, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF1,
  0xFF, 0xC0, 0x0F, 0x8F, 0xFF, 0xC0, 0x7E, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x07, 0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x07,
  0xE3, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xF8,
  0xFC, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x3E,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x7C, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x81, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8,
  0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x01,
  0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF0,
  0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFE,
  0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x01,
  0xF8, 0x7C, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x1F, 0x3F, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x7E, 0x3E, 0x00, 0x07, 0xF1, 0xF0, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xFC,
  0x7F, 0x00, 0x3F, 0xC1, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0xFD, 0xF0, 0x3F,
  0xFF, 0xDF, 0x80, 0xFF, 0xFC, 0xFC, 0x01, 0xFF, 0x87, 0xC0, 0x01, 0xE0,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0xE0, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xF8, 0x1F, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x7C,
  0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x03, 0xF0, 0x0E, 0x00,
  0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xC7, 0xE0, 0x3F, 0x8E, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x07, 0xC0, 0x01, 0xFF, 0x80, 0x3E, 0x0F, 0x80, 0x07, 0xFF, 0xF0,
  0x1E, 0x0F, 0x80, 0x1F, 0xFF, 0xF0, 0x1F, 0x1F, 0x00, 0x3F, 0xFF, 0xF0,
  0x1F, 0x1F, 0x00, 0x7E, 0x01, 0xE0, 0x1F, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x3C, 0x03, 0xE0, 0x03, 0xC0,
  0x1F, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x7C, 0x07, 0xC0, 0x07, 0xC0,
  0x1F, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x78, 0x0F, 0x80, 0x07, 0x80,
  0x1F, 0x78, 0x0F, 0x80, 0x0F, 0x80, 0x1E, 0xF8, 0x0F, 0x80, 0x0F, 0x80,
  0x3E, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0xF8, 0x0F, 0x80, 0x1F, 0x00,
  0x3C, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0xF8, 0x0F, 0x80, 0x3F, 0x00,
  0x7C, 0xF8, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0xF8, 0x0F, 0x80, 0x7F, 0x01,
  0xF8, 0xF8, 0x0F, 0xC0, 0xFF, 0x83, 0xF0, 0x78, 0x07, 0xF7, 0xE7, 0xFF,
  0xE0, 0x7C, 0x07, 0xFF, 0xC7, 0xFF, 0xC0, 0x7C, 0x03, 0xFF, 0x83, 0xFF,
  0x80, 0x7C, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x40,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x07, 0xE1, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00,
  0x7C, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00,
  0x3E, 0x3F, 0x00, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x1F, 0x80, 0x03,
  0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0x03, 0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x0F,
  0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7F, 0x80,
  0x7C, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x7F,
  0xC0, 0x0F, 0x80, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x1F, 0x00, 0x01, 0xFE,
  0x07, 0xC0, 0x01, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xE0, 0x1F, 0x80, 0x1F, 0xF0, 0x00, 0x60, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0x00, 0x0F, 0xFE, 0x1F,
  0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0x80, 0x0F, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0x80, 0x01, 0xFC,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00,
  0x07, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x0F, 0xE1, 0xF0,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x00, 0x3F, 0x83, 0xE0, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x07, 0xFC, 0x07, 0xC0,
  0x01, 0xFF, 0x80, 0x7C, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0xC0, 0x1F, 0xE0, 0x00,
  0x02, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0x8F, 0xC0,
  0x01, 0xFF, 0xFC, 0x7E, 0x00, 0x0F, 0xFF, 0xC3, 0xE0, 0x00, 0x7F, 0xFE,
  0x1F, 0x00, 0x03, 0xFF, 0xF1, 0xF8, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x00, 0xF8, 0x7E, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00,
  0xF8, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0xFE, 0x00, 0x00, 0x7E, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0x00, 0xF8,
  0x03, 0xFE, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x03, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF8, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x3F, 0x80, 0x00, 0x7C, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x3F, 0x80, 0x00, 0x0F, 0x83, 0xF8, 0x00, 0x00, 0x7C, 0x3F, 0x80,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x01, 0xF3,
  0xF8, 0x00, 0x00, 0x0F, 0xBF, 0x80, 0x00, 0x00, 0x7D, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x7E,
  0x00, 0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x3E, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x1E, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xBC, 0x00, 0x00,
  0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0xFB, 0xE0, 0x00,
  0x07, 0xDF, 0x80, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00,
  0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x00, 0x7E, 0x7C, 0x01, 0xF3, 0xE0,
  0x00, 0x1F, 0x3F, 0x00, 0x7C, 0x78, 0x00, 0x0F, 0x8F, 0x80, 0x1F, 0x1E,
  0x00, 0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x01, 0xF0, 0xF8, 0x03, 0xE1,
  0xF0, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x80, 0x3E,
  0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC1, 0xF0, 0x07,
  0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x3C, 0x00, 0xF8, 0x3F, 0x00,
  0x7C, 0x0F, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x03, 0xC0, 0x1F, 0x03, 0xE0,
  0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7E,
  0x00, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x7C, 0x07,
  0xE0, 0x0F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x1E, 0x0F, 0x80,
  0x7C, 0x01, 0xF8, 0x07, 0x87, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xE1, 0xF0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xDF, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xFF,
  0x80, 0x1F, 0x80, 0x3E, 0x00, 0x7F, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0xF0, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xFC, 0x00, 0x7C, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0xFE, 0x00,
  0x00, 0x3E, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x00, 0x03,
  0xE0, 0x0F, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x7E, 0x00,
  0xFB, 0xE0, 0x00, 0x1F, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xC0, 0x0F, 0xBF,
  0x00, 0x01, 0xF0, 0x07, 0xC7, 0xC0, 0x00, 0xFC, 0x01, 0xF1, 0xF0, 0x00,
  0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x03, 0xE0,
  0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x00, 0xF8,
  0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0xF8,
  0x01, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x00,
  0xFC, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xC1,
  0xF0, 0x03, 0xE0, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x00, 0x3E, 0x3F, 0x00,
  0x7C, 0x00, 0x0F, 0xCF, 0x80, 0x1F, 0x00, 0x01, 0xF3, 0xE0, 0x07, 0xC0,
  0x00, 0x7C, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0xF8, 0x00, 0x03,
  0xEF, 0x80, 0x3E, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x3F, 0xF0,
  0x03, 0xE0, 0x00, 0x07, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xC0, 0x00,
  0x03, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x1F,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0xF8, 0x00,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x3F, 0x1F, 0x00,
  0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x0F,
  0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xF8, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xFE, 0x07, 0xC0, 0x01,
  0xFC, 0x07, 0xC0, 0x07, 0xF8, 0x0F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x0F, 0x87, 0xE0, 0x00,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x01, 0xFE, 0x01, 0xF8,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0xFC, 0x07, 0xC0, 0x03, 0xFC, 0x07, 0xC0, 0x1F, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0x80, 0x7E, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xF0, 0x1F, 0x80, 0x7F, 0x80, 0x06, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x20, 0x00, 0x0F,
  0xE0, 0x70, 0x00, 0x3F, 0xC0, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x3F, 0x00,
  0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x07, 0xC3, 0xF0,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x1F, 0x1F,
  0x80, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0xFF, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3F, 0x1F, 0x00,
  0x07, 0xDF, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFB, 0xE0, 0x01, 0xF8, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0xC1,
  0xF8, 0x01, 0xF1, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x7E,
  0x07, 0xE0, 0x0F, 0x87, 0xC0, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0xF8, 0x03,
  0xF0, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x81, 0xE0,
  0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x3C, 0x03, 0xF0, 0x07, 0xC0, 0x7C, 0x07,
  0x80, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x80, 0x1F, 0x03, 0xE0,
  0x1E, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x03, 0xC0, 0xFC, 0x00, 0x7C, 0x1F,
  0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x0F, 0x87, 0xE0, 0x01, 0xF0,
  0xF8, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x07,
  0xC7, 0xC0, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0x1F, 0x3E, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0,
  0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xBE,
  0x00, 0x01, 0xF7, 0xC0, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3E,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF9, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x3E,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8,
  0x03, 0xF0, 0x01, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x03, 0xE0,
  0x7E, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7D, 0xF8,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01,
  0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x3C, 0xF8,
  0x00, 0x00, 0xF8, 0xF0, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x78, 0x07, 0xC0,
  0x01, 0xF0, 0x07, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x3E, 0x01,
  0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFE, 0xFC, 0x1F, 0x87, 0xE0, 0xF8, 0x1F, 0x03, 0xC0,
  0xF8, 0x1F, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x3C,
  0x01, 0xFF, 0xF0, 0xF8, 0x07, 0xFF, 0xF1, 0xF0, 0x1F, 0xFF, 0xF7, 0xC0,
  0x7F, 0x81, 0xEF, 0x81, 0xFC, 0x01, 0xFF, 0x07, 0xF0, 0x01, 0xFE, 0x0F,
  0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3E, 0x1F, 0x80,
  0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0x83, 0xF0, 0x01, 0xFF,
  0x07, 0xE0, 0x07, 0xFC, 0x07, 0xE0, 0x1F, 0xF8, 0x0F, 0xE0, 0xFD, 0xF0,
  0x0F, 0xFF, 0xF3, 0xE0, 0x1F, 0xFF, 0xC7, 0xC0, 0x1F, 0xFE, 0x0F, 0x00,
  0x0F, 0xF8, 0x1E, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x7C, 0x1F, 0xF8, 0x01, 0xF8, 0xFF, 0xF8, 0x03, 0xF3,
  0xFF, 0xF8, 0x07, 0xCF, 0xFF, 0xF0, 0x0F, 0xBE, 0x07, 0xF0, 0x1F, 0xF0,
  0x07, 0xE0, 0x7F, 0xC0, 0x07, 0xC0, 0xFF, 0x00, 0x0F, 0xC1, 0xFE, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x00,
  0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7E,
  0x1F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x0F,
  0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0xFF,
  0x80, 0x3F, 0x81, 0xFF, 0x81, 0xFE, 0x07, 0xCF, 0xFF, 0xF8, 0x0F, 0x8F,
  0xFF, 0xE0, 0x1E, 0x0F, 0xFF, 0x80, 0x3C, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0xC0, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x08,
  0x0F, 0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xFF, 0x83, 0xE0,
  0x01, 0xFF, 0xF1, 0xF8, 0x00, 0xFF, 0xFE, 0x7E, 0x00, 0xFF, 0xFF, 0xDF,
  0x00, 0x3F, 0x80, 0xF7, 0xC0, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xE0, 0x03,
  0xFC, 0x03, 0xF0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFE, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x07,
  0xF0, 0x0F, 0xC0, 0x03, 0xFC, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0x80, 0x7B, 0xE0, 0x07, 0xF0, 0x7E, 0xF8, 0x00, 0xFF,
  0xFF, 0x3E, 0x00, 0x3F, 0xFF, 0x8F, 0x80, 0x07, 0xFF, 0x83, 0xC0, 0x00,
  0x7F, 0xC0, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0xFE, 0x07, 0xF0, 0x7F, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x0F, 0xC0,
  0x07, 0xC7, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3E, 0x3E,
  0x00, 0x1F, 0x9F, 0x80, 0x1F, 0xC7, 0xE0, 0x3F, 0xF1, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x0C, 0x0F, 0xF0, 0x1F, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x0F, 0x00, 0x3F,
  0xFE, 0x1F, 0x00, 0x7F, 0xFF, 0x1F, 0x01, 0xFF, 0xFF, 0x9E, 0x01, 0xFE,
  0x07, 0xFE, 0x03, 0xF8, 0x03, 0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x07, 0xE0,
  0x01, 0xFE, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x3F, 0x00,
  0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xE0, 0x7E, 0x00,
  0x3F, 0xE0, 0x7E, 0x00, 0x7F, 0xC0, 0x3F, 0x00, 0xF7, 0xC0, 0x3F, 0x83,
  0xF7, 0xC0, 0x1F, 0xFF, 0xE7, 0xC0, 0x1F, 0xFF, 0xCF, 0xC0, 0x0F, 0xFF,
  0x0F, 0x80, 0x03, 0xFE, 0x0F, 0x80, 0x00, 0x60, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x80, 0x00, 0xFC, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x1F,
  0x07, 0xFE, 0x00, 0xFC, 0x7F, 0xFC, 0x03, 0xE3, 0xFF, 0xF8, 0x0F, 0x9F,
  0xFF, 0xF0, 0x3E, 0xF8, 0x1F, 0xC0, 0xFF, 0xC0, 0x3F, 0x07, 0xFC, 0x00,
  0x7C, 0x1F, 0xE0, 0x01, 0xF0, 0x7F, 0x80, 0x07, 0xC1, 0xFC, 0x00, 0x1F,
  0x0F, 0xE0, 0x00, 0x7C, 0x3F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x03, 0xE1, 0xF8,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF8, 0x7C, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xF8,
  0x7E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7C, 0x3F,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x18, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x40,
  0x7C, 0x00, 0x7F, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xC0, 0x1F, 0xC0, 0x0F, 0x80, 0x7F, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x7E,
  0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x03, 0xE0,
  0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3E, 0x3F,
  0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0xFB, 0xF8, 0x00, 0x03, 0xEF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xE7, 0xC0,
  0x00, 0x3F, 0x8F, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x80,
  0x03, 0xE0, 0x3F, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFC, 0x01,
  0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F,
  0x80, 0x07, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x3F, 0xE0, 0x07,
  0xFE, 0x00, 0xF8, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x7C, 0x7F, 0xFE, 0x0F,
  0xFF, 0xE0, 0x3E, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0x1F, 0x7C, 0x0F, 0xCF,
  0x81, 0xF8, 0x0F, 0xF8, 0x07, 0xEF, 0x00, 0x7E, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x7C,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xF0,
  0x7F, 0xF8, 0x01, 0xF0, 0xFF, 0xFC, 0x01, 0xF1, 0xFF, 0xFC, 0x01, 0xF3,
  0xFF, 0xFE, 0x01, 0xF7, 0xE0, 0xFE, 0x03, 0xFF, 0x80, 0x7E, 0x03, 0xFF,
  0x00, 0x3F, 0x03, 0xFE, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0x3F, 0x07, 0xF8,
  0x00, 0x3E, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0x80,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80,
  0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x01, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC1,
  0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0xFD, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x03,
  0xFF, 0x00, 0x07, 0xC3, 0xFF, 0xE0, 0x01, 0xF1, 0xFF, 0xFC, 0x00, 0x7C,
  0xFF, 0xFF, 0x00, 0x1F, 0x7C, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xF8, 0x03,
  0xFE, 0x00, 0x3E, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x3F, 0xC0, 0x03, 0xF0,
  0x0F, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xC0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xC0,
  0x3F, 0xC0, 0x07, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x03, 0xFF, 0x03, 0xFC,
  0x00, 0xFB, 0xFF, 0xFE, 0x00, 0x7E, 0x7F, 0xFF, 0x00, 0x1F, 0x0F, 0xFF,
  0x80, 0x07, 0xC1, 0xFF, 0x80, 0x01, 0xF0, 0x0E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x3C, 0x01, 0xFF, 0xF0, 0xF8, 0x07, 0xFF,
  0xF1, 0xF0, 0x3F, 0xFF, 0xF3, 0xC0, 0x7F, 0x81, 0xEF, 0x81, 0xFC, 0x01,
  0xFF, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF8,
  0x7C, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0x87,
  0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xFC, 0x3F,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x7F, 0x83, 0xF0, 0x01, 0xFF, 0x07, 0xE0, 0x07, 0xFC, 0x07, 0xE0,
  0x1E, 0xF8, 0x0F, 0xE0, 0xFD, 0xF0, 0x0F, 0xFF, 0xF3, 0xE0, 0x1F, 0xFF,
  0xCF, 0xC0, 0x1F, 0xFE, 0x1F, 0x00, 0x0F, 0xF8, 0x3E, 0x00, 0x03, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0xF0, 0x7F, 0x80, 0xF8, 0x7F, 0xC0, 0x7C, 0x7F, 0xE0, 0x3E, 0x7F, 0xF0,
  0x1F, 0x7E, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81,
  0xFC, 0x03, 0xC0, 0x7E, 0x00, 0x10, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC2, 0x00,
  0x03, 0xF0, 0xC0, 0x01, 0xFC, 0x3E, 0x00, 0xFE, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0x3F, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x04, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x18, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF8,
  0x3E, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF8, 0x1F,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0xC1, 0xF8,
  0x00, 0xFF, 0x83, 0xF0, 0x03, 0xFE, 0x03, 0xF0, 0x0F, 0x7C, 0x07, 0xF0,
  0x7E, 0xF8, 0x0F, 0xFF, 0xF9, 0xF0, 0x0F, 0xFF, 0xE3, 0xE0, 0x0F, 0xFF,
  0x07, 0x80, 0x0F, 0xFC, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x0F,
  0xC7, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x7E, 0x0F,
  0x80, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x80,
  0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E,
  0x00, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x03, 0xF0, 0x01,
  0xF0, 0x1F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xF0,
  0xFC, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x1F, 0x3F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFB, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x7C, 0x00, 0x7F, 0x80, 0x07, 0xCF, 0x80, 0x0F, 0xF0, 0x01,
  0xF9, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x3E, 0x00, 0x7B, 0xC0, 0x0F, 0xC7,
  0xC0, 0x0F, 0x78, 0x01, 0xF8, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0x1F, 0x00,
  0x79, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xC7,
  0xC0, 0x7E, 0x0F, 0x80, 0xF8, 0xF8, 0x0F, 0x81, 0xF0, 0x1E, 0x1F, 0x03,
  0xF0, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x7C, 0x1F, 0x80,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x03, 0xE1,
  0xF0, 0x3E, 0x1F, 0x80, 0x7C, 0x3E, 0x03, 0xC3, 0xE0, 0x0F, 0x8F, 0x80,
  0x78, 0xFC, 0x01, 0xF1, 0xF0, 0x0F, 0x1F, 0x00, 0x3E, 0x3C, 0x01, 0xE7,
  0xE0, 0x03, 0xCF, 0x80, 0x3C, 0xF8, 0x00, 0x79, 0xE0, 0x07, 0x9F, 0x00,
  0x0F, 0x7C, 0x00, 0xF7, 0xC0, 0x01, 0xEF, 0x00, 0x1E, 0xF8, 0x00, 0x3D,
  0xE0, 0x03, 0xDE, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x3E, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xE0,
  0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x07,
  0xE3, 0xE0, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00,
  0x07, 0x9F, 0x80, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x00, 0x7B, 0xE0,
  0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x04, 0x7F, 0xF8, 0x00, 0x37, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xEC, 0x00, 0x1F, 0xFF,
  0x20, 0x00, 0x1F, 0xF0,
};

const GFXglyph NotoSans_Italic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 16, 45, 16, 1, -44 },
  { 91, 19, 16, 24, 7, -44 },
  { 129, 39, 44, 40, 2, -44 },
  { 344, 31, 51, 34, 2, -47 },
  { 542, 42, 46, 50, 5, -45 },
  { 784, 38, 46, 42, 2, -45 },
  { 1003, 8, 16, 14, 7, -44 },
  { 1019, 21, 54, 18, 2, -44 },
  { 1161, 20, 54, 18, -5, -44 },
  { 1296, 29, 28, 34, 6, -47 },
  { 1398, 29, 30, 35, 4, -37 },
  { 1507, 13, 15, 16, -3, -7 },
  { 1532, 15, 5, 19, 2, -19 },
  { 1542, 8, 9, 16, 1, -8 },
  { 1551, 30, 44, 22, -3, -44 },
  { 1716, 29, 46, 34, 4, -45 },
  { 1883, 19, 44, 34, 9, -44 },
  { 1988, 33, 45, 34, 0, -45 },
  { 2174, 32, 46, 34, 1, -45 },
  { 2358, 33, 44, 34, 0, -44 },
  { 2540, 31, 45, 34, 2, -44 },
  { 2715, 30, 46, 34, 4, -45 },
  { 2888, 30, 44, 34, 5, -44 },
  { 3053, 31, 46, 34, 3, -45 },
  { 3232, 29, 46, 34, 3, -45 },
  { 3399, 13, 35, 16, 1, -34 },
  { 3456, 17, 42, 16, -3, -34 },
  { 3546, 30, 31, 35, 4, -38 },
  { 3663, 28, 17, 35, 5, -30 },
  { 3723, 30, 31, 35, 4, -38 },
  { 3840, 23, 46, 27, 5, -45 },
  { 3973, 48, 50, 53, 3, -44 },
  { 4273, 36, 44, 35, -4, -44 },
  { 4471, 34, 44, 37, 3, -44 },
  { 4658, 35, 46, 36, 4, -45 },
  { 4860, 36, 44, 41, 3, -44 },
  { 5058, 31, 44, 32, 3, -44 },
  { 5229, 31, 44, 30, 3, -44 },
  { 5400, 37, 46, 42, 4, -45 },
  { 5613, 39, 44, 42, 3, -44 },
  { 5828, 25, 44, 20, -1, -44 },
  { 5966, 27, 56, 17, -10, -44 },
  { 6155, 37, 44, 35, 3, -44 },
  { 6359, 23, 44, 30, 3, -44 },
  { 6486, 50, 44, 52, 2, -44 },
  { 6761, 42, 44, 44, 2, -44 },
  { 6992, 39, 46, 45, 4, -45 },
  { 7217, 32, 44, 35, 3, -44 },
  { 7393, 39, 56, 45, 4, -45 },
  { 7666, 32, 44, 36, 3, -44 },
  { 7842, 31, 46, 31, 1, -45 },
  { 8021, 31, 44, 31, 6, -44 },
  { 8192, 38, 45, 42, 5, -44 },
  { 8406, 34, 44, 34, 6, -44 },
  { 8593, 51, 44, 53, 7, -44 },
  { 8874, 41, 44, 33, -3, -44 },
  { 9100, 31, 44, 32, 6, -44 },
  { 9271, 37, 44, 33, -1, -44 },
  { 9475, 24, 54, 18, -1, -44 },
  { 9637, 11, 44, 22, 7, -44 },
  { 9698, 23, 54, 18, -4, -44 },
  { 9854, 31, 28, 35, 2, -45 },
  { 9963, 26, 4, 24, -6, 6 },
  { 9976, 10, 9, 17, 9, -47 },
  { 9988, 31, 35, 35, 3, -34 },
  { 10124, 31, 48, 36, 2, -47 },
  { 10310, 26, 35, 28, 3, -34 },
  { 10424, 34, 48, 36, 3, -47 },
  { 10628, 26, 35, 31, 3, -34 },
  { 10742, 34, 62, 20, -7, -47 },
  { 11006, 32, 49, 36, 2, -34 },
  { 11202, 30, 47, 36, 2, -47 },
  { 11379, 15, 46, 16, 2, -46 },
  { 11466, 25, 61, 16, -8, -46 },
  { 11657, 31, 47, 31, 2, -47 },
  { 11840, 15, 47, 16, 2, -47 },
  { 11929, 49, 34, 54, 2, -34 },
  { 12138, 32, 34, 36, 1, -34 },
  { 12274, 29, 35, 35, 3, -34 },
  { 12401, 34, 49, 36, -1, -34 },
  { 12610, 31, 49, 36, 3, -34 },
  { 12800, 25, 34, 25, 2, -34 },
  { 12907, 26, 35, 27, 0, -34 },
  { 13021, 20, 42, 21, 3, -41 },
  { 13126, 31, 34, 36, 3, -33 },
  { 13258, 29, 33, 29, 3, -33 },
  { 13378, 43, 33, 45, 4, -33 },
  { 13556, 34, 33, 30, -2, -33 },
  { 13697, 38, 48, 29, -6, -33 },
  { 13925, 28, 33, 28, -1, -33 },
  { 14041, 24, 54, 22, 1, -44 },
  { 14203, 5, 62, 34, 16, -47 },
  { 14242, 23, 54, 22, -2, -44 },
  { 14398, 30, 8, 35, 4, -26 },
};

const GFXfont NotoSans_Italic62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic62pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_ITALIC62PT7B_H_
