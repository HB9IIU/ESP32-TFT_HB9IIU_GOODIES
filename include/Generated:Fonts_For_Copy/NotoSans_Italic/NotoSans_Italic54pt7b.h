#ifndef _NOTOSANS_ITALIC54PT7B_H_
#define _NOTOSANS_ITALIC54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x01, 0xF0,
  0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x0C, 0x00, 0x3E,
  0x1F, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1E, 0x7C, 0x1E, 0x7C, 0x3E, 0x78,
  0x3E, 0x78, 0x3C, 0x78, 0x3C, 0x70, 0x3C, 0xF0, 0x38, 0xF0, 0x38, 0xE0,
  0x78, 0xE0, 0x70, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1C, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x03, 0xC0, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x38, 0x07,
  0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xC0,
  0x38, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3C,
  0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x70, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0xFC, 0xF0, 0xE0, 0x7C, 0x3C, 0x08, 0x1E, 0x0E, 0x00, 0x07,
  0x83, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x3E, 0x1E, 0x00,
  0x07, 0x87, 0x00, 0x01, 0xF1, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x1E, 0xFC, 0x00, 0x07, 0x9F, 0x80, 0x01, 0xC3, 0xE0,
  0x00, 0x70, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0x83,
  0xE0, 0x00, 0xE0, 0xF0, 0x80, 0x78, 0x7C, 0x3C, 0x1E, 0x7E, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xE0,
  0x1F, 0xF0, 0x00, 0x1E, 0x01, 0xFF, 0xC0, 0x01, 0xE0, 0x1F, 0xBE, 0x00,
  0x1F, 0x01, 0xF0, 0xF8, 0x00, 0xF0, 0x0F, 0x03, 0xC0, 0x0F, 0x00, 0xF0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x0F,
  0x07, 0xC0, 0x07, 0x80, 0xF0, 0x3C, 0x00, 0x78, 0x07, 0x83, 0xC0, 0x03,
  0xC0, 0x3C, 0x3E, 0x00, 0x1E, 0x01, 0xE1, 0xE0, 0xC0, 0xF0, 0x1E, 0x1E,
  0x3F, 0xC7, 0x80, 0xF1, 0xE3, 0xFF, 0x3C, 0x0F, 0x1F, 0x3F, 0xFC, 0xF0,
  0xF8, 0xF3, 0xE1, 0xE7, 0xFF, 0x8F, 0x1E, 0x0F, 0x9F, 0xF8, 0xF1, 0xE0,
  0x3C, 0xFF, 0x8F, 0x8F, 0x01, 0xE1, 0xF8, 0x78, 0xF0, 0x0F, 0x00, 0x07,
  0x87, 0x80, 0x78, 0x00, 0x78, 0x3C, 0x03, 0xC0, 0x07, 0xC1, 0xE0, 0x3C,
  0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x0F, 0x00, 0x3C, 0x07,
  0x80, 0x78, 0x03, 0xE0, 0x3C, 0x03, 0x80, 0x1E, 0x01, 0xE0, 0x3C, 0x01,
  0xE0, 0x0F, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x1E, 0x01, 0xF0, 0x03, 0xE0,
  0xF0, 0x0F, 0x00, 0x0F, 0x1F, 0x00, 0xF0, 0x00, 0x7F, 0xF8, 0x0F, 0x00,
  0x01, 0xFF, 0x80, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xF0, 0x03,
  0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x03, 0xE3,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x78, 0x7E, 0x1F, 0x80, 0x7C, 0x7C,
  0x07, 0xC0, 0x3E, 0x7C, 0x01, 0xF0, 0x3E, 0x3E, 0x00, 0xFC, 0x1E, 0x3E,
  0x00, 0x3F, 0x1F, 0x1F, 0x00, 0x0F, 0x9F, 0x0F, 0x00, 0x03, 0xFF, 0x07,
  0x80, 0x01, 0xFF, 0x83, 0xC0, 0x00, 0x7F, 0x81, 0xF0, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x3F, 0xF0, 0x1F, 0x80, 0x7F, 0xF8,
  0x0F, 0xF9, 0xFF, 0x3E, 0x03, 0xFF, 0xFF, 0x1F, 0x80, 0xFF, 0xFE, 0x07,
  0xE0, 0x1F, 0xFC, 0x01, 0xF8, 0x00, 0x80, 0x00, 0x00, 0x3E, 0x7D, 0xF3,
  0xE7, 0xCF, 0x9E, 0x3C, 0x78, 0xE3, 0xC7, 0x8E, 0x1C, 0x00, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x40, 0x1E, 0x00, 0x60, 0x1E,
  0x00, 0xF8, 0x1C, 0x00, 0xFE, 0x1C, 0x00, 0xFF, 0x9C, 0x00, 0x3F, 0xF8,
  0x1F, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFD, 0xFF, 0x01, 0xFC,
  0x01, 0x03, 0xCE, 0x00, 0x07, 0xCE, 0x00, 0x0F, 0x8F, 0x00, 0x1F, 0x0F,
  0x00, 0x7E, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x1C, 0x07, 0xC0, 0x08, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xC3, 0xF0, 0xF8, 0x3E, 0x1F, 0x07,
  0xC3, 0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x00, 0x7F, 0xFD,
  0xFF, 0xF7, 0xFF, 0xDF, 0xFE, 0xFF, 0xF8, 0x08, 0xF9, 0xFF, 0xFF, 0xFF,
  0xBF, 0x38, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xF8,
  0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x7E, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xC7, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F,
  0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7D, 0xF0, 0x00,
  0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x79, 0xE0,
  0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB,
  0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01,
  0xF3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x8F, 0x80,
  0x07, 0xC1, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x3F, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0x00,
  0x7F, 0x01, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x3F, 0xFE, 0x7F, 0x3C, 0xFE,
  0x3C, 0x78, 0x7C, 0x70, 0x7C, 0x20, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x78, 0x01, 0xF8, 0x01,
  0x80, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xC0, 0x0F, 0xC0, 0x20, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x18, 0x00, 0x0F, 0xC3, 0xC0, 0x07, 0xF0, 0x7F, 0xEF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x0F, 0x9E, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x7C,
  0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x03,
  0xE0, 0x1E, 0x00, 0x3E, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xC1, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x10, 0x00, 0x1F, 0x83, 0x80, 0x0F, 0xE0, 0x7F, 0xBF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00,
  0x05, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x40, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x7F, 0x80, 0x3E, 0x7F, 0xF8, 0x0F, 0xBF,
  0xFF, 0x03, 0xDF, 0xFF, 0xE1, 0xFF, 0x01, 0xF8, 0x7F, 0x00, 0x3E, 0x1F,
  0x80, 0x07, 0xC7, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F,
  0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00,
  0x1F, 0x3E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C,
  0x00, 0x7C, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x80,
  0x00, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xC0,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03,
  0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01,
  0xF0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x07,
  0xC1, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xE3, 0xF8, 0x03, 0xF0,
  0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xE1,
  0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF1, 0xF0, 0x00,
  0x3E, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xC1, 0xFC, 0x03, 0xF8, 0x1F, 0xF3, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x7F, 0x07, 0xF0, 0x7E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x1F,
  0x1F, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01,
  0xF3, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0x78, 0x00,
  0x1F, 0x3E, 0x00, 0x1F, 0x9F, 0x00, 0x0F, 0xCF, 0x80, 0x0F, 0xE3, 0xE0,
  0x0F, 0xE1, 0xFC, 0x3F, 0xF0, 0x7F, 0xFE, 0xF8, 0x1F, 0xFE, 0x7C, 0x07,
  0xFE, 0x3C, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x20, 0x07, 0xF0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC1, 0xF0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x7C, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xE0, 0x7F, 0x08, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x03,
  0xC1, 0xE0, 0x01, 0xFE, 0x00, 0xF1, 0xF0, 0x07, 0xFF, 0xE0, 0x78, 0xF0,
  0x07, 0xFF, 0xF0, 0x3C, 0xF8, 0x07, 0xF3, 0xF0, 0x1E, 0x78, 0x07, 0xC0,
  0x78, 0x0F, 0x7C, 0x07, 0xC0, 0x3C, 0x07, 0xBC, 0x07, 0xC0, 0x1E, 0x03,
  0xDE, 0x03, 0xC0, 0x1E, 0x01, 0xEF, 0x03, 0xC0, 0x0F, 0x00, 0xFF, 0x01,
  0xE0, 0x07, 0x80, 0x7F, 0x81, 0xF0, 0x07, 0xC0, 0x3F, 0xC0, 0xF0, 0x03,
  0xC0, 0x1F, 0xE0, 0x78, 0x01, 0xE0, 0x1E, 0xF0, 0x3C, 0x01, 0xF0, 0x0F,
  0x78, 0x1E, 0x00, 0xF8, 0x07, 0xBC, 0x0F, 0x00, 0xFC, 0x07, 0x9E, 0x07,
  0x80, 0x7E, 0x07, 0xCF, 0x03, 0xE0, 0x7F, 0x07, 0xC7, 0x80, 0xF8, 0xF7,
  0xC7, 0xC3, 0xC0, 0x7F, 0xF9, 0xFF, 0xC0, 0xF0, 0x1F, 0xF0, 0xFF, 0xC0,
  0x78, 0x07, 0xF0, 0x3F, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x30, 0x00,
  0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0xF9,
  0xE0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x0F, 0x8F,
  0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x7C, 0x03, 0xC0, 0x01, 0xF0, 0x07, 0x80, 0x03, 0xE0, 0x0F, 0x00,
  0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0x00, 0x03, 0xC0, 0x3E, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x01, 0xE7, 0xE0, 0x00,
  0x03, 0xCF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0,
  0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x0F,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xFC, 0x07, 0xC0,
  0x1F, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xFC,
  0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF8, 0x3C, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0xF8, 0x07, 0xF8, 0x00, 0x40,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x03, 0xFC, 0x01, 0xF0, 0x01, 0xFC, 0x01,
  0xF0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03,
  0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0xFC, 0x3E,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x3E,
  0x00, 0x07, 0xE0, 0x3C, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x7F, 0x80, 0x7C,
  0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xC0,
  0xFE, 0x01, 0xFE, 0x00, 0x0C, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F,
  0xFC, 0xF8, 0x00, 0x7F, 0xF8, 0xF8, 0x00, 0x7F, 0xF8, 0xF8, 0x00, 0x7F,
  0xF8, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00,
  0xF0, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x03,
  0xE0, 0x7F, 0x00, 0x03, 0xE0, 0x3F, 0x80, 0x03, 0xE0, 0x1F, 0xE0, 0x07,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x08, 0x3F, 0x80, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x07, 0xC0,
  0x1F, 0x80, 0x03, 0xE0, 0x1F, 0x80, 0x01, 0xE0, 0x1F, 0x80, 0x01, 0xF0,
  0x1F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x01,
  0xEF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x7C, 0x00, 0x00,
  0x7F, 0x3E, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x03, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xE0,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x03,
  0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x1E, 0xF0, 0x00, 0x07, 0xFE, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0,
  0x1E, 0xF0, 0x00, 0x0F, 0xBC, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0xC0, 0x3E,
  0xF0, 0x00, 0x1F, 0x7C, 0x03, 0xEF, 0x00, 0x01, 0xE7, 0xC0, 0x3C, 0xF0,
  0x00, 0x3E, 0x78, 0x03, 0xCF, 0x80, 0x03, 0xCF, 0x80, 0x3C, 0x78, 0x00,
  0x78, 0xF8, 0x07, 0xC7, 0x80, 0x07, 0x8F, 0x80, 0x7C, 0x78, 0x00, 0xF0,
  0xF0, 0x07, 0x87, 0x80, 0x1F, 0x1F, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xF0,
  0x0F, 0x87, 0x80, 0x3E, 0x1F, 0x00, 0xF8, 0x78, 0x03, 0xC1, 0xF0, 0x0F,
  0x87, 0x80, 0x7C, 0x1E, 0x00, 0xF0, 0x3C, 0x07, 0x83, 0xE0, 0x0F, 0x03,
  0xC0, 0xF8, 0x3E, 0x01, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0x1F, 0x03, 0xC1,
  0xE0, 0x3E, 0x01, 0xF0, 0x3C, 0x1E, 0x03, 0xC0, 0x1E, 0x03, 0xC3, 0xC0,
  0x7C, 0x01, 0xE0, 0x3C, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xC7, 0x80, 0x7C,
  0x03, 0xE0, 0x3E, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xEF, 0x00, 0x78, 0x03,
  0xC0, 0x1F, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xFE, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xFC, 0x00, 0xF8, 0x07, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x78, 0x01, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x0F, 0xE0,
  0x00, 0x1F, 0x01, 0xFE, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0x00, 0x1E, 0x01,
  0xFF, 0x00, 0x01, 0xE0, 0x1F, 0xF0, 0x00, 0x3E, 0x01, 0xEF, 0x00, 0x03,
  0xE0, 0x3E, 0xF8, 0x00, 0x3E, 0x03, 0xE7, 0x80, 0x03, 0xC0, 0x3C, 0x7C,
  0x00, 0x7C, 0x03, 0xC7, 0xC0, 0x07, 0xC0, 0x3C, 0x3C, 0x00, 0x7C, 0x07,
  0xC3, 0xE0, 0x07, 0x80, 0x7C, 0x3E, 0x00, 0x78, 0x07, 0x81, 0xE0, 0x0F,
  0x80, 0x78, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x07, 0x81, 0xF0, 0x0F,
  0x00, 0x7C, 0x1F, 0x01, 0xF0, 0x07, 0xC1, 0xF0, 0x1F, 0x00, 0x3C, 0x1E,
  0x01, 0xF0, 0x03, 0xE1, 0xE0, 0x1E, 0x00, 0x3E, 0x3E, 0x01, 0xE0, 0x01,
  0xE3, 0xE0, 0x3E, 0x00, 0x1F, 0x3E, 0x03, 0xE0, 0x00, 0xF3, 0xC0, 0x3E,
  0x00, 0x0F, 0xBC, 0x03, 0xC0, 0x00, 0xFB, 0xC0, 0x3C, 0x00, 0x07, 0xFC,
  0x07, 0xC0, 0x00, 0x7F, 0x80, 0x7C, 0x00, 0x07, 0xF8, 0x07, 0x80, 0x00,
  0x3F, 0x80, 0x78, 0x00, 0x03, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x00, 0x7D, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x0F, 0xCF,
  0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xF0,
  0x07, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xF8, 0x03, 0xF8, 0x07,
  0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07,
  0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x3F, 0x01, 0xE0, 0x07, 0xF0, 0x1F, 0x01,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0xBE, 0x00,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x07, 0xE1, 0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x17, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0xF8, 0x03, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x01, 0xE0,
  0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01,
  0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x7F, 0x01, 0xE0,
  0x1F, 0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0xF8, 0x07, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x3C, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x07,
  0xC0, 0x3C, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF8, 0x3C, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xE0, 0xFC, 0x07, 0xE0, 0x03, 0x80,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x10, 0x00, 0x3F, 0x83, 0xC0, 0x0F,
  0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01,
  0xF0, 0x3C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x3F, 0x00,
  0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x50, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xF1, 0xE0, 0x00,
  0x0F, 0x87, 0x80, 0x00, 0x7E, 0x1E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0x00, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x0F,
  0x80, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1E, 0x0F, 0x80,
  0x00, 0x78, 0x3C, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x1E, 0x3E, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07,
  0xDE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xE0, 0x00, 0x7D, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xF8, 0x00, 0x3E, 0x7C, 0x00,
  0x3F, 0xC0, 0x01, 0xF3, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0x1F, 0x00, 0x0F,
  0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF7, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xBC,
  0x00, 0x7C, 0x3E, 0x00, 0x79, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xCF, 0x00,
  0x3E, 0x0F, 0x80, 0x3E, 0x78, 0x01, 0xE0, 0x7C, 0x01, 0xE3, 0xC0, 0x1F,
  0x03, 0xE0, 0x1F, 0x1E, 0x00, 0xF8, 0x1F, 0x00, 0xF0, 0xF0, 0x0F, 0x80,
  0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x3E, 0x07, 0xC0, 0x1E,
  0x07, 0xC0, 0xF0, 0x3E, 0x00, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x07, 0x83,
  0xE0, 0x3C, 0x1F, 0x00, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0,
  0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x78, 0x78, 0x00, 0x78, 0x78, 0x03,
  0xC7, 0xC0, 0x03, 0xC7, 0xC0, 0x1E, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0xF1,
  0xE0, 0x00, 0xF3, 0xE0, 0x07, 0x9F, 0x00, 0x07, 0x9E, 0x00, 0x3C, 0xF0,
  0x00, 0x3C, 0xF0, 0x01, 0xEF, 0x80, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0xFC, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x00, 0x3E, 0xFC,
  0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x1F,
  0x1E, 0x00, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF8, 0xF8,
  0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x7C,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x07, 0xE0, 0x0F, 0x00, 0xF8, 0x01, 0xF0,
  0x3E, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xC1, 0xF0, 0x00, 0x78, 0x7C, 0x00,
  0x0F, 0x9F, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x7C,
  0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x3E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07,
  0x83, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x00, 0xF0,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x03, 0xC0,
  0x03, 0xC0, 0x78, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78,
  0xF8, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0xF0, 0x00,
  0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x0F, 0x00, 0x7F,
  0xC1, 0xE0, 0x3F, 0xFC, 0x38, 0x0F, 0xFF, 0xCF, 0x03, 0xFF, 0xFD, 0xE0,
  0xFE, 0x07, 0xFC, 0x1F, 0x80, 0x7F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x00,
  0xFC, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0x7C, 0x3E,
  0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07,
  0xC7, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xC0,
  0x01, 0xF8, 0x78, 0x00, 0x3F, 0x0F, 0x00, 0x0F, 0xC1, 0xF0, 0x03, 0xF8,
  0x3E, 0x00, 0x7F, 0x07, 0xC0, 0x1F, 0xE0, 0xFC, 0x0F, 0xFC, 0x0F, 0xFF,
  0xEF, 0x01, 0xFF, 0xF9, 0xE0, 0x1F, 0xFC, 0x3C, 0x01, 0xFF, 0x07, 0x80,
  0x02, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x1F, 0xE0,
  0x0F, 0x8F, 0xFE, 0x01, 0xF3, 0xFF, 0xE0, 0x3C, 0xFF, 0xFC, 0x07, 0xBC,
  0x0F, 0xC1, 0xFF, 0x00, 0xF8, 0x3F, 0xC0, 0x1F, 0x07, 0xF0, 0x01, 0xF0,
  0xFC, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xF8, 0xF8, 0x00,
  0x1F, 0x1F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x1F, 0x1F,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03,
  0xE1, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE1, 0xF8,
  0x00, 0xF8, 0x3F, 0x80, 0x3F, 0x0F, 0xF8, 0x0F, 0xC1, 0xE7, 0xEF, 0xF0,
  0x3C, 0xFF, 0xFC, 0x07, 0x8F, 0xFF, 0x00, 0xE0, 0xFF, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFE, 0x0F, 0xE0, 0x08, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0xC1, 0xFF,
  0x3F, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xFC, 0x3E,
  0x00, 0xFF, 0xF1, 0xE0, 0x0F, 0xFF, 0xCF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F,
  0xE0, 0x3F, 0xC0, 0xFC, 0x01, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0x3F, 0x03, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7C,
  0x0F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00,
  0x1F, 0x03, 0xC0, 0x01, 0xF8, 0x1E, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0xFC,
  0x07, 0xC0, 0x0F, 0xE0, 0x3E, 0x00, 0x7F, 0x01, 0xF0, 0x07, 0xF8, 0x0F,
  0xC0, 0xF7, 0xC0, 0x3F, 0xDF, 0x3C, 0x01, 0xFF, 0xF1, 0xE0, 0x07, 0xFF,
  0x0F, 0x00, 0x1F, 0xF0, 0x78, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xC0, 0x7C,
  0x3E, 0x01, 0xF1, 0xF0, 0x03, 0xCF, 0x80, 0x0F, 0x3E, 0x00, 0x7D, 0xF0,
  0x01, 0xF7, 0xC0, 0x0F, 0x9F, 0x00, 0xFE, 0xF8, 0x7F, 0xF3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x08, 0x7E, 0x00, 0xE1, 0xFF, 0x3F, 0x83, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x02, 0x1F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x78,
  0x03, 0xFF, 0xC3, 0x80, 0x3F, 0xFF, 0x3C, 0x03, 0xFF, 0xFD, 0xE0, 0x3F,
  0x80, 0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x00,
  0xFC, 0x0F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8,
  0x3E, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x7C, 0x0F, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x3F, 0x03, 0xC0, 0x03, 0xF0,
  0x1F, 0x00, 0x3F, 0x80, 0xF8, 0x01, 0xFC, 0x07, 0xC0, 0x1F, 0xE0, 0x3F,
  0x03, 0xDF, 0x00, 0xFF, 0x7C, 0xF0, 0x07, 0xFF, 0xCF, 0x80, 0x1F, 0xFC,
  0x7C, 0x00, 0x7F, 0xC3, 0xE0, 0x00, 0x60, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x0C, 0x00, 0x3F, 0x00, 0x7C, 0x07,
  0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC1, 0xFE, 0x01,
  0xF1, 0xFF, 0xC0, 0x7C, 0xFF, 0xF8, 0x1E, 0x7F, 0xFF, 0x07, 0xBC, 0x07,
  0xC3, 0xFE, 0x01, 0xF0, 0xFF, 0x00, 0x7C, 0x3F, 0x80, 0x1F, 0x0F, 0xC0,
  0x07, 0xC3, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F,
  0x00, 0x07, 0x87, 0xC0, 0x03, 0xE1, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xC3, 0xE0, 0x01, 0xF0, 0xF0, 0x00,
  0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x03, 0xE1, 0xE0,
  0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xC3,
  0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x60, 0x07, 0x80, 0x7E,
  0x03, 0xF0, 0x1F, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x87, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x07, 0xC0,
  0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x03, 0xC0, 0x7E, 0x00,
  0xF8, 0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0x78, 0x7E,
  0x00, 0x0F, 0x1F, 0x80, 0x03, 0xE7, 0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x0F,
  0x3E, 0x00, 0x01, 0xEF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFC, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0x81, 0xF0, 0x01, 0xF0,
  0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0xC0,
  0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00,
  0x3E, 0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xC3, 0xFC,
  0x01, 0xFE, 0x01, 0xE1, 0xFF, 0x81, 0xFF, 0xE0, 0x78, 0xFF, 0xF0, 0xFF,
  0xF8, 0x1E, 0x7F, 0xFC, 0x7F, 0xFF, 0x07, 0xBC, 0x0F, 0xBE, 0x07, 0xC1,
  0xFC, 0x03, 0xEE, 0x01, 0xF0, 0xFE, 0x00, 0x7F, 0x00, 0x7C, 0x3F, 0x80,
  0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xF0,
  0x01, 0xF1, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xC0, 0x03, 0xE1, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x8F, 0x80, 0x07, 0x80, 0x03, 0xC3, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xC0, 0x03, 0xE1, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x8F, 0x80, 0x07, 0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xE0, 0x01, 0xF0,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x7C, 0x3F,
  0xE0, 0x0F, 0x8F, 0xFF, 0x01, 0xE3, 0xFF, 0xE0, 0x3C, 0xFF, 0xFE, 0x07,
  0xBE, 0x0F, 0xC1, 0xFF, 0x00, 0xF8, 0x3F, 0xC0, 0x1F, 0x07, 0xF0, 0x03,
  0xE0, 0xFC, 0x00, 0x7C, 0x3F, 0x80, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xFC,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x3E,
  0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80,
  0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xE1,
  0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00,
  0x7C, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0xFE, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0x1E, 0x3E, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0xDE,
  0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF0,
  0xF8, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x78, 0x3F, 0xC0, 0x03,
  0xC3, 0xFF, 0x80, 0x0F, 0x1F, 0xFF, 0x00, 0x3C, 0xFF, 0xFC, 0x00, 0xF7,
  0x81, 0xF8, 0x03, 0xFC, 0x03, 0xE0, 0x1F, 0xE0, 0x0F, 0x80, 0x7F, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x03, 0xE0,
  0x3C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0xC0,
  0x03, 0xE0, 0x3F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x7C, 0x03, 0xF8, 0x03,
  0xF0, 0x1F, 0xF0, 0x1F, 0x80, 0x7D, 0xFB, 0xFC, 0x01, 0xF7, 0xFF, 0xE0,
  0x07, 0xCF, 0xFF, 0x00, 0x1E, 0x1F, 0xF0, 0x00, 0xF8, 0x04, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC1,
  0xE0, 0x3F, 0xFC, 0x38, 0x0F, 0xFF, 0xCF, 0x03, 0xFF, 0xFD, 0xE0, 0xFE,
  0x07, 0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC,
  0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0x7C, 0x3E, 0x00,
  0x0F, 0x8F, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7,
  0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xC0, 0x01,
  0xF8, 0x78, 0x00, 0x3F, 0x0F, 0x00, 0x0F, 0xC1, 0xF0, 0x03, 0xF8, 0x3E,
  0x00, 0x7F, 0x07, 0xC0, 0x1F, 0xE0, 0xFC, 0x0F, 0x7C, 0x0F, 0xF7, 0xCF,
  0x01, 0xFF, 0xF3, 0xE0, 0x1F, 0xFC, 0x7C, 0x01, 0xFF, 0x0F, 0x80, 0x06,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC3, 0xF8, 0x3C, 0x3F,
  0xC1, 0xE3, 0xFE, 0x0F, 0x3F, 0xE0, 0x7B, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xC0, 0x18, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x20, 0x00, 0xF8, 0xE0, 0x07, 0xE3, 0xF0, 0xFF, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF8,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7F,
  0x38, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0x00, 0x00, 0x0F,
  0x80, 0x03, 0xE1, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x1F, 0x07, 0x80, 0x03,
  0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xE0, 0xF8,
  0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3C,
  0x1F, 0x00, 0x07, 0x83, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC3,
  0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01,
  0xF8, 0x3E, 0x00, 0x7F, 0x07, 0xC0, 0x1F, 0xE0, 0xFC, 0x0F, 0x7C, 0x1F,
  0xEF, 0xCF, 0x01, 0xFF, 0xF1, 0xE0, 0x1F, 0xFC, 0x3C, 0x01, 0xFF, 0x07,
  0x80, 0x02, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xBE,
  0x00, 0x0F, 0xDF, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3,
  0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0x3C, 0x00, 0xF8,
  0x1E, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E,
  0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x1E, 0x1F,
  0x00, 0x0F, 0x0F, 0x80, 0x07, 0x8F, 0x80, 0x03, 0xC7, 0xC0, 0x01, 0xE7,
  0xC0, 0x00, 0xF3, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xE0, 0x03, 0xEF, 0x80, 0x1F,
  0xC0, 0x0F, 0xBE, 0x00, 0x7F, 0x00, 0x3E, 0xF8, 0x03, 0xFC, 0x01, 0xF3,
  0xE0, 0x0F, 0xF0, 0x07, 0xCF, 0x80, 0x7B, 0xC0, 0x3E, 0x3E, 0x01, 0xEF,
  0x00, 0xF8, 0xF8, 0x0F, 0x3C, 0x07, 0xC3, 0xE0, 0x3C, 0xF0, 0x1F, 0x07,
  0x81, 0xF3, 0xC0, 0xF8, 0x1E, 0x07, 0x8F, 0x03, 0xE0, 0x78, 0x3E, 0x3C,
  0x0F, 0x01, 0xE0, 0xF0, 0xF0, 0x7C, 0x07, 0x83, 0xC3, 0xC1, 0xE0, 0x1E,
  0x1E, 0x0F, 0x0F, 0x80, 0x78, 0x78, 0x3C, 0x3E, 0x01, 0xE3, 0xC0, 0xF1,
  0xF0, 0x07, 0x8F, 0x03, 0xC7, 0xC0, 0x1E, 0x78, 0x0F, 0x1E, 0x00, 0x79,
  0xE0, 0x1C, 0xF8, 0x01, 0xEF, 0x00, 0x73, 0xC0, 0x07, 0xBC, 0x01, 0xDF,
  0x00, 0x1E, 0xE0, 0x07, 0x78, 0x00, 0x7F, 0x80, 0x1D, 0xE0, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xC0,
  0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0xF8, 0x0F,
  0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x0F, 0x80,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF0, 0xF0,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x1F,
  0x80, 0x07, 0x80, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x03, 0xE0,
  0x00, 0xF0, 0x01, 0xF0, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x1F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x9F, 0xF8, 0x00, 0x5F, 0xFF, 0x00, 0x7F, 0xFF, 0xF9, 0xFF,
  0x9F, 0xFF, 0xFE, 0x00, 0xFF, 0xFA, 0x00, 0x1F, 0xF9, 0x00, 0x00, 0x40,
};

const GFXglyph NotoSans_Italic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 14, 40, 14, 1, -39 },
  { 71, 16, 14, 21, 6, -39 },
  { 99, 33, 39, 35, 2, -39 },
  { 260, 26, 44, 30, 2, -41 },
  { 403, 37, 40, 43, 4, -39 },
  { 588, 33, 40, 36, 2, -39 },
  { 753, 7, 14, 12, 6, -39 },
  { 766, 18, 48, 16, 2, -39 },
  { 874, 17, 48, 16, -4, -39 },
  { 976, 24, 25, 30, 6, -41 },
  { 1051, 25, 26, 31, 4, -32 },
  { 1133, 10, 13, 14, -2, -6 },
  { 1150, 14, 5, 17, 1, -17 },
  { 1159, 7, 8, 14, 1, -7 },
  { 1166, 26, 39, 19, -2, -39 },
  { 1293, 26, 40, 30, 3, -39 },
  { 1423, 16, 39, 30, 8, -39 },
  { 1501, 29, 39, 30, 0, -39 },
  { 1643, 27, 40, 30, 1, -39 },
  { 1778, 29, 39, 30, 0, -39 },
  { 1920, 27, 40, 30, 2, -39 },
  { 2055, 26, 40, 30, 3, -39 },
  { 2185, 26, 39, 30, 4, -39 },
  { 2312, 27, 40, 30, 2, -39 },
  { 2447, 25, 40, 30, 3, -39 },
  { 2572, 11, 31, 14, 1, -30 },
  { 2615, 15, 37, 14, -3, -30 },
  { 2685, 25, 27, 31, 4, -33 },
  { 2770, 25, 14, 31, 4, -26 },
  { 2814, 25, 27, 31, 4, -33 },
  { 2899, 21, 40, 23, 4, -39 },
  { 3004, 41, 44, 46, 3, -39 },
  { 3230, 31, 39, 30, -3, -39 },
  { 3382, 30, 39, 32, 2, -39 },
  { 3529, 30, 40, 32, 4, -39 },
  { 3679, 32, 39, 36, 2, -39 },
  { 3835, 28, 39, 28, 2, -39 },
  { 3972, 28, 39, 26, 2, -39 },
  { 4109, 32, 40, 37, 4, -39 },
  { 4269, 35, 39, 37, 2, -39 },
  { 4440, 22, 39, 18, -1, -39 },
  { 4548, 23, 49, 15, -8, -39 },
  { 4689, 33, 39, 30, 2, -39 },
  { 4850, 21, 39, 26, 2, -39 },
  { 4953, 44, 39, 45, 2, -39 },
  { 5168, 36, 39, 38, 2, -39 },
  { 5344, 33, 40, 39, 4, -39 },
  { 5509, 29, 39, 31, 2, -39 },
  { 5651, 33, 48, 39, 4, -39 },
  { 5849, 29, 39, 31, 2, -39 },
  { 5991, 27, 40, 27, 1, -39 },
  { 6126, 27, 39, 27, 5, -39 },
  { 6258, 33, 40, 37, 4, -39 },
  { 6423, 30, 39, 30, 5, -39 },
  { 6570, 45, 39, 46, 6, -39 },
  { 6790, 36, 39, 28, -3, -39 },
  { 6966, 27, 39, 27, 5, -39 },
  { 7098, 32, 39, 29, -1, -39 },
  { 7254, 20, 48, 16, 0, -39 },
  { 7374, 10, 39, 19, 6, -39 },
  { 7423, 21, 48, 16, -4, -39 },
  { 7549, 27, 25, 31, 2, -39 },
  { 7634, 22, 4, 21, -5, 5 },
  { 7645, 9, 8, 15, 8, -41 },
  { 7654, 27, 30, 31, 3, -29 },
  { 7756, 27, 42, 31, 2, -41 },
  { 7898, 22, 30, 24, 3, -29 },
  { 7981, 29, 42, 31, 3, -41 },
  { 8134, 22, 30, 27, 3, -29 },
  { 8217, 30, 54, 17, -6, -41 },
  { 8420, 29, 42, 31, 1, -29 },
  { 8573, 26, 41, 31, 2, -41 },
  { 8707, 13, 40, 14, 2, -40 },
  { 8772, 22, 53, 14, -7, -40 },
  { 8918, 27, 41, 27, 1, -41 },
  { 9057, 14, 41, 14, 1, -41 },
  { 9129, 42, 29, 47, 2, -29 },
  { 9282, 27, 30, 31, 1, -30 },
  { 9384, 25, 29, 30, 3, -29 },
  { 9475, 30, 42, 31, -1, -29 },
  { 9633, 27, 42, 31, 3, -29 },
  { 9775, 21, 29, 21, 2, -29 },
  { 9852, 22, 30, 23, 0, -29 },
  { 9935, 18, 37, 18, 2, -36 },
  { 10019, 27, 30, 31, 3, -29 },
  { 10121, 25, 29, 25, 3, -29 },
  { 10212, 38, 29, 39, 3, -29 },
  { 10350, 30, 29, 26, -2, -29 },
  { 10459, 33, 42, 25, -5, -29 },
  { 10633, 25, 29, 24, -1, -29 },
  { 10724, 21, 48, 19, 1, -39 },
  { 10850, 4, 54, 30, 14, -41 },
  { 10877, 21, 48, 19, -2, -39 },
  { 11003, 25, 8, 31, 4, -23 },
};

const GFXfont NotoSans_Italic54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic54pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_ITALIC54PT7B_H_
