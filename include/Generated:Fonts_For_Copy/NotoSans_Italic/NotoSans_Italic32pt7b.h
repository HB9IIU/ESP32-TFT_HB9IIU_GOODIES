#ifndef _NOTOSANS_ITALIC32PT7B_H_
#define _NOTOSANS_ITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18,
  0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x00, 0x00, 0x60, 0xF0, 0xF0, 0xE0,
  0x39, 0xDC, 0x77, 0x1D, 0xC6, 0x61, 0x98, 0xE6, 0x33, 0x8C, 0x00, 0x61,
  0xC0, 0x0E, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x01, 0xC3, 0x80, 0x18,
  0x30, 0x01, 0x83, 0x03, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0x30, 0x60, 0x03,
  0x0E, 0x00, 0x70, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x1C, 0x30, 0x01, 0x83, 0x00,
  0x18, 0x30, 0x01, 0x87, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x70, 0x03, 0xFF, 0x0F, 0xFE, 0x1E, 0x62, 0x1C, 0xE0, 0x18, 0xC0,
  0x18, 0xC0, 0x1C, 0xC0, 0x1E, 0xC0, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x01, 0xB8, 0x01, 0x9C, 0x03, 0x1C, 0x03, 0x1C, 0x03, 0x38, 0xC3, 0x78,
  0xFF, 0xF0, 0x7F, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x1F, 0x00, 0x71, 0xFC, 0x03, 0x1C, 0x60, 0x30, 0xC3, 0x03, 0x8E, 0x18,
  0x38, 0x60, 0xC1, 0x83, 0x06, 0x18, 0x18, 0x31, 0xC0, 0xC3, 0x9C, 0x06,
  0x18, 0xCF, 0x30, 0xCC, 0xFD, 0x8E, 0xEE, 0x7F, 0xEE, 0x61, 0xBE, 0x67,
  0x0C, 0x06, 0x30, 0x60, 0x71, 0x83, 0x07, 0x1C, 0x38, 0x30, 0xE1, 0xC3,
  0x07, 0x0C, 0x38, 0x38, 0xE3, 0x81, 0xC6, 0x18, 0x07, 0xF1, 0xC0, 0x1F,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0x8E, 0x00, 0x70, 0x70, 0x06,
  0x07, 0x00, 0x60, 0x70, 0x06, 0x0E, 0x00, 0x71, 0xE0, 0x07, 0x3C, 0x00,
  0x3F, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x1E, 0xE0, 0x67, 0x8E, 0x0E,
  0x70, 0x70, 0xEE, 0x03, 0x9C, 0xE0, 0x3F, 0x8E, 0x01, 0xF0, 0xE0, 0x0E,
  0x0E, 0x01, 0xF0, 0x70, 0x7F, 0x87, 0xFF, 0x38, 0x1F, 0xC1, 0xC0, 0x3B,
  0x9C, 0xE6, 0x31, 0x9C, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x1C,
  0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x18, 0x03,
  0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x00, 0xC0, 0x38, 0x06,
  0x01, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x03, 0x80, 0xC0,
  0x70, 0x38, 0x0C, 0x07, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x02,
  0x0C, 0x07, 0x18, 0x1F, 0xB0, 0x03, 0xFF, 0x81, 0xFF, 0x07, 0x80, 0x39,
  0x80, 0xE3, 0x03, 0xC7, 0x03, 0x0E, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x7F, 0xFF,
  0xFF, 0xFE, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x1C, 0xF3, 0x8E, 0x71, 0x8E, 0x30, 0xFF, 0xFF, 0xFE, 0x6F,
  0xFE, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x03, 0xF0, 0x0F,
  0xF8, 0x3C, 0xF0, 0xE0, 0xF3, 0xC0, 0xE7, 0x01, 0xDC, 0x03, 0xB8, 0x07,
  0x70, 0x0E, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xB8,
  0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x73, 0x80, 0xE7, 0x03, 0x87, 0x1E,
  0x0F, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0x83, 0xC7, 0xEF, 0xEF, 0xF7, 0x39,
  0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0x01, 0xFC, 0x03, 0xFF, 0x83,
  0xE3, 0xC0, 0xC0, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x07, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF0, 0x03, 0xF8, 0x0F, 0xFE,
  0x1F, 0x1E, 0x08, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x3C, 0x07, 0xF0, 0x07, 0xE0, 0x09, 0xF0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x80, 0x38,
  0xE0, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0x60, 0x03, 0xF0, 0x03, 0xB8, 0x03, 0x98, 0x03, 0x8C, 0x03,
  0x8E, 0x01, 0xC7, 0x01, 0xC3, 0x81, 0xC1, 0x81, 0xC1, 0xC1, 0xC0, 0xE1,
  0xC0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x03, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1F, 0xE0, 0x1F, 0xF8, 0x18, 0x7C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x80, 0x38, 0xE0,
  0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x00, 0xFE, 0x07, 0xFC, 0x1F, 0x08, 0x78,
  0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE7, 0xE1,
  0xFF, 0xE3, 0xE1, 0xCF, 0x01, 0xDE, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0,
  0x1D, 0xC0, 0x3B, 0x80, 0xE7, 0x81, 0xC7, 0x8F, 0x07, 0xFC, 0x07, 0xF0,
  0x00, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFC, 0x03,
  0xFE, 0x07, 0x8F, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E,
  0x07, 0x0F, 0x0E, 0x07, 0xBC, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0x78, 0x38,
  0x3C, 0x70, 0x1C, 0x70, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0x70,
  0x1C, 0x78, 0x7C, 0x3F, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xFC, 0x0F,
  0x1E, 0x1C, 0x0E, 0x1C, 0x06, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38,
  0x07, 0x38, 0x0F, 0x38, 0x0E, 0x3C, 0x1E, 0x1F, 0xFE, 0x0F, 0xEE, 0x03,
  0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0xC1,
  0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x08, 0x73, 0xCF, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x3C, 0xF3, 0x80, 0x01, 0x01, 0xC1, 0xE0, 0xF0,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x38, 0x1C, 0x1C, 0x0E, 0x06, 0x07, 0x07, 0x00, 0x00, 0x06, 0x00, 0x3C,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xC0, 0x00,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x1E, 0x01,
  0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x1E, 0x00, 0x30, 0x00, 0x00, 0x1F,
  0xC3, 0xFF, 0x0E, 0x3C, 0x40, 0xE0, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x60, 0x07, 0x80, 0x78, 0x01, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0xF8, 0x07, 0x80,
  0x1C, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x38, 0x04, 0x07, 0x30, 0x3F,
  0xC3, 0x70, 0xFB, 0xC3, 0x61, 0xC1, 0xC3, 0xE1, 0x81, 0x83, 0xE3, 0x81,
  0x83, 0xC3, 0x03, 0x83, 0xC3, 0x03, 0x87, 0xC3, 0x03, 0x07, 0xC3, 0x07,
  0x06, 0xC3, 0x0F, 0x0E, 0xC3, 0xFF, 0xBC, 0xE1, 0xF9, 0xF8, 0xE0, 0xC0,
  0x40, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x40, 0x1F, 0x07,
  0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x6C, 0x00, 0x3B, 0x00, 0x0C, 0xC0, 0x07, 0x30, 0x01,
  0x8E, 0x00, 0xE3, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x0E, 0x0E, 0x03, 0x83,
  0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0E, 0x01, 0xC7, 0x00, 0x71,
  0xC0, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xDC, 0x00, 0x7F, 0x00, 0x0C, 0x07,
  0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x38, 0x0F, 0x0E, 0x01, 0xC3, 0x80,
  0x70, 0xE0, 0x1C, 0x30, 0x0E, 0x1C, 0x03, 0x87, 0x03, 0xC1, 0xFF, 0xE0,
  0x7F, 0xE0, 0x18, 0x1E, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x38,
  0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x38, 0x70, 0x7E, 0x1F, 0xFE,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x7E, 0x3C, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x0C, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xE0,
  0x1F, 0xFE, 0x07, 0x01, 0xE0, 0xE0, 0x1C, 0x1C, 0x01, 0xC3, 0x80, 0x38,
  0x60, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71,
  0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x79, 0xC0, 0x0E, 0x38, 0x03, 0xCE,
  0x00, 0xF1, 0xC0, 0x3C, 0x38, 0x0F, 0x07, 0x1F, 0xC0, 0xFF, 0xF0, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0x03, 0xFF,
  0x83, 0xFF, 0xC0, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x1F, 0x8F, 0x87,
  0xC0, 0x21, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x0F, 0xEE, 0x03, 0xFD, 0xC0,
  0x03, 0xB8, 0x00, 0xE7, 0x00, 0x1C, 0xF0, 0x03, 0x8E, 0x00, 0x71, 0xC0,
  0x0C, 0x3C, 0x03, 0x83, 0xE0, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x07,
  0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0C, 0x1C, 0x00, 0xE0, 0xE0, 0x07,
  0x07, 0x00, 0x38, 0x38, 0x01, 0xC1, 0x80, 0x0C, 0x1C, 0x00, 0xE0, 0xE0,
  0x07, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0x80, 0x1C, 0x1C, 0x00, 0xE0,
  0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x01, 0x83, 0x80, 0x1C, 0x1C, 0x00,
  0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x01, 0x83, 0x80, 0x1C, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x3F, 0xC3,
  0xFC, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x0D,
  0xF0, 0x3F, 0x80, 0xF8, 0x00, 0x07, 0x00, 0xF0, 0x70, 0x1E, 0x06, 0x03,
  0xC0, 0xE0, 0x78, 0x0E, 0x0F, 0x00, 0xE1, 0xE0, 0x0E, 0x3C, 0x00, 0xC7,
  0x80, 0x1C, 0xF0, 0x01, 0xDE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1E,
  0xE0, 0x03, 0xCE, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0x38, 0x07,
  0x03, 0x80, 0x70, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x00, 0xE0,
  0xE0, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7F, 0xF7, 0xFF,
  0xFF, 0xF0, 0x07, 0x80, 0x07, 0xC1, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0xFC,
  0x3F, 0x00, 0x36, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x06, 0xE0, 0xDC, 0x03,
  0xB8, 0x33, 0x00, 0xCC, 0x1C, 0xC0, 0x77, 0x07, 0x30, 0x19, 0xC1, 0xCC,
  0x0E, 0x70, 0x63, 0x07, 0x1C, 0x38, 0xE1, 0xC6, 0x0E, 0x38, 0xE3, 0x83,
  0x8E, 0x30, 0xE0, 0xE1, 0x9C, 0x38, 0x30, 0x66, 0x0E, 0x1C, 0x1B, 0x83,
  0x07, 0x06, 0xC1, 0xC1, 0xC1, 0xF0, 0x70, 0x70, 0x78, 0x1C, 0x18, 0x1E,
  0x07, 0x0E, 0x07, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x1E, 0x00, 0x70, 0x78,
  0x01, 0x83, 0xE0, 0x0E, 0x0F, 0xC0, 0x38, 0x3F, 0x00, 0xE0, 0xCE, 0x03,
  0x03, 0x38, 0x1C, 0x1C, 0xE0, 0x70, 0x71, 0xC1, 0xC1, 0xC7, 0x07, 0x06,
  0x0C, 0x18, 0x38, 0x38, 0xE0, 0xE0, 0xE3, 0x83, 0x81, 0x8E, 0x0E, 0x07,
  0x38, 0x30, 0x1C, 0xC1, 0xC0, 0x3F, 0x07, 0x00, 0xFC, 0x1C, 0x01, 0xF0,
  0x70, 0x07, 0x81, 0x80, 0x1E, 0x0E, 0x00, 0x38, 0x00, 0x00, 0xFF, 0x00,
  0x3F, 0xF8, 0x07, 0xE7, 0xC0, 0xF0, 0x1E, 0x1E, 0x00, 0xE3, 0xC0, 0x0F,
  0x38, 0x00, 0x73, 0x80, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xEE, 0x00,
  0x0E, 0xF0, 0x01, 0xE7, 0x00, 0x1C, 0x70, 0x03, 0xC7, 0x80, 0x78, 0x3E,
  0x3F, 0x01, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x01,
  0xFF, 0xC1, 0xC0, 0xF0, 0xE0, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x18, 0x07,
  0x1C, 0x03, 0x8E, 0x03, 0xC7, 0x03, 0xC3, 0x87, 0xC1, 0xFF, 0xC1, 0xFF,
  0x80, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x3F,
  0xF8, 0x07, 0xE7, 0xC0, 0xF0, 0x1E, 0x1E, 0x00, 0xE3, 0xC0, 0x0F, 0x38,
  0x00, 0x73, 0x80, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xEE, 0x00, 0x0E,
  0xF0, 0x01, 0xE7, 0x00, 0x1C, 0x70, 0x03, 0x87, 0x80, 0x78, 0x3E, 0x3F,
  0x01, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xFF,
  0xC1, 0xC0, 0xF0, 0xE0, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x18, 0x07, 0x1C,
  0x03, 0x8E, 0x03, 0x87, 0x03, 0xC3, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x80,
  0xE1, 0xC0, 0x70, 0x60, 0x38, 0x38, 0x38, 0x1C, 0x1C, 0x07, 0x0E, 0x03,
  0x87, 0x01, 0xC3, 0x00, 0x73, 0x80, 0x38, 0x03, 0xFC, 0x07, 0xFF, 0x0F,
  0x9E, 0x1E, 0x02, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x80, 0x78, 0xE1,
  0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0xE3, 0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x00,
  0xE3, 0x80, 0x1C, 0x70, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x0C, 0x70, 0x03,
  0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x31, 0xC0, 0x0E,
  0x38, 0x01, 0xC7, 0x00, 0x38, 0xC0, 0x06, 0x18, 0x01, 0xC3, 0x80, 0x38,
  0x70, 0x0E, 0x0F, 0x87, 0xC0, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xE0, 0x03,
  0xF8, 0x00, 0xEE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0E, 0x18, 0x03, 0x86,
  0x01, 0xC1, 0x80, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x01, 0xC1,
  0xC0, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x1C, 0x00, 0xC6, 0x00, 0x33, 0x80,
  0x0C, 0xC0, 0x03, 0x70, 0x00, 0xD8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x0E, 0x00, 0xFC, 0x01, 0xC0, 0x1D, 0x80, 0x78, 0x07,
  0x30, 0x0F, 0x00, 0xE6, 0x03, 0xE0, 0x38, 0xC0, 0x6C, 0x07, 0x18, 0x1D,
  0xC1, 0xC3, 0x03, 0x38, 0x38, 0x70, 0xE7, 0x06, 0x0E, 0x1C, 0xE1, 0xC1,
  0xC7, 0x1C, 0x30, 0x38, 0xE3, 0x8E, 0x07, 0x18, 0x71, 0xC0, 0xE7, 0x0E,
  0x70, 0x1C, 0xC1, 0xCE, 0x03, 0xB8, 0x19, 0x80, 0x76, 0x03, 0x70, 0x0F,
  0xC0, 0x6C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x1C,
  0x03, 0x80, 0xE0, 0x1C, 0x03, 0x81, 0xC0, 0x1C, 0x1C, 0x00, 0x61, 0xC0,
  0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0x6E, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x07, 0x70, 0x00,
  0x71, 0x80, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x03, 0x81, 0xC0, 0x38, 0x0E,
  0x03, 0x80, 0x70, 0x3C, 0x01, 0xC3, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0xE0,
  0x0E, 0x60, 0x1E, 0x70, 0x1C, 0x70, 0x38, 0x70, 0x78, 0x30, 0x70, 0x38,
  0xE0, 0x38, 0xE0, 0x39, 0xC0, 0x1B, 0x80, 0x1B, 0x80, 0x1F, 0x00, 0x1E,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0, 0x03,
  0xF0, 0x7F, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xFC, 0x0F, 0xC0, 0xE1, 0x86, 0x1C, 0x71, 0xC7, 0x0C, 0x30,
  0xC3, 0x8E, 0x38, 0xE1, 0x86, 0x18, 0x71, 0xC7, 0x1C, 0x30, 0xC0, 0x03,
  0xF0, 0x7F, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0xFC, 0x0F, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x07,
  0xC0, 0x06, 0x60, 0x0E, 0x60, 0x0C, 0x30, 0x1C, 0x30, 0x18, 0x18, 0x18,
  0x1C, 0x30, 0x0C, 0x30, 0x0E, 0x70, 0x06, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0xE7, 0x18, 0xE3, 0x8C, 0x07, 0xE7, 0x1F, 0xF6, 0x3C, 0x3E, 0x38,
  0x1E, 0x70, 0x1E, 0x70, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0,
  0x1C, 0xC0, 0x38, 0xC0, 0x38, 0xC0, 0x78, 0xE0, 0xF8, 0xF1, 0xB0, 0x7F,
  0x30, 0x3E, 0x30, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0xFC, 0x1D, 0xFE, 0x1F, 0x8E, 0x1E,
  0x07, 0x1C, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x70,
  0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x78, 0x3C, 0xF8, 0x78, 0xEF,
  0xF0, 0xC7, 0xE0, 0x07, 0xF8, 0xFF, 0x8F, 0x04, 0x70, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00,
  0x70, 0x03, 0xC1, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x0F, 0xCC,
  0x1F, 0xF6, 0x1E, 0x1F, 0x0E, 0x07, 0x8E, 0x03, 0xC7, 0x01, 0xC7, 0x00,
  0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x60, 0x1C, 0x30, 0x0E, 0x18,
  0x0F, 0x0E, 0x0F, 0x87, 0x8D, 0x81, 0xFC, 0xC0, 0x7C, 0x60, 0x07, 0xF0,
  0xFF, 0xCF, 0x0E, 0x70, 0x77, 0x03, 0xB8, 0x1F, 0x83, 0xDF, 0xFC, 0xFF,
  0x87, 0x80, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0xC1, 0x8F, 0xFC,
  0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xC0, 0x00, 0x07, 0xF3, 0x87, 0xFD, 0x87, 0x87, 0xC3, 0x81, 0xE3, 0x80,
  0xF1, 0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x18,
  0x07, 0x0C, 0x03, 0x86, 0x03, 0xC3, 0x83, 0xE1, 0xE3, 0x60, 0x7F, 0x30,
  0x1F, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x04, 0x07,
  0x03, 0xFF, 0x81, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0xFC,
  0x1D, 0xFE, 0x1F, 0x8F, 0x1E, 0x07, 0x1C, 0x07, 0x3C, 0x07, 0x38, 0x06,
  0x38, 0x0E, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x70, 0x1C,
  0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x18, 0xE0, 0x38, 0x02, 0x0F, 0x0F, 0x06,
  0x00, 0x00, 0x00, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38,
  0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0x00, 0x10, 0x03, 0xC0,
  0x1E, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x7E, 0x03, 0xE0, 0x0E, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0C, 0x01, 0x1C, 0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x1C, 0x70, 0x38, 0xE0,
  0x39, 0xC0, 0x3B, 0x80, 0x37, 0x80, 0x3F, 0x80, 0x7D, 0xC0, 0x71, 0xC0,
  0x71, 0xC0, 0x70, 0xE0, 0x60, 0xE0, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x38,
  0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18,
  0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0,
  0x1C, 0xFC, 0x3F, 0x0E, 0xFF, 0x3F, 0xC7, 0xC3, 0xB0, 0xE3, 0xC1, 0xF0,
  0x71, 0xC0, 0xF0, 0x39, 0xE0, 0x78, 0x1C, 0xE0, 0x38, 0x0E, 0x70, 0x1C,
  0x07, 0x38, 0x0E, 0x03, 0x38, 0x0E, 0x03, 0x9C, 0x07, 0x01, 0xCE, 0x03,
  0x80, 0xE7, 0x01, 0xC0, 0x73, 0x00, 0xC0, 0x33, 0x80, 0xE0, 0x39, 0xC0,
  0x70, 0x1C, 0xE0, 0x38, 0x0E, 0x00, 0x00, 0x10, 0x1C, 0xFE, 0x1D, 0xFE,
  0x1F, 0x8F, 0x1E, 0x07, 0x3C, 0x07, 0x3C, 0x07, 0x38, 0x0F, 0x38, 0x0E,
  0x38, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0x07, 0xF0, 0x3F, 0xF0, 0xF0, 0xF3,
  0xC0, 0xE7, 0x01, 0xDC, 0x01, 0xB8, 0x03, 0xF0, 0x06, 0xE0, 0x1D, 0x80,
  0x3B, 0x00, 0x76, 0x00, 0xEE, 0x03, 0x9C, 0x0E, 0x3C, 0x3C, 0x3F, 0xF0,
  0x1F, 0x80, 0x07, 0x3F, 0x01, 0xDF, 0xE0, 0x7E, 0x38, 0x1E, 0x07, 0x07,
  0x01, 0xC3, 0xC0, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0xC7, 0x00,
  0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x07, 0x07, 0x83, 0xC3, 0xE1, 0xE0,
  0xEF, 0xF0, 0x39, 0xF8, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0xE7, 0x1F, 0xF6, 0x3C, 0x3E, 0x38, 0x1E, 0x70, 0x1E, 0x70, 0x1C, 0xE0,
  0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xC0, 0x38, 0xC0, 0x38, 0xC0,
  0x78, 0xE0, 0xF8, 0xF1, 0xB0, 0x7F, 0x30, 0x3E, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xC0, 0x1C, 0xF8, 0xEF, 0x87, 0xE0, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0xC7, 0x04, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0x78, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0x73, 0x07, 0x9F, 0xF8, 0x7F, 0x80, 0x06, 0x00, 0xC0,
  0x38, 0x06, 0x07, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3F,
  0x83, 0xF0, 0x38, 0x07, 0x38, 0x0E, 0x38, 0x0E, 0x30, 0x0E, 0x70, 0x0E,
  0x70, 0x0C, 0x70, 0x1C, 0x70, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38,
  0xE0, 0x38, 0xE0, 0x78, 0xE0, 0xF8, 0xE1, 0xB0, 0xFF, 0x30, 0x7E, 0x30,
  0xC0, 0x1F, 0x80, 0x7E, 0x03, 0xB8, 0x0E, 0xE0, 0x73, 0x83, 0x8E, 0x0E,
  0x38, 0x70, 0x61, 0xC1, 0x8E, 0x06, 0x38, 0x19, 0xC0, 0x77, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x00, 0x78, 0x00, 0xE0, 0x78, 0x1F, 0x81, 0xE0, 0x7E,
  0x0F, 0x83, 0xB8, 0x3E, 0x0E, 0xE1, 0xF8, 0x73, 0x86, 0xE1, 0xCE, 0x39,
  0x8E, 0x38, 0xC6, 0x38, 0xE7, 0x18, 0xC3, 0x98, 0x67, 0x0E, 0xE1, 0x98,
  0x3B, 0x06, 0xE0, 0xEC, 0x1B, 0x83, 0xF0, 0x6C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0x80, 0x70, 0x1E, 0x00, 0x0E, 0x03, 0x87, 0x03, 0x81, 0x83, 0x80,
  0xE3, 0x80, 0x33, 0x80, 0x1D, 0xC0, 0x0F, 0xC0, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xF0, 0x01, 0xF8, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0xE1, 0xC0, 0xE0,
  0xE0, 0xE0, 0x30, 0xE0, 0x1C, 0x00, 0x06, 0x00, 0xE0, 0xE0, 0x1C, 0x1C,
  0x07, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x0E, 0x0E, 0x00, 0xC1, 0xC0, 0x18,
  0x70, 0x03, 0x0E, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0xDC, 0x00, 0x3B,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x03, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x3F, 0xF8, 0xFF, 0xE0,
  0x00, 0x38, 0x07, 0xC0, 0x7C, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x3C, 0x03, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00,
  0x78, 0x07, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1F, 0x00, 0xF0, 0x3F, 0x07, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0xF8, 0x0E, 0x00, 0x7F, 0x03, 0xFF, 0xDF, 0x07, 0xFC, 0x03, 0xC0,
};

const GFXglyph NotoSans_Italic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 23, 8, 1, -23 },
  { 24, 10, 8, 13, 3, -23 },
  { 34, 20, 23, 21, 1, -23 },
  { 92, 16, 26, 18, 1, -24 },
  { 144, 21, 23, 26, 3, -23 },
  { 205, 20, 23, 22, 1, -23 },
  { 263, 5, 8, 7, 3, -23 },
  { 268, 11, 28, 9, 1, -23 },
  { 307, 10, 28, 9, -2, -23 },
  { 342, 15, 14, 18, 3, -24 },
  { 369, 15, 15, 18, 2, -19 },
  { 398, 6, 8, 8, -1, -4 },
  { 404, 8, 3, 10, 1, -10 },
  { 407, 4, 4, 8, 1, -4 },
  { 409, 15, 23, 11, -1, -23 },
  { 453, 15, 23, 18, 2, -23 },
  { 497, 9, 23, 18, 5, -23 },
  { 523, 17, 23, 18, 0, -23 },
  { 572, 16, 23, 18, 1, -23 },
  { 618, 17, 23, 18, 0, -23 },
  { 667, 16, 23, 18, 1, -23 },
  { 713, 15, 23, 18, 2, -23 },
  { 757, 15, 23, 18, 3, -23 },
  { 801, 16, 23, 18, 1, -23 },
  { 847, 16, 23, 18, 1, -23 },
  { 893, 6, 18, 8, 1, -18 },
  { 907, 9, 22, 8, -2, -18 },
  { 932, 15, 15, 18, 2, -19 },
  { 961, 15, 9, 18, 2, -16 },
  { 978, 15, 15, 18, 2, -19 },
  { 1007, 13, 23, 14, 2, -23 },
  { 1045, 24, 26, 27, 2, -23 },
  { 1123, 18, 23, 18, -2, -23 },
  { 1175, 18, 23, 19, 1, -23 },
  { 1227, 18, 23, 19, 2, -23 },
  { 1279, 19, 23, 21, 1, -23 },
  { 1334, 17, 23, 16, 1, -23 },
  { 1383, 17, 23, 15, 1, -23 },
  { 1432, 19, 23, 22, 2, -23 },
  { 1487, 21, 23, 22, 1, -23 },
  { 1548, 13, 23, 10, -1, -23 },
  { 1586, 14, 29, 9, -5, -23 },
  { 1637, 20, 23, 18, 1, -23 },
  { 1695, 12, 23, 15, 1, -23 },
  { 1730, 26, 23, 27, 1, -23 },
  { 1805, 22, 23, 23, 1, -23 },
  { 1869, 20, 23, 23, 2, -23 },
  { 1927, 17, 23, 18, 1, -23 },
  { 1976, 20, 28, 23, 2, -23 },
  { 2046, 17, 23, 18, 1, -23 },
  { 2095, 16, 23, 16, 1, -23 },
  { 2141, 16, 23, 16, 3, -23 },
  { 2187, 19, 23, 22, 3, -23 },
  { 2242, 18, 23, 18, 3, -23 },
  { 2294, 27, 23, 27, 3, -23 },
  { 2372, 21, 23, 17, -2, -23 },
  { 2433, 16, 23, 16, 3, -23 },
  { 2479, 18, 23, 17, 0, -23 },
  { 2531, 12, 28, 9, 0, -23 },
  { 2573, 6, 23, 11, 3, -23 },
  { 2591, 12, 28, 9, -2, -23 },
  { 2633, 16, 14, 18, 1, -23 },
  { 2661, 13, 2, 13, -3, 3 },
  { 2665, 5, 6, 9, 5, -25 },
  { 2669, 16, 17, 18, 2, -17 },
  { 2703, 16, 24, 19, 1, -24 },
  { 2751, 13, 17, 15, 2, -17 },
  { 2779, 17, 24, 19, 2, -24 },
  { 2830, 13, 17, 16, 2, -17 },
  { 2858, 18, 32, 10, -4, -24 },
  { 2930, 17, 25, 19, 1, -17 },
  { 2984, 16, 24, 19, 1, -24 },
  { 3032, 8, 24, 8, 1, -24 },
  { 3056, 13, 32, 8, -4, -24 },
  { 3108, 16, 24, 16, 1, -24 },
  { 3156, 8, 24, 8, 1, -24 },
  { 3180, 25, 17, 28, 1, -17 },
  { 3234, 16, 18, 19, 1, -18 },
  { 3270, 15, 17, 18, 2, -17 },
  { 3302, 18, 25, 19, -1, -17 },
  { 3359, 16, 25, 19, 2, -17 },
  { 3409, 13, 17, 13, 1, -17 },
  { 3437, 13, 17, 14, 0, -17 },
  { 3465, 11, 21, 11, 1, -21 },
  { 3494, 16, 17, 19, 2, -17 },
  { 3528, 14, 17, 15, 2, -17 },
  { 3558, 22, 17, 23, 2, -17 },
  { 3605, 17, 17, 15, -1, -17 },
  { 3642, 19, 25, 15, -3, -17 },
  { 3702, 14, 17, 14, 0, -17 },
  { 3732, 13, 28, 11, 0, -23 },
  { 3778, 3, 32, 18, 8, -24 },
  { 3790, 12, 28, 11, -1, -23 },
  { 3832, 15, 4, 18, 2, -13 },
};

const GFXfont NotoSans_Italic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic32pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_ITALIC32PT7B_H_
