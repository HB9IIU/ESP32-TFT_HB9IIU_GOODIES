#ifndef _NOTOSANS_ITALIC14PT7B_H_
#define _NOTOSANS_ITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x22, 0x24, 0x40, 0x4C, 0xBA, 0xAA, 0x09, 0x04, 0x82, 0x4F,
  0xF1, 0x20, 0x93, 0xFC, 0x48, 0x24, 0x24, 0x00, 0x04, 0x10, 0xF9, 0x42,
  0x87, 0x07, 0x0B, 0x15, 0xF8, 0x41, 0x00, 0x70, 0x94, 0x49, 0x22, 0x50,
  0x97, 0xBA, 0x91, 0x4C, 0xD2, 0x24, 0x90, 0xC0, 0x1E, 0x09, 0x0C, 0x82,
  0xC1, 0x83, 0x45, 0x15, 0x8E, 0x46, 0x3C, 0x80, 0xF0, 0x12, 0x44, 0x88,
  0x88, 0x88, 0x8C, 0x11, 0x11, 0x11, 0x11, 0x32, 0x4C, 0x08, 0x13, 0x41,
  0xF2, 0x89, 0x02, 0x00, 0x10, 0x20, 0x47, 0xF1, 0x02, 0x00, 0x2D, 0x60,
  0xF0, 0x70, 0x02, 0x08, 0x10, 0x41, 0x82, 0x0C, 0x10, 0x41, 0x80, 0x3D,
  0x94, 0x71, 0x86, 0x18, 0x63, 0x89, 0xC0, 0x37, 0xB2, 0x22, 0x26, 0x44,
  0x1E, 0x44, 0x08, 0x10, 0x61, 0x86, 0x10, 0x41, 0xF8, 0x3E, 0x44, 0x08,
  0x11, 0xC5, 0x81, 0x83, 0x85, 0xF0, 0x02, 0x06, 0x0A, 0x16, 0x24, 0x64,
  0xC5, 0xFE, 0x0C, 0x08, 0x3E, 0xC1, 0x02, 0x07, 0x81, 0x81, 0x06, 0x89,
  0xE0, 0x1E, 0x41, 0x02, 0x0B, 0x98, 0xA1, 0x42, 0x88, 0xF0, 0x7F, 0x08,
  0x10, 0x41, 0x82, 0x08, 0x10, 0x41, 0x80, 0x3C, 0xCD, 0x1B, 0x23, 0x89,
  0x23, 0x42, 0x8D, 0xF0, 0x39, 0x1C, 0x61, 0xC5, 0xF0, 0xC2, 0x1B, 0xC0,
  0x2C, 0x00, 0x16, 0x13, 0x00, 0x00, 0x26, 0x48, 0x02, 0x0C, 0x63, 0x0C,
  0x07, 0x01, 0x80, 0xFC, 0x00, 0x3F, 0x81, 0x80, 0xC0, 0x60, 0xE6, 0x30,
  0x00, 0xFC, 0x42, 0x13, 0x31, 0x00, 0xC6, 0x00, 0x0F, 0x86, 0x19, 0x01,
  0x67, 0xA9, 0x27, 0x64, 0xA8, 0x95, 0xB6, 0x89, 0x08, 0x00, 0xF8, 0x00,
  0x06, 0x06, 0x0A, 0x0A, 0x13, 0x13, 0x3F, 0x21, 0x41, 0xC1, 0x3C, 0xC5,
  0x0A, 0x17, 0xC9, 0xB1, 0xC3, 0x85, 0xF0, 0x1F, 0x30, 0x40, 0x40, 0xC0,
  0x80, 0x80, 0xC0, 0x40, 0x7C, 0x3C, 0x62, 0x43, 0x41, 0x41, 0x43, 0xC2,
  0x86, 0x8C, 0xF8, 0x3E, 0xC1, 0x02, 0x07, 0xC8, 0x30, 0x40, 0x81, 0xF0,
  0x3E, 0xC1, 0x02, 0x04, 0x4F, 0x30, 0x40, 0x81, 0x00, 0x1F, 0x31, 0x40,
  0x40, 0xC0, 0x8F, 0x82, 0xC2, 0x42, 0x7E, 0x21, 0xB0, 0x90, 0x48, 0x27,
  0xF2, 0x13, 0x09, 0x04, 0x82, 0x43, 0x00, 0x38, 0x8C, 0x42, 0x10, 0x8C,
  0x47, 0x00, 0x04, 0x30, 0x82, 0x08, 0x21, 0x84, 0x10, 0x43, 0x38, 0xC0,
  0x23, 0x66, 0x4C, 0x58, 0x70, 0x50, 0xD8, 0x88, 0x8C, 0x84, 0x23, 0x10,
  0x84, 0x23, 0x10, 0x87, 0xC0, 0x20, 0x6A, 0x1D, 0x43, 0x28, 0xA5, 0x34,
  0xA5, 0xA5, 0x24, 0xA4, 0x98, 0x91, 0x30, 0x20, 0xB8, 0xD4, 0x4A, 0x25,
  0x92, 0x4A, 0x2D, 0x0C, 0x86, 0x43, 0x00, 0x1E, 0x10, 0x90, 0x78, 0x3C,
  0x1C, 0x0E, 0x05, 0x86, 0x46, 0x3E, 0x00, 0x3C, 0xCD, 0x0A, 0x14, 0x4F,
  0x30, 0x40, 0x81, 0x00, 0x1E, 0x10, 0x90, 0x78, 0x3C, 0x1C, 0x0E, 0x05,
  0x86, 0x46, 0x3E, 0x03, 0x00, 0xC0, 0x3C, 0xCD, 0x0A, 0x14, 0x4F, 0x32,
  0x44, 0x8D, 0x08, 0x1E, 0x45, 0x81, 0x03, 0x01, 0x81, 0x02, 0x8D, 0xF0,
  0xFE, 0x20, 0x41, 0x83, 0x04, 0x08, 0x10, 0x60, 0x80, 0x61, 0xA0, 0x90,
  0x48, 0x24, 0x36, 0x12, 0x09, 0x04, 0xC6, 0x3E, 0x00, 0xC3, 0xC2, 0x46,
  0x44, 0x4C, 0x48, 0x58, 0x50, 0x70, 0x60, 0xC6, 0x14, 0x63, 0x46, 0x24,
  0xA6, 0x4A, 0x45, 0x2C, 0x52, 0x86, 0x28, 0x63, 0x04, 0x30, 0x10, 0xC4,
  0x40, 0xB0, 0x38, 0x0C, 0x03, 0x01, 0x40, 0xD8, 0x62, 0x30, 0xC0, 0xC2,
  0x89, 0x32, 0x47, 0x06, 0x08, 0x10, 0x60, 0x80, 0x3F, 0x02, 0x06, 0x0C,
  0x08, 0x10, 0x20, 0x60, 0xC0, 0xFC, 0x39, 0x08, 0x42, 0x21, 0x08, 0x46,
  0x21, 0xC0, 0xAA, 0xAD, 0x50, 0x38, 0x42, 0x31, 0x08, 0x42, 0x21, 0x09,
  0xC0, 0x20, 0xC5, 0x92, 0x86, 0x10, 0xF8, 0x94, 0x32, 0xDB, 0x14, 0x28,
  0x51, 0xA6, 0x74, 0x10, 0x60, 0x81, 0x23, 0xA4, 0x58, 0xA1, 0x42, 0x8B,
  0xF0, 0x1B, 0x71, 0x08, 0x42, 0x1E, 0x02, 0x04, 0x09, 0xB6, 0xD8, 0xA1,
  0x42, 0x8D, 0x33, 0xA0, 0x31, 0xAC, 0xE6, 0xE2, 0x08, 0x3E, 0x03, 0x05,
  0x0C, 0x0E, 0x18, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x20, 0xE0,
  0x19, 0x37, 0x62, 0x42, 0x42, 0x46, 0x4C, 0x74, 0x04, 0x0C, 0xF8, 0x10,
  0x60, 0x81, 0x23, 0xA4, 0x58, 0xA1, 0x46, 0x8F, 0x10, 0x30, 0x22, 0x26,
  0x44, 0x4C, 0x0C, 0x00, 0x82, 0x08, 0x61, 0x04, 0x10, 0x43, 0x08, 0xE0,
  0x10, 0x60, 0x81, 0x12, 0x45, 0x14, 0x38, 0x48, 0x93, 0x10, 0x13, 0x22,
  0x22, 0x64, 0x44, 0xC0, 0x2C, 0x46, 0xF4, 0x8C, 0xB1, 0x14, 0x62, 0x8C,
  0x51, 0x1E, 0x22, 0x2C, 0x74, 0x8B, 0x14, 0x28, 0xD1, 0xE2, 0x11, 0xBC,
  0x61, 0x86, 0x18, 0x9C, 0x24, 0x74, 0x8B, 0x14, 0x28, 0x51, 0x3E, 0xC1,
  0x02, 0x00, 0x32, 0xDB, 0x14, 0x28, 0x51, 0xA6, 0x74, 0x08, 0x10, 0x60,
  0x2C, 0xF2, 0x18, 0x41, 0x04, 0x30, 0x39, 0xB4, 0x18, 0x38, 0x20, 0xBC,
  0x67, 0xC4, 0xC8, 0x88, 0xE0, 0x46, 0x8B, 0x16, 0x28, 0x51, 0xA6, 0x74,
  0x86, 0x38, 0xA6, 0x92, 0xCA, 0x30, 0x88, 0xE2, 0x29, 0x9A, 0x74, 0xA5,
  0x29, 0x8C, 0x63, 0x10, 0x21, 0x12, 0x14, 0x1C, 0x18, 0x1C, 0x24, 0xC6,
  0x21, 0x23, 0x22, 0x26, 0x24, 0x38, 0x18, 0x10, 0x10, 0x20, 0xE0, 0x3D,
  0x10, 0x84, 0x21, 0x8C, 0x3E, 0x0C, 0x41, 0x0C, 0x23, 0x8C, 0x08, 0x61,
  0x04, 0x18, 0xFF, 0xFC, 0x18, 0x20, 0x82, 0x10, 0x61, 0xC4, 0x30, 0x82,
  0x38, 0xE3, 0x38,
};

const GFXglyph NotoSans_Italic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 10, 4, 0, -10 },
  { 6, 4, 4, 5, 2, -10 },
  { 8, 9, 10, 9, 0, -10 },
  { 20, 7, 12, 8, 0, -11 },
  { 31, 10, 10, 11, 1, -10 },
  { 44, 9, 10, 9, 0, -10 },
  { 56, 1, 4, 3, 2, -10 },
  { 57, 4, 12, 4, 1, -10 },
  { 63, 4, 12, 4, -1, -10 },
  { 69, 7, 7, 8, 1, -11 },
  { 76, 7, 6, 8, 1, -8 },
  { 82, 3, 4, 4, -1, -2 },
  { 84, 4, 1, 4, 0, -4 },
  { 85, 2, 2, 4, 0, -2 },
  { 86, 7, 10, 5, -1, -10 },
  { 95, 6, 10, 8, 1, -10 },
  { 103, 4, 10, 8, 2, -10 },
  { 108, 7, 10, 8, 0, -10 },
  { 117, 7, 10, 8, 0, -10 },
  { 126, 8, 10, 8, 0, -10 },
  { 136, 7, 10, 8, 1, -10 },
  { 145, 7, 10, 8, 1, -10 },
  { 154, 7, 10, 8, 1, -10 },
  { 163, 7, 10, 8, 1, -10 },
  { 172, 6, 10, 8, 1, -10 },
  { 180, 3, 8, 4, 0, -8 },
  { 183, 4, 10, 4, -1, -8 },
  { 188, 7, 7, 8, 1, -9 },
  { 195, 6, 4, 8, 1, -7 },
  { 198, 7, 7, 8, 1, -9 },
  { 205, 5, 10, 6, 1, -10 },
  { 212, 11, 11, 12, 1, -10 },
  { 228, 8, 10, 8, -1, -10 },
  { 238, 7, 10, 8, 1, -10 },
  { 247, 8, 10, 8, 1, -10 },
  { 257, 8, 10, 9, 1, -10 },
  { 267, 7, 10, 7, 1, -10 },
  { 276, 7, 10, 7, 1, -10 },
  { 285, 8, 10, 9, 1, -10 },
  { 295, 9, 10, 10, 1, -10 },
  { 307, 5, 10, 5, 0, -10 },
  { 314, 6, 13, 4, -2, -10 },
  { 324, 8, 10, 8, 1, -10 },
  { 334, 5, 10, 7, 1, -10 },
  { 341, 11, 10, 12, 1, -10 },
  { 355, 9, 10, 10, 1, -10 },
  { 367, 9, 10, 10, 1, -10 },
  { 379, 7, 10, 8, 1, -10 },
  { 388, 9, 12, 10, 1, -10 },
  { 402, 7, 10, 8, 1, -10 },
  { 411, 7, 10, 7, 0, -10 },
  { 420, 7, 10, 7, 1, -10 },
  { 429, 9, 10, 9, 1, -10 },
  { 441, 8, 10, 8, 1, -10 },
  { 451, 12, 10, 12, 1, -10 },
  { 466, 10, 10, 7, -1, -10 },
  { 479, 7, 10, 7, 1, -10 },
  { 488, 8, 10, 7, 0, -10 },
  { 498, 5, 12, 4, 0, -10 },
  { 506, 2, 10, 5, 2, -10 },
  { 509, 5, 12, 4, -1, -10 },
  { 517, 6, 6, 8, 1, -10 },
  { 522, 5, 1, 6, -1, 1 },
  { 523, 2, 3, 4, 2, -11 },
  { 524, 7, 8, 8, 1, -8 },
  { 531, 7, 11, 8, 0, -11 },
  { 541, 5, 8, 6, 1, -8 },
  { 546, 7, 11, 8, 1, -11 },
  { 556, 6, 8, 7, 1, -8 },
  { 562, 8, 14, 4, -2, -11 },
  { 576, 8, 11, 8, 0, -8 },
  { 587, 7, 11, 8, 0, -11 },
  { 597, 4, 10, 4, 0, -10 },
  { 602, 6, 13, 4, -2, -10 },
  { 612, 7, 11, 7, 0, -11 },
  { 622, 4, 11, 4, 0, -11 },
  { 628, 11, 8, 12, 0, -8 },
  { 639, 7, 8, 8, 0, -8 },
  { 646, 6, 8, 8, 1, -8 },
  { 652, 7, 11, 8, 0, -8 },
  { 662, 7, 11, 8, 1, -8 },
  { 672, 6, 8, 6, 0, -8 },
  { 678, 6, 8, 6, 0, -8 },
  { 684, 4, 9, 5, 1, -9 },
  { 689, 7, 8, 8, 1, -8 },
  { 696, 6, 8, 7, 1, -8 },
  { 702, 10, 8, 10, 1, -8 },
  { 712, 8, 8, 7, -1, -8 },
  { 720, 8, 11, 7, -1, -8 },
  { 731, 6, 8, 6, 0, -8 },
  { 737, 6, 12, 5, 0, -10 },
  { 746, 1, 14, 8, 4, -11 },
  { 748, 6, 12, 5, -1, -10 },
  { 757, 7, 2, 8, 1, -6 },
};

const GFXfont NotoSans_Italic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic14pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_ITALIC14PT7B_H_
