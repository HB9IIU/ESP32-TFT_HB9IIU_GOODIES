#ifndef _NOTOSANS_ITALIC56PT7B_H_
#define _NOTOSANS_ITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x30,
  0x00, 0x3E, 0x0F, 0x9F, 0x0F, 0xCF, 0x87, 0xC7, 0x83, 0xE7, 0xC1, 0xF3,
  0xE0, 0xF1, 0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x1E, 0x1C, 0x0F,
  0x1E, 0x07, 0x8F, 0x03, 0x87, 0x81, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x78, 0x03, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xEF, 0xC0, 0x7E, 0x3C, 0x18,
  0x1F, 0x87, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07,
  0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0xC7, 0x80, 0x00,
  0xFC, 0xF0, 0x00, 0x0F, 0xDE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0E, 0xFE, 0x00, 0x01, 0xCF, 0xC0, 0x00, 0x78, 0xFC, 0x00, 0x0F, 0x0F,
  0x80, 0x01, 0xE1, 0xF0, 0x00, 0x38, 0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x01,
  0xE0, 0xF8, 0x00, 0x3C, 0x3E, 0x18, 0x07, 0x0F, 0xC3, 0xE0, 0xE7, 0xF0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xC0, 0x3F, 0xF0, 0x00, 0x1E,
  0x01, 0xFF, 0xE0, 0x00, 0xF8, 0x0F, 0x8F, 0x80, 0x07, 0xC0, 0x7C, 0x1E,
  0x00, 0x1E, 0x01, 0xE0, 0x7C, 0x00, 0xF0, 0x0F, 0x80, 0xF0, 0x07, 0xC0,
  0x3C, 0x03, 0xC0, 0x3E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x7C,
  0x07, 0x80, 0x1E, 0x01, 0xE0, 0x3E, 0x00, 0x78, 0x07, 0x81, 0xF0, 0x01,
  0xE0, 0x1E, 0x07, 0x80, 0x07, 0x80, 0x78, 0x3C, 0x00, 0x1E, 0x01, 0xE1,
  0xF0, 0x00, 0xF8, 0x0F, 0x07, 0x81, 0x83, 0xE0, 0x3C, 0x3C, 0x3F, 0xC7,
  0x81, 0xF1, 0xE3, 0xFF, 0x9E, 0x07, 0x8F, 0x9F, 0xFE, 0x78, 0x3E, 0x3C,
  0xFC, 0x7D, 0xF1, 0xF1, 0xE3, 0xC0, 0xF3, 0xFF, 0x8F, 0x1F, 0x03, 0xCF,
  0xFC, 0x7C, 0x78, 0x0F, 0x1F, 0xE1, 0xE3, 0xE0, 0x3C, 0x08, 0x0F, 0x0F,
  0x00, 0xF0, 0x00, 0x78, 0x3C, 0x03, 0xC0, 0x03, 0xE0, 0xF0, 0x0F, 0x00,
  0x0F, 0x07, 0xC0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x03, 0xE0, 0x78,
  0x07, 0x80, 0x1F, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x1E, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x0F, 0x00, 0xF8, 0x01, 0xE0,
  0x7C, 0x03, 0xC0, 0x07, 0xC1, 0xE0, 0x1E, 0x00, 0x0F, 0x9F, 0x80, 0xF8,
  0x00, 0x3F, 0xFC, 0x07, 0xC0, 0x00, 0x7F, 0xE0, 0x3E, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0x9F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0x3E, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x01, 0xF1,
  0xFC, 0x00, 0x00, 0x7D, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x7C, 0x00, 0x7C, 0x7F, 0x0F, 0x80, 0x1E,
  0x3F, 0x03, 0xF0, 0x0F, 0x8F, 0x80, 0x7E, 0x03, 0xE7, 0xC0, 0x0F, 0x81,
  0xF3, 0xF0, 0x03, 0xF0, 0xF8, 0xF8, 0x00, 0x7E, 0x7E, 0x3E, 0x00, 0x0F,
  0x9F, 0x0F, 0x80, 0x01, 0xFF, 0x83, 0xE0, 0x00, 0x7F, 0xC0, 0xF8, 0x00,
  0x0F, 0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xFE, 0x03, 0xF0,
  0x00, 0xFF, 0xC0, 0x7E, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x3E, 0x03,
  0xFF, 0xFF, 0x0F, 0xC0, 0x7F, 0xFF, 0x81, 0xF8, 0x07, 0xFF, 0x80, 0x3E,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x3E, 0x7C, 0xF9, 0xE7, 0xCF, 0x9F, 0x3C,
  0x78, 0xF1, 0xC7, 0x8F, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x04, 0x00, 0xF0, 0x01, 0xC0, 0x38, 0x00, 0xFC, 0x0E, 0x00, 0x3F,
  0xC3, 0x80, 0x0F, 0xFD, 0xC0, 0x00, 0x7F, 0xF1, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xF8, 0x02, 0x03, 0xEF,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x7E, 0x1E, 0x00, 0x3F,
  0x07, 0xC0, 0x1F, 0x80, 0xF0, 0x01, 0xC0, 0x3C, 0x00, 0x30, 0x0F, 0x80,
  0x08, 0x03, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF0, 0x3E, 0x07,
  0x81, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x00, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF,
  0xF7, 0xFF, 0xE0, 0x1C, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03,
  0xF0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x3E, 0x07, 0xC0, 0x07,
  0xC1, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF1, 0xF0,
  0x00, 0x3E, 0x7E, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F,
  0x3E, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x3E, 0x3E,
  0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x0F,
  0x81, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F,
  0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0xFF, 0x78, 0xFF, 0x7C, 0xFE, 0x3E, 0x3E,
  0x1F, 0x0C, 0x0F, 0x84, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xF0, 0x0F, 0xE0, 0x07, 0x00, 0x1F, 0x80, 0x18, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x7F,
  0x00, 0xE0, 0x03, 0xF0, 0x08, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x87, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x0C, 0x00, 0x07, 0xF0, 0xF8, 0x00, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0xFD, 0xF0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x1F, 0x1E, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x01,
  0xF8, 0x3C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0,
  0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x01, 0xE0, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0,
  0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0xC0,
  0x00, 0xFE, 0x0F, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x1F, 0xE0, 0x0F, 0x8F, 0xFE,
  0x01, 0xF3, 0xFF, 0xF0, 0x3E, 0xFF, 0xFE, 0x07, 0xFC, 0x0F, 0xE1, 0xFE,
  0x00, 0x7C, 0x3F, 0x80, 0x0F, 0xC7, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x1F,
  0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x00,
  0x01, 0xF1, 0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xF0,
  0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x3E, 0x00,
  0x7C, 0x07, 0xE0, 0x3F, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x03,
  0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01,
  0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0x1F,
  0x80, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x9F, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFC,
  0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xC1,
  0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00,
  0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x0F,
  0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFC,
  0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xC7,
  0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07,
  0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00,
  0x07, 0xCF, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x7F, 0x1F,
  0x00, 0x3F, 0x87, 0xF0, 0x3F, 0xE0, 0xFF, 0xFE, 0xF8, 0x3F, 0xFF, 0xBE,
  0x03, 0xFF, 0x8F, 0x80, 0x7F, 0x87, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x80, 0x1F, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x3E, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xFC, 0x07,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0x01, 0xFC, 0x40, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xFC,
  0x01, 0xE0, 0xF0, 0x03, 0xFF, 0xF0, 0x3E, 0x3C, 0x00, 0xFF, 0xFE, 0x03,
  0xC7, 0x80, 0x7F, 0xFF, 0xC0, 0x79, 0xE0, 0x1F, 0x80, 0xF0, 0x0F, 0x3C,
  0x07, 0xE0, 0x1E, 0x01, 0xEF, 0x80, 0xF8, 0x03, 0xC0, 0x3D, 0xE0, 0x3E,
  0x00, 0xF8, 0x07, 0xBC, 0x07, 0x80, 0x1E, 0x00, 0xF7, 0x81, 0xF0, 0x03,
  0xC0, 0x1F, 0xF0, 0x3C, 0x00, 0x78, 0x07, 0xFC, 0x07, 0x80, 0x1F, 0x00,
  0xF7, 0x80, 0xF0, 0x03, 0xC0, 0x1E, 0xF0, 0x3E, 0x00, 0x78, 0x03, 0xDE,
  0x07, 0xC0, 0x1F, 0x00, 0xFB, 0xC0, 0xF8, 0x03, 0xE0, 0x1E, 0x78, 0x1F,
  0x00, 0xFC, 0x07, 0xCF, 0x01, 0xE0, 0x3F, 0x81, 0xF1, 0xE0, 0x3E, 0x0F,
  0xF0, 0x7C, 0x3E, 0x07, 0xFF, 0xCF, 0xBF, 0x87, 0xC0, 0x7F, 0xF1, 0xFF,
  0xE0, 0x78, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x30, 0x00, 0x07, 0xF8, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x01, 0xF0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x3C, 0x07,
  0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x1F,
  0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0xFF, 0xC0, 0x1F,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xF0, 0x07, 0xF8, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xC0, 0x01, 0xF0,
  0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7F, 0x03, 0xE0, 0x07, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0,
  0x07, 0x80, 0x7F, 0x80, 0x01, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x70, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x15, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0xF8, 0x0F, 0xFC, 0x00, 0x3E, 0x00, 0x7F, 0x80, 0x1F,
  0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0xFC, 0x1F, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x0F,
  0xE0, 0x3E, 0x00, 0x07, 0xF0, 0x0F, 0x80, 0x07, 0xF8, 0x07, 0xC0, 0x07,
  0xFC, 0x01, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x08, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFC,
  0x00, 0xF8, 0x07, 0xF8, 0x00, 0x0C, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x03, 0xFF, 0xE7, 0xE0, 0x01, 0xFF, 0xF3, 0xF0, 0x00, 0xFF, 0xF9,
  0xF0, 0x00, 0xFF, 0xF8, 0xF8, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00,
  0x7C, 0x07, 0xF8, 0x00, 0x3E, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x78, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x1F, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF0,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x07, 0xE0, 0x0F, 0x80,
  0x03, 0xF0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x01,
  0xF0, 0x0F, 0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x1F, 0x03, 0xF0, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0xF8, 0x7E, 0x00,
  0x00, 0x3E, 0x3F, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x07, 0xCF, 0xC0,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0xF8, 0x00, 0x00, 0xFE,
  0x3E, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x1F, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0xFC, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0x07, 0xBE, 0x01, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x0F, 0x3C, 0x00, 0x07,
  0xDF, 0x00, 0xF9, 0xE0, 0x00, 0x3C, 0xF8, 0x07, 0xCF, 0x00, 0x03, 0xE7,
  0xC0, 0x3E, 0x78, 0x00, 0x1E, 0x3E, 0x01, 0xF3, 0xC0, 0x01, 0xF1, 0xE0,
  0x0F, 0x1E, 0x00, 0x0F, 0x1F, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x07,
  0xC7, 0xC0, 0x07, 0x87, 0xC0, 0x3E, 0x1E, 0x00, 0x7C, 0x3E, 0x01, 0xF0,
  0xF0, 0x03, 0xC3, 0xE0, 0x0F, 0x07, 0x80, 0x3E, 0x1F, 0x00, 0xF8, 0x3C,
  0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xE0, 0x1E, 0x07, 0xC0, 0x3E, 0x0F, 0x01,
  0xF0, 0x3E, 0x01, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x0F, 0x03, 0xE0, 0xF8,
  0x1F, 0x00, 0xF8, 0x0F, 0x07, 0x80, 0xF8, 0x07, 0xC0, 0x78, 0x7C, 0x07,
  0xC0, 0x3E, 0x03, 0xC3, 0xC0, 0x3E, 0x01, 0xE0, 0x1E, 0x3E, 0x03, 0xE0,
  0x1F, 0x00, 0xF1, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x9F, 0x00, 0xF8, 0x07,
  0xC0, 0x3D, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0x00, 0x3E, 0x01, 0xE0,
  0x07, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x3F, 0x80, 0x1F, 0x00, 0xF8, 0x01,
  0xFC, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x3C, 0x00, 0x7E,
  0x00, 0x7E, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xF8, 0x00, 0x01, 0xF0,
  0x0F, 0xE0, 0x00, 0x07, 0x80, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0xFF, 0x00,
  0x00, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x00, 0x0F, 0x80,
  0x7B, 0xE0, 0x00, 0x7C, 0x01, 0xEF, 0x80, 0x01, 0xF0, 0x07, 0x9F, 0x00,
  0x07, 0xC0, 0x3E, 0x7C, 0x00, 0x1F, 0x00, 0xF9, 0xF0, 0x00, 0x78, 0x03,
  0xE3, 0xE0, 0x03, 0xE0, 0x0F, 0x0F, 0x80, 0x0F, 0x80, 0x3C, 0x1E, 0x00,
  0x3E, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x03, 0xC0, 0x1F,
  0x03, 0xE0, 0x1F, 0x00, 0x78, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1E, 0x00, 0xF8,
  0x03, 0xC0, 0xF8, 0x03, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0x00, 0x3E, 0x0F,
  0x80, 0x7C, 0x00, 0x78, 0x3C, 0x01, 0xF0, 0x01, 0xF1, 0xF0, 0x07, 0xC0,
  0x07, 0xC7, 0xC0, 0x1E, 0x00, 0x0F, 0x9F, 0x00, 0xF8, 0x00, 0x3E, 0x7C,
  0x03, 0xE0, 0x00, 0x79, 0xE0, 0x0F, 0x80, 0x01, 0xF7, 0x80, 0x3E, 0x00,
  0x07, 0xFE, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x07, 0xC0, 0x00, 0x3F, 0xE0,
  0x1F, 0x00, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x01, 0xE0, 0x00,
  0x07, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x1F, 0xBE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00,
  0x0F, 0xDF, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFE,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03,
  0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xF8, 0x1F, 0xF0, 0x03,
  0xE0, 0x0F, 0xE0, 0x1F, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x7E, 0x01, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x0F, 0xCF,
  0x80, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x0F, 0xBF, 0x00,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x0F, 0xDF,
  0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xF8, 0x3F,
  0xF0, 0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x3E,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xF0, 0x1F, 0x00,
  0x1F, 0xC0, 0x7C, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x07,
  0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0,
  0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x3E, 0x03, 0xF8, 0x00,
  0x40, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x08, 0x00, 0x0F, 0xE0, 0xF0, 0x03, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0xC0,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xF3, 0xC0,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0xFC, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xC0, 0x01,
  0xF0, 0x07, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0,
  0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x7E, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x3E, 0x1F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x07,
  0xBE, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFB, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xCF, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F,
  0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x3F, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7B,
  0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF7, 0x80, 0x0F, 0xC3, 0xE0, 0x03, 0xCF,
  0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x9E, 0x00, 0x7E, 0x07, 0x80, 0x1F, 0x3E,
  0x00, 0xF8, 0x0F, 0x00, 0x3C, 0x7C, 0x01, 0xF0, 0x1E, 0x00, 0xF8, 0xF8,
  0x07, 0xC0, 0x3C, 0x01, 0xE1, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC3, 0xE0,
  0x3E, 0x00, 0xF0, 0x0F, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x3E, 0x07, 0x81,
  0xF0, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x1E, 0x07,
  0xC0, 0x0F, 0x83, 0xC0, 0x3C, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x78, 0x3E,
  0x00, 0x3E, 0x1E, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x7C, 0x01, 0xE1, 0xF0,
  0x00, 0xF8, 0xF8, 0x03, 0xC7, 0xC0, 0x01, 0xF3, 0xE0, 0x07, 0x8F, 0x80,
  0x03, 0xE7, 0xC0, 0x0F, 0x1E, 0x00, 0x07, 0xCF, 0x00, 0x1E, 0x7C, 0x00,
  0x0F, 0xBE, 0x00, 0x3C, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x79, 0xE0, 0x00,
  0x3E, 0xF0, 0x00, 0xF7, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xEF, 0x00, 0x00,
  0xFF, 0x80, 0x03, 0xDE, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x07,
  0xBF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x01, 0xFB, 0xC0, 0x00, 0x1F, 0x9F, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0xFC, 0x1E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7C, 0x07,
  0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x3F, 0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x3C, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xF8,
  0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x78,
  0x1F, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x83,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x3C,
  0x0F, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x3E, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x07,
  0x80, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0xF0, 0x1E, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0xC3,
  0xC0, 0x00, 0x3C, 0x7C, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x1E, 0xF8, 0x00,
  0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xE0, 0xFC, 0x3E, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x0F, 0x03,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFE, 0x0F, 0x00, 0xFF, 0xF1, 0xE0,
  0x1F, 0xFF, 0x9E, 0x07, 0xFF, 0xF9, 0xE0, 0x7F, 0x03, 0xFE, 0x0F, 0xC0,
  0x1F, 0xE1, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC,
  0x3E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x1F,
  0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF0, 0xF8,
  0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x0F,
  0xE0, 0xF8, 0x01, 0xFE, 0x0F, 0xC0, 0x3F, 0xE0, 0x7C, 0x07, 0xBC, 0x07,
  0xFF, 0xF3, 0xC0, 0x3F, 0xFE, 0x3C, 0x03, 0xFF, 0xC3, 0xC0, 0x0F, 0xF0,
  0x3C, 0x00, 0x10, 0x04, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x10, 0x00, 0x3E, 0x1F, 0xF0, 0x03, 0xC3, 0xFF, 0x80, 0x7C, 0xFF,
  0xFC, 0x07, 0xDF, 0xFF, 0xC0, 0x7F, 0xE0, 0x7E, 0x07, 0xB8, 0x03, 0xE0,
  0x7F, 0x00, 0x3E, 0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x0F, 0xC0,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x3F,
  0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x3E, 0x3E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF8, 0x7F,
  0x00, 0x3F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xBF, 0xFF,
  0xC0, 0xF1, 0xFF, 0xF8, 0x0F, 0x0F, 0xFF, 0x00, 0xE0, 0x7F, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFE, 0x01, 0x83, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0x81, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x02, 0x01, 0xF0,
  0x00, 0xFF, 0x07, 0xC0, 0x0F, 0xFF, 0x1E, 0x00, 0xFF, 0xFE, 0x78, 0x07,
  0xFF, 0xFB, 0xE0, 0x1F, 0x80, 0xFF, 0x80, 0xFC, 0x01, 0xFE, 0x07, 0xE0,
  0x03, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00,
  0x3F, 0x80, 0xF8, 0x01, 0xFE, 0x03, 0xF0, 0x0F, 0xF8, 0x0F, 0xC0, 0x7B,
  0xC0, 0x1F, 0xFF, 0xCF, 0x00, 0x3F, 0xFE, 0x3C, 0x00, 0xFF, 0xF0, 0xF0,
  0x00, 0xFF, 0x07, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFC,
  0x07, 0xC3, 0xF0, 0x0F, 0x8F, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x00,
  0x7C, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xE7, 0xC0, 0x1F, 0xCF, 0x81, 0xFF,
  0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x21, 0xFC,
  0x01, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0xF0, 0x03, 0xFF, 0xC7, 0xC0, 0x3F, 0xFF, 0x9E, 0x01, 0xFF, 0xFE, 0x78,
  0x07, 0xE0, 0x3F, 0xE0, 0x3F, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0xFC, 0x07,
  0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0xFC, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xE0, 0x3E,
  0x00, 0x7F, 0x80, 0xFC, 0x03, 0xFE, 0x01, 0xF0, 0x1E, 0xF0, 0x07, 0xFF,
  0xF7, 0xC0, 0x0F, 0xFF, 0x9F, 0x00, 0x3F, 0xFC, 0x7C, 0x00, 0x3F, 0xC1,
  0xF0, 0x00, 0x10, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x08, 0x00, 0x1F, 0x80, 0x3C, 0x00, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x01, 0x00, 0x07, 0xC3,
  0xFE, 0x00, 0xF0, 0xFF, 0xE0, 0x3E, 0x7F, 0xFE, 0x07, 0xDF, 0xFF, 0xE0,
  0xFF, 0xC0, 0xFC, 0x1E, 0xE0, 0x0F, 0x83, 0xF8, 0x01, 0xF0, 0xFE, 0x00,
  0x3E, 0x1F, 0xC0, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x1F,
  0x80, 0x03, 0xE3, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03,
  0xE1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE1, 0xF0,
  0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1E, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x07, 0xC0,
  0x3F, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x00,
  0xF8, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE3, 0xF0, 0x00, 0x78, 0xFC,
  0x00, 0x1F, 0x3F, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xBE, 0x00, 0x0F, 0xE7, 0xE0,
  0x01, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0x80, 0xF8, 0x01, 0xF0,
  0x1F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00,
  0x1F, 0x83, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x3C, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xC7, 0xFF,
  0x01, 0xFF, 0xC0, 0x7C, 0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xDF, 0xFF, 0x8F,
  0xFF, 0xE0, 0x7B, 0xE0, 0xFD, 0xF0, 0x3F, 0x07, 0xB8, 0x07, 0xDE, 0x01,
  0xF0, 0x7F, 0x00, 0x7F, 0x80, 0x1F, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xF0,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE1, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC3, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x3E,
  0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x1E, 0x0F, 0xF8, 0x03, 0xE3, 0xFF, 0xE0,
  0x3E, 0x7F, 0xFE, 0x03, 0xEF, 0xFF, 0xF0, 0x3F, 0xF0, 0x3F, 0x03, 0xFE,
  0x01, 0xF0, 0x7F, 0xC0, 0x1F, 0x07, 0xF8, 0x01, 0xF0, 0x7F, 0x00, 0x1F,
  0x07, 0xE0, 0x01, 0xF0, 0xFE, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xFC,
  0x00, 0x3F, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x03,
  0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x7C, 0x1F,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0xFC, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0xFC, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x07, 0xE1, 0xF8, 0x00,
  0xF8, 0xFC, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF7, 0xC0,
  0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00,
  0x0F, 0xCF, 0x80, 0x03, 0xE3, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x1F,
  0xC0, 0x7E, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0xF0, 0x7F, 0xC0,
  0x01, 0xE1, 0xFF, 0xC0, 0x07, 0xCF, 0xFF, 0xC0, 0x0F, 0xBF, 0xFF, 0x80,
  0x1E, 0xF8, 0x1F, 0x80, 0x3D, 0xC0, 0x1F, 0x00, 0x7F, 0x00, 0x3E, 0x01,
  0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0xF8, 0x0F,
  0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x01,
  0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F,
  0x00, 0xFB, 0xFF, 0xFC, 0x01, 0xF3, 0xFF, 0xF0, 0x03, 0xE3, 0xFF, 0xC0,
  0x07, 0xC3, 0xFE, 0x00, 0x1F, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0xFE, 0x0F, 0x00, 0xFF, 0xF1, 0xE0, 0x3F, 0xFF, 0x9E, 0x07, 0xFF, 0xF9,
  0xE0, 0x7E, 0x03, 0xFE, 0x0F, 0xC0, 0x1F, 0xE1, 0xF8, 0x00, 0xFC, 0x1F,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0xFC, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE0,
  0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xE0, 0xF8, 0x01, 0xFE, 0x0F, 0xC0,
  0x3F, 0xE0, 0xFC, 0x07, 0xBC, 0x07, 0xFF, 0xF7, 0xC0, 0x3F, 0xFE, 0x7C,
  0x03, 0xFF, 0xC7, 0xC0, 0x0F, 0xF0, 0x7C, 0x00, 0x10, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x30, 0x0F, 0x07, 0xF0, 0x3C,
  0x7F, 0xC1, 0xF3, 0xFE, 0x07, 0xDF, 0xF8, 0x1E, 0xF8, 0x00, 0x7B, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xF8, 0x03,
  0x83, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF1, 0x00, 0x07, 0xE3, 0x80, 0x1F,
  0x87, 0xFB, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x0F, 0xF8, 0x00, 0x30, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1E,
  0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE1, 0xF0,
  0x00, 0x3E, 0x1F, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x3E,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x0F,
  0x80, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00,
  0xFE, 0x0F, 0x80, 0x1F, 0xE0, 0xF8, 0x03, 0xFE, 0x0F, 0xC0, 0xFB, 0xC0,
  0x7F, 0xFF, 0x3C, 0x07, 0xFF, 0xE3, 0xC0, 0x3F, 0xFC, 0x3C, 0x01, 0xFF,
  0x07, 0xC0, 0x01, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xEF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x3E, 0x00,
  0x0F, 0x8F, 0x80, 0x07, 0xC1, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x1F,
  0x00, 0x7E, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x1F, 0x01, 0xF8, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0x3C, 0x0F,
  0x80, 0x0F, 0x07, 0xC0, 0x03, 0xC1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFB, 0xE0, 0x00,
  0x1E, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0xF8,
  0x01, 0xFE, 0x00, 0x7C, 0xF8, 0x01, 0xFE, 0x00, 0xFC, 0xF8, 0x03, 0xDE,
  0x00, 0xF8, 0xF8, 0x03, 0xDE, 0x01, 0xF8, 0x78, 0x07, 0xDE, 0x01, 0xF0,
  0x78, 0x07, 0x9E, 0x01, 0xF0, 0x78, 0x07, 0x9E, 0x03, 0xE0, 0x78, 0x0F,
  0x1E, 0x03, 0xE0, 0x78, 0x0F, 0x1E, 0x07, 0xC0, 0x78, 0x1E, 0x1E, 0x07,
  0xC0, 0x78, 0x1E, 0x1E, 0x0F, 0x80, 0x78, 0x3E, 0x1E, 0x0F, 0x80, 0x78,
  0x3C, 0x1E, 0x1F, 0x00, 0x78, 0x7C, 0x1E, 0x1F, 0x00, 0x78, 0x78, 0x1E,
  0x1F, 0x00, 0x7C, 0xF8, 0x1E, 0x3E, 0x00, 0x78, 0xF0, 0x1E, 0x3E, 0x00,
  0x79, 0xF0, 0x1E, 0x7C, 0x00, 0x79, 0xE0, 0x1E, 0x7C, 0x00, 0x79, 0xE0,
  0x1E, 0x78, 0x00, 0x7B, 0xC0, 0x1E, 0xF8, 0x00, 0x7B, 0xC0, 0x0E, 0xF0,
  0x00, 0x7B, 0x80, 0x0E, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x7E, 0x00, 0x0F, 0x81,
  0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x3C, 0xFC, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07,
  0xC0, 0x3C, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8,
  0x00, 0xF8, 0x07, 0xE0, 0x01, 0xF0, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x01, 0xF0,
  0x0F, 0xC0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x78, 0xF8, 0x00,
  0x00, 0x1E, 0x3E, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x5F, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xC8, 0x00,
  0x0F, 0xC0,
};

const GFXglyph NotoSans_Italic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 14, 41, 15, 1, -40 },
  { 73, 17, 14, 22, 6, -40 },
  { 103, 35, 40, 36, 2, -40 },
  { 278, 27, 45, 31, 2, -42 },
  { 430, 38, 42, 45, 4, -41 },
  { 630, 34, 42, 38, 2, -41 },
  { 809, 7, 14, 12, 6, -40 },
  { 822, 19, 49, 16, 2, -40 },
  { 939, 18, 49, 16, -4, -40 },
  { 1050, 26, 26, 31, 6, -43 },
  { 1135, 26, 27, 32, 4, -33 },
  { 1223, 11, 14, 14, -2, -7 },
  { 1243, 15, 4, 18, 1, -17 },
  { 1251, 7, 8, 14, 1, -7 },
  { 1258, 28, 40, 20, -3, -40 },
  { 1398, 27, 42, 31, 3, -41 },
  { 1540, 17, 40, 31, 8, -40 },
  { 1625, 30, 41, 31, 0, -41 },
  { 1779, 28, 42, 31, 1, -41 },
  { 1926, 30, 40, 31, 0, -40 },
  { 2076, 28, 41, 31, 2, -40 },
  { 2220, 27, 42, 31, 4, -41 },
  { 2362, 26, 40, 31, 5, -40 },
  { 2492, 27, 42, 31, 3, -41 },
  { 2634, 26, 42, 31, 3, -41 },
  { 2771, 12, 32, 14, 1, -31 },
  { 2819, 16, 38, 14, -3, -31 },
  { 2895, 26, 28, 32, 4, -34 },
  { 2986, 26, 15, 32, 4, -27 },
  { 3035, 26, 28, 32, 4, -34 },
  { 3126, 21, 42, 24, 4, -41 },
  { 3237, 43, 45, 47, 3, -40 },
  { 3479, 32, 40, 31, -3, -40 },
  { 3639, 31, 40, 34, 2, -40 },
  { 3794, 31, 42, 33, 4, -41 },
  { 3957, 34, 40, 37, 2, -40 },
  { 4127, 29, 40, 29, 2, -40 },
  { 4272, 29, 40, 27, 2, -40 },
  { 4417, 33, 42, 38, 4, -41 },
  { 4591, 36, 40, 38, 2, -40 },
  { 4771, 22, 40, 18, -1, -40 },
  { 4881, 25, 51, 15, -9, -40 },
  { 5041, 34, 40, 31, 2, -40 },
  { 5211, 22, 40, 27, 2, -40 },
  { 5321, 45, 40, 47, 2, -40 },
  { 5546, 38, 40, 40, 2, -40 },
  { 5736, 35, 42, 40, 4, -41 },
  { 5920, 30, 40, 32, 2, -40 },
  { 6070, 35, 51, 40, 4, -41 },
  { 6294, 30, 40, 32, 2, -40 },
  { 6444, 28, 42, 28, 1, -41 },
  { 6591, 28, 40, 28, 5, -40 },
  { 6731, 35, 41, 38, 4, -40 },
  { 6911, 31, 40, 31, 5, -40 },
  { 7066, 47, 40, 48, 6, -40 },
  { 7301, 37, 40, 30, -3, -40 },
  { 7486, 29, 40, 29, 5, -40 },
  { 7631, 33, 40, 30, -1, -40 },
  { 7796, 22, 49, 16, -1, -40 },
  { 7931, 10, 40, 20, 6, -40 },
  { 7981, 21, 49, 16, -4, -40 },
  { 8110, 28, 25, 32, 2, -40 },
  { 8198, 23, 4, 22, -5, 5 },
  { 8210, 9, 9, 16, 8, -43 },
  { 8221, 28, 32, 32, 3, -31 },
  { 8333, 28, 44, 32, 2, -43 },
  { 8487, 23, 32, 25, 3, -31 },
  { 8579, 30, 44, 32, 3, -43 },
  { 8744, 23, 32, 28, 3, -31 },
  { 8836, 31, 56, 18, -6, -43 },
  { 9053, 30, 44, 32, 1, -31 },
  { 9218, 27, 43, 32, 2, -43 },
  { 9364, 13, 41, 14, 2, -41 },
  { 9431, 22, 54, 14, -7, -41 },
  { 9580, 27, 43, 28, 2, -43 },
  { 9726, 14, 43, 14, 2, -43 },
  { 9802, 44, 31, 49, 2, -31 },
  { 9973, 28, 31, 32, 1, -31 },
  { 10082, 26, 30, 32, 3, -30 },
  { 10180, 31, 44, 32, -1, -31 },
  { 10351, 28, 44, 32, 3, -31 },
  { 10505, 22, 31, 22, 2, -31 },
  { 10591, 23, 32, 24, 0, -31 },
  { 10683, 18, 38, 19, 2, -37 },
  { 10769, 28, 31, 32, 3, -30 },
  { 10878, 26, 30, 26, 3, -30 },
  { 10976, 40, 30, 40, 3, -30 },
  { 11126, 31, 30, 27, -2, -30 },
  { 11243, 34, 43, 26, -5, -30 },
  { 11426, 26, 30, 25, -1, -30 },
  { 11524, 21, 49, 20, 1, -40 },
  { 11653, 4, 57, 31, 15, -43 },
  { 11682, 21, 49, 20, -2, -40 },
  { 11811, 26, 7, 32, 4, -23 },
};

const GFXfont NotoSans_Italic56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic56pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_ITALIC56PT7B_H_
