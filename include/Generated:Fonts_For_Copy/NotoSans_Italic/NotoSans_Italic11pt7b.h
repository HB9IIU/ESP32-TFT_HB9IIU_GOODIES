#ifndef _NOTOSANS_ITALIC11PT7B_H_
#define _NOTOSANS_ITALIC11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x86, 0x7A, 0xA0, 0x14, 0x29, 0xF9, 0x22, 0x9F, 0xD2,
  0x28, 0x10, 0xF5, 0x0C, 0x18, 0xAF, 0x88, 0x20, 0x63, 0x4A, 0xA5, 0x7D,
  0xA5, 0x52, 0xE6, 0x18, 0x48, 0xB1, 0x85, 0x31, 0xA3, 0x3B, 0x68, 0x12,
  0x44, 0x48, 0x88, 0x44, 0x21, 0x11, 0x11, 0x22, 0x48, 0x37, 0x0F, 0xA1,
  0x00, 0x21, 0x09, 0xF2, 0x10, 0xE0, 0xE0, 0xC0, 0x04, 0x20, 0x84, 0x20,
  0x84, 0x30, 0x72, 0x63, 0x18, 0xCA, 0x5C, 0x75, 0x24, 0x94, 0x39, 0x10,
  0x42, 0x10, 0x84, 0x3E, 0x78, 0x10, 0x4E, 0x18, 0x20, 0xBC, 0x0C, 0x51,
  0x8A, 0x4B, 0xF1, 0x04, 0x3C, 0x82, 0x1C, 0x08, 0x20, 0xBC, 0x3A, 0x21,
  0xE9, 0x4E, 0x5C, 0xF8, 0x44, 0x22, 0x21, 0x10, 0x38, 0x92, 0x4E, 0x69,
  0x2C, 0x9E, 0x74, 0x63, 0x1F, 0x08, 0x5C, 0x40, 0x30, 0x20, 0x02, 0xB0,
  0x09, 0x91, 0x83, 0x04, 0xF8, 0x3E, 0x86, 0x0C, 0x36, 0x40, 0xF1, 0x12,
  0x48, 0x08, 0x1C, 0x63, 0x9D, 0xA5, 0xA9, 0xA9, 0xB6, 0x80, 0x7C, 0x0C,
  0x18, 0x50, 0xA2, 0x47, 0x91, 0x61, 0x3C, 0x92, 0x5F, 0x4D, 0x14, 0x7E,
  0x3D, 0x08, 0x20, 0x82, 0x08, 0x1E, 0x3C, 0x4C, 0x8A, 0x14, 0x28, 0xD1,
  0x7C, 0x3C, 0x82, 0x1E, 0x41, 0x04, 0x3E, 0x3C, 0x82, 0x10, 0x79, 0x04,
  0x30, 0x3D, 0x08, 0x20, 0x9E, 0x18, 0x9E, 0x23, 0x22, 0x22, 0x7E, 0x42,
  0x44, 0x44, 0xC4, 0x72, 0x22, 0x44, 0x4E, 0x08, 0x42, 0x21, 0x08, 0x42,
  0x27, 0x00, 0x22, 0x48, 0xA2, 0x87, 0x09, 0x12, 0x66, 0x21, 0x08, 0x84,
  0x21, 0x1F, 0x30, 0x98, 0xCC, 0xAA, 0x55, 0x52, 0xA9, 0x65, 0x12, 0x21,
  0x31, 0x32, 0x52, 0x4A, 0x4A, 0x44, 0x84, 0x38, 0x8A, 0x0C, 0x18, 0x50,
  0xA3, 0x3C, 0x38, 0x92, 0x51, 0x79, 0x04, 0x30, 0x38, 0x8A, 0x0C, 0x18,
  0x50, 0xA3, 0x3C, 0x10, 0x10, 0x38, 0x92, 0x51, 0x79, 0x24, 0xB3, 0x3D,
  0x04, 0x08, 0x10, 0x20, 0xBC, 0xF9, 0x08, 0x44, 0x21, 0x08, 0x46, 0x8A,
  0x14, 0x28, 0x51, 0x22, 0x78, 0x86, 0x28, 0xA4, 0x91, 0x86, 0x10, 0x88,
  0xC4, 0x66, 0x53, 0x2A, 0x65, 0x33, 0x11, 0x88, 0x23, 0x12, 0x14, 0x18,
  0x18, 0x28, 0x24, 0xC4, 0x8E, 0x25, 0x18, 0x61, 0x04, 0x10, 0x7C, 0x10,
  0x84, 0x21, 0x84, 0x3E, 0x32, 0x44, 0x44, 0x48, 0x8C, 0xA9, 0x55, 0x31,
  0x11, 0x22, 0x22, 0x2C, 0x10, 0xC2, 0x92, 0xC4, 0xF8, 0x80, 0x7C, 0x63,
  0x29, 0x78, 0x20, 0x85, 0x99, 0x45, 0x14, 0xAE, 0x78, 0x88, 0x8E, 0x0C,
  0x27, 0xA2, 0x8A, 0x49, 0x3C, 0x79, 0xBC, 0x8E, 0x1C, 0x43, 0x88, 0x20,
  0x82, 0x08, 0x41, 0x08, 0x00, 0x3D, 0x14, 0x52, 0x49, 0xE0, 0xA4, 0x60,
  0x20, 0x85, 0x99, 0x45, 0x24, 0xA2, 0x21, 0xA4, 0x94, 0x10, 0x32, 0x22,
  0x24, 0x44, 0x80, 0x20, 0x84, 0xD4, 0x61, 0x45, 0x22, 0x25, 0x24, 0x94,
  0x5B, 0xB2, 0x53, 0x29, 0x14, 0x94, 0x48, 0x5D, 0x94, 0x52, 0x4A, 0x20,
  0x74, 0x63, 0x19, 0x70, 0x59, 0x94, 0x51, 0x4A, 0xE8, 0x20, 0x80, 0x7C,
  0xE3, 0x29, 0x78, 0x44, 0x20, 0x5B, 0x10, 0x84, 0x40, 0x7A, 0x10, 0x61,
  0x78, 0x2F, 0x44, 0x44, 0x60, 0x8C, 0x63, 0x29, 0x78, 0x9C, 0xA9, 0x4C,
  0x60, 0x93, 0x66, 0xD6, 0xAD, 0x93, 0x00, 0x4D, 0x43, 0x08, 0x52, 0x60,
  0x26, 0x48, 0xA1, 0x43, 0x06, 0x08, 0x10, 0xC0, 0x78, 0x88, 0xC4, 0x78,
  0x12, 0x22, 0xC4, 0x44, 0x46, 0xFF, 0xE0, 0x62, 0x22, 0x23, 0x44, 0x48,
  0xCD, 0xC0,
};

const GFXglyph NotoSans_Italic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 8, 3, 0, -8 },
  { 4, 4, 3, 4, 1, -8 },
  { 6, 7, 8, 7, 0, -8 },
  { 13, 6, 9, 6, 0, -8 },
  { 20, 7, 8, 9, 1, -8 },
  { 27, 7, 8, 7, 0, -8 },
  { 34, 2, 3, 2, 1, -8 },
  { 35, 4, 10, 3, 0, -8 },
  { 40, 4, 10, 3, -1, -8 },
  { 45, 5, 5, 6, 1, -8 },
  { 49, 5, 6, 6, 1, -7 },
  { 53, 2, 2, 3, 0, -1 },
  { 54, 3, 1, 3, 0, -3 },
  { 55, 2, 1, 3, 0, -1 },
  { 56, 6, 8, 4, -1, -8 },
  { 62, 5, 8, 6, 1, -8 },
  { 67, 3, 8, 6, 2, -8 },
  { 70, 6, 8, 6, 0, -8 },
  { 76, 6, 8, 6, 0, -8 },
  { 82, 6, 8, 6, 0, -8 },
  { 88, 6, 8, 6, 0, -8 },
  { 94, 5, 8, 6, 1, -8 },
  { 99, 5, 8, 6, 1, -8 },
  { 104, 6, 8, 6, 0, -8 },
  { 110, 5, 8, 6, 1, -8 },
  { 115, 2, 6, 3, 0, -6 },
  { 117, 3, 7, 3, -1, -6 },
  { 120, 5, 6, 6, 1, -7 },
  { 124, 5, 3, 6, 1, -5 },
  { 126, 5, 6, 6, 1, -7 },
  { 130, 4, 8, 5, 1, -8 },
  { 134, 8, 9, 9, 1, -8 },
  { 143, 7, 8, 6, -1, -8 },
  { 150, 6, 8, 7, 0, -8 },
  { 156, 6, 8, 6, 1, -8 },
  { 162, 7, 8, 7, 0, -8 },
  { 169, 6, 8, 6, 0, -8 },
  { 175, 6, 8, 5, 0, -8 },
  { 181, 6, 8, 7, 1, -8 },
  { 187, 8, 8, 7, 0, -8 },
  { 195, 4, 8, 4, 0, -8 },
  { 199, 5, 10, 3, -2, -8 },
  { 206, 7, 8, 6, 0, -8 },
  { 213, 5, 8, 5, 0, -8 },
  { 218, 9, 8, 9, 0, -8 },
  { 227, 8, 8, 8, 0, -8 },
  { 235, 7, 8, 8, 1, -8 },
  { 242, 6, 8, 6, 0, -8 },
  { 248, 7, 10, 8, 1, -8 },
  { 257, 6, 8, 6, 0, -8 },
  { 263, 6, 8, 6, 0, -8 },
  { 269, 5, 8, 6, 1, -8 },
  { 274, 7, 8, 7, 1, -8 },
  { 281, 6, 8, 6, 1, -8 },
  { 287, 9, 8, 9, 1, -8 },
  { 296, 8, 8, 6, -1, -8 },
  { 304, 6, 8, 6, 1, -8 },
  { 310, 6, 8, 6, 0, -8 },
  { 316, 4, 10, 3, 0, -8 },
  { 321, 2, 8, 4, 1, -8 },
  { 323, 4, 10, 3, -1, -8 },
  { 328, 6, 5, 6, 0, -8 },
  { 332, 5, 1, 4, -1, 1 },
  { 333, 1, 1, 3, 2, -8 },
  { 334, 5, 6, 6, 1, -6 },
  { 338, 6, 8, 6, 0, -8 },
  { 344, 4, 6, 5, 1, -6 },
  { 347, 6, 8, 6, 1, -8 },
  { 353, 4, 6, 5, 1, -6 },
  { 356, 6, 11, 4, -1, -8 },
  { 365, 6, 9, 6, 0, -6 },
  { 372, 6, 8, 6, 0, -8 },
  { 378, 3, 8, 3, 0, -8 },
  { 381, 4, 11, 3, -1, -8 },
  { 387, 6, 8, 5, 0, -8 },
  { 393, 3, 8, 3, 0, -8 },
  { 396, 9, 6, 10, 0, -6 },
  { 403, 6, 6, 6, 0, -6 },
  { 408, 5, 6, 6, 1, -6 },
  { 412, 6, 9, 6, 0, -6 },
  { 419, 5, 9, 6, 1, -6 },
  { 425, 5, 6, 4, 0, -6 },
  { 429, 5, 6, 5, 0, -6 },
  { 433, 4, 7, 4, 0, -7 },
  { 437, 5, 6, 6, 1, -6 },
  { 441, 5, 6, 5, 1, -6 },
  { 445, 7, 6, 8, 1, -6 },
  { 451, 6, 6, 5, 0, -6 },
  { 456, 7, 9, 5, -1, -6 },
  { 464, 5, 6, 5, 0, -6 },
  { 468, 4, 10, 4, 0, -8 },
  { 473, 1, 11, 6, 3, -8 },
  { 475, 4, 10, 4, 0, -8 },
  { 480, 5, 2, 6, 1, -5 },
};

const GFXfont NotoSans_Italic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic11pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_ITALIC11PT7B_H_
