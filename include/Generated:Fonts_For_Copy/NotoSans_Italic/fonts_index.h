#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &NotoSans_Italic6pt7b, 6, "NotoSans_Italic6pt7b" },
  { &NotoSans_Italic7pt7b, 7, "NotoSans_Italic7pt7b" },
  { &NotoSans_Italic8pt7b, 8, "NotoSans_Italic8pt7b" },
  { &NotoSans_Italic9pt7b, 9, "NotoSans_Italic9pt7b" },
  { &NotoSans_Italic10pt7b, 10, "NotoSans_Italic10pt7b" },
  { &NotoSans_Italic11pt7b, 11, "NotoSans_Italic11pt7b" },
  { &NotoSans_Italic12pt7b, 12, "NotoSans_Italic12pt7b" },
  { &NotoSans_Italic13pt7b, 13, "NotoSans_Italic13pt7b" },
  { &NotoSans_Italic14pt7b, 14, "NotoSans_Italic14pt7b" },
  { &NotoSans_Italic15pt7b, 15, "NotoSans_Italic15pt7b" },
  { &NotoSans_Italic16pt7b, 16, "NotoSans_Italic16pt7b" },
  { &NotoSans_Italic17pt7b, 17, "NotoSans_Italic17pt7b" },
  { &NotoSans_Italic18pt7b, 18, "NotoSans_Italic18pt7b" },
  { &NotoSans_Italic19pt7b, 19, "NotoSans_Italic19pt7b" },
  { &NotoSans_Italic20pt7b, 20, "NotoSans_Italic20pt7b" },
  { &NotoSans_Italic21pt7b, 21, "NotoSans_Italic21pt7b" },
  { &NotoSans_Italic22pt7b, 22, "NotoSans_Italic22pt7b" },
  { &NotoSans_Italic23pt7b, 23, "NotoSans_Italic23pt7b" },
  { &NotoSans_Italic24pt7b, 24, "NotoSans_Italic24pt7b" },
  { &NotoSans_Italic25pt7b, 25, "NotoSans_Italic25pt7b" },
  { &NotoSans_Italic26pt7b, 26, "NotoSans_Italic26pt7b" },
  { &NotoSans_Italic27pt7b, 27, "NotoSans_Italic27pt7b" },
  { &NotoSans_Italic28pt7b, 28, "NotoSans_Italic28pt7b" },
  { &NotoSans_Italic29pt7b, 29, "NotoSans_Italic29pt7b" },
  { &NotoSans_Italic30pt7b, 30, "NotoSans_Italic30pt7b" },
  { &NotoSans_Italic31pt7b, 31, "NotoSans_Italic31pt7b" },
  { &NotoSans_Italic32pt7b, 32, "NotoSans_Italic32pt7b" },
  { &NotoSans_Italic33pt7b, 33, "NotoSans_Italic33pt7b" },
  { &NotoSans_Italic34pt7b, 34, "NotoSans_Italic34pt7b" },
  { &NotoSans_Italic35pt7b, 35, "NotoSans_Italic35pt7b" },
  { &NotoSans_Italic36pt7b, 36, "NotoSans_Italic36pt7b" },
  { &NotoSans_Italic37pt7b, 37, "NotoSans_Italic37pt7b" },
  { &NotoSans_Italic38pt7b, 38, "NotoSans_Italic38pt7b" },
  { &NotoSans_Italic39pt7b, 39, "NotoSans_Italic39pt7b" },
  { &NotoSans_Italic40pt7b, 40, "NotoSans_Italic40pt7b" },
  { &NotoSans_Italic41pt7b, 41, "NotoSans_Italic41pt7b" },
  { &NotoSans_Italic42pt7b, 42, "NotoSans_Italic42pt7b" },
  { &NotoSans_Italic43pt7b, 43, "NotoSans_Italic43pt7b" },
  { &NotoSans_Italic44pt7b, 44, "NotoSans_Italic44pt7b" },
  { &NotoSans_Italic45pt7b, 45, "NotoSans_Italic45pt7b" },
  { &NotoSans_Italic46pt7b, 46, "NotoSans_Italic46pt7b" },
  { &NotoSans_Italic47pt7b, 47, "NotoSans_Italic47pt7b" },
  { &NotoSans_Italic48pt7b, 48, "NotoSans_Italic48pt7b" },
  { &NotoSans_Italic49pt7b, 49, "NotoSans_Italic49pt7b" },
  { &NotoSans_Italic50pt7b, 50, "NotoSans_Italic50pt7b" },
  { &NotoSans_Italic51pt7b, 51, "NotoSans_Italic51pt7b" },
  { &NotoSans_Italic52pt7b, 52, "NotoSans_Italic52pt7b" },
  { &NotoSans_Italic53pt7b, 53, "NotoSans_Italic53pt7b" },
  { &NotoSans_Italic54pt7b, 54, "NotoSans_Italic54pt7b" },
  { &NotoSans_Italic55pt7b, 55, "NotoSans_Italic55pt7b" },
  { &NotoSans_Italic56pt7b, 56, "NotoSans_Italic56pt7b" },
  { &NotoSans_Italic57pt7b, 57, "NotoSans_Italic57pt7b" },
  { &NotoSans_Italic58pt7b, 58, "NotoSans_Italic58pt7b" },
  { &NotoSans_Italic59pt7b, 59, "NotoSans_Italic59pt7b" },
  { &NotoSans_Italic60pt7b, 60, "NotoSans_Italic60pt7b" },
  { &NotoSans_Italic61pt7b, 61, "NotoSans_Italic61pt7b" },
  { &NotoSans_Italic62pt7b, 62, "NotoSans_Italic62pt7b" },
  { &NotoSans_Italic63pt7b, 63, "NotoSans_Italic63pt7b" },
  { &NotoSans_Italic64pt7b, 64, "NotoSans_Italic64pt7b" },
  { &NotoSans_Italic65pt7b, 65, "NotoSans_Italic65pt7b" },
  { &NotoSans_Italic66pt7b, 66, "NotoSans_Italic66pt7b" },
  { &NotoSans_Italic67pt7b, 67, "NotoSans_Italic67pt7b" },
  { &NotoSans_Italic68pt7b, 68, "NotoSans_Italic68pt7b" },
  { &NotoSans_Italic69pt7b, 69, "NotoSans_Italic69pt7b" },
  { &NotoSans_Italic70pt7b, 70, "NotoSans_Italic70pt7b" },
  { &NotoSans_Italic71pt7b, 71, "NotoSans_Italic71pt7b" },
  { &NotoSans_Italic72pt7b, 72, "NotoSans_Italic72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
