#ifndef _NOTOSANS_ITALIC67PT7B_H_
#define _NOTOSANS_ITALIC67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x83,
  0xF9, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3E, 0x1F,
  0x83, 0xF0, 0xF8, 0x1F, 0x87, 0xC0, 0xF8, 0x7E, 0x07, 0xC3, 0xE0, 0x3E,
  0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x07, 0xC0, 0xF8, 0x3C, 0x07, 0xC1, 0xE0,
  0x3C, 0x0F, 0x01, 0xE0, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x07,
  0x80, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xE7, 0xC3, 0xE0, 0x1F, 0xC3, 0xE0,
  0x20, 0x0F, 0xC1, 0xE0, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0xF8, 0x1E,
  0x00, 0x00, 0x7E, 0x0F, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x1F, 0xC7,
  0xC0, 0x00, 0x07, 0xF3, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xBF, 0xC0, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x03, 0xC1, 0xF8, 0x00,
  0x01, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x3F, 0x00,
  0x00, 0x78, 0x1F, 0x80, 0x00, 0x3C, 0x0F, 0xC0, 0x00, 0x1E, 0x07, 0xE0,
  0x00, 0x1F, 0x07, 0xE0, 0xC0, 0x0F, 0x87, 0xF0, 0x78, 0x07, 0x87, 0xF0,
  0x3F, 0xC3, 0xDF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0x7C, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x3F,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x07, 0xC0,
  0x3E, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0xE0,
  0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x07,
  0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0xF8,
  0x00, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x3F, 0x00,
  0x00, 0xF8, 0x03, 0xE0, 0xF8, 0x7F, 0xC3, 0xE0, 0x0F, 0x87, 0xC3, 0xFF,
  0x8F, 0x80, 0x7C, 0x3E, 0x1F, 0xFF, 0x1E, 0x01, 0xF1, 0xF8, 0xFF, 0xFE,
  0x7C, 0x0F, 0x87, 0xC7, 0xE1, 0xF9, 0xF8, 0x7E, 0x3E, 0x3F, 0x03, 0xE7,
  0xFF, 0xF1, 0xF8, 0xF8, 0x0F, 0x8F, 0xFF, 0x87, 0xC7, 0xE0, 0x1F, 0x1F,
  0xFC, 0x3E, 0x1F, 0x00, 0x7C, 0x3F, 0xC1, 0xF0, 0x7C, 0x01, 0xF0, 0x08,
  0x0F, 0xC3, 0xE0, 0x07, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x1E, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x00, 0x7E,
  0x07, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x07, 0xC0,
  0x7C, 0x00, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x3E, 0x0F,
  0x80, 0x1F, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x03, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x81,
  0xFE, 0x00, 0x00, 0x07, 0xE1, 0xFE, 0x00, 0x00, 0x03, 0xF3, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xBF, 0x00, 0x07,
  0xE0, 0xFF, 0x1F, 0xC0, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0x03, 0xF0, 0xFE,
  0x01, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0xFE, 0x01, 0xF8, 0x7E, 0x00, 0x3F,
  0x80, 0xFC, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC,
  0x3F, 0x00, 0x01, 0xFC, 0xFE, 0x1F, 0x80, 0x00, 0x7F, 0xFE, 0x0F, 0xC0,
  0x00, 0x1F, 0xFE, 0x07, 0xE0, 0x00, 0x0F, 0xFE, 0x03, 0xF0, 0x00, 0x03,
  0xFE, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xC0, 0x01, 0xFF, 0xF0, 0x0F, 0xF0,
  0x03, 0xFF, 0xF8, 0x03, 0xFE, 0x07, 0xFE, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x3F, 0x80, 0x7F, 0xFF, 0xFC, 0x0F, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xF0,
  0x03, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x9F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x7E, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x10, 0x01, 0xF0, 0x00, 0x78, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0x80, 0x03,
  0xFE, 0x0F, 0x00, 0x07, 0xFF, 0x1E, 0x00, 0x07, 0xFF, 0xB8, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0x81, 0xFC, 0x01, 0xF7, 0x80, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xF8,
  0x3C, 0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x30, 0x03, 0xF0, 0x00, 0x20, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xA0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xC0,
  0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x00, 0x7F, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF8, 0x1F,
  0x1F, 0x9F, 0xEF, 0xFF, 0xFF, 0xFB, 0xFC, 0xFC, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC,
  0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F,
  0x1F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0xFF, 0x00,
  0x3F, 0xE7, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xEF, 0xCF, 0xFC,
  0xFC, 0xFF, 0x0F, 0xC7, 0xC1, 0xF8, 0x78, 0x1F, 0x82, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x01, 0xF0, 0x00, 0xFF, 0x00,
  0x1C, 0x00, 0x0F, 0xE0, 0x02, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0xFF,
  0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x30, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x20, 0x00, 0x00, 0xFE, 0x0E, 0x00, 0x00,
  0x7F, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x00, 0xFC, 0x1F, 0x00, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x03, 0xF8, 0x3F,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x3F,
  0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xF1,
  0xFF, 0xC0, 0x00, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x80, 0x00,
  0x07, 0xF0, 0x38, 0x00, 0x03, 0xFC, 0x0F, 0x80, 0x03, 0xFE, 0x03, 0xFE,
  0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x03,
  0xF0, 0xFF, 0xF8, 0x01, 0xF8, 0xFF, 0xFE, 0x00, 0xFD, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xF0, 0x3F, 0xF0, 0x01, 0xFC,
  0x1F, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x07, 0xC3, 0xF8, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x07, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF8, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xBF, 0xF8, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0xFE, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xDF,
  0xF0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x07, 0xF1, 0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x03,
  0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x17, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xEF,
  0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7F, 0x1F, 0x80, 0x00,
  0x7F, 0x1F, 0x80, 0x00, 0xFF, 0x1F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x01,
  0xFE, 0x0F, 0xE0, 0x03, 0xFE, 0x0F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0xFF,
  0x7E, 0x07, 0xFF, 0xFE, 0xFC, 0x03, 0xFF, 0xFC, 0xFC, 0x00, 0xFF, 0xF8,
  0xFC, 0x00, 0x3F, 0xE0, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x80, 0x03, 0xFE, 0x00, 0xFE, 0x7F, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x07,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0,
  0x7E, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7C, 0x01, 0xFE,
  0x30, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7F,
  0xFC, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0x1F, 0x00, 0x1F,
  0xFF, 0xFC, 0x03, 0xE3, 0xE0, 0x07, 0xFE, 0xFF, 0x80, 0x7C, 0xF8, 0x01,
  0xFC, 0x03, 0xE0, 0x0F, 0x9F, 0x00, 0x7E, 0x00, 0x7C, 0x01, 0xF7, 0xE0,
  0x1F, 0x80, 0x0F, 0x80, 0x3E, 0xF8, 0x03, 0xE0, 0x03, 0xF0, 0x07, 0xDF,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0xFB, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x1F,
  0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xFF, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7F, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x7C, 0x07, 0xC0, 0x01, 0xF0,
  0x03, 0xEF, 0x80, 0xF8, 0x00, 0x7E, 0x00, 0x7D, 0xF0, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0xBE, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0xE7, 0xC0, 0x7C, 0x00,
  0x7E, 0x00, 0x7C, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0x1F, 0x01, 0xF0,
  0x03, 0xF8, 0x03, 0xE3, 0xE0, 0x3F, 0x00, 0xFF, 0x00, 0xF8, 0x7C, 0x03,
  0xE0, 0x3D, 0xF0, 0x3F, 0x0F, 0x80, 0x7F, 0x1F, 0x3F, 0x3F, 0xC1, 0xF0,
  0x0F, 0xFF, 0xE7, 0xFF, 0xF0, 0x3F, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x03,
  0xE0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x1F,
  0x87, 0xC0, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x7F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0xE0,
  0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07,
  0xE0, 0x1F, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0x07, 0xF8, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x01,
  0xFE, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x00, 0xFF, 0x07, 0xE0, 0x00, 0x3F, 0xE0, 0x7E, 0x00, 0x1F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0xF8, 0x00,
  0x04, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x02, 0x00, 0x3F, 0xF0, 0x00, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x01, 0xFF, 0xE0, 0x00, 0x7E,
  0x00, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x00, 0xFE,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x3F,
  0x00, 0x00, 0x0F, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x00,
  0x3F, 0xC0, 0x3F, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0x00, 0x00, 0xFF, 0x80,
  0x7E, 0x00, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x0F, 0xFE, 0x00, 0x7E, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x00, 0x0E, 0x00, 0xFF, 0x80, 0x00, 0x04,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0xF9, 0xFC, 0x00, 0x0F, 0xFF, 0xF3, 0xF0,
  0x00, 0x1F, 0xFF, 0xC7, 0xE0, 0x00, 0x3F, 0xFF, 0x8F, 0xC0, 0x00, 0x7F,
  0xFF, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x7F, 0x80, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0xFF, 0xC0,
  0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00,
  0x03, 0xF0, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x7F, 0x80, 0x00, 0x00, 0xFC,
  0x7F, 0x80, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xBF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x7E, 0x00, 0x00, 0x03, 0xFE, 0x3F, 0x00, 0x00, 0x01, 0xFE, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xDF, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFB, 0xE0, 0x00,
  0x00, 0xFB, 0xF0, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x0F, 0xBE,
  0x00, 0x00, 0x1F, 0x3E, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x01,
  0xF9, 0xF0, 0x00, 0x03, 0xE7, 0xE0, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x9F,
  0x80, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x03,
  0xF1, 0xF0, 0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xC0,
  0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x1F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0xF8,
  0x7E, 0x00, 0x0F, 0x83, 0xF0, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x83, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC1,
  0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xC0, 0xF8, 0x01,
  0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0xFC, 0x0F,
  0x80, 0x3E, 0x03, 0xF0, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x3F, 0x00, 0x3E, 0x01, 0xF0, 0x3F, 0x00, 0xF8,
  0x01, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x07, 0xE0,
  0x1F, 0x80, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0x7E, 0x00, 0x7C, 0x01, 0xF0,
  0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFB, 0xE0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xEF, 0x80, 0x0F,
  0xC0, 0x1F, 0x80, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0xF0,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x07, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xE0, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xF8,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x07, 0xDF, 0x80, 0x00, 0x3F, 0x00, 0x3E,
  0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0x80, 0x1F, 0x9F,
  0x80, 0x00, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xC3, 0xE0,
  0x00, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF0, 0x03, 0xF0, 0xFC, 0x00,
  0x0F, 0x80, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x07,
  0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF0,
  0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0xFC, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0x7E, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80,
  0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xC0, 0x03,
  0xF0, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0x81, 0xF0, 0x03, 0xF0, 0x00, 0x7E,
  0x1F, 0x80, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0xC7,
  0xE0, 0x07, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x00, 0x01, 0xF1, 0xF0,
  0x03, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x1F, 0x80, 0x00, 0x7E, 0xFC, 0x00,
  0xF8, 0x00, 0x01, 0xF7, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x1F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x9F,
  0xC0, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x01, 0xFD, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0x00, 0x3F, 0xC3, 0xF0, 0x00, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0xFC, 0x0F, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xFC, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00,
  0xFF, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x9F, 0xC0,
  0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00,
  0x7F, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0xFC, 0x0F, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x01, 0xFC, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x0F,
  0xC0, 0x01, 0xFE, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFC, 0x01, 0xF0, 0x03, 0xFC, 0x00, 0x0C, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x0C, 0x00, 0x01, 0xFE, 0x03,
  0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x01, 0xFC, 0xF8, 0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x00, 0xFE, 0x3F,
  0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x07, 0xF0, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07,
  0xDF, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xF0, 0x7C,
  0x00, 0x0F, 0x9F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x9F, 0x00, 0x0F,
  0xE0, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x1F,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x7E, 0x1F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x1F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xF8, 0x1F, 0x00, 0x7E, 0x00, 0x7E, 0x01, 0xF8,
  0x1F, 0x00, 0x7E, 0x00, 0x7E, 0x01, 0xF0, 0x1F, 0x00, 0xFC, 0x00, 0x7E,
  0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x00, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8,
  0x00, 0x7E, 0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x1F,
  0x03, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x00, 0x7E, 0x0F,
  0x80, 0x1F, 0x83, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x00,
  0x7E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0x8F,
  0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x3E, 0x3E, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x3E,
  0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xBF, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xBE, 0x00, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xDF, 0x00,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x01, 0xFC, 0x7E,
  0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x07, 0xC0, 0x01, 0xFC,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F,
  0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x7C,
  0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00,
  0xF8, 0xFC, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xFC,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x07, 0xCF, 0xC0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0xFC, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03,
  0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x01, 0xF0, 0x01, 0xFF, 0xF0, 0x7C, 0x01, 0xFF, 0xFE, 0x3E, 0x00, 0xFF,
  0xFF, 0xCF, 0x80, 0x7F, 0xE3, 0xF3, 0xE0, 0x3F, 0xC0, 0x3F, 0xF8, 0x1F,
  0xE0, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01,
  0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x80,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x03, 0xF8, 0x3F, 0x00, 0x01, 0xFE, 0x0F, 0xC0, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0x80, 0x0F, 0xFC,
  0x07, 0xE0, 0x07, 0xFF, 0x01, 0xFC, 0x03, 0xEF, 0x80, 0x3F, 0xC7, 0xF3,
  0xE0, 0x0F, 0xFF, 0xF8, 0xF8, 0x01, 0xFF, 0xFC, 0x3E, 0x00, 0x3F, 0xFE,
  0x0F, 0x80, 0x07, 0xFE, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x10, 0x00, 0x07, 0xE0, 0x7F, 0xC0, 0x01, 0xF8, 0x7F, 0xFC, 0x00,
  0x7E, 0x3F, 0xFF, 0x80, 0x1F, 0x1F, 0xFF, 0xE0, 0x07, 0xCF, 0xEF, 0xFC,
  0x03, 0xF7, 0xC0, 0x7F, 0x00, 0xFF, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0x01,
  0xF8, 0x0F, 0xF8, 0x00, 0x7E, 0x07, 0xFC, 0x00, 0x1F, 0x81, 0xFE, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01,
  0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0x1F, 0xC1, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8, 0x1F, 0xF8,
  0x03, 0xFC, 0x07, 0xDF, 0x83, 0xFE, 0x01, 0xF3, 0xFF, 0xFF, 0x00, 0xF8,
  0x7F, 0xFF, 0x80, 0x3E, 0x0F, 0xFF, 0xC0, 0x0F, 0x81, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC,
  0x7E, 0x03, 0xFE, 0x00, 0x40, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xE0, 0x3F, 0xF0, 0x7E, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0x80, 0x3F, 0x00, 0x01, 0xFF, 0x81, 0xF8, 0x00, 0x1F, 0xFF, 0x0F, 0xC0,
  0x03, 0xFF, 0xFC, 0x7C, 0x00, 0x3F, 0xFF, 0xF7, 0xE0, 0x03, 0xFF, 0x1F,
  0xBF, 0x00, 0x3F, 0xC0, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xC0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7F, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xFC,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x07, 0xFC, 0x00,
  0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x7D,
  0xF0, 0x00, 0xFF, 0x0F, 0xCF, 0x80, 0x07, 0xFF, 0xFC, 0x7C, 0x00, 0x1F,
  0xFF, 0xC3, 0xE0, 0x00, 0x7F, 0xFC, 0x1F, 0x00, 0x01, 0xFF, 0x81, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xF9, 0xFF, 0x03, 0xFC, 0x03, 0xF0, 0x7F, 0x80, 0x3F, 0x07, 0xE0,
  0x01, 0xF0, 0xFE, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF1, 0xF8, 0x00, 0x3F,
  0x1F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0xE7, 0xF0,
  0x07, 0xFC, 0x7E, 0x0F, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x01, 0x03, 0xF8, 0x00, 0x70, 0x3F, 0xF0,
  0x7F, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0x02, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x20,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x02, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x7C, 0x00,
  0x7F, 0xFE, 0x0F, 0x80, 0x1F, 0xFF, 0xE3, 0xE0, 0x07, 0xFF, 0xFE, 0x7C,
  0x01, 0xFF, 0x8F, 0xCF, 0x80, 0x7F, 0x80, 0x7F, 0xF0, 0x1F, 0xE0, 0x07,
  0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F,
  0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8,
  0x3F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0x0F, 0xE0,
  0x3F, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x7E, 0x00, 0x3F,
  0xF0, 0x0F, 0xC0, 0x0F, 0xFE, 0x01, 0xFC, 0x03, 0xEF, 0x80, 0x1F, 0xE1,
  0xF9, 0xF0, 0x03, 0xFF, 0xFE, 0x7E, 0x00, 0x3F, 0xFF, 0x8F, 0xC0, 0x03,
  0xFF, 0xE1, 0xF8, 0x00, 0x3F, 0xF0, 0x3E, 0x00, 0x00, 0x70, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x01, 0x00, 0x00, 0x7F, 0x00, 0x30,
  0x00, 0x1F, 0xC0, 0x07, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x06, 0x00, 0x03, 0xF0, 0x3F, 0xF0,
  0x01, 0xF8, 0x7F, 0xFC, 0x00, 0xFC, 0x7F, 0xFF, 0x00, 0x7C, 0x7F, 0xFF,
  0xC0, 0x3E, 0x7F, 0xBF, 0xE0, 0x3F, 0x7C, 0x03, 0xF8, 0x1F, 0xFC, 0x00,
  0xFC, 0x0F, 0xF8, 0x00, 0x7E, 0x07, 0xFC, 0x00, 0x3F, 0x07, 0xFC, 0x00,
  0x1F, 0x83, 0xFC, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x02, 0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x07, 0xC0,
  0x7F, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x01, 0xF8,
  0x7F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x7C, 0x7F, 0x00, 0x00, 0x7E,
  0x7F, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x1F, 0x7F, 0x80, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03,
  0xFE, 0x7E, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07,
  0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x0F, 0x80, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7C, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x03, 0xE1, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x1F, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x00, 0xF9, 0xFC, 0xFF, 0x1F, 0xCF, 0xF8, 0x0F,
  0xDF, 0x01, 0xF9, 0xF8, 0x0F, 0xE0, 0x7F, 0xE0, 0x07, 0xDF, 0x00, 0x7F,
  0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xF8, 0x1F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xFC, 0x00, 0x7C, 0x1F,
  0xFF, 0x80, 0x3E, 0x1F, 0xFF, 0xE0, 0x1F, 0x3F, 0xFF, 0xF0, 0x1F, 0x9F,
  0xFF, 0xFC, 0x0F, 0xDF, 0x80, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0x03, 0xFF,
  0x00, 0x1F, 0x83, 0xFF, 0x00, 0x0F, 0xC1, 0xFF, 0x00, 0x07, 0xE0, 0xFF,
  0x00, 0x03, 0xF0, 0x7F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1,
  0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8,
  0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF0,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7F, 0x7E, 0x00,
  0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF8, 0x7E, 0x00,
  0x03, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x1F, 0xF1, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x01, 0xF0, 0x1F, 0xF0, 0x00,
  0x0F, 0x83, 0xFF, 0xE0, 0x00, 0x7C, 0x3F, 0xFF, 0x80, 0x03, 0xE3, 0xFF,
  0xFC, 0x00, 0x1F, 0x3F, 0xBF, 0xF0, 0x01, 0xFB, 0xE0, 0x3F, 0x80, 0x0F,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xF0, 0x03, 0xFE, 0x00, 0x1F,
  0x80, 0x1F, 0xE0, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x3F, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x03,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xBF, 0x07, 0xFC, 0x00, 0x7C,
  0xFF, 0xFF, 0xC0, 0x07, 0xE3, 0xFF, 0xFC, 0x00, 0x3F, 0x0F, 0xFF, 0xC0,
  0x01, 0xF8, 0x3F, 0xF8, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x01, 0xF0, 0x01, 0xFF, 0xF0, 0x7C, 0x01, 0xFF, 0xFE,
  0x3E, 0x00, 0xFF, 0xFF, 0xCF, 0x80, 0x7F, 0xE3, 0xF3, 0xE0, 0x3F, 0xC0,
  0x3F, 0xF8, 0x1F, 0xE0, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F,
  0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x01, 0xFE, 0x0F, 0xC0,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xF0, 0x1F,
  0x80, 0x0F, 0xFC, 0x07, 0xE0, 0x07, 0xFF, 0x01, 0xFC, 0x03, 0xEF, 0x80,
  0x3F, 0xC3, 0xF3, 0xE0, 0x0F, 0xFF, 0xF9, 0xF8, 0x01, 0xFF, 0xFC, 0x7E,
  0x00, 0x3F, 0xFE, 0x1F, 0x80, 0x07, 0xFE, 0x0F, 0xC0, 0x00, 0x1C, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x3E, 0x07,
  0xFC, 0x07, 0xC1, 0xFF, 0x00, 0xF8, 0x7F, 0xE0, 0x1F, 0x1F, 0xFC, 0x03,
  0xE7, 0xFF, 0x80, 0xFD, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xF1, 0xFE, 0x07, 0xF8, 0x01, 0xC0,
  0x7E, 0x00, 0x04, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x80, 0x00, 0x7F, 0x0F,
  0x00, 0x0F, 0xE0, 0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0xC0, 0x7F, 0xFE, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x00,
  0x07, 0xF8, 0x1F, 0x80, 0x07, 0xFC, 0x0F, 0xC0, 0x07, 0xFE, 0x07, 0xE0,
  0x07, 0xFF, 0x03, 0xF8, 0x07, 0xDF, 0x01, 0xFE, 0x1F, 0xCF, 0x80, 0x7F,
  0xFF, 0xC7, 0xC0, 0x3F, 0xFF, 0xC3, 0xE0, 0x0F, 0xFF, 0xC1, 0xF0, 0x01,
  0xFF, 0x81, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xFC,
  0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x80,
  0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF7, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0x9F, 0x80, 0x0F, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0xF8, 0x00,
  0xFC, 0x7E, 0x00, 0x7D, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFB, 0xE0, 0x07,
  0xE1, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xCF, 0x80, 0x3F,
  0x07, 0xE0, 0x0F, 0x9F, 0x00, 0x7E, 0x0F, 0xC0, 0x3E, 0x3E, 0x01, 0xF8,
  0x1F, 0x80, 0x7C, 0x7C, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xE1, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0x83, 0xE0, 0x7E, 0x00,
  0xF8, 0x1F, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x03,
  0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0x07, 0xC3, 0xF0, 0x3E, 0x0F, 0xC0, 0x0F,
  0x87, 0xC0, 0x3C, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x78, 0x7E, 0x00, 0x3E,
  0x3E, 0x00, 0xF9, 0xF8, 0x00, 0x7C, 0x7C, 0x01, 0xF3, 0xF0, 0x00, 0xF9,
  0xF0, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x80, 0x03, 0xEF,
  0x80, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBC,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0xFE, 0x00,
  0x01, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x07,
  0xDF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x7F,
  0x00, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x87, 0xE0,
  0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x00, 0x00, 0x1E, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x20, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x02, 0x7F, 0xFC, 0x00, 0x05, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x40, 0x00, 0x7F, 0xF8, 0x80, 0x00,
  0x07, 0xC0,
};

const GFXglyph NotoSans_Italic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 17, 49, 17, 1, -48 },
  { 106, 21, 17, 26, 7, -48 },
  { 151, 42, 48, 43, 2, -48 },
  { 403, 33, 55, 37, 2, -51 },
  { 630, 46, 50, 54, 5, -49 },
  { 918, 41, 50, 45, 2, -49 },
  { 1175, 9, 17, 15, 7, -48 },
  { 1195, 22, 59, 19, 3, -48 },
  { 1358, 22, 59, 19, -5, -48 },
  { 1521, 31, 31, 37, 7, -51 },
  { 1642, 31, 33, 38, 5, -40 },
  { 1770, 13, 17, 17, -3, -8 },
  { 1798, 17, 6, 21, 2, -21 },
  { 1811, 9, 9, 17, 1, -8 },
  { 1822, 33, 48, 24, -3, -48 },
  { 2020, 32, 50, 37, 4, -49 },
  { 2220, 20, 48, 37, 10, -48 },
  { 2340, 35, 49, 37, 0, -49 },
  { 2555, 34, 50, 37, 1, -49 },
  { 2768, 36, 48, 37, 0, -48 },
  { 2984, 34, 49, 37, 2, -48 },
  { 3193, 33, 50, 37, 4, -49 },
  { 3400, 33, 48, 37, 5, -48 },
  { 3598, 33, 50, 37, 3, -49 },
  { 3805, 32, 50, 37, 3, -49 },
  { 4005, 14, 38, 17, 1, -37 },
  { 4072, 18, 46, 17, -3, -37 },
  { 4176, 31, 33, 38, 5, -41 },
  { 4304, 31, 18, 38, 5, -33 },
  { 4374, 31, 33, 38, 5, -41 },
  { 4502, 25, 50, 29, 5, -49 },
  { 4659, 51, 54, 57, 4, -48 },
  { 5004, 38, 48, 38, -4, -48 },
  { 5232, 36, 48, 40, 3, -48 },
  { 5448, 37, 50, 39, 5, -49 },
  { 5680, 40, 48, 45, 3, -48 },
  { 5920, 34, 48, 34, 3, -48 },
  { 6124, 34, 48, 32, 3, -48 },
  { 6328, 39, 50, 45, 5, -49 },
  { 6572, 43, 48, 46, 3, -48 },
  { 6830, 27, 48, 22, -1, -48 },
  { 6992, 29, 61, 18, -10, -48 },
  { 7214, 41, 48, 38, 3, -48 },
  { 7460, 25, 48, 32, 3, -48 },
  { 7610, 54, 48, 56, 3, -48 },
  { 7934, 45, 48, 47, 3, -48 },
  { 8204, 41, 50, 48, 5, -49 },
  { 8461, 35, 48, 38, 3, -48 },
  { 8671, 41, 60, 48, 5, -49 },
  { 8979, 35, 48, 38, 3, -48 },
  { 9189, 34, 50, 34, 1, -49 },
  { 9402, 33, 48, 34, 6, -48 },
  { 9600, 41, 49, 45, 5, -48 },
  { 9852, 37, 48, 37, 6, -48 },
  { 10074, 56, 48, 57, 7, -48 },
  { 10410, 44, 48, 35, -3, -48 },
  { 10674, 34, 48, 34, 6, -48 },
  { 10878, 39, 48, 36, -1, -48 },
  { 11112, 26, 59, 19, -1, -48 },
  { 11304, 13, 48, 24, 7, -48 },
  { 11382, 26, 59, 19, -5, -48 },
  { 11574, 33, 30, 38, 3, -48 },
  { 11698, 27, 5, 26, -6, 6 },
  { 11715, 11, 10, 19, 10, -51 },
  { 11729, 34, 38, 38, 3, -37 },
  { 11891, 34, 52, 39, 2, -51 },
  { 12112, 28, 38, 30, 3, -37 },
  { 12245, 37, 52, 39, 3, -51 },
  { 12486, 28, 38, 33, 3, -37 },
  { 12619, 38, 67, 21, -8, -51 },
  { 12938, 35, 53, 39, 2, -37 },
  { 13170, 33, 51, 39, 2, -51 },
  { 13381, 16, 49, 17, 2, -49 },
  { 13479, 26, 65, 17, -8, -49 },
  { 13691, 33, 51, 33, 2, -51 },
  { 13902, 17, 51, 17, 2, -51 },
  { 14011, 53, 37, 59, 2, -37 },
  { 14257, 33, 37, 39, 2, -37 },
  { 14410, 32, 37, 38, 3, -36 },
  { 14558, 37, 53, 39, -1, -37 },
  { 14804, 34, 53, 39, 3, -37 },
  { 15030, 27, 37, 27, 2, -37 },
  { 15155, 28, 38, 29, 0, -37 },
  { 15288, 21, 45, 22, 3, -44 },
  { 15407, 33, 37, 39, 4, -36 },
  { 15560, 32, 36, 31, 3, -36 },
  { 15704, 47, 36, 48, 4, -36 },
  { 15916, 36, 36, 32, -2, -36 },
  { 16078, 41, 52, 31, -6, -36 },
  { 16345, 30, 36, 30, -1, -36 },
  { 16480, 26, 59, 23, 1, -48 },
  { 16672, 5, 67, 37, 17, -51 },
  { 16714, 25, 59, 23, -2, -48 },
  { 16899, 31, 9, 38, 5, -28 },
};

const GFXfont NotoSans_Italic67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic67pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_ITALIC67PT7B_H_
