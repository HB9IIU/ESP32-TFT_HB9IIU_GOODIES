#ifndef _NOTOSANS_ITALIC51PT7B_H_
#define _NOTOSANS_ITALIC51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x07,
  0x00, 0x00, 0x7C, 0x3E, 0xF8, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x87, 0xCF,
  0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x07,
  0x8E, 0x0E, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x03,
  0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x3C, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1C,
  0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x03, 0xFB, 0xBF, 0x03, 0xE3, 0xC1, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xE0,
  0x00, 0xF0, 0x70, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x1F, 0x1C,
  0x00, 0x0F, 0x8E, 0x00, 0x03, 0xF7, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x7B, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x1C, 0x3E, 0x00, 0x0E, 0x1F, 0x00,
  0x07, 0x0F, 0x80, 0x07, 0x87, 0xC0, 0x03, 0x83, 0xC0, 0x01, 0xC3, 0xE1,
  0x80, 0xE3, 0xE0, 0xFC, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x80, 0xFF, 0x80, 0x01, 0xE0, 0x3F, 0xF8, 0x00, 0x78,
  0x0F, 0xDF, 0x00, 0x0F, 0x01, 0xE1, 0xE0, 0x03, 0xC0, 0x78, 0x1E, 0x00,
  0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F,
  0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x78, 0x01, 0xC0, 0x38, 0x1E, 0x00, 0x78,
  0x07, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x3C, 0x3C, 0x00,
  0x3C, 0x07, 0x8F, 0x00, 0x07, 0x81, 0xE1, 0xE3, 0xF8, 0xF0, 0x3C, 0x78,
  0xFF, 0x9E, 0x0F, 0x1E, 0x3F, 0xFB, 0xC1, 0xE7, 0x8F, 0x0F, 0x3E, 0xF8,
  0xF3, 0xC1, 0xE7, 0xFE, 0x3C, 0x78, 0x1C, 0x7F, 0x8F, 0x1E, 0x03, 0xC3,
  0xE1, 0xE3, 0xC0, 0x70, 0x00, 0x78, 0x70, 0x0E, 0x00, 0x1E, 0x1E, 0x01,
  0xC0, 0x07, 0x83, 0xC0, 0x78, 0x00, 0xF0, 0x78, 0x0F, 0x00, 0x3C, 0x0F,
  0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x38, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0x78,
  0x07, 0x81, 0xE0, 0x1E, 0x00, 0xF0, 0x38, 0x07, 0x80, 0x1E, 0x0F, 0x01,
  0xE0, 0x03, 0xC3, 0xC0, 0x3C, 0x00, 0x3F, 0xF8, 0x0F, 0x00, 0x07, 0xFE,
  0x03, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0xF0, 0x07, 0xC0, 0x01, 0xE0, 0x0F, 0x80, 0x03, 0xC0, 0x1E,
  0x00, 0x07, 0x80, 0x7C, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x1E, 0x1F, 0x80, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFC, 0xF8, 0x03, 0xE7, 0xE0, 0xF8, 0x07, 0x9F,
  0x81, 0xF0, 0x1F, 0x3E, 0x01, 0xF0, 0x3C, 0xF8, 0x01, 0xF0, 0xF1, 0xE0,
  0x03, 0xE3, 0xE3, 0xC0, 0x03, 0xEF, 0x87, 0x80, 0x03, 0xFE, 0x0F, 0x00,
  0x07, 0xF8, 0x1E, 0x00, 0x07, 0xF0, 0x3C, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x3F, 0xC0, 0xFC, 0x01, 0xFF, 0xC0, 0xFE, 0x1F, 0xEF, 0x80, 0xFF, 0xFF,
  0x8F, 0x80, 0xFF, 0xFC, 0x0F, 0x80, 0xFF, 0xE0, 0x1F, 0x80, 0x10, 0x00,
  0x00, 0x00, 0x7D, 0xF7, 0x9E, 0x79, 0xEF, 0x3C, 0xF3, 0x8E, 0x38, 0xE0,
  0x00, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x40,
  0x1E, 0x00, 0x70, 0x1E, 0x00, 0x7C, 0x1C, 0x00, 0x7F, 0x1C, 0x00, 0xFF,
  0xDC, 0x00, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0xFC, 0x3F, 0x01, 0xFE, 0x00, 0x03, 0xCE, 0x00, 0x07, 0x8E, 0x00, 0x0F,
  0x0F, 0x00, 0x3F, 0x07, 0x00, 0x3E, 0x07, 0x80, 0x1C, 0x07, 0x80, 0x08,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x07, 0xC3, 0xF0, 0xF8,
  0x3E, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xE0,
  0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x3D, 0xFF, 0xFF, 0xFF,
  0xE7, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x1F, 0x0F,
  0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x3E,
  0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x7C,
  0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF8,
  0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0x7C,
  0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x3F, 0x1F, 0xC0, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0x00, 0x7E,
  0x01, 0xFE, 0x03, 0xFE, 0x0F, 0xFE, 0x3F, 0xBC, 0xFF, 0x3C, 0x7E, 0x7C,
  0x78, 0x7C, 0x30, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0x80,
  0xFC, 0x01, 0xC0, 0x0F, 0x80, 0x10, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x70, 0x03, 0xE0, 0x10, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC2, 0x00, 0x03, 0xF0, 0xE0, 0x01, 0xF8,
  0x3F, 0x83, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xE7, 0x80,
  0x00, 0xF8, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xE0,
  0xF0, 0x00, 0x78, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC0, 0xF0, 0x01,
  0xF0, 0x1E, 0x00, 0x7C, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F,
  0x00, 0xF0, 0x03, 0xC0, 0x3E, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x03, 0xE0,
  0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x03, 0xC3, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC2, 0x00, 0x07, 0xE1, 0x80, 0x07, 0xE0, 0xFC,
  0x1F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xF0, 0x10, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x7E, 0x00, 0x78, 0xFF, 0xC0, 0x3C, 0xFF, 0xF0, 0x3E, 0xFF, 0xFC, 0x1F,
  0xE0, 0x3F, 0x0F, 0xE0, 0x0F, 0x87, 0xE0, 0x07, 0xC3, 0xE0, 0x01, 0xE3,
  0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3C, 0x7C, 0x00, 0x1E,
  0x3E, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03,
  0xC1, 0xE0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0xC7,
  0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xF8, 0x1F, 0x80,
  0xFC, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x07,
  0xC0, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x3E, 0x03, 0xE0,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x03, 0xE7, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x0F, 0xE3, 0xF0, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0xF0, 0x01,
  0xF0, 0x7C, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0,
  0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xC1,
  0xF0, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x0F, 0xE1, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x3F, 0x07, 0xE0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x1E,
  0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0xC7, 0x80, 0x03, 0xE3, 0xC0, 0x01,
  0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3C, 0x3C, 0x00,
  0x3E, 0x1E, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x1F, 0xC1, 0xF8,
  0x7F, 0xE0, 0xFF, 0xFD, 0xE0, 0x3F, 0xFC, 0xF0, 0x07, 0xF8, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7C, 0x7F, 0xC0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xC1,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0x70, 0x00, 0x00,
  0x3C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x03, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xC0, 0xFE,
  0x60, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x7C, 0x01, 0xFF, 0xC0,
  0x70, 0xF0, 0x0F, 0xFF, 0xC0, 0xF3, 0xC0, 0x3F, 0xFF, 0x81, 0xE7, 0x80,
  0xF8, 0x0E, 0x03, 0xDE, 0x03, 0xE0, 0x3C, 0x07, 0xBC, 0x0F, 0x80, 0x78,
  0x0F, 0x78, 0x1E, 0x00, 0xF0, 0x1F, 0xE0, 0x78, 0x03, 0xC0, 0x3F, 0xC0,
  0xF0, 0x07, 0x80, 0x7F, 0x81, 0xE0, 0x0F, 0x00, 0xEF, 0x07, 0x80, 0x1E,
  0x03, 0xDE, 0x0F, 0x00, 0x78, 0x07, 0xBC, 0x1E, 0x00, 0xF0, 0x0F, 0x78,
  0x3C, 0x03, 0xE0, 0x3C, 0xF0, 0x78, 0x07, 0xC0, 0x79, 0xE0, 0xF0, 0x1F,
  0x81, 0xE3, 0xC0, 0xF0, 0x77, 0x07, 0xC7, 0x81, 0xFF, 0xEF, 0xFF, 0x0F,
  0x01, 0xFF, 0x8F, 0xFC, 0x1F, 0x01, 0xFC, 0x1F, 0xE0, 0x1E, 0x00, 0x40,
  0x06, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x80, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x1F, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00,
  0x78, 0x3C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x03, 0xE0,
  0x7C, 0x00, 0x1E, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x78, 0x7C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xE0, 0x07, 0xE0, 0x1E, 0x00, 0x3F, 0x03,
  0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0, 0x3C, 0x00,
  0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xE0,
  0x78, 0x00, 0x7C, 0x07, 0x80, 0x1F, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xF0, 0x03, 0xF0,
  0x1F, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x7C, 0x1E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07,
  0xC3, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF8, 0x7C,
  0x00, 0x3F, 0x07, 0xC0, 0x0F, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0x01, 0xE0, 0x3F, 0x80, 0x02, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x0C, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x01, 0xE0, 0x07, 0xF0, 0x07, 0x80, 0x0F, 0xE0, 0x3E, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x0F, 0x0F, 0x80, 0x00,
  0x3C, 0x3E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87,
  0x80, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0x3E, 0x0F, 0x00, 0x01, 0xF8, 0x3C, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0xFE, 0x07, 0xC0, 0x07, 0xF0, 0x1F, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0x01,
  0xF8, 0x0F, 0xE0, 0x00, 0xC0, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x0F, 0xFF, 0x3E, 0x00, 0x3F, 0xFC, 0xF8, 0x00, 0xFF,
  0xE3, 0xE0, 0x07, 0xFF, 0x8F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x3C, 0x3E,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1E, 0x07, 0xE0,
  0x00, 0x78, 0x1F, 0xC0, 0x03, 0xE0, 0x3F, 0x80, 0x0F, 0x80, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x01, 0xF0, 0x0F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x78, 0x07, 0xC0,
  0x00, 0x3C, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x03, 0xE0, 0x1E, 0x00, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01,
  0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x7C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x03, 0x1F, 0xE0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0xF8,
  0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0xF1, 0xF0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x07, 0xDF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7E, 0x7C, 0x00, 0x01, 0xF8, 0x78, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x03,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x1E,
  0xF0, 0x00, 0x0F, 0x78, 0x0F, 0x78, 0x00, 0x0F, 0x7C, 0x07, 0xBC, 0x00,
  0x07, 0xBC, 0x03, 0xDE, 0x00, 0x07, 0x9E, 0x01, 0xEF, 0x00, 0x03, 0xCF,
  0x01, 0xF3, 0x80, 0x03, 0xCF, 0x80, 0xF1, 0xE0, 0x01, 0xE7, 0xC0, 0x78,
  0xF0, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x01, 0xF1, 0xE0, 0x1E, 0x3C, 0x00,
  0xF1, 0xF0, 0x1F, 0x1E, 0x00, 0xF8, 0xF8, 0x0F, 0x0F, 0x00, 0x78, 0x7C,
  0x07, 0x87, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xC0, 0x3C, 0x1E, 0x01, 0xE0,
  0xF0, 0x3C, 0x1F, 0x01, 0xF0, 0x78, 0x1E, 0x0F, 0x80, 0xF0, 0x3C, 0x1E,
  0x07, 0xC0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x0F, 0x01, 0xE0,
  0x3E, 0x07, 0x8F, 0x81, 0xF0, 0x1F, 0x03, 0xC7, 0x80, 0xF8, 0x0F, 0x00,
  0xE7, 0xC0, 0x78, 0x07, 0x80, 0x73, 0xC0, 0x3C, 0x03, 0xC0, 0x3F, 0xC0,
  0x3E, 0x03, 0xE0, 0x1F, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0xE0, 0x0F, 0x80,
  0xF0, 0x07, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xF0, 0x03, 0xC0, 0x3C, 0x01,
  0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x1E, 0x00, 0x3C, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x7E, 0x00, 0x00, 0xF0, 0x1F,
  0xC0, 0x00, 0x7C, 0x07, 0xF0, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x07, 0x80,
  0xFF, 0x80, 0x01, 0xE0, 0x3D, 0xE0, 0x00, 0xF8, 0x0F, 0x7C, 0x00, 0x3E,
  0x03, 0xDF, 0x00, 0x0F, 0x00, 0xF3, 0xC0, 0x03, 0xC0, 0x7C, 0xF8, 0x00,
  0xF0, 0x1E, 0x1E, 0x00, 0x7C, 0x07, 0x87, 0x80, 0x1F, 0x01, 0xE1, 0xF0,
  0x07, 0x80, 0x78, 0x3C, 0x01, 0xE0, 0x3E, 0x0F, 0x80, 0x78, 0x0F, 0x03,
  0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0xF0, 0x1F, 0x00, 0xF0, 0x7C, 0x07, 0x80, 0x3E, 0x1F, 0x01,
  0xE0, 0x07, 0x87, 0x80, 0x78, 0x01, 0xE1, 0xE0, 0x3E, 0x00, 0x7C, 0x78,
  0x0F, 0x80, 0x0F, 0x1E, 0x03, 0xC0, 0x03, 0xEF, 0x80, 0xF0, 0x00, 0x7B,
  0xC0, 0x3C, 0x00, 0x1E, 0xF0, 0x1F, 0x00, 0x07, 0xFC, 0x07, 0xC0, 0x00,
  0xFF, 0x01, 0xE0, 0x00, 0x3F, 0xC0, 0x78, 0x00, 0x0F, 0xE0, 0x1E, 0x00,
  0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x7E, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x7C, 0xFC, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFD,
  0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF8, 0x1F,
  0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0xFC, 0x03, 0xC0, 0x0F, 0x80,
  0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xE0, 0x78, 0x00,
  0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F,
  0x00, 0x0F, 0x81, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x3F,
  0x81, 0xF0, 0x1F, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x7F,
  0x00, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3F, 0x0F, 0x80, 0x00,
  0x7C, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0xFC, 0x03, 0xC0, 0x0F,
  0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xE0, 0x78,
  0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E,
  0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x0F, 0x80,
  0x7F, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0x80, 0xF8, 0x00, 0xF0, 0x0F,
  0x00, 0x1E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1E,
  0x00, 0x7C, 0x03, 0xC0, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F,
  0x03, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xC1, 0xF0, 0x1F, 0x80,
  0x18, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE1, 0x00, 0x03, 0xF0, 0xE0, 0x07,
  0xF0, 0x7F, 0xBF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0xF0, 0x7C, 0x00,
  0x01, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00,
  0x1F, 0x07, 0x80, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0xF8,
  0x3C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x78, 0x3E,
  0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x3F, 0x00,
  0x7F, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C,
  0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x07, 0x80,
  0x01, 0xF0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x7C,
  0x07, 0x80, 0x07, 0xC0, 0x78, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x3C, 0x03, 0xE0, 0x03, 0xC0, 0x3C,
  0x00, 0x3C, 0x07, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x0F, 0x80, 0x03,
  0xC0, 0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3E,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1E, 0x7C, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xEF, 0x00, 0x03,
  0xE0, 0x00, 0xF9, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x80,
  0x03, 0xC7, 0x80, 0x07, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xEE, 0x00, 0x1E,
  0x1E, 0x00, 0x3D, 0xC0, 0x07, 0xC3, 0xC0, 0x07, 0xB8, 0x00, 0xF8, 0x78,
  0x01, 0xE7, 0x00, 0x3E, 0x0F, 0x00, 0x3C, 0xF0, 0x07, 0xC1, 0xE0, 0x0F,
  0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xE3, 0xC0, 0x3E, 0x07, 0x80, 0x7C, 0x78,
  0x07, 0x80, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE1, 0xE0, 0x3C,
  0x03, 0xC0, 0x78, 0x3C, 0x0F, 0x80, 0x78, 0x0F, 0x07, 0x81, 0xE0, 0x0F,
  0x83, 0xC0, 0xF0, 0x7C, 0x01, 0xF0, 0x78, 0x1E, 0x0F, 0x80, 0x3E, 0x1E,
  0x03, 0xC1, 0xE0, 0x07, 0xC3, 0xC0, 0x78, 0x7C, 0x00, 0xF8, 0xF0, 0x0F,
  0x0F, 0x00, 0x1F, 0x1E, 0x01, 0xE3, 0xE0, 0x03, 0xE7, 0x80, 0x3C, 0x78,
  0x00, 0x3C, 0xF0, 0x07, 0x8F, 0x00, 0x07, 0xBE, 0x00, 0xF3, 0xC0, 0x00,
  0xF7, 0x80, 0x1E, 0x78, 0x00, 0x1E, 0xF0, 0x01, 0xDE, 0x00, 0x03, 0xFC,
  0x00, 0x3B, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0x78, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x1F,
  0x00, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x3C, 0x07, 0xC0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x03, 0xDF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xCF, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x00, 0x7C, 0x1E, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x3C, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xCF, 0x80, 0x01,
  0xF1, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0,
  0x0F, 0x80, 0xF0, 0x07, 0xC0, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x01,
  0xE0, 0x7C, 0x00, 0x78, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0xC7, 0xC0,
  0x00, 0xF1, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE3, 0xC0, 0x01,
  0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x70, 0x3C, 0x00, 0x78, 0x0F, 0x00,
  0x38, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1C, 0x00, 0xF0, 0x1E, 0x00, 0x3C,
  0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC7, 0x80, 0x00,
  0xF3, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1C, 0x0F,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF0, 0xF0, 0x1F, 0xFE, 0x3C, 0x0F, 0xFF,
  0xCE, 0x07, 0xF0, 0x7F, 0x83, 0xF0, 0x0F, 0xE0, 0xF8, 0x01, 0xF8, 0x7C,
  0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0,
  0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0x87, 0xC0, 0x01,
  0xE1, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x1E, 0x00, 0x7F, 0x07,
  0xC0, 0x3F, 0x81, 0xF0, 0x1F, 0xE0, 0x7F, 0x1F, 0x78, 0x0F, 0xFF, 0x9E,
  0x01, 0xFF, 0xC7, 0x80, 0x3F, 0xC1, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x83, 0xE0, 0x03, 0xC3, 0xFE, 0x00, 0xF1, 0xFF, 0xC0, 0x3C, 0xFF, 0xF8,
  0x1F, 0x78, 0x7E, 0x07, 0xB8, 0x0F, 0x81, 0xFC, 0x01, 0xF0, 0x7E, 0x00,
  0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1,
  0xF0, 0x00, 0x78, 0x78, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x8F, 0x80, 0x03,
  0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x0F, 0xC0,
  0x1F, 0x87, 0xF8, 0x0F, 0xC1, 0xEF, 0x8F, 0xE0, 0x79, 0xFF, 0xF0, 0x1C,
  0x3F, 0xF8, 0x0F, 0x07, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xC0,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xF0, 0x30, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x10, 0x3F, 0x87, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x3C, 0x00,
  0x7F, 0xC7, 0xC0, 0x1F, 0xFE, 0x7C, 0x03, 0xFF, 0xF7, 0x80, 0x7F, 0x07,
  0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x81,
  0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xE0,
  0x78, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x0F, 0x80,
  0x07, 0xC0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0xC0, 0x78, 0x01, 0xFC,
  0x07, 0xC0, 0x3F, 0x80, 0x7C, 0x07, 0x78, 0x07, 0xF1, 0xF7, 0x80, 0x3F,
  0xFE, 0x78, 0x01, 0xFF, 0x87, 0x80, 0x0F, 0xF0, 0x70, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE,
  0x07, 0xE0, 0xFC, 0x3F, 0x01, 0xF0, 0xF8, 0x03, 0xC7, 0xC0, 0x1F, 0x1E,
  0x00, 0x7C, 0xF8, 0x01, 0xE3, 0xC0, 0x0F, 0x9F, 0x00, 0xFC, 0x7D, 0xFF,
  0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x18, 0x3F, 0x83, 0xE0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x10, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFC, 0x3C, 0x03, 0xFF, 0xC7,
  0x80, 0xFF, 0xFC, 0xE0, 0x3F, 0x83, 0xFC, 0x0F, 0xC0, 0x3F, 0x81, 0xF0,
  0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x01, 0xF0,
  0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00,
  0x1E, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x07,
  0xE0, 0x78, 0x01, 0xFC, 0x0F, 0x80, 0x7F, 0x01, 0xF0, 0x1D, 0xE0, 0x3F,
  0x8F, 0xBC, 0x03, 0xFF, 0xEF, 0x80, 0x3F, 0xF1, 0xF0, 0x03, 0xFC, 0x3C,
  0x00, 0x0C, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x02, 0x00, 0x0F, 0x80,
  0x70, 0x03, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xC3, 0xFE, 0x00,
  0xF1, 0xFF, 0xC0, 0x3C, 0xFF, 0xF8, 0x1F, 0x78, 0x3E, 0x07, 0xB8, 0x07,
  0xC1, 0xFC, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0xC0,
  0x07, 0x83, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x78, 0x3C, 0x00, 0x3E, 0x1F,
  0x00, 0x0F, 0x87, 0xC0, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x7C,
  0x1E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xE0, 0xF8, 0x00,
  0x78, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0,
  0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC0,
  0x00, 0x20, 0x07, 0x80, 0x3E, 0x03, 0xF0, 0x0F, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80,
  0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80,
  0x7C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0xDF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x01, 0x03, 0xC0,
  0x0F, 0x80, 0xF0, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x07,
  0xC0, 0xF8, 0x01, 0xE0, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x3E, 0x1F, 0x00,
  0x0F, 0x8F, 0x80, 0x03, 0xC7, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0x3D, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFD, 0xE0, 0x00, 0x7E,
  0x7C, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x78, 0x00,
  0xF0, 0x1F, 0x00, 0x3C, 0x07, 0xC0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x78, 0x01, 0xF0, 0x1E, 0x00, 0x3E, 0x0F, 0x80,
  0x0F, 0x80, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0x80, 0x3C, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xE1, 0xFE, 0x03, 0xFF, 0x00, 0xF3, 0xFF, 0x83, 0xFF, 0xC0, 0x7B, 0xFF,
  0xE3, 0xFF, 0xE0, 0x7D, 0xE1, 0xF3, 0xC1, 0xF0, 0x3D, 0xC0, 0x7B, 0xC0,
  0x7C, 0x1F, 0xC0, 0x3F, 0xC0, 0x3E, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xE0, 0x07, 0xC3, 0xE0, 0x03,
  0xE0, 0x03, 0xC1, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x01,
  0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x3E,
  0x00, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x1F,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC0, 0x07,
  0x83, 0xE0, 0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x00, 0x3E,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xF0, 0xFF,
  0xC0, 0x3C, 0xFF, 0xF8, 0x1F, 0x7F, 0xFE, 0x07, 0xFE, 0x0F, 0xC1, 0xFF,
  0x01, 0xF0, 0x7F, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x0F, 0xE0, 0x07, 0xC3,
  0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F,
  0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x1F, 0x00,
  0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8,
  0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xC3, 0xE0, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x1F, 0x1F, 0x00,
  0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x7C, 0x00,
  0x0F, 0x7C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x78, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0x78, 0x00,
  0x3E, 0x78, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x3E, 0x01,
  0xF0, 0x3F, 0xCF, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x0F, 0xF8, 0x00, 0xF1, 0xFF, 0xC0,
  0x0F, 0x3F, 0xFE, 0x01, 0xE7, 0x87, 0xE0, 0x1E, 0xE0, 0x3E, 0x01, 0xFC,
  0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x1F,
  0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0, 0x3C,
  0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x03,
  0xE0, 0x78, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x0F,
  0x80, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x81, 0xFE, 0x03,
  0xF0, 0x1E, 0xF8, 0xFE, 0x01, 0xE7, 0xFF, 0xC0, 0x1E, 0x3F, 0xF8, 0x01,
  0xE1, 0xFE, 0x00, 0x3E, 0x02, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0xF0, 0xF0, 0x1F, 0xFE, 0x3C, 0x0F, 0xFF, 0xCE, 0x07, 0xF0,
  0x7F, 0x83, 0xF0, 0x0F, 0xE0, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x1F,
  0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7C,
  0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0x87, 0xC0, 0x03, 0xE1, 0xE0, 0x00,
  0xF8, 0x78, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0,
  0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x1E, 0x00, 0x7F, 0x07, 0xC0, 0x3F, 0x81,
  0xF0, 0x1D, 0xE0, 0x7F, 0x1F, 0x78, 0x0F, 0xFF, 0xBE, 0x01, 0xFF, 0x8F,
  0x80, 0x3F, 0xC3, 0xC0, 0x01, 0x80, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x1E, 0x1F,
  0xC0, 0xF3, 0xFC, 0x07, 0xBF, 0xE0, 0x7D, 0xE1, 0x03, 0xDC, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0x07, 0x07, 0xC0,
  0x08, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x18, 0x00, 0xF8,
  0xF8, 0x3F, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x3F, 0x02, 0x7F, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0x83,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x40, 0xFF, 0xE0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0xC7,
  0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x1E, 0x00, 0x0F,
  0x0F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xC3, 0xE0, 0x01,
  0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x78, 0x7C, 0x00,
  0x7C, 0x3E, 0x00, 0x7E, 0x1E, 0x00, 0x3F, 0x0F, 0x00, 0x3F, 0x87, 0x80,
  0x3F, 0x83, 0xE0, 0x3B, 0xC1, 0xF8, 0x7D, 0xE0, 0x7F, 0xFC, 0xF0, 0x3F,
  0xF8, 0x78, 0x07, 0xF8, 0x38, 0x00, 0x40, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0x78, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x7C,
  0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xE0,
  0x3C, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x3C, 0x07, 0x80,
  0x3C, 0x0F, 0x80, 0x3C, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0x1E, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xFF, 0x00,
  0x3F, 0x00, 0x3E, 0xF0, 0x03, 0xF0, 0x03, 0xEF, 0x00, 0x7F, 0x00, 0x7C,
  0xF0, 0x07, 0xF0, 0x07, 0xCF, 0x00, 0xF7, 0x00, 0xF8, 0xF0, 0x0F, 0x70,
  0x0F, 0x8F, 0x80, 0xE7, 0x80, 0xF0, 0xF8, 0x1E, 0x78, 0x1F, 0x0F, 0x81,
  0xC7, 0x81, 0xE0, 0xF8, 0x3C, 0x78, 0x3E, 0x0F, 0x83, 0xC7, 0x83, 0xC0,
  0xF8, 0x78, 0x78, 0x7C, 0x0F, 0x87, 0x87, 0x87, 0x80, 0x78, 0xF0, 0x78,
  0xF8, 0x07, 0x8F, 0x07, 0x8F, 0x00, 0x79, 0xE0, 0x78, 0xF0, 0x07, 0x9E,
  0x07, 0x9F, 0x00, 0x7B, 0xC0, 0x79, 0xE0, 0x07, 0xBC, 0x07, 0xBE, 0x00,
  0x7B, 0x80, 0x7B, 0xC0, 0x07, 0xF8, 0x07, 0xBC, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xF0,
  0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0xF8, 0x00, 0xF8,
  0x1F, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x3C, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x01,
  0xF1, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x7C, 0x0F,
  0x00, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0x7C, 0x07,
  0xE0, 0x03, 0xC0, 0xFC, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x01,
  0xE0, 0x00, 0xF8, 0x03, 0xC0, 0x01, 0xF0, 0x07, 0x80, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3C,
  0x01, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x80, 0x01, 0xE0,
  0x1E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0x01, 0xCF, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x07, 0x78, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x7F,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xC0,
  0x01, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0x1F, 0xF1, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFE, 0x80, 0x07, 0xF8,
};

const GFXglyph NotoSans_Italic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 13, 37, 13, 1, -36 },
  { 62, 15, 13, 20, 6, -36 },
  { 87, 31, 36, 33, 2, -36 },
  { 227, 25, 42, 28, 2, -39 },
  { 359, 35, 38, 41, 4, -37 },
  { 526, 31, 38, 34, 2, -37 },
  { 674, 6, 13, 11, 6, -36 },
  { 684, 17, 44, 15, 2, -36 },
  { 778, 17, 44, 15, -4, -36 },
  { 872, 24, 24, 28, 5, -39 },
  { 944, 24, 24, 29, 4, -30 },
  { 1016, 10, 13, 13, -2, -6 },
  { 1033, 13, 4, 16, 1, -16 },
  { 1040, 6, 7, 13, 1, -6 },
  { 1046, 24, 36, 18, -2, -36 },
  { 1154, 24, 38, 28, 3, -37 },
  { 1268, 16, 36, 28, 7, -36 },
  { 1340, 27, 37, 28, 0, -37 },
  { 1465, 26, 38, 28, 1, -37 },
  { 1589, 27, 36, 28, 0, -36 },
  { 1711, 25, 37, 28, 2, -36 },
  { 1827, 25, 38, 28, 3, -37 },
  { 1946, 25, 36, 28, 4, -36 },
  { 2059, 26, 38, 28, 2, -37 },
  { 2183, 25, 38, 28, 2, -37 },
  { 2302, 10, 29, 13, 1, -28 },
  { 2339, 14, 35, 13, -3, -28 },
  { 2401, 24, 25, 29, 4, -31 },
  { 2476, 23, 14, 29, 4, -25 },
  { 2517, 24, 25, 29, 4, -31 },
  { 2592, 19, 38, 22, 4, -37 },
  { 2683, 39, 41, 43, 3, -36 },
  { 2883, 29, 36, 29, -3, -36 },
  { 3014, 28, 36, 31, 2, -36 },
  { 3140, 28, 38, 30, 4, -37 },
  { 3273, 30, 36, 34, 2, -36 },
  { 3408, 26, 36, 26, 2, -36 },
  { 3525, 26, 36, 24, 2, -36 },
  { 3642, 30, 38, 35, 4, -37 },
  { 3785, 33, 36, 35, 2, -36 },
  { 3934, 20, 36, 17, -1, -36 },
  { 4024, 22, 46, 14, -8, -36 },
  { 4151, 31, 36, 29, 2, -36 },
  { 4291, 19, 36, 24, 2, -36 },
  { 4377, 41, 36, 43, 2, -36 },
  { 4562, 34, 36, 36, 2, -36 },
  { 4715, 31, 38, 37, 4, -37 },
  { 4863, 27, 36, 29, 2, -36 },
  { 4985, 31, 46, 37, 4, -37 },
  { 5164, 27, 36, 29, 2, -36 },
  { 5286, 25, 38, 26, 1, -37 },
  { 5405, 25, 36, 26, 5, -36 },
  { 5518, 31, 37, 35, 4, -36 },
  { 5662, 28, 36, 28, 5, -36 },
  { 5788, 43, 36, 44, 5, -36 },
  { 5982, 34, 36, 27, -3, -36 },
  { 6135, 26, 36, 26, 5, -36 },
  { 6252, 30, 36, 27, -1, -36 },
  { 6387, 19, 44, 15, 0, -36 },
  { 6492, 9, 36, 18, 6, -36 },
  { 6533, 20, 44, 15, -4, -36 },
  { 6643, 25, 23, 29, 2, -37 },
  { 6715, 21, 3, 20, -5, 5 },
  { 6723, 9, 8, 14, 7, -39 },
  { 6732, 26, 29, 29, 2, -28 },
  { 6827, 26, 40, 30, 1, -39 },
  { 6957, 22, 29, 23, 2, -28 },
  { 7037, 28, 40, 30, 2, -39 },
  { 7177, 22, 29, 25, 2, -28 },
  { 7257, 29, 51, 16, -6, -39 },
  { 7442, 27, 40, 30, 1, -28 },
  { 7577, 26, 39, 30, 1, -39 },
  { 7704, 13, 38, 13, 1, -38 },
  { 7766, 20, 50, 13, -6, -38 },
  { 7891, 26, 39, 25, 1, -39 },
  { 8018, 13, 39, 13, 1, -39 },
  { 8082, 41, 28, 45, 1, -28 },
  { 8226, 26, 28, 30, 1, -28 },
  { 8317, 24, 28, 29, 2, -28 },
  { 8401, 28, 40, 30, -1, -28 },
  { 8541, 26, 40, 30, 2, -28 },
  { 8671, 21, 28, 20, 1, -28 },
  { 8745, 21, 29, 22, 0, -28 },
  { 8822, 17, 35, 17, 2, -34 },
  { 8897, 25, 28, 30, 3, -27 },
  { 8985, 24, 27, 24, 2, -27 },
  { 9066, 36, 27, 37, 3, -27 },
  { 9188, 28, 27, 25, -2, -27 },
  { 9283, 31, 39, 24, -5, -27 },
  { 9435, 23, 27, 23, -1, -27 },
  { 9513, 19, 44, 18, 1, -36 },
  { 9618, 4, 51, 28, 13, -39 },
  { 9644, 20, 44, 18, -2, -36 },
  { 9754, 24, 6, 29, 4, -21 },
};

const GFXfont NotoSans_Italic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic51pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_ITALIC51PT7B_H_
