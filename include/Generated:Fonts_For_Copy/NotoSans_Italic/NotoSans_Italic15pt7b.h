#ifndef _NOTOSANS_ITALIC15PT7B_H_
#define _NOTOSANS_ITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x32, 0x22, 0x64, 0x04, 0xC0, 0xD9, 0xBA, 0x0C, 0x82, 0x40,
  0x91, 0xFF, 0x11, 0x04, 0x81, 0x23, 0xFE, 0x24, 0x09, 0x06, 0x40, 0x08,
  0x7D, 0x4A, 0x85, 0x07, 0x07, 0x12, 0x2D, 0xF0, 0x83, 0x00, 0x30, 0xD2,
  0x24, 0x92, 0x28, 0x92, 0xA5, 0x56, 0xA4, 0x49, 0x12, 0x48, 0x94, 0x38,
  0x0E, 0x04, 0xC1, 0x10, 0x48, 0x1C, 0x06, 0x06, 0xCD, 0x1E, 0xC3, 0x11,
  0xC7, 0xD8, 0xEA, 0x19, 0x88, 0x8C, 0x42, 0x10, 0x84, 0x21, 0x0C, 0x00,
  0x10, 0x86, 0x31, 0x8C, 0x62, 0x11, 0x88, 0xCC, 0x00, 0x12, 0x4E, 0x4F,
  0x52, 0x61, 0x00, 0x10, 0x20, 0x47, 0xF1, 0x02, 0x04, 0x00, 0x2D, 0x60,
  0x7F, 0x70, 0x03, 0x02, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60,
  0xC0, 0x1C, 0x4D, 0x0A, 0x1C, 0x30, 0x61, 0xC2, 0x85, 0x91, 0xE0, 0x19,
  0xB4, 0x23, 0x18, 0x84, 0x23, 0x10, 0x1E, 0x33, 0x01, 0x03, 0x02, 0x06,
  0x0C, 0x18, 0x20, 0x40, 0xFE, 0x1E, 0x33, 0x01, 0x03, 0x06, 0x18, 0x06,
  0x02, 0x02, 0x86, 0xFC, 0x03, 0x07, 0x0E, 0x0A, 0x12, 0x26, 0x46, 0xFF,
  0xFF, 0x04, 0x0C, 0x3E, 0x41, 0x82, 0x05, 0x0F, 0x81, 0x02, 0x05, 0x1B,
  0xE0, 0x0E, 0x61, 0x82, 0x0D, 0x9D, 0xB1, 0xC2, 0x85, 0x99, 0xE0, 0x7E,
  0x04, 0x18, 0x20, 0x83, 0x04, 0x18, 0x20, 0xC3, 0x00, 0x1C, 0x4D, 0x8B,
  0x12, 0xC7, 0x33, 0x42, 0x85, 0x19, 0xE0, 0x3C, 0xC9, 0x1E, 0x1C, 0x68,
  0xDF, 0x02, 0x0C, 0x33, 0xC0, 0x64, 0x00, 0x16, 0x31, 0x00, 0x00, 0x26,
  0x4C, 0x02, 0x18, 0xC6, 0x06, 0x03, 0x81, 0x80, 0xFE, 0x00, 0x07, 0xF0,
  0x80, 0xC0, 0x60, 0x30, 0xCE, 0x30, 0x00, 0xF9, 0x30, 0xC3, 0x18, 0xC6,
  0x10, 0x03, 0x0C, 0x00, 0x07, 0x03, 0x18, 0x80, 0xA3, 0x98, 0x93, 0x22,
  0x64, 0x4C, 0x91, 0x9D, 0xD0, 0x01, 0x00, 0x1F, 0x80, 0x02, 0x03, 0x81,
  0xC1, 0xA0, 0x90, 0xC8, 0x7C, 0x7E, 0x21, 0x20, 0xF0, 0x60, 0x3C, 0x27,
  0x63, 0x63, 0x46, 0x78, 0x46, 0xC2, 0x82, 0x86, 0xF8, 0x0F, 0x39, 0x60,
  0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x3E, 0x3C, 0x13, 0x98, 0x4C,
  0x24, 0x1A, 0x09, 0x05, 0x86, 0x82, 0x47, 0x3E, 0x00, 0x3E, 0x41, 0x83,
  0x04, 0x0F, 0x90, 0x60, 0x81, 0x03, 0xE0, 0x3E, 0x41, 0x83, 0x04, 0x0F,
  0x90, 0x60, 0x81, 0x02, 0x00, 0x0F, 0x1C, 0xD8, 0x08, 0x0C, 0x06, 0x3B,
  0x1D, 0x82, 0xC3, 0x31, 0x8F, 0x80, 0x20, 0x90, 0x58, 0x6C, 0x34, 0x13,
  0xF9, 0x05, 0x86, 0x83, 0x41, 0x20, 0x80, 0x3C, 0x41, 0x0C, 0x30, 0x82,
  0x08, 0x61, 0x8F, 0x00, 0x04, 0x10, 0xC3, 0x08, 0x20, 0x86, 0x18, 0x41,
  0x0C, 0x23, 0x00, 0x21, 0x91, 0x99, 0x8D, 0x85, 0x83, 0x81, 0x61, 0x90,
  0x8C, 0x42, 0x21, 0x80, 0x21, 0x18, 0xC4, 0x21, 0x18, 0x84, 0x3E, 0x30,
  0x73, 0x06, 0x70, 0xE5, 0x0A, 0x51, 0xE5, 0x16, 0x52, 0x4D, 0xA4, 0x8C,
  0x48, 0xCC, 0x88, 0xC0, 0x20, 0xCC, 0x27, 0x09, 0x42, 0x48, 0x92, 0x64,
  0xD3, 0x14, 0x85, 0x21, 0xC8, 0x30, 0x0E, 0x19, 0xD8, 0x28, 0x1C, 0x0E,
  0x07, 0x03, 0x83, 0xC1, 0x31, 0x8F, 0x80, 0x3C, 0x26, 0x62, 0x63, 0x42,
  0x4E, 0x78, 0xC0, 0x80, 0x80, 0x80, 0x0E, 0x19, 0xD8, 0x28, 0x1C, 0x0E,
  0x07, 0x03, 0x83, 0xC1, 0x31, 0x8F, 0x00, 0x80, 0x60, 0x18, 0x3C, 0x26,
  0x62, 0x63, 0x42, 0x7C, 0x78, 0xC8, 0x8C, 0x84, 0x86, 0x1E, 0x33, 0x20,
  0x20, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x84, 0xF8, 0x7F, 0x98, 0x10, 0x10,
  0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x20, 0xB0, 0x58, 0x28, 0x34,
  0x12, 0x0B, 0x05, 0x86, 0xC2, 0x63, 0x1F, 0x00, 0xC1, 0xA0, 0x90, 0x88,
  0x44, 0x42, 0x61, 0x20, 0xB0, 0x50, 0x38, 0x18, 0x00, 0x86, 0x18, 0x63,
  0x8A, 0x28, 0xA6, 0x92, 0x49, 0x2C, 0xB2, 0x8A, 0x28, 0xE3, 0x0C, 0x30,
  0xC3, 0x00, 0x10, 0x44, 0x20, 0x90, 0x2C, 0x0E, 0x03, 0x00, 0xC0, 0x48,
  0x32, 0x18, 0xCC, 0x10, 0xC3, 0x42, 0x46, 0x4C, 0x68, 0x30, 0x30, 0x20,
  0x20, 0x20, 0x60, 0x3F, 0x80, 0x80, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x60,
  0x60, 0x60, 0x3F, 0x80, 0x1C, 0xC2, 0x08, 0x20, 0x86, 0x10, 0x41, 0x0C,
  0x30, 0xE0, 0xAA, 0xB5, 0x54, 0x1C, 0xA0, 0x82, 0x18, 0x41, 0x04, 0x10,
  0xC2, 0x08, 0xE0, 0x10, 0x60, 0xA2, 0x44, 0x50, 0xA0, 0x80, 0xFC, 0xCC,
  0x3A, 0x8F, 0x1C, 0x28, 0x51, 0xA3, 0x7E, 0x10, 0x30, 0x30, 0x2E, 0x33,
  0x21, 0x61, 0x43, 0x42, 0x66, 0xFC, 0x3D, 0x0C, 0x20, 0x82, 0x08, 0x1E,
  0x03, 0x03, 0x02, 0x3A, 0x46, 0xC6, 0x84, 0x84, 0x8C, 0x8C, 0xFC, 0x3D,
  0x1C, 0x7E, 0xC2, 0x08, 0x9E, 0x07, 0x82, 0x03, 0x03, 0xC0, 0x80, 0x40,
  0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x03, 0x07, 0x03, 0x00, 0x1D, 0x23,
  0x63, 0x43, 0x42, 0x46, 0x46, 0x7E, 0x04, 0x04, 0xFC, 0x30, 0x10, 0x30,
  0x30, 0x2E, 0x33, 0x23, 0x63, 0x42, 0x42, 0x42, 0xC6, 0x31, 0x02, 0x22,
  0x64, 0x44, 0xC0, 0x0C, 0x10, 0x02, 0x08, 0x21, 0x84, 0x10, 0x41, 0x0C,
  0x23, 0x8C, 0x00, 0x10, 0x30, 0x30, 0x23, 0x24, 0x28, 0x70, 0x68, 0x48,
  0x4C, 0xC6, 0x13, 0x32, 0x22, 0x64, 0x44, 0xC0, 0x2E, 0x73, 0x39, 0x23,
  0x16, 0x21, 0x42, 0x34, 0x23, 0x46, 0x2C, 0x62, 0x2F, 0x33, 0x23, 0x63,
  0x62, 0x42, 0x42, 0xC6, 0x3C, 0x8B, 0x1C, 0x38, 0x70, 0xB3, 0x3C, 0x2E,
  0x33, 0x21, 0x61, 0x43, 0x42, 0x66, 0x7C, 0xC0, 0x80, 0x80, 0x80, 0x3A,
  0x8F, 0x1C, 0x28, 0x51, 0xA3, 0x7E, 0x08, 0x10, 0x20, 0xC0, 0x2C, 0xC2,
  0x18, 0x41, 0x04, 0x30, 0x3D, 0x04, 0x0C, 0x18, 0x28, 0xBE, 0x26, 0xF4,
  0x4C, 0x88, 0x8E, 0x42, 0x87, 0x1E, 0x28, 0x51, 0xA3, 0x7E, 0x87, 0x1A,
  0x24, 0xC9, 0x1E, 0x38, 0x30, 0x8C, 0x63, 0x39, 0x4A, 0x56, 0xA5, 0x29,
  0x4C, 0x63, 0x18, 0x31, 0x89, 0x07, 0x81, 0x81, 0xC0, 0xA0, 0x91, 0x84,
  0x21, 0x91, 0x88, 0x86, 0xC3, 0x40, 0xE0, 0x60, 0x30, 0x10, 0x18, 0x38,
  0x10, 0x00, 0x7E, 0x08, 0x20, 0x83, 0x0C, 0x30, 0x7C, 0x0C, 0x61, 0x04,
  0x10, 0x8E, 0x18, 0x20, 0x86, 0x10, 0x60, 0xFF, 0xFE, 0x10, 0x20, 0x82,
  0x08, 0x60, 0xC7, 0x10, 0x43, 0x08, 0xE0, 0xFB, 0x18,
};

const GFXglyph NotoSans_Italic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 4, 4, 6, 2, -11 },
  { 9, 10, 11, 10, 0, -11 },
  { 23, 7, 12, 8, 1, -11 },
  { 34, 10, 11, 12, 1, -11 },
  { 48, 10, 11, 10, 0, -11 },
  { 62, 2, 4, 3, 2, -11 },
  { 63, 5, 13, 4, 1, -11 },
  { 72, 5, 13, 4, -1, -11 },
  { 81, 6, 7, 8, 2, -11 },
  { 87, 7, 7, 9, 1, -9 },
  { 94, 3, 4, 4, -1, -2 },
  { 96, 4, 2, 5, 0, -5 },
  { 97, 2, 2, 4, 0, -2 },
  { 98, 8, 11, 5, -1, -11 },
  { 109, 7, 11, 8, 1, -11 },
  { 119, 5, 11, 8, 2, -11 },
  { 126, 8, 11, 8, 0, -11 },
  { 137, 8, 11, 8, 0, -11 },
  { 148, 8, 11, 8, 0, -11 },
  { 159, 7, 11, 8, 1, -11 },
  { 169, 7, 11, 8, 1, -11 },
  { 179, 7, 11, 8, 1, -11 },
  { 189, 7, 11, 8, 1, -11 },
  { 199, 7, 11, 8, 1, -11 },
  { 209, 3, 8, 4, 0, -8 },
  { 212, 4, 10, 4, -1, -8 },
  { 217, 7, 7, 9, 1, -9 },
  { 224, 7, 4, 9, 1, -7 },
  { 228, 7, 7, 9, 1, -9 },
  { 235, 6, 11, 6, 1, -11 },
  { 244, 11, 12, 13, 1, -11 },
  { 261, 9, 11, 8, -1, -11 },
  { 274, 8, 11, 9, 1, -11 },
  { 285, 8, 11, 9, 1, -11 },
  { 296, 9, 11, 10, 1, -11 },
  { 309, 7, 11, 8, 1, -11 },
  { 319, 7, 11, 7, 1, -11 },
  { 329, 9, 11, 10, 1, -11 },
  { 342, 9, 11, 10, 1, -11 },
  { 355, 6, 11, 5, 0, -11 },
  { 364, 6, 14, 4, -2, -11 },
  { 375, 9, 11, 8, 1, -11 },
  { 388, 5, 11, 7, 1, -11 },
  { 395, 12, 11, 13, 1, -11 },
  { 412, 10, 11, 11, 1, -11 },
  { 426, 9, 11, 11, 1, -11 },
  { 439, 8, 11, 9, 1, -11 },
  { 450, 9, 14, 11, 1, -11 },
  { 466, 8, 11, 9, 1, -11 },
  { 477, 8, 11, 8, 0, -11 },
  { 488, 8, 11, 8, 1, -11 },
  { 499, 9, 11, 10, 1, -11 },
  { 512, 9, 11, 8, 1, -11 },
  { 525, 12, 11, 13, 2, -11 },
  { 542, 10, 11, 8, -1, -11 },
  { 556, 8, 11, 8, 1, -11 },
  { 567, 9, 11, 8, 0, -11 },
  { 580, 6, 13, 4, 0, -11 },
  { 590, 2, 11, 5, 2, -11 },
  { 593, 6, 13, 4, -1, -11 },
  { 603, 7, 7, 9, 1, -11 },
  { 610, 6, 1, 6, -1, 1 },
  { 611, 3, 2, 4, 2, -11 },
  { 612, 7, 8, 9, 1, -8 },
  { 619, 8, 11, 9, 0, -11 },
  { 630, 6, 8, 7, 1, -8 },
  { 636, 8, 11, 9, 1, -11 },
  { 647, 6, 8, 7, 1, -8 },
  { 653, 9, 15, 5, -2, -11 },
  { 670, 8, 12, 9, 0, -8 },
  { 682, 8, 11, 9, 0, -11 },
  { 693, 4, 11, 4, 0, -11 },
  { 699, 6, 15, 4, -2, -11 },
  { 711, 8, 11, 7, 0, -11 },
  { 722, 4, 11, 4, 0, -11 },
  { 728, 12, 8, 13, 0, -8 },
  { 740, 8, 8, 9, 0, -8 },
  { 748, 7, 8, 8, 1, -8 },
  { 755, 8, 12, 9, 0, -8 },
  { 767, 7, 12, 9, 1, -8 },
  { 778, 6, 8, 6, 0, -8 },
  { 784, 6, 8, 6, 0, -8 },
  { 790, 4, 10, 5, 1, -10 },
  { 795, 7, 8, 9, 1, -8 },
  { 802, 7, 8, 7, 1, -8 },
  { 809, 10, 8, 11, 1, -8 },
  { 819, 9, 8, 7, -1, -8 },
  { 828, 9, 12, 7, -1, -8 },
  { 842, 7, 8, 7, 0, -8 },
  { 849, 6, 13, 5, 0, -11 },
  { 859, 1, 15, 8, 4, -11 },
  { 861, 6, 13, 5, -1, -11 },
  { 871, 7, 2, 9, 1, -6 },
};

const GFXfont NotoSans_Italic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic15pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_ITALIC15PT7B_H_
