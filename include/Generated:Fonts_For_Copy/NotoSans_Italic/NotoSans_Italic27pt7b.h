#ifndef _NOTOSANS_ITALIC27PT7B_H_
#define _NOTOSANS_ITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xC7, 0x18, 0xE3, 0x8E, 0x30, 0xC3, 0x1C, 0x61, 0x80,
  0x00, 0xE3, 0x8E, 0x00, 0x67, 0x67, 0x66, 0xC6, 0xC6, 0xC4, 0xC4, 0x01,
  0x86, 0x00, 0xC6, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x30, 0x81, 0xFF, 0xFD,
  0xFF, 0xFE, 0x0C, 0x30, 0x06, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x84,
  0x0F, 0xFF, 0xE0, 0xC3, 0x00, 0x61, 0x80, 0x31, 0x80, 0x30, 0xC0, 0x18,
  0x60, 0x0C, 0x60, 0x00, 0x00, 0xC0, 0x06, 0x01, 0xFC, 0x3F, 0xF1, 0x98,
  0x9C, 0xC0, 0xC4, 0x07, 0x60, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0,
  0x66, 0x03, 0x38, 0x19, 0x80, 0xCC, 0xE5, 0xC7, 0xFC, 0x07, 0x80, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0x04, 0x00, 0x07, 0xC0, 0x63, 0x30, 0x31, 0x8C,
  0x18, 0x63, 0x06, 0x18, 0xC3, 0x0C, 0x31, 0x83, 0x0C, 0xC0, 0xC3, 0x33,
  0xB1, 0x9B, 0xFE, 0xED, 0xCD, 0xF6, 0x63, 0x11, 0x98, 0xC0, 0xCC, 0x30,
  0x63, 0x0C, 0x38, 0xC3, 0x0C, 0x31, 0x86, 0x0C, 0x63, 0x03, 0xF1, 0xC0,
  0x78, 0x00, 0x80, 0x07, 0xF0, 0x0F, 0x38, 0x0C, 0x18, 0x0C, 0x18, 0x0C,
  0x18, 0x0C, 0x38, 0x0C, 0xF0, 0x07, 0xC0, 0x07, 0x00, 0x1F, 0x00, 0x39,
  0x83, 0x61, 0xC7, 0xE0, 0xE6, 0xC0, 0x6C, 0xC0, 0x7C, 0xC0, 0x38, 0xE0,
  0xF8, 0x7F, 0xDC, 0x3F, 0x8E, 0x6D, 0xED, 0xB0, 0x03, 0x83, 0x03, 0x81,
  0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x06, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60,
  0x30, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x03, 0x03, 0x83, 0x80,
  0x02, 0x00, 0x30, 0x03, 0x08, 0x20, 0xE6, 0x0F, 0xE0, 0x0F, 0xF0, 0xE7,
  0x1B, 0x03, 0x30, 0x63, 0x82, 0x18, 0x01, 0x00, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x03, 0xFF, 0xE0, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x39, 0xDC, 0xC6, 0x60, 0xFF, 0xF8,
  0xFF, 0x80, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x00, 0x01, 0x80, 0xFE,
  0x1E, 0xF3, 0x87, 0x30, 0x37, 0x03, 0x60, 0x3E, 0x03, 0xE0, 0x3C, 0x03,
  0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x06, 0xC0, 0x6C, 0x0E, 0xC0, 0xCE, 0x1C,
  0x7F, 0x83, 0xE0, 0x07, 0x1F, 0x3E, 0xF6, 0xC6, 0x0E, 0x0E, 0x0C, 0x0C,
  0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x70, 0x00, 0xC0,
  0x1F, 0xE0, 0xFF, 0xC3, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xFF, 0x3F, 0xFC, 0x01, 0x80, 0x7F,
  0x87, 0xFE, 0x20, 0x70, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0xF0,
  0x7E, 0x03, 0xE0, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x64, 0x07, 0x3F, 0xF1, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x06, 0xC0,
  0x3E, 0x01, 0xD8, 0x06, 0x60, 0x33, 0x81, 0x8E, 0x0C, 0x30, 0x70, 0xC3,
  0x83, 0x1C, 0x1C, 0x60, 0x73, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x00, 0xE0,
  0x03, 0x00, 0x0C, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0x00, 0x38, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x07, 0xF0, 0x3F, 0xE0, 0x87, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x80, 0xE7, 0xFE, 0x1F, 0xC0, 0x00,
  0x60, 0x1F, 0xC3, 0xFC, 0x38, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00,
  0x67, 0xC7, 0xFF, 0x3C, 0x39, 0xC0, 0xCC, 0x07, 0x60, 0x33, 0x01, 0x98,
  0x0C, 0xC0, 0xE7, 0x0E, 0x1F, 0xE0, 0x7E, 0x00, 0x7F, 0xFB, 0xFF, 0xC0,
  0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x80, 0x18,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03,
  0x80, 0x38, 0x00, 0x00, 0xC0, 0x1F, 0xC0, 0xF7, 0x87, 0x06, 0x1C, 0x1C,
  0x60, 0x71, 0x81, 0x87, 0x0E, 0x0E, 0xF0, 0x1F, 0x01, 0xFC, 0x0E, 0x38,
  0x70, 0x71, 0x80, 0xCE, 0x03, 0x38, 0x0C, 0xE0, 0x71, 0xC1, 0xC7, 0xFE,
  0x0F, 0xE0, 0x00, 0x80, 0x7F, 0x07, 0xFC, 0x70, 0x73, 0x01, 0x98, 0x0D,
  0xC0, 0x6E, 0x03, 0x70, 0x39, 0x81, 0xCE, 0x3E, 0x3F, 0x60, 0xF3, 0x00,
  0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x1E, 0x3F, 0xE1, 0xFC, 0x00, 0x19,
  0xCE, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x73, 0x80, 0x06, 0x1C, 0x38,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x86, 0x1C, 0x30, 0x61,
  0x80, 0x00, 0x18, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x1E, 0x07,
  0xC0, 0xF8, 0x1E, 0x01, 0xC0, 0x08, 0x00, 0x00, 0x04, 0x1F, 0xE7, 0xFD,
  0x07, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0x60, 0x30,
  0x0C, 0x06, 0x00, 0x00, 0x00, 0x18, 0x0E, 0x03, 0x80, 0x00, 0x7F, 0x80,
  0x1F, 0xFF, 0x01, 0xC0, 0x1C, 0x1C, 0x00, 0x61, 0x80, 0x03, 0x9C, 0x1F,
  0x0C, 0xC3, 0xFC, 0x6C, 0x38, 0xE3, 0x63, 0x86, 0x1B, 0x18, 0x30, 0xD8,
  0xC1, 0x87, 0x8E, 0x18, 0x3C, 0x70, 0xC3, 0x71, 0x8E, 0x39, 0x8F, 0xDF,
  0x8C, 0x3C, 0xF8, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3E,
  0x3C, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x6C, 0x00, 0xEC, 0x00, 0xCC, 0x01, 0xCC, 0x01, 0x8C, 0x03, 0x8E, 0x03,
  0x0E, 0x07, 0x0E, 0x07, 0xFE, 0x0F, 0xFE, 0x1C, 0x06, 0x18, 0x06, 0x38,
  0x06, 0x30, 0x07, 0x70, 0x07, 0xE0, 0x07, 0x0F, 0xF8, 0x1F, 0xF8, 0x30,
  0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x01, 0xC6, 0x03, 0x0C, 0x1E, 0x3F, 0xF0,
  0x7F, 0xE0, 0xC0, 0xE1, 0x80, 0xC7, 0x01, 0xCE, 0x03, 0x98, 0x06, 0x30,
  0x1C, 0x60, 0x79, 0xFF, 0xE3, 0xFF, 0x00, 0x00, 0x60, 0x07, 0xFC, 0x3F,
  0xF8, 0xF0, 0x13, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xF0, 0x20, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x0F,
  0xFC, 0x0C, 0x1E, 0x1C, 0x06, 0x1C, 0x07, 0x18, 0x07, 0x18, 0x03, 0x18,
  0x03, 0x38, 0x03, 0x38, 0x07, 0x30, 0x07, 0x30, 0x07, 0x70, 0x0E, 0x70,
  0x0E, 0x60, 0x1C, 0x60, 0x38, 0x60, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x0F,
  0xFC, 0x3F, 0xF0, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x3F, 0xF0, 0xFF, 0x83, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x3F,
  0xF0, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x10, 0xFF, 0x83, 0xFE, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x03, 0xFF, 0x0F,
  0xFF, 0x1E, 0x02, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xE0, 0x7E, 0xE0, 0xFE, 0xE0, 0x0C, 0xE0, 0x0C, 0xE0,
  0x1C, 0xE0, 0x1C, 0x70, 0x18, 0x78, 0x18, 0x3F, 0xF8, 0x1F, 0xF0, 0x0E,
  0x01, 0x86, 0x00, 0xC3, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x30, 0xC0, 0x18,
  0x60, 0x0C, 0x30, 0x0E, 0x3F, 0xFF, 0x1F, 0xFF, 0x0C, 0x01, 0x86, 0x00,
  0xC3, 0x00, 0xE3, 0x80, 0x71, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x0C, 0x70,
  0x0E, 0x38, 0x07, 0x00, 0x0F, 0xE0, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0xE0, 0x1C, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0xFC, 0x0F, 0x80, 0x0E, 0x07, 0x86, 0x07, 0x03,
  0x07, 0x03, 0x87, 0x01, 0xC7, 0x00, 0xC7, 0x00, 0x67, 0x00, 0x37, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x0E, 0x60, 0x06, 0x38, 0x07, 0x0C, 0x03, 0x86,
  0x01, 0x83, 0x80, 0xC0, 0xC0, 0x60, 0x70, 0x70, 0x18, 0x38, 0x0E, 0x00,
  0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E,
  0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x3F, 0xFF, 0xFC,
  0x0F, 0x00, 0x3C, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x86, 0xC0, 0x36, 0x1B,
  0x01, 0xF8, 0x6C, 0x06, 0xE1, 0xB0, 0x3B, 0x0E, 0xC0, 0xCC, 0x39, 0x87,
  0x30, 0xC6, 0x19, 0xC3, 0x18, 0xC7, 0x0C, 0x63, 0x18, 0x71, 0x98, 0x61,
  0xC6, 0x61, 0x86, 0x1B, 0x0E, 0x18, 0x7C, 0x38, 0x60, 0xE0, 0xC3, 0x83,
  0x83, 0x0C, 0x0C, 0x1C, 0x00, 0x0E, 0x00, 0xC3, 0x80, 0x30, 0xF0, 0x1C,
  0x6C, 0x06, 0x1B, 0x81, 0x86, 0x60, 0x61, 0x98, 0x38, 0xE7, 0x0E, 0x38,
  0xC3, 0x0C, 0x30, 0xC3, 0x0E, 0x30, 0xC1, 0x9C, 0x70, 0x67, 0x1C, 0x0D,
  0x86, 0x03, 0x61, 0x80, 0xF8, 0x60, 0x1E, 0x38, 0x07, 0x0C, 0x01, 0xC0,
  0x00, 0x60, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0x81, 0xE3, 0x80, 0x71, 0x80,
  0x19, 0xC0, 0x0E, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xDC,
  0x00, 0x6E, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x19, 0xC0, 0x1C, 0x70, 0x1C,
  0x3C, 0x1C, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0xC1,
  0xC7, 0x03, 0x1C, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x07, 0x38, 0x38, 0xFF,
  0xC3, 0xFE, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x03, 0xFE, 0x03, 0xFF, 0x83,
  0x81, 0xE3, 0x80, 0x71, 0x80, 0x19, 0xC0, 0x0E, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xDC, 0x00, 0x6E, 0x00, 0x77, 0x00, 0x3B, 0x80,
  0x19, 0xC0, 0x1C, 0x70, 0x1C, 0x3C, 0x1C, 0x0F, 0xFC, 0x03, 0xFC, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0xF0, 0x3F, 0xE0, 0xC1, 0xC7, 0x03, 0x1C, 0x0C, 0x60, 0x31, 0x80, 0xC6,
  0x07, 0x38, 0x78, 0xFF, 0xC3, 0xFC, 0x0C, 0x70, 0x70, 0xC1, 0xC3, 0x86,
  0x06, 0x18, 0x18, 0x60, 0x73, 0x80, 0xCE, 0x03, 0x80, 0x01, 0x80, 0x7F,
  0xC7, 0xFE, 0x70, 0x23, 0x80, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x1C, 0x00,
  0xE4, 0x0E, 0x3F, 0xE1, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x18, 0x03, 0x8C, 0x01, 0x8E, 0x00, 0xC7, 0x00,
  0xE3, 0x00, 0x71, 0x80, 0x31, 0xC0, 0x18, 0xE0, 0x1C, 0x60, 0x0E, 0x30,
  0x07, 0x18, 0x03, 0x1C, 0x01, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x61,
  0xC0, 0x70, 0x70, 0x70, 0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0xE0, 0x0E, 0xC0,
  0x19, 0x80, 0x73, 0x00, 0xC6, 0x03, 0x8C, 0x06, 0x1C, 0x1C, 0x38, 0x30,
  0x70, 0xE0, 0x61, 0x80, 0xC7, 0x01, 0x8C, 0x03, 0x38, 0x06, 0x60, 0x0D,
  0xC0, 0x1B, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x0F,
  0x01, 0xC0, 0x7C, 0x07, 0x81, 0xB0, 0x36, 0x0E, 0xC0, 0xD8, 0x33, 0x06,
  0x61, 0xCC, 0x19, 0x86, 0x38, 0xC6, 0x18, 0xE3, 0x18, 0xC3, 0x9C, 0x63,
  0x0E, 0x61, 0x9C, 0x3B, 0x86, 0x60, 0xEC, 0x1B, 0x83, 0xB0, 0x6C, 0x07,
  0x81, 0xB0, 0x1E, 0x07, 0x80, 0x70, 0x1E, 0x01, 0xC0, 0x70, 0x06, 0x01,
  0xC0, 0x00, 0x0E, 0x03, 0x83, 0x03, 0x81, 0x81, 0x80, 0xE1, 0x80, 0x31,
  0xC0, 0x1D, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xF8, 0x00, 0xEC, 0x00, 0x66, 0x00, 0x63, 0x80, 0x70, 0xC0, 0x70, 0x70,
  0x30, 0x38, 0x30, 0x0C, 0x38, 0x07, 0x00, 0xE0, 0x1D, 0x80, 0xE7, 0x03,
  0x1C, 0x1C, 0x30, 0xE0, 0xC3, 0x03, 0x9C, 0x0E, 0xE0, 0x1B, 0x00, 0x7C,
  0x01, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x30, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60,
  0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x07, 0xC3, 0xF0, 0xC0, 0x30, 0x0C, 0x03,
  0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01,
  0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x3E, 0x0F, 0x80, 0xC6, 0x31,
  0xC6, 0x31, 0x8C, 0x63, 0x8C, 0x63, 0x18, 0xC6, 0x38, 0xC6, 0x07, 0xC1,
  0xF0, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30,
  0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x3F, 0x0F, 0x80, 0x07, 0x00, 0x38, 0x03, 0x60, 0x1B, 0x01, 0x8C, 0x0C,
  0x60, 0xC1, 0x86, 0x0C, 0x30, 0x33, 0x01, 0x98, 0x07, 0x80, 0x30, 0xFF,
  0xFF, 0xF8, 0xEE, 0x63, 0x10, 0x03, 0x80, 0x3F, 0x31, 0xE7, 0x8E, 0x0E,
  0x30, 0x39, 0xC0, 0xE6, 0x03, 0x98, 0x0C, 0xE0, 0x33, 0x81, 0xCE, 0x07,
  0x38, 0x3C, 0x61, 0xE1, 0xFD, 0x83, 0xE6, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x63, 0x83, 0x7E, 0x3F, 0x39, 0xE0,
  0xCE, 0x06, 0x70, 0x33, 0x01, 0xB8, 0x0D, 0x80, 0xEC, 0x07, 0x60, 0x37,
  0x03, 0xBC, 0x39, 0xBF, 0x8C, 0xF8, 0x00, 0x03, 0xC1, 0xFC, 0x78, 0x9C,
  0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x07,
  0x04, 0xFF, 0x07, 0xE0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xC0, 0x01, 0x80, 0xC3, 0x07, 0xEE, 0x1E, 0x78, 0x70, 0x70, 0xC0,
  0xE3, 0x81, 0xC6, 0x03, 0x8C, 0x06, 0x38, 0x0C, 0x70, 0x38, 0xE0, 0x71,
  0xC1, 0xE1, 0x87, 0x83, 0xFB, 0x03, 0xE6, 0x00, 0x03, 0x80, 0xFE, 0x1C,
  0xE3, 0x87, 0x30, 0x77, 0x06, 0x63, 0xE7, 0xF8, 0xFC, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x47, 0xFC, 0x3F, 0x80, 0x00, 0x1C, 0x00, 0xFC, 0x03,
  0x88, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x72, 0x07, 0xF8, 0x01, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x01, 0x70, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x3F, 0x31, 0xE7, 0x8E, 0x0E, 0x30, 0x39, 0xC0, 0xE6, 0x03, 0x98, 0x0C,
  0xE0, 0x33, 0x81, 0xCE, 0x07, 0x38, 0x3C, 0x61, 0xE1, 0xFD, 0x83, 0xE6,
  0x00, 0x38, 0x00, 0xC0, 0x03, 0x08, 0x1C, 0x3F, 0xE0, 0xFF, 0x00, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x63, 0x03, 0x7E,
  0x3F, 0x39, 0xE0, 0xCE, 0x06, 0x70, 0x33, 0x03, 0xB8, 0x1D, 0xC0, 0xCC,
  0x06, 0x60, 0x77, 0x03, 0xB8, 0x19, 0x80, 0xCC, 0x06, 0x00, 0x0C, 0x70,
  0xC0, 0x00, 0x01, 0x8E, 0x38, 0xC3, 0x0C, 0x71, 0xC6, 0x18, 0xE3, 0x8C,
  0x30, 0x00, 0xC0, 0x70, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x0E, 0x03,
  0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80,
  0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0xF8, 0x3C, 0x00, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x23, 0x0E, 0x38,
  0xE1, 0xCE, 0x0C, 0xE0, 0x6E, 0x03, 0xE0, 0x37, 0x01, 0xFC, 0x0E, 0x60,
  0x63, 0x87, 0x0C, 0x38, 0x71, 0x81, 0x8C, 0x0E, 0x00, 0x0C, 0x30, 0xC7,
  0x1C, 0x61, 0x86, 0x38, 0xE3, 0x0C, 0x31, 0xC7, 0x18, 0x63, 0x8E, 0x30,
  0xC0, 0x00, 0xE0, 0x60, 0xDF, 0x9F, 0x8F, 0xCD, 0xCE, 0x78, 0x78, 0x33,
  0x83, 0xC1, 0x9C, 0x1C, 0x0C, 0xC0, 0xC0, 0xEE, 0x06, 0x07, 0x70, 0x30,
  0x33, 0x03, 0x81, 0x98, 0x1C, 0x0D, 0xC0, 0xC0, 0xEE, 0x06, 0x06, 0x60,
  0x70, 0x33, 0x03, 0x81, 0x80, 0x18, 0xE0, 0xDF, 0xCF, 0xDE, 0x78, 0x33,
  0x81, 0x9C, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x33, 0x01, 0x98, 0x1D, 0xC0,
  0xEE, 0x07, 0x70, 0x33, 0x03, 0x80, 0x03, 0x80, 0x7F, 0x07, 0x9C, 0x70,
  0x77, 0x03, 0xB8, 0x1D, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xB8, 0x0C,
  0xC0, 0xE7, 0x0E, 0x3F, 0xE0, 0x7E, 0x00, 0x00, 0x38, 0x0D, 0xF8, 0x3F,
  0x38, 0x78, 0x30, 0xE0, 0x61, 0xC0, 0xC3, 0x01, 0x8E, 0x03, 0x18, 0x0E,
  0x30, 0x1C, 0x60, 0x31, 0xC0, 0xE3, 0xC3, 0x86, 0xFE, 0x0C, 0xF8, 0x18,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x3F, 0x31, 0xE7, 0x8E, 0x0E, 0x30, 0x39, 0xC0, 0xE6, 0x03, 0x98,
  0x0C, 0xE0, 0x33, 0x81, 0xCE, 0x07, 0x38, 0x3C, 0x61, 0xE1, 0xFD, 0x83,
  0xE6, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0xE3, 0x78, 0xFD, 0x1E, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x00, 0x07, 0x83, 0xFC,
  0xF3, 0x98, 0x03, 0x00, 0x70, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x38, 0x07,
  0x00, 0xE8, 0x1D, 0xFF, 0x3F, 0xC0, 0x0C, 0x06, 0x06, 0x07, 0x0F, 0xF9,
  0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x7C, 0x3E, 0x00, 0x38, 0x1C, 0xE0, 0x63, 0x01, 0x8C, 0x06, 0x30, 0x39,
  0xC0, 0xE7, 0x03, 0x18, 0x0C, 0x60, 0x71, 0x81, 0xCE, 0x0F, 0x18, 0x78,
  0x7F, 0x60, 0xF9, 0x80, 0xE0, 0x3B, 0x03, 0x98, 0x18, 0xC1, 0xC6, 0x0C,
  0x30, 0xE1, 0x86, 0x0C, 0x70, 0x73, 0x03, 0xB8, 0x0D, 0x80, 0x78, 0x03,
  0xC0, 0x1C, 0x00, 0xC1, 0xC0, 0xF8, 0x38, 0x3B, 0x0D, 0x06, 0x61, 0xA1,
  0xCC, 0x64, 0x31, 0x8C, 0xCE, 0x33, 0x19, 0x86, 0x63, 0x70, 0xDC, 0x6C,
  0x1B, 0x0D, 0x83, 0x61, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xC0, 0xE0,
  0x00, 0x1C, 0x1E, 0x18, 0x70, 0x38, 0xC0, 0x33, 0x00, 0x7E, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x19, 0x80, 0x73, 0x01, 0xC3, 0x07,
  0x06, 0x1C, 0x0E, 0x00, 0x0E, 0x03, 0x83, 0x03, 0x81, 0x81, 0x80, 0xC1,
  0xC0, 0x60, 0xC0, 0x30, 0xE0, 0x1C, 0x60, 0x0E, 0x70, 0x03, 0x30, 0x01,
  0xB0, 0x00, 0xD8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0xF0, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x06, 0x00, 0xFF, 0xCF, 0xF8, 0x01, 0xE0, 0x78, 0x0C,
  0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x81, 0xE0, 0x70,
  0x07, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x78, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0x03, 0xC0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x00, 0xC0,
  0x38, 0x07, 0x07, 0xC1, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60,
  0x38, 0x3C, 0x0F, 0x00, 0x7E, 0x0F, 0xFF, 0xE0, 0xFC,
};

const GFXglyph NotoSans_Italic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 19, 7, 1, -19 },
  { 16, 8, 7, 11, 3, -19 },
  { 23, 17, 19, 17, 1, -19 },
  { 64, 13, 22, 15, 1, -20 },
  { 100, 18, 20, 22, 2, -20 },
  { 145, 16, 20, 18, 1, -20 },
  { 185, 3, 7, 6, 3, -19 },
  { 188, 9, 23, 8, 1, -19 },
  { 214, 9, 23, 8, -2, -19 },
  { 240, 12, 13, 15, 3, -21 },
  { 260, 13, 13, 15, 2, -16 },
  { 282, 5, 6, 7, -1, -3 },
  { 286, 7, 2, 8, 1, -8 },
  { 288, 3, 3, 7, 1, -3 },
  { 290, 13, 19, 10, -1, -19 },
  { 321, 12, 20, 15, 2, -20 },
  { 351, 8, 19, 15, 4, -19 },
  { 370, 14, 20, 15, 0, -20 },
  { 405, 13, 20, 15, 1, -20 },
  { 438, 14, 19, 15, 0, -19 },
  { 472, 13, 19, 15, 1, -19 },
  { 503, 13, 20, 15, 2, -20 },
  { 536, 13, 19, 15, 2, -19 },
  { 567, 14, 20, 15, 1, -20 },
  { 602, 13, 20, 15, 1, -20 },
  { 635, 5, 15, 7, 1, -15 },
  { 645, 7, 18, 7, -1, -15 },
  { 661, 13, 13, 15, 2, -16 },
  { 683, 12, 7, 15, 2, -13 },
  { 694, 13, 13, 15, 2, -16 },
  { 716, 10, 20, 12, 2, -20 },
  { 741, 21, 21, 23, 1, -19 },
  { 797, 16, 19, 15, -2, -19 },
  { 835, 15, 19, 16, 1, -19 },
  { 871, 15, 20, 16, 2, -20 },
  { 909, 16, 19, 18, 1, -19 },
  { 947, 14, 19, 14, 1, -19 },
  { 981, 14, 19, 13, 1, -19 },
  { 1015, 16, 20, 18, 2, -20 },
  { 1055, 17, 19, 18, 1, -19 },
  { 1096, 11, 19, 9, -1, -19 },
  { 1123, 12, 24, 7, -4, -19 },
  { 1159, 17, 19, 15, 1, -19 },
  { 1200, 10, 19, 13, 1, -19 },
  { 1224, 22, 19, 23, 1, -19 },
  { 1277, 18, 19, 19, 1, -19 },
  { 1320, 17, 20, 19, 2, -20 },
  { 1363, 14, 19, 15, 1, -19 },
  { 1397, 17, 25, 19, 2, -20 },
  { 1451, 14, 19, 15, 1, -19 },
  { 1485, 13, 20, 14, 1, -20 },
  { 1518, 14, 19, 14, 2, -19 },
  { 1552, 17, 19, 18, 2, -19 },
  { 1593, 15, 19, 15, 2, -19 },
  { 1629, 22, 19, 23, 3, -19 },
  { 1682, 17, 19, 14, -1, -19 },
  { 1723, 14, 19, 14, 2, -19 },
  { 1757, 15, 19, 14, 0, -19 },
  { 1793, 10, 23, 8, 0, -19 },
  { 1822, 5, 19, 10, 3, -19 },
  { 1834, 10, 23, 8, -2, -19 },
  { 1863, 13, 12, 15, 1, -19 },
  { 1883, 11, 2, 11, -2, 2 },
  { 1886, 4, 5, 8, 4, -21 },
  { 1889, 14, 15, 15, 1, -15 },
  { 1916, 13, 21, 16, 1, -21 },
  { 1951, 11, 15, 12, 1, -15 },
  { 1972, 15, 21, 16, 1, -21 },
  { 2012, 12, 15, 13, 1, -15 },
  { 2035, 15, 27, 9, -3, -21 },
  { 2086, 14, 21, 16, 1, -15 },
  { 2123, 13, 21, 16, 1, -21 },
  { 2158, 6, 20, 7, 1, -20 },
  { 2173, 10, 26, 7, -3, -20 },
  { 2206, 13, 21, 13, 1, -21 },
  { 2241, 6, 21, 7, 1, -21 },
  { 2257, 21, 15, 24, 1, -15 },
  { 2297, 13, 15, 16, 1, -15 },
  { 2322, 13, 15, 15, 1, -15 },
  { 2347, 15, 21, 16, -1, -15 },
  { 2387, 14, 21, 16, 1, -15 },
  { 2424, 11, 15, 11, 1, -15 },
  { 2445, 11, 15, 12, 0, -15 },
  { 2466, 9, 18, 9, 1, -18 },
  { 2487, 14, 14, 16, 1, -14 },
  { 2512, 13, 14, 13, 1, -14 },
  { 2535, 19, 14, 20, 2, -14 },
  { 2569, 15, 14, 13, -1, -14 },
  { 2596, 17, 20, 13, -3, -14 },
  { 2639, 12, 14, 12, 0, -14 },
  { 2660, 11, 23, 9, 0, -19 },
  { 2692, 2, 28, 15, 7, -21 },
  { 2699, 10, 23, 9, -1, -19 },
  { 2728, 13, 3, 15, 2, -11 },
};

const GFXfont NotoSans_Italic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic27pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_ITALIC27PT7B_H_
