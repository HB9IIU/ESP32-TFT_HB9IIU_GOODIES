#ifndef _NOTOSANS_ITALIC60PT7B_H_
#define _NOTOSANS_ITALIC60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Italic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Italic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x38, 0x00, 0x3E, 0x0F, 0xDF, 0x83, 0xE7, 0xE0, 0xF9,
  0xF0, 0x7E, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xE0, 0x7C, 0xF8,
  0x1E, 0x3E, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F,
  0x0E, 0x03, 0xC3, 0x80, 0xE0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x3C, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x7C, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xF3,
  0xC7, 0xC0, 0x3F, 0x0F, 0x03, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xE0, 0xF0,
  0x00, 0x1F, 0x07, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x1F, 0x87, 0x80, 0x00, 0x3E, 0x3C, 0x00, 0x00,
  0xFE, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xC7, 0xE0, 0x00, 0x0F, 0x0F,
  0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xC1, 0xF0,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xE0, 0xF8, 0x20,
  0x07, 0x87, 0xE0, 0xF0, 0x3C, 0x7F, 0x03, 0xFC, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7C, 0x03, 0xFF, 0x00, 0x00, 0x78, 0x0F, 0xFF,
  0x80, 0x00, 0xF8, 0x0F, 0xFF, 0x80, 0x01, 0xF0, 0x1F, 0x07, 0xC0, 0x03,
  0xE0, 0x3E, 0x03, 0xC0, 0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x07, 0xC0, 0x3C,
  0x03, 0xC0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x7C, 0x00,
  0xF8, 0x07, 0xC0, 0xF8, 0x00, 0xF0, 0x07, 0xC0, 0xF0, 0x00, 0xF0, 0x07,
  0x81, 0xF0, 0x00, 0xF0, 0x07, 0x83, 0xE0, 0x00, 0xF0, 0x0F, 0x87, 0xC0,
  0x00, 0xF0, 0x0F, 0x87, 0x87, 0xF8, 0xF0, 0x0F, 0x0F, 0x8F, 0xFC, 0xF0,
  0x1F, 0x1F, 0x1F, 0xFE, 0xF8, 0x1E, 0x3E, 0x3F, 0xFE, 0xF8, 0x3E, 0x3C,
  0x7C, 0x1F, 0x7F, 0xFC, 0x7C, 0x78, 0x0F, 0x7F, 0xF8, 0xF8, 0xF8, 0x0F,
  0x3F, 0xF1, 0xF0, 0xF0, 0x0F, 0x1F, 0xE1, 0xE1, 0xF0, 0x0F, 0x00, 0x03,
  0xE1, 0xE0, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x0F, 0x00, 0x07, 0x83, 0xE0,
  0x0F, 0x00, 0x0F, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x1F, 0x00,
  0x3E, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0x7C, 0x03,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x03, 0xC0, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x78, 0x07, 0xC0,
  0x03, 0xE0, 0xF8, 0x0F, 0x80, 0x01, 0xFB, 0xF0, 0x0F, 0x00, 0x01, 0xFF,
  0xE0, 0x1F, 0x00, 0x00, 0xFF, 0xC0, 0x3E, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F,
  0xC0, 0x00, 0x0F, 0x81, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x01,
  0xF3, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0x0F, 0xF3, 0xF0, 0x01, 0xF0,
  0xFE, 0x0F, 0xC0, 0x0F, 0x8F, 0xE0, 0x3F, 0x00, 0xF8, 0x7E, 0x01, 0xF8,
  0x07, 0xC7, 0xE0, 0x07, 0xE0, 0x7C, 0x3E, 0x00, 0x1F, 0x87, 0xE3, 0xF0,
  0x00, 0xFC, 0x3E, 0x1F, 0x00, 0x03, 0xF3, 0xE0, 0xF8, 0x00, 0x0F, 0xFF,
  0x07, 0xC0, 0x00, 0x3F, 0xF0, 0x3E, 0x00, 0x01, 0xFF, 0x01, 0xF0, 0x00,
  0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x07, 0xFC, 0x01,
  0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x3F, 0x00, 0xFF, 0xFF, 0xE1, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xE0, 0x0F,
  0xFF, 0x80, 0x1F, 0x80, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3E, 0xFD, 0xFB,
  0xE7, 0xCF, 0x9F, 0x3C, 0xF9, 0xF3, 0xC7, 0x8F, 0x1E, 0x38, 0x70, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x40, 0x07, 0x80, 0x07, 0x00, 0x78, 0x00, 0x7C,
  0x07, 0x80, 0x07, 0xF0, 0x70, 0x00, 0xFF, 0xC7, 0x00, 0x07, 0xFF, 0x70,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x03, 0xF7, 0xFF, 0x00, 0x7F, 0x80, 0x30, 0x0F, 0x78, 0x00, 0x03, 0xE3,
  0xC0, 0x00, 0x7E, 0x3C, 0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0x1E, 0x00,
  0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x0E, 0x01, 0xF0, 0x00, 0x40,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC,
  0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0x3E, 0x7F,
  0x7F, 0xFF, 0xFF, 0xFE, 0x7E, 0x38, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0x87, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0x7E, 0x03,
  0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x03, 0xF0, 0xF8, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0xCF,
  0x80, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0xFD, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x00,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x03,
  0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF1, 0xFF, 0x7C, 0xFF, 0x9F, 0x3F, 0x8F,
  0xC7, 0x83, 0xE1, 0xC0, 0xF8, 0x20, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0x83, 0xFC, 0x00,
  0x7C, 0x00, 0xFE, 0x00, 0x30, 0x00, 0x7E, 0x00, 0x20, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xE0, 0x3F, 0x80, 0x1F, 0x00, 0x3F, 0x80, 0x18, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x08, 0x00, 0x01, 0xFC, 0x1C, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xBC, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00,
  0x7E, 0x7C, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x01, 0xF8,
  0x03, 0xE0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x3F, 0x00,
  0x07, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0E, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x80, 0x00, 0x1F, 0x83, 0x80, 0x01, 0xFC,
  0x0F, 0x80, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x03, 0xFE, 0x03, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x07, 0xE0,
  0x01, 0xF0, 0xFF, 0xE0, 0x1F, 0x9F, 0xFF, 0x80, 0xFD, 0xFF, 0xFE, 0x07,
  0xDF, 0x8F, 0xF8, 0x3F, 0xE0, 0x0F, 0xC1, 0xFE, 0x00, 0x7E, 0x1F, 0xE0,
  0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x7C, 0x3E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x03,
  0xF0, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xF8,
  0x1F, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0xF8, 0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xE0,
  0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7C, 0x3E,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x7C, 0x3E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x7E, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x58, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x00,
  0x7E, 0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF1,
  0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x3F, 0x00,
  0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F,
  0x3E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xF1, 0xF0,
  0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xF1, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0xFF,
  0xE0, 0xFF, 0xFF, 0xBE, 0x07, 0xFF, 0xF7, 0xE0, 0x3F, 0xFC, 0x7C, 0x00,
  0xFF, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0xE0, 0x1F, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x01, 0xE0, 0x1F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xF8,
  0x1F, 0x80, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xFE, 0x07,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x7E, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x7F,
  0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0x03, 0xF8, 0xE0, 0x07,
  0xF2, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0x81, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xFE, 0x00, 0x7C,
  0x3E, 0x00, 0x3F, 0xFF, 0x01, 0xF0, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xC7,
  0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0x1E, 0x00, 0xFC, 0x07, 0xC0, 0x3C, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0xF3, 0xC0, 0x3E, 0x00, 0x78, 0x03, 0xDF, 0x00,
  0xF8, 0x01, 0xE0, 0x0F, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0x3D, 0xE0, 0x1E,
  0x00, 0x3E, 0x00, 0xF7, 0x80, 0xF8, 0x00, 0xF0, 0x03, 0xDE, 0x03, 0xE0,
  0x03, 0xC0, 0x1F, 0xF8, 0x0F, 0x00, 0x1F, 0x00, 0x7F, 0xE0, 0x3C, 0x00,
  0x7C, 0x01, 0xEF, 0x81, 0xF0, 0x01, 0xE0, 0x07, 0xBE, 0x07, 0xC0, 0x0F,
  0x80, 0x3E, 0xF8, 0x1F, 0x00, 0x3E, 0x00, 0xF3, 0xE0, 0x7C, 0x01, 0xF8,
  0x07, 0xCF, 0x80, 0xF0, 0x0F, 0xE0, 0x3E, 0x3E, 0x03, 0xE0, 0x7F, 0x81,
  0xF8, 0xF8, 0x0F, 0xC3, 0xDF, 0x0F, 0xC1, 0xE0, 0x1F, 0xFE, 0x3F, 0xFE,
  0x07, 0xC0, 0x7F, 0xF0, 0xFF, 0xF0, 0x1F, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x7C, 0x00, 0x70, 0x00, 0x60, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x01, 0xF8,
  0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x7C, 0x07, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x3E, 0x7E,
  0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x07,
  0xF8, 0x03, 0xF0, 0x00, 0xFE, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0x80, 0x0F, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x81, 0xF0, 0x00, 0x7F,
  0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0xC0,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x10, 0x00, 0xFF, 0xC0, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0xC0, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0x80,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x3E, 0x00,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0xFE, 0x0F,
  0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0x00, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xFE, 0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x3E,
  0x00, 0x0F, 0xF8, 0x03, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x1C, 0x00, 0xFF, 0x00, 0x00,
  0x40, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x0F, 0xFF, 0xC7, 0xC0, 0x00, 0xFF, 0xF8, 0x7C, 0x00, 0x1F, 0xFF,
  0x8F, 0xC0, 0x01, 0xFF, 0xF8, 0xFC, 0x00, 0x1F, 0xFF, 0x8F, 0xC0, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0xFC,
  0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x3F,
  0xC0, 0x00, 0x7C, 0x01, 0xFE, 0x00, 0x07, 0xC0, 0x0F, 0xFC, 0x07, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00,
  0x7E, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x7E, 0x00,
  0x00, 0x7E, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x30, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x03,
  0xF8, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x03, 0xF8, 0x00, 0x07,
  0xC0, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0x80,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00,
  0x1F, 0x1F, 0x80, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x0F, 0xDF, 0xC0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x3E, 0x00, 0x00, 0x0F, 0xE1, 0xF8, 0x00,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0x00, 0x3E, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00,
  0xF9, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x7C, 0xF0, 0x00, 0x07, 0xDF, 0x80,
  0x3E, 0x78, 0x00, 0x07, 0xCF, 0x80, 0x1F, 0x3C, 0x00, 0x03, 0xE7, 0xC0,
  0x0F, 0x9F, 0x00, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x01, 0xF3, 0xF0,
  0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x00, 0xF0, 0xF8,
  0x01, 0xF0, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x3E,
  0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x1F,
  0x00, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x3E, 0x07,
  0xC0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xE0, 0x0F, 0x81, 0xF0, 0x1F, 0x03,
  0xF0, 0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xF0, 0x03, 0xE0, 0x3C, 0x0F, 0x80,
  0xF8, 0x01, 0xF0, 0x1E, 0x07, 0x80, 0x7C, 0x01, 0xF8, 0x0F, 0x07, 0xC0,
  0x7E, 0x00, 0xF8, 0x07, 0x87, 0xC0, 0x3F, 0x00, 0x7C, 0x03, 0xE3, 0xE0,
  0x1F, 0x00, 0x3E, 0x01, 0xF3, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0xF9, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7D, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1E, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xF8,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xFC, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x0F,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0x80,
  0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x0F, 0xE0, 0x00, 0x03,
  0xE0, 0x07, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x00, 0x01, 0xF8, 0x03,
  0xFF, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0xF7, 0xC0,
  0x00, 0x3E, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0xF8, 0x00, 0x1F,
  0x80, 0x3E, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x07, 0xC0, 0x0F,
  0x8F, 0x80, 0x03, 0xE0, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0x07, 0xC1, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7C,
  0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x3F, 0x00, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x00, 0x3E,
  0x3F, 0x00, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x00, 0x07, 0xCF, 0x80,
  0x1F, 0x00, 0x03, 0xE7, 0xC0, 0x1F, 0x00, 0x01, 0xFB, 0xE0, 0x0F, 0x80,
  0x00, 0x7D, 0xE0, 0x07, 0xC0, 0x00, 0x3F, 0xF0, 0x03, 0xE0, 0x00, 0x0F,
  0xF8, 0x01, 0xF0, 0x00, 0x07, 0xFC, 0x01, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x1F, 0x3F,
  0x00, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x00,
  0x3E, 0xFC, 0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xBF, 0x00,
  0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0xFE, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x03,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFC,
  0x01, 0xFE, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x07, 0xE0,
  0x07, 0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x00,
  0xF9, 0xF8, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x00, 0x3E, 0xFC, 0x00,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x00, 0xFD,
  0xF0, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFC, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7E,
  0x03, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF8,
  0x07, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x07, 0xC0,
  0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xC3, 0xF8, 0x07, 0xF0, 0x01, 0xE0, 0x3F, 0x80, 0x01, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x80,
  0x00, 0x3F, 0x83, 0x80, 0x03, 0xFC, 0x0F, 0xC0, 0x3F, 0xE0, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0xF8, 0x3F,
  0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF0,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xBE, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x0F, 0xC7, 0xC0, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x00,
  0x01, 0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0xFC, 0x03, 0xE0,
  0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x07,
  0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0xF8, 0x07, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x01, 0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x7C, 0x7E, 0x00,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x3E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xC3,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x7E,
  0x0F, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xFB, 0xE0, 0x03,
  0xF0, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xCF, 0x80,
  0x0F, 0x80, 0xF8, 0x00, 0xF1, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0x7C, 0x03, 0xE0, 0x07, 0x87, 0xC0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0xFC, 0x01, 0xF0, 0x0F,
  0x81, 0xE0, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x3C, 0x07, 0xE0, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x00, 0x1F,
  0x03, 0xE0, 0x1E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x03, 0xC0, 0xF8, 0x00,
  0x7C, 0x1F, 0x00, 0x78, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x0F, 0x07, 0xC0,
  0x00, 0xF8, 0xF8, 0x01, 0xE1, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0x03, 0xE3, 0xC0, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0xF9,
  0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF7, 0xC0, 0x03,
  0xE7, 0x80, 0x00, 0x3C, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0x07, 0x9E, 0x00,
  0x0F, 0xBC, 0x00, 0x00, 0xF7, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x1E, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x01, 0xF1, 0xF8, 0x00,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0x1F,
  0x87, 0xC0, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0x00,
  0xFC, 0x00, 0x7C, 0x07, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0xFC, 0x00,
  0x01, 0xE7, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0xF8, 0x07,
  0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x1E, 0x01, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x03, 0xE1, 0xE0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x01,
  0xE0, 0x3E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0xF8, 0x00,
  0x7C, 0x03, 0xC0, 0x00, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x3F, 0x07,
  0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0xF0, 0x07, 0xFF, 0x87, 0xC0, 0x7F, 0xFF,
  0x1E, 0x03, 0xFF, 0xFE, 0x78, 0x1F, 0xE0, 0x7F, 0xE0, 0x7E, 0x00, 0xFF,
  0x83, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0xFC, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7F, 0x0F, 0x80, 0x01, 0xF8,
  0x3E, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xFE, 0x0F,
  0xC0, 0x0F, 0xF8, 0x1F, 0x80, 0x7B, 0xC0, 0x7F, 0x07, 0xCF, 0x01, 0xFF,
  0xFE, 0x7C, 0x03, 0xFF, 0xF1, 0xF0, 0x07, 0xFF, 0x87, 0x80, 0x0F, 0xF8,
  0x1E, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x3F,
  0x0F, 0xFC, 0x00, 0xF8, 0x7F, 0xF8, 0x03, 0xE7, 0xFF, 0xF0, 0x0F, 0xBF,
  0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0x81, 0xF7, 0x80, 0x7E, 0x07, 0xFC, 0x00,
  0xF8, 0x1F, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F,
  0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3,
  0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x07,
  0xE1, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xF0,
  0x7F, 0x80, 0x3F, 0x81, 0xEF, 0x01, 0xFC, 0x0F, 0x9F, 0xFF, 0xF0, 0x3E,
  0x7F, 0xFF, 0x00, 0xF0, 0xFF, 0xF8, 0x03, 0xC0, 0xFF, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xC0, 0x30, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x02, 0x07, 0xF8, 0x07, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x03, 0xE0,
  0x00, 0xFF, 0xC1, 0xF0, 0x00, 0xFF, 0xF1, 0xF8, 0x01, 0xFF, 0xFC, 0xF8,
  0x01, 0xFF, 0xFF, 0x7C, 0x01, 0xFE, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0xFC, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x07, 0xF0, 0x1F, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x03, 0xF8, 0x07, 0xC0,
  0x01, 0xFC, 0x03, 0xF0, 0x01, 0xFE, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0x7C,
  0x01, 0xFF, 0x00, 0x3F, 0x83, 0xEF, 0x80, 0x1F, 0xFF, 0xE7, 0xC0, 0x07,
  0xFF, 0xE3, 0xE0, 0x01, 0xFF, 0xE1, 0xE0, 0x00, 0x7F, 0xC0, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0x80, 0xFC, 0x1F,
  0x80, 0x3E, 0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xCF,
  0xC0, 0x07, 0xE7, 0xC0, 0x03, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x07, 0xF1,
  0xF0, 0x7F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x01, 0x07, 0xF8, 0x07, 0x81, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00,
  0x2C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xF7,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x02, 0x0F, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x0F, 0x00, 0x3F, 0xFF, 0x1F, 0x00, 0x7F, 0xFF, 0x1F, 0x00, 0xFF,
  0xFF, 0x9E, 0x01, 0xFE, 0x07, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF0,
  0x01, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x03, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xF0, 0x3E, 0x00,
  0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x1F, 0xE0, 0x3F, 0x00, 0x3F, 0xE0, 0x1F, 0x80, 0x7F, 0xC0, 0x1F, 0xC1,
  0xF7, 0xC0, 0x1F, 0xFF, 0xE7, 0xC0, 0x0F, 0xFF, 0xC7, 0xC0, 0x07, 0xFF,
  0x8F, 0x80, 0x03, 0xFE, 0x0F, 0x80, 0x00, 0x30, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x80, 0x00,
  0x7E, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0xC3, 0xFF, 0x00, 0x7C, 0x3F, 0xFC,
  0x03, 0xE7, 0xFF, 0xF0, 0x1F, 0x7F, 0xFF, 0xC1, 0xF7, 0xE0, 0x7E, 0x0F,
  0xBC, 0x01, 0xF0, 0x7F, 0xC0, 0x0F, 0x83, 0xFC, 0x00, 0x7C, 0x1F, 0xC0,
  0x03, 0xE1, 0xFC, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00,
  0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x3F, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x83, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x10, 0x3F, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0xFC,
  0x03, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x01,
  0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x7E, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7C,
  0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3E, 0x3F,
  0x00, 0x00, 0xF9, 0xF8, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0x1F, 0x7F, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFB, 0xF0, 0x00,
  0x3F, 0xCF, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x07, 0xE0,
  0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x07, 0xC1, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0x8F, 0xFF, 0x01,
  0xFF, 0xE0, 0x1F, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x3C, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE0, 0x7B, 0xE0, 0x7E, 0x7C, 0x0F, 0xC1, 0xF7, 0x80, 0x7D, 0xE0,
  0x1F, 0x83, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x3E, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7C, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xF8, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xE1, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0xFF, 0xE0, 0x07, 0xC7, 0xFF, 0xE0, 0x0F, 0x9F,
  0xFF, 0xC0, 0x1F, 0x7F, 0xFF, 0xC0, 0x7D, 0xF8, 0x3F, 0x80, 0xFF, 0xC0,
  0x3F, 0x01, 0xFF, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0x7E, 0x0F, 0xF0, 0x00,
  0xFC, 0x1F, 0xC0, 0x01, 0xF0, 0x3F, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7C,
  0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7E, 0x07,
  0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x3E, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0x80,
  0x03, 0xE1, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x1F,
  0x7E, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7E, 0xF8,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x01,
  0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x81, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x0F, 0xFC, 0x00, 0x1F,
  0x0F, 0xFF, 0x00, 0x0F, 0x9F, 0xFF, 0xC0, 0x07, 0x9F, 0xFF, 0xE0, 0x03,
  0xDF, 0x03, 0xF8, 0x03, 0xEF, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0x3E, 0x00,
  0xFF, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x07, 0xE0,
  0x3F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC,
  0x07, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01,
  0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x00,
  0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x80,
  0xFE, 0x00, 0xF9, 0xFF, 0xFF, 0x00, 0x7C, 0xFF, 0xFE, 0x00, 0x3E, 0x3F,
  0xFE, 0x00, 0x1F, 0x07, 0xFC, 0x00, 0x0F, 0x80, 0x60, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0xF0,
  0x0F, 0xFF, 0xC7, 0xC0, 0x7F, 0xFF, 0x1E, 0x03, 0xFF, 0xFE, 0x78, 0x1F,
  0xE0, 0x7F, 0xE0, 0xFE, 0x00, 0xFF, 0x83, 0xF0, 0x01, 0xFE, 0x1F, 0x80,
  0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0xFC, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3E,
  0x1F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0x7F, 0x0F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xE0, 0xF8, 0x00,
  0x3F, 0x83, 0xF0, 0x01, 0xFE, 0x0F, 0xC0, 0x0F, 0xF8, 0x1F, 0x00, 0x7F,
  0xC0, 0x7F, 0x07, 0xDF, 0x01, 0xFF, 0xFE, 0x7C, 0x03, 0xFF, 0xF1, 0xF0,
  0x07, 0xFF, 0x8F, 0x80, 0x0F, 0xF8, 0x3E, 0x00, 0x03, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0xFF, 0x03, 0xE3, 0xFE, 0x03, 0xE7,
  0xFE, 0x03, 0xCF, 0xFE, 0x03, 0xDF, 0x80, 0x07, 0xDE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0x80, 0x78, 0x3F,
  0x00, 0x08, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x18, 0x00, 0x3F, 0x0F, 0x00, 0x7F, 0x87, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00,
  0xE8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x10, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0x1E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF0,
  0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xFC, 0x3F,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80,
  0x01, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00,
  0xFC, 0x1F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7E,
  0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x7F, 0x83,
  0xF0, 0x03, 0xFE, 0x0F, 0xC0, 0x1F, 0xF0, 0x1F, 0x81, 0xF7, 0xC0, 0x7F,
  0xFF, 0x9F, 0x00, 0xFF, 0xFC, 0x7C, 0x03, 0xFF, 0xE1, 0xE0, 0x03, 0xFE,
  0x07, 0x80, 0x01, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7E, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00,
  0x3E, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0xC0,
  0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x03, 0xF0, 0x03, 0xE0,
  0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0xC0,
  0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x3E,
  0x3F, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x1E, 0x7E, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xF9, 0xF0, 0x01, 0xFC,
  0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x80, 0x0F, 0xC7, 0xC0, 0x0F, 0xF0, 0x01,
  0xF8, 0xF8, 0x01, 0xFE, 0x00, 0x3E, 0x1F, 0x00, 0x7F, 0xE0, 0x0F, 0xC3,
  0xE0, 0x0F, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xEF, 0x80, 0x7E, 0x0F, 0x80,
  0x79, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x3E, 0x03, 0xF0, 0x3E, 0x03, 0xE7,
  0xC0, 0x7C, 0x07, 0xC0, 0x78, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0x1F, 0x03,
  0xE0, 0x1F, 0x03, 0xC1, 0xE0, 0x7C, 0x03, 0xE0, 0xF8, 0x3C, 0x1F, 0x00,
  0x7C, 0x1E, 0x07, 0x83, 0xE0, 0x0F, 0x87, 0xC0, 0xF0, 0xFC, 0x01, 0xF0,
  0xF0, 0x1E, 0x1F, 0x00, 0x3E, 0x3E, 0x03, 0xC7, 0xE0, 0x07, 0xC7, 0x80,
  0x78, 0xF8, 0x00, 0xF9, 0xF0, 0x0F, 0x1F, 0x00, 0x1F, 0x3C, 0x01, 0xE7,
  0xC0, 0x03, 0xE7, 0x80, 0x3C, 0xF8, 0x00, 0x7D, 0xE0, 0x07, 0xBE, 0x00,
  0x0F, 0xBC, 0x00, 0xF7, 0xC0, 0x00, 0xFF, 0x80, 0x1E, 0xF0, 0x00, 0x1F,
  0xE0, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xC0, 0x1F, 0x80, 0x03,
  0xE0, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x80, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x03, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x1F,
  0x00, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0xFC, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0x3E, 0x7E, 0x00,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x00, 0x3D,
  0xF0, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3C, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x13, 0xFF, 0xE0, 0x01,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0xC0, 0x01, 0xFF, 0xC8, 0x00, 0x01, 0xF0,
};

const GFXglyph NotoSans_Italic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 16, 44, 16, 1, -43 },
  { 89, 18, 16, 24, 7, -43 },
  { 125, 37, 43, 39, 2, -43 },
  { 324, 30, 48, 33, 2, -45 },
  { 504, 40, 44, 48, 5, -43 },
  { 724, 37, 45, 40, 2, -44 },
  { 933, 7, 16, 13, 7, -43 },
  { 947, 20, 52, 17, 2, -43 },
  { 1077, 20, 52, 17, -5, -43 },
  { 1207, 28, 28, 33, 6, -46 },
  { 1305, 28, 29, 34, 4, -36 },
  { 1407, 12, 15, 15, -3, -7 },
  { 1430, 15, 4, 19, 2, -18 },
  { 1438, 8, 8, 15, 1, -7 },
  { 1446, 29, 43, 21, -3, -43 },
  { 1602, 29, 45, 33, 3, -44 },
  { 1766, 18, 43, 33, 9, -43 },
  { 1863, 32, 43, 33, 0, -43 },
  { 2035, 31, 44, 33, 1, -43 },
  { 2206, 32, 43, 33, 0, -43 },
  { 2378, 30, 44, 33, 2, -43 },
  { 2543, 29, 44, 33, 4, -43 },
  { 2703, 29, 43, 33, 5, -43 },
  { 2859, 30, 45, 33, 3, -44 },
  { 3028, 28, 44, 33, 3, -43 },
  { 3182, 13, 34, 15, 1, -33 },
  { 3238, 17, 41, 15, -3, -33 },
  { 3326, 28, 29, 34, 4, -36 },
  { 3428, 27, 16, 34, 5, -29 },
  { 3482, 28, 29, 34, 4, -36 },
  { 3584, 22, 44, 26, 5, -43 },
  { 3705, 46, 48, 51, 3, -43 },
  { 3981, 34, 43, 34, -3, -43 },
  { 4164, 33, 43, 36, 2, -43 },
  { 4342, 34, 44, 35, 4, -43 },
  { 4529, 36, 43, 40, 2, -43 },
  { 4723, 31, 43, 31, 2, -43 },
  { 4890, 31, 43, 29, 2, -43 },
  { 5057, 36, 44, 41, 4, -43 },
  { 5255, 38, 43, 41, 3, -43 },
  { 5460, 24, 43, 19, -1, -43 },
  { 5589, 26, 54, 16, -9, -43 },
  { 5765, 37, 43, 34, 2, -43 },
  { 5964, 23, 43, 29, 2, -43 },
  { 6088, 49, 43, 50, 2, -43 },
  { 6352, 41, 43, 42, 2, -43 },
  { 6573, 37, 45, 43, 4, -44 },
  { 6782, 32, 43, 34, 2, -43 },
  { 6954, 37, 54, 43, 4, -44 },
  { 7204, 32, 43, 34, 2, -43 },
  { 7376, 30, 44, 30, 1, -43 },
  { 7541, 30, 43, 30, 5, -43 },
  { 7703, 36, 44, 41, 5, -43 },
  { 7901, 33, 43, 33, 6, -43 },
  { 8079, 51, 43, 51, 6, -43 },
  { 8354, 40, 43, 32, -3, -43 },
  { 8569, 30, 43, 31, 6, -43 },
  { 8731, 35, 43, 32, -1, -43 },
  { 8920, 23, 52, 17, -1, -43 },
  { 9070, 12, 43, 21, 6, -43 },
  { 9135, 22, 52, 17, -4, -43 },
  { 9278, 30, 27, 34, 2, -43 },
  { 9380, 25, 4, 24, -6, 5 },
  { 9393, 10, 10, 17, 9, -46 },
  { 9406, 30, 34, 34, 3, -33 },
  { 9534, 30, 47, 35, 2, -46 },
  { 9711, 25, 34, 27, 3, -33 },
  { 9818, 33, 47, 35, 3, -46 },
  { 10012, 25, 34, 30, 3, -33 },
  { 10119, 34, 60, 19, -7, -46 },
  { 10374, 32, 47, 35, 1, -33 },
  { 10562, 29, 46, 35, 2, -46 },
  { 10729, 14, 44, 15, 2, -44 },
  { 10806, 24, 58, 15, -8, -44 },
  { 10980, 30, 46, 30, 2, -46 },
  { 11153, 15, 46, 15, 2, -46 },
  { 11240, 47, 33, 53, 2, -33 },
  { 11434, 31, 33, 35, 1, -33 },
  { 11562, 28, 33, 34, 3, -33 },
  { 11678, 33, 47, 35, -1, -33 },
  { 11872, 30, 47, 35, 3, -33 },
  { 12049, 24, 33, 24, 2, -33 },
  { 12148, 25, 34, 26, 0, -33 },
  { 12255, 19, 40, 20, 3, -39 },
  { 12350, 30, 33, 35, 3, -32 },
  { 12474, 28, 32, 28, 3, -32 },
  { 12586, 43, 32, 43, 3, -32 },
  { 12758, 33, 32, 29, -2, -32 },
  { 12890, 37, 46, 28, -6, -32 },
  { 13103, 27, 32, 27, -1, -32 },
  { 13211, 23, 52, 21, 1, -43 },
  { 13361, 4, 60, 33, 16, -46 },
  { 13391, 23, 52, 21, -2, -43 },
  { 13541, 28, 8, 34, 4, -25 },
};

const GFXfont NotoSans_Italic60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Italic60pt7bBitmaps,
  (GFXglyph *)NotoSans_Italic60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_ITALIC60PT7B_H_
