#ifndef _NOTOSANS_SEMICONDENSED_LIGHT37PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFD, 0xB6, 0xDB, 0x6D, 0xB2, 0x49, 0x00, 0x07, 0xFC, 0xE3,
  0xB1, 0xD8, 0xEC, 0x26, 0x12, 0x09, 0x04, 0x82, 0x41, 0x00, 0x01, 0x83,
  0x00, 0x30, 0x60, 0x04, 0x0C, 0x00, 0x81, 0x80, 0x30, 0x20, 0x06, 0x04,
  0x00, 0xC1, 0x80, 0x18, 0x30, 0x7F, 0xFF, 0xE0, 0x40, 0xC0, 0x18, 0x10,
  0x03, 0x02, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x03, 0x00, 0x20, 0x60,
  0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x30, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x80,
  0x10, 0x30, 0x06, 0x04, 0x00, 0xC0, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xFF, 0xC3, 0xF7, 0xCC, 0x61, 0x30,
  0xC0, 0x61, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x0C, 0x03, 0x18, 0x07, 0xB0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0x78, 0x06, 0x38, 0x0C, 0x30,
  0x18, 0x30, 0x30, 0x60, 0x60, 0xC0, 0xC3, 0x01, 0x8E, 0xE3, 0x39, 0xFF,
  0xE0, 0x7E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x00,
  0x3F, 0x00, 0x60, 0x63, 0x00, 0xC0, 0x41, 0x80, 0xC0, 0xC1, 0x81, 0x80,
  0xC1, 0x81, 0x80, 0xC0, 0x83, 0x00, 0xC0, 0x83, 0x00, 0xC0, 0x86, 0x00,
  0xC0, 0x86, 0x00, 0xC0, 0x8C, 0x00, 0xC1, 0x8C, 0xF8, 0xC1, 0x99, 0xDC,
  0x41, 0x99, 0x86, 0x63, 0x31, 0x06, 0x3F, 0x33, 0x06, 0x1C, 0x63, 0x02,
  0x00, 0x63, 0x02, 0x00, 0x43, 0x03, 0x00, 0xC3, 0x03, 0x00, 0x83, 0x03,
  0x01, 0x83, 0x02, 0x01, 0x83, 0x06, 0x03, 0x01, 0x06, 0x03, 0x01, 0x86,
  0x06, 0x01, 0xDC, 0x06, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x1C,
  0x30, 0x03, 0x83, 0x80, 0x30, 0x18, 0x03, 0x01, 0x80, 0x30, 0x18, 0x03,
  0x01, 0x80, 0x18, 0x30, 0x01, 0x87, 0x00, 0x0C, 0xE0, 0x00, 0xFC, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x39, 0xC0, 0x07, 0x0C, 0x06, 0x60, 0x60,
  0x6C, 0x03, 0x0C, 0xC0, 0x38, 0xCC, 0x01, 0xCC, 0xC0, 0x0F, 0x8C, 0x00,
  0x78, 0xC0, 0x07, 0x0E, 0x00, 0xF8, 0x70, 0x1D, 0xC3, 0xFF, 0x8E, 0x1F,
  0xE0, 0x70, 0xED, 0xB6, 0x92, 0x40, 0x0E, 0x18, 0x61, 0xC3, 0x0E, 0x18,
  0x30, 0x61, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x38, 0x30, 0x60, 0xC0, 0xC1, 0x81, 0x83, 0x03, 0x03, 0xE0, 0x30,
  0x30, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x06, 0x06, 0x07,
  0x03, 0x03, 0x03, 0x07, 0x07, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C,
  0x1C, 0x18, 0x38, 0x30, 0x60, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x83, 0x07, 0xCC, 0xFF, 0xFF, 0x80, 0xC0, 0x07, 0x80, 0x33, 0x01,
  0xCC, 0x06, 0x18, 0x30, 0x70, 0x40, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0xFF, 0xFF,
  0xFF, 0xFC, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x39, 0x8C, 0x67, 0x31, 0x8C, 0xC0, 0xFF,
  0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0xC0, 0x18, 0x00, 0x03, 0x80, 0x3F, 0xE0, 0xF1, 0xC1, 0x80, 0xC7,
  0x01, 0xCC, 0x01, 0x98, 0x03, 0x70, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x36, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x18,
  0x0C, 0x38, 0x38, 0x3F, 0xE0, 0x3F, 0x80, 0x03, 0x87, 0xC7, 0x67, 0x7F,
  0x3A, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0x07, 0x80, 0x7F, 0xC3, 0xC1, 0xC2, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0x7F, 0xE3, 0xC1, 0xE6, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x60, 0x03, 0x81, 0xFE, 0x03, 0xF8, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00,
  0x0E, 0x80, 0x39, 0xFB, 0xE1, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x06, 0x60, 0x03, 0x70, 0x03, 0x38,
  0x03, 0x1C, 0x01, 0x8E, 0x01, 0x87, 0x01, 0x83, 0x80, 0xC1, 0xC0, 0xC0,
  0xE0, 0xE0, 0x70, 0x60, 0x38, 0x60, 0x1C, 0x30, 0x0E, 0x30, 0x07, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0xFF, 0x03, 0xFF, 0x84, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x40, 0x1C, 0xFF, 0xF0, 0xFF, 0x80, 0x00, 0xF8, 0x0F, 0xF8, 0x3C, 0x10,
  0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x3F, 0x8D, 0xE7, 0x9A, 0x03, 0xB8, 0x03, 0x70, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x36, 0x00, 0x6C, 0x00, 0xD8,
  0x03, 0x98, 0x06, 0x38, 0x1C, 0x3D, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x07, 0xC0,
  0x3F, 0xE0, 0xE0, 0xE3, 0x80, 0xE6, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x30,
  0x06, 0x60, 0x0C, 0xE0, 0x38, 0xE0, 0xE0, 0xE3, 0x80, 0xFC, 0x00, 0xF8,
  0x07, 0x3C, 0x1C, 0x1C, 0x60, 0x1D, 0xC0, 0x1F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x06, 0x70, 0x1C, 0x7D, 0xF0, 0x7F,
  0x80, 0x07, 0x80, 0x3F, 0xC0, 0xE1, 0xC3, 0x80, 0xC6, 0x01, 0xD8, 0x01,
  0xB0, 0x03, 0x60, 0x06, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0xEC, 0x03, 0xDC, 0x0D, 0x9F, 0xF3, 0x0F, 0x86, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60,
  0xCF, 0x81, 0xFE, 0x00, 0xDF, 0xA0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x31, 0xCE, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x39, 0x8C,
  0x66, 0x31, 0x88, 0xC0, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x02,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x70,
  0x00, 0x80, 0x00, 0x1E, 0x0F, 0xFC, 0xE1, 0xE0, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x7F, 0xC0, 0x01,
  0xF0, 0x78, 0x01, 0xC0, 0x06, 0x01, 0xC0, 0x01, 0x81, 0x80, 0x00, 0x61,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0xC0, 0x3F, 0x03, 0x60, 0x7F, 0xC1,
  0xB0, 0x70, 0x60, 0xF0, 0x30, 0x30, 0x78, 0x30, 0x18, 0x1C, 0x18, 0x0C,
  0x0E, 0x0C, 0x06, 0x07, 0x06, 0x03, 0x03, 0x83, 0x01, 0x83, 0xC1, 0x80,
  0xC1, 0xE0, 0xC0, 0xE0, 0xF0, 0x60, 0x70, 0x58, 0x18, 0x68, 0x64, 0x0F,
  0xE7, 0xE3, 0x01, 0xE1, 0xE1, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x08, 0x00, 0xF8, 0x7C, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0B,
  0x00, 0x01, 0x98, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x30, 0xC0, 0x03,
  0x0C, 0x00, 0x30, 0xC0, 0x06, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0x80, 0x18,
  0x18, 0x01, 0x83, 0x00, 0x1C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x60, 0x00,
  0xE6, 0x00, 0x06, 0xE0, 0x00, 0x6C, 0x00, 0x07, 0xFF, 0xF0, 0xC0, 0xFC,
  0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x1C, 0xFF, 0xF0, 0xFF, 0xF0, 0xC0, 0x3C,
  0xC0, 0x0E, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x1E, 0xFF, 0xF8, 0xFF, 0xE0,
  0x00, 0x7C, 0x01, 0xFF, 0xC1, 0xE0, 0xE1, 0xC0, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x83, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xF0,
  0x30, 0x7F, 0x0C, 0x01, 0xE3, 0x00, 0x1C, 0xC0, 0x03, 0x30, 0x00, 0xEC,
  0x00, 0x1B, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x03, 0xB0, 0x01, 0xCC,
  0x00, 0xE3, 0x00, 0xF0, 0xFF, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x3F, 0xFE, 0x07, 0x81, 0xE0, 0xE0, 0x02, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x1F,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00,
  0x03, 0x70, 0x00, 0x33, 0x00, 0x03, 0x38, 0x00, 0x31, 0xC0, 0x03, 0x0E,
  0x00, 0x30, 0x7F, 0xFF, 0x01, 0xFF, 0xC0, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x70, 0xFE, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x7D, 0xFC, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x8F,
  0xFE, 0x78, 0xC0, 0x07, 0xC0, 0x0E, 0xC0, 0x1C, 0xC0, 0x38, 0xC0, 0x30,
  0xC0, 0x60, 0xC0, 0xC0, 0xC1, 0xC0, 0xC3, 0x80, 0xC3, 0x00, 0xC6, 0x00,
  0xCE, 0x00, 0xDF, 0x00, 0xF3, 0x00, 0xE1, 0x80, 0xE1, 0xC0, 0xC0, 0xC0,
  0xC0, 0xE0, 0xC0, 0x70, 0xC0, 0x30, 0xC0, 0x38, 0xC0, 0x1C, 0xC0, 0x0C,
  0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0xC0, 0x00,
  0xFD, 0x80, 0x03, 0x79, 0x80, 0x06, 0xF3, 0x00, 0x0D, 0xE6, 0x00, 0x33,
  0xC6, 0x00, 0x67, 0x8C, 0x00, 0xCF, 0x18, 0x03, 0x1E, 0x18, 0x06, 0x3C,
  0x30, 0x0C, 0x78, 0x60, 0x30, 0xF0, 0x60, 0x61, 0xE0, 0xC0, 0xC3, 0xC1,
  0xC3, 0x07, 0x81, 0x86, 0x0F, 0x03, 0x18, 0x1E, 0x03, 0x30, 0x3C, 0x06,
  0x60, 0x78, 0x0D, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x38,
  0x07, 0x80, 0x30, 0x0C, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x60,
  0x03, 0xDC, 0x00, 0xF3, 0x00, 0x3C, 0xE0, 0x0F, 0x18, 0x03, 0xC3, 0x00,
  0xF0, 0xC0, 0x3C, 0x18, 0x0F, 0x07, 0x03, 0xC0, 0xC0, 0xF0, 0x38, 0x3C,
  0x06, 0x0F, 0x00, 0xC3, 0xC0, 0x38, 0xF0, 0x06, 0x3C, 0x01, 0xCF, 0x00,
  0x33, 0xC0, 0x0E, 0xF0, 0x01, 0xBC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x70, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xC1, 0xE0, 0x38,
  0x03, 0x83, 0x80, 0x0E, 0x18, 0x00, 0x31, 0xC0, 0x01, 0xCC, 0x00, 0x06,
  0x60, 0x00, 0x37, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xD8, 0x00, 0x0E, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x18, 0x00,
  0x38, 0xE0, 0x01, 0x83, 0x00, 0x1C, 0x1E, 0x01, 0xC0, 0x3F, 0xFC, 0x00,
  0xFF, 0x80, 0xFF, 0xE1, 0x87, 0xF3, 0x00, 0x76, 0x00, 0x6C, 0x00, 0xD8,
  0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x36, 0x00,
  0xEC, 0x03, 0x9F, 0xFE, 0x3F, 0xF0, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xC1, 0xE0, 0x38,
  0x03, 0x83, 0x80, 0x0E, 0x18, 0x00, 0x31, 0xC0, 0x01, 0xCC, 0x00, 0x06,
  0x60, 0x00, 0x37, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xD8, 0x00, 0x0E, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x18, 0x00,
  0x38, 0xE0, 0x01, 0x83, 0x00, 0x1C, 0x1E, 0x01, 0xC0, 0x3F, 0xFC, 0x00,
  0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xE0, 0xFF, 0xE0, 0xC3, 0xF8, 0xC0, 0x1C,
  0xC0, 0x0C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0E,
  0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0,
  0xC0, 0xC0, 0xC0, 0x60, 0xC0, 0x70, 0xC0, 0x30, 0xC0, 0x38, 0xC0, 0x18,
  0xC0, 0x1C, 0xC0, 0x0C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x07, 0x07, 0xC0,
  0x3F, 0xF8, 0xF0, 0x73, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x80, 0x39, 0xFF, 0xE3, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x06, 0xE0, 0x01, 0x98, 0x00, 0x67, 0x00,
  0x30, 0xE0, 0x1C, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0xC0, 0x00, 0x6C, 0x00,
  0x19, 0x80, 0x03, 0x30, 0x00, 0x63, 0x00, 0x1C, 0x60, 0x03, 0x0C, 0x00,
  0x60, 0xC0, 0x1C, 0x18, 0x03, 0x03, 0x00, 0x60, 0x70, 0x1C, 0x06, 0x03,
  0x00, 0xC0, 0x60, 0x1C, 0x1C, 0x01, 0x83, 0x00, 0x30, 0x60, 0x07, 0x0C,
  0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x1B, 0x00, 0x03, 0x60,
  0x00, 0x6C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xC0, 0x06,
  0x00, 0x3E, 0x00, 0x38, 0x01, 0xB0, 0x03, 0xC0, 0x0C, 0xC0, 0x1E, 0x00,
  0x66, 0x00, 0xF0, 0x07, 0x30, 0x06, 0xC0, 0x31, 0x80, 0x66, 0x01, 0x86,
  0x03, 0x30, 0x0C, 0x30, 0x19, 0x80, 0xE1, 0x80, 0xC6, 0x06, 0x0C, 0x0C,
  0x30, 0x30, 0x30, 0x61, 0x81, 0x81, 0x83, 0x0C, 0x1C, 0x0C, 0x18, 0x30,
  0xC0, 0x61, 0x81, 0x86, 0x01, 0x8C, 0x0C, 0x30, 0x0C, 0x60, 0x63, 0x80,
  0x63, 0x01, 0x98, 0x03, 0x30, 0x0C, 0xC0, 0x0D, 0x80, 0x66, 0x00, 0x6C,
  0x01, 0x70, 0x03, 0x60, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x70, 0x03,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x70, 0x03, 0x8C,
  0x00, 0xC3, 0x80, 0x70, 0x60, 0x18, 0x0C, 0x0E, 0x03, 0x03, 0x00, 0x61,
  0x80, 0x18, 0x60, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xC0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0C, 0xC0, 0x07, 0x38, 0x01,
  0x86, 0x00, 0xC1, 0xC0, 0x30, 0x30, 0x18, 0x0E, 0x06, 0x01, 0x83, 0x00,
  0x71, 0xC0, 0x0C, 0x60, 0x01, 0xB8, 0x00, 0x70, 0xE0, 0x01, 0xB0, 0x01,
  0x9C, 0x00, 0xC6, 0x00, 0xE3, 0x80, 0x60, 0xC0, 0x70, 0x60, 0x30, 0x18,
  0x38, 0x0C, 0x18, 0x03, 0x0C, 0x01, 0x8C, 0x00, 0x66, 0x00, 0x36, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60,
  0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30,
  0x06, 0x00, 0x60, 0x0C, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF,
  0x00, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x31,
  0x80, 0x18, 0xC0, 0x18, 0x30, 0x0C, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x06,
  0x00, 0xC3, 0x00, 0x63, 0x00, 0x19, 0x80, 0x0D, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0xE0, 0x60, 0xE0, 0xE0, 0xC0, 0x40, 0x0F, 0xC3, 0xFF, 0x88,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0xFF,
  0xCF, 0x06, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3F,
  0x03, 0xDE, 0xF6, 0x7F, 0x30, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC7, 0xE1, 0x9F, 0xE3,
  0x60, 0xE7, 0x80, 0xEE, 0x00, 0xDC, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xF0, 0x06, 0xE0, 0x0D, 0xE0, 0x33, 0x7B, 0xE6, 0x7F, 0x00, 0x07, 0xF8,
  0xFF, 0x8E, 0x04, 0x60, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x07, 0xC6,
  0x3F, 0xEC, 0xE0, 0xDB, 0x80, 0x76, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF8, 0x01, 0xB0, 0x07, 0x60, 0x0E, 0x60, 0x3C, 0xF9, 0xD8, 0x7F, 0x30,
  0x07, 0xC0, 0x7F, 0xC3, 0x83, 0x9C, 0x06, 0x60, 0x0D, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x11, 0xF7, 0xC3, 0xFE, 0x03,
  0xF0, 0x7F, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x3F,
  0xCF, 0xFC, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xC6, 0x3F, 0xEC, 0xE0, 0xDB, 0x80,
  0x76, 0x00, 0xFC, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xB0, 0x07, 0x60,
  0x0E, 0x60, 0x3C, 0xFB, 0xD8, 0x7F, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x19, 0x80, 0xE3, 0xFF, 0x80, 0xFC, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC7, 0xE3, 0x3F, 0xCD, 0x83, 0xBC, 0x06, 0xE0, 0x0F, 0x80,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0C, 0x30, 0xC0, 0x00,
  0x00, 0x03, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x7F, 0xBC, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x3E, 0x03, 0xB0, 0x19, 0x81, 0x8C, 0x18, 0x61, 0xC3, 0x1C, 0x18,
  0xC0, 0xCC, 0x06, 0xF0, 0x3D, 0x81, 0xC6, 0x0C, 0x38, 0x60, 0xC3, 0x03,
  0x18, 0x1C, 0xC0, 0x66, 0x03, 0xB0, 0x0D, 0x80, 0x30, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xC0, 0xF8, 0xDF, 0xE3, 0xFC, 0xD0, 0x76,
  0x0E, 0xE0, 0x34, 0x06, 0xE0, 0x1C, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18,
  0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18,
  0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18,
  0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18,
  0x03, 0xC0, 0x18, 0x03, 0xC7, 0xE3, 0x3F, 0xCD, 0x83, 0xBC, 0x06, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x07, 0xE0, 0x1F, 0xF8, 0x38, 0x1C, 0x70, 0x0C, 0x60,
  0x0E, 0x60, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x06, 0x60, 0x06, 0x60, 0x06, 0x70,
  0x0C, 0x38, 0x1C, 0x1E, 0xF8, 0x0F, 0xE0, 0xC7, 0xE1, 0x9F, 0xE3, 0x60,
  0xE7, 0x80, 0xEE, 0x00, 0xDC, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x03, 0xF0,
  0x06, 0xE0, 0x0D, 0xA0, 0x33, 0x7B, 0xE6, 0x7F, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x00, 0x0F, 0xC6, 0x3F, 0xEC, 0xE0, 0xDB, 0x80, 0xF6, 0x00, 0xFC,
  0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xB0, 0x07, 0x60, 0x0E, 0x60, 0x2C,
  0xFB, 0xD8, 0x7E, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0xC7, 0xF3, 0xED,
  0x83, 0xC0, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x1F, 0xC7,
  0xFF, 0xE0, 0x2C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x38,
  0x06, 0xFB, 0xEF, 0xF8, 0x10, 0x18, 0x0C, 0x06, 0x07, 0xFF, 0xFC, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0xC0, 0x72, 0x1F, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0,
  0x3D, 0x80, 0xB7, 0xDE, 0xCF, 0xE3, 0xC0, 0x07, 0xC0, 0x0D, 0x80, 0x1B,
  0x00, 0x67, 0x00, 0xC6, 0x01, 0x8C, 0x06, 0x1C, 0x0C, 0x18, 0x18, 0x30,
  0x60, 0x70, 0xC0, 0x61, 0x80, 0xC6, 0x01, 0x8C, 0x01, 0x98, 0x03, 0x60,
  0x06, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x1C, 0x03, 0x60,
  0x1C, 0x03, 0x60, 0x1C, 0x03, 0x60, 0x16, 0x03, 0x30, 0x36, 0x06, 0x30,
  0x36, 0x06, 0x30, 0x36, 0x06, 0x30, 0x63, 0x06, 0x18, 0x63, 0x0C, 0x18,
  0x63, 0x0C, 0x18, 0x61, 0x0C, 0x18, 0xC1, 0x8C, 0x0C, 0xC1, 0x98, 0x0C,
  0xC1, 0x98, 0x0D, 0x80, 0xD8, 0x0D, 0x80, 0xD8, 0x07, 0x80, 0xF0, 0x07,
  0x80, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0xE0, 0x0C, 0xC0, 0x39,
  0xC0, 0x61, 0x81, 0x81, 0x83, 0x03, 0x8C, 0x03, 0x38, 0x03, 0x60, 0x07,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0xEC, 0x01, 0x9C, 0x06, 0x18,
  0x0C, 0x18, 0x30, 0x38, 0xE0, 0x31, 0x80, 0x76, 0x00, 0x70, 0xC0, 0x07,
  0x60, 0x06, 0x60, 0x06, 0x60, 0x0E, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x1C,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x70,
  0x06, 0x60, 0x06, 0x60, 0x06, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x7F, 0xF7, 0xFF, 0x00,
  0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06,
  0x00, 0xE0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x70, 0x06, 0x00, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0xF8, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x0E, 0x07, 0x80,
  0xF8, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x0F, 0x80, 0x30,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x00, 0xE0, 0x0F, 0x03, 0xE0, 0xE0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0,
  0x38, 0x3E, 0x07, 0x00, 0x7E, 0x03, 0xFF, 0x06, 0x07, 0xFC, 0x03, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Light37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 26, 9, 3, -26 },
  { 11, 9, 9, 13, 2, -26 },
  { 22, 19, 26, 21, 1, -26 },
  { 84, 15, 30, 19, 2, -28 },
  { 141, 24, 27, 27, 2, -27 },
  { 222, 20, 27, 23, 2, -27 },
  { 290, 3, 9, 7, 2, -26 },
  { 294, 7, 32, 10, 2, -26 },
  { 322, 8, 32, 10, 1, -26 },
  { 354, 14, 14, 18, 2, -28 },
  { 379, 15, 18, 19, 2, -22 },
  { 413, 5, 9, 8, 1, -4 },
  { 419, 9, 2, 11, 1, -11 },
  { 422, 3, 3, 8, 3, -3 },
  { 424, 11, 26, 13, 1, -26 },
  { 460, 15, 27, 19, 2, -27 },
  { 511, 9, 26, 19, 3, -26 },
  { 541, 15, 27, 19, 2, -27 },
  { 592, 15, 27, 19, 2, -27 },
  { 643, 17, 27, 19, 1, -27 },
  { 701, 15, 26, 19, 2, -26 },
  { 750, 15, 27, 19, 2, -27 },
  { 801, 15, 26, 19, 2, -26 },
  { 850, 15, 27, 19, 2, -27 },
  { 901, 15, 27, 19, 2, -27 },
  { 952, 3, 20, 8, 3, -20 },
  { 960, 5, 25, 8, 1, -20 },
  { 976, 15, 17, 19, 2, -22 },
  { 1008, 15, 10, 19, 2, -18 },
  { 1027, 15, 17, 19, 2, -22 },
  { 1059, 12, 27, 14, 1, -27 },
  { 1100, 25, 29, 29, 2, -26 },
  { 1191, 20, 26, 20, 0, -26 },
  { 1256, 16, 26, 21, 3, -26 },
  { 1308, 17, 27, 20, 2, -27 },
  { 1366, 18, 26, 23, 3, -26 },
  { 1425, 13, 26, 18, 3, -26 },
  { 1468, 13, 26, 17, 3, -26 },
  { 1511, 20, 27, 24, 2, -27 },
  { 1579, 18, 26, 24, 3, -26 },
  { 1638, 7, 26, 11, 2, -26 },
  { 1661, 8, 33, 9, -3, -26 },
  { 1694, 16, 26, 19, 3, -26 },
  { 1746, 13, 26, 17, 3, -26 },
  { 1789, 23, 26, 30, 3, -26 },
  { 1864, 18, 26, 24, 3, -26 },
  { 1923, 21, 27, 25, 2, -27 },
  { 1994, 15, 26, 20, 3, -26 },
  { 2043, 21, 33, 25, 2, -27 },
  { 2130, 16, 26, 20, 3, -26 },
  { 2182, 15, 27, 18, 2, -27 },
  { 2233, 17, 26, 17, 0, -26 },
  { 2289, 18, 26, 24, 3, -26 },
  { 2348, 19, 26, 19, 0, -26 },
  { 2410, 29, 26, 30, 1, -26 },
  { 2505, 18, 26, 18, 0, -26 },
  { 2564, 17, 26, 17, 0, -26 },
  { 2620, 16, 26, 18, 1, -26 },
  { 2672, 8, 32, 12, 3, -26 },
  { 2704, 11, 26, 13, 1, -26 },
  { 2740, 8, 32, 12, 1, -26 },
  { 2772, 17, 16, 19, 1, -27 },
  { 2806, 15, 2, 15, 0, 3 },
  { 2810, 7, 6, 10, 1, -28 },
  { 2816, 13, 20, 18, 2, -20 },
  { 2849, 15, 28, 20, 3, -28 },
  { 2902, 13, 20, 16, 2, -20 },
  { 2935, 15, 28, 20, 2, -28 },
  { 2988, 14, 20, 18, 2, -20 },
  { 3023, 12, 28, 10, 0, -28 },
  { 3065, 15, 29, 20, 2, -20 },
  { 3120, 14, 28, 20, 3, -28 },
  { 3169, 2, 27, 8, 3, -27 },
  { 3176, 6, 36, 8, -1, -27 },
  { 3203, 13, 28, 16, 3, -28 },
  { 3249, 2, 28, 8, 3, -28 },
  { 3256, 24, 20, 30, 3, -20 },
  { 3316, 14, 20, 20, 3, -20 },
  { 3351, 16, 20, 20, 2, -20 },
  { 3391, 15, 29, 20, 3, -20 },
  { 3446, 15, 29, 20, 2, -20 },
  { 3501, 10, 20, 13, 3, -20 },
  { 3526, 12, 20, 15, 2, -20 },
  { 3556, 9, 24, 11, 1, -24 },
  { 3583, 14, 20, 20, 3, -20 },
  { 3618, 15, 20, 16, 0, -20 },
  { 3656, 24, 20, 25, 0, -20 },
  { 3716, 15, 20, 16, 1, -20 },
  { 3754, 16, 29, 16, 0, -20 },
  { 3812, 12, 20, 15, 1, -20 },
  { 3842, 11, 32, 13, 1, -26 },
  { 3886, 2, 37, 18, 8, -28 },
  { 3896, 11, 32, 13, 1, -26 },
  { 3940, 15, 4, 19, 2, -15 },
};

const GFXfont NotoSans_SemiCondensed_Light37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light37pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT37PT7B_H_
