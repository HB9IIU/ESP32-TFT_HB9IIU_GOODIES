#ifndef _NOTOSANS_SEMICONDENSED_LIGHT63PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light63pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xBD, 0xEF, 0x7B, 0xDE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x70, 0x00, 0x00,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0x90, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xDC, 0x07, 0x70, 0x1D, 0xC0, 0x77,
  0x01, 0xDC, 0x07, 0x70, 0x1D, 0xC0, 0x76, 0x01, 0x98, 0x06, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x0C,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70,
  0x03, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x18, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x1F, 0x1C, 0x1E, 0x1E, 0x0E, 0x01, 0x1E,
  0x07, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x07, 0x80, 0xE0, 0x03,
  0xC0, 0x70, 0x01, 0xE0, 0x38, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x0E, 0x00,
  0x1E, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x03, 0xC1, 0xC0, 0x00, 0xF8, 0xE0,
  0x00, 0x3F, 0x70, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xC7, 0xE0, 0x00,
  0xE1, 0xF8, 0x00, 0x70, 0x3C, 0x00, 0x38, 0x0F, 0x00, 0x1C, 0x07, 0x80,
  0x0E, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x38,
  0x00, 0xE0, 0x1C, 0x00, 0x70, 0x1E, 0x00, 0x38, 0x0F, 0x80, 0x1C, 0x0F,
  0x70, 0x0E, 0x1F, 0x3F, 0xC7, 0x7F, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xC0, 0x07, 0xFE, 0x00,
  0x01, 0xC0, 0x07, 0x87, 0x80, 0x01, 0xC0, 0x03, 0x81, 0xE0, 0x00, 0xE0,
  0x03, 0xC0, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x0E, 0x00, 0x78, 0x00, 0x70, 0x07, 0x00, 0x38, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x1E, 0x00,
  0x0E, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x0F, 0x00, 0x03, 0x80,
  0x1C, 0x07, 0x00, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x03,
  0x80, 0x00, 0x70, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x01, 0xC1, 0xC0, 0x30,
  0x1E, 0x00, 0xE0, 0xE0, 0xFE, 0x07, 0x00, 0x70, 0xE1, 0xFF, 0x83, 0x80,
  0x38, 0x70, 0xF1, 0xE1, 0xC0, 0x38, 0x70, 0xE0, 0x78, 0x70, 0x1C, 0x38,
  0x70, 0x1C, 0x38, 0x1E, 0x38, 0x70, 0x0F, 0x0F, 0x1E, 0x1C, 0x38, 0x03,
  0x87, 0xFE, 0x1E, 0x1C, 0x01, 0xC1, 0xFE, 0x0E, 0x0E, 0x00, 0xE0, 0x18,
  0x0F, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x07, 0x00, 0x38, 0x00, 0x07, 0x83,
  0x80, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x0F, 0x00, 0x03, 0xC0, 0xE0, 0x07,
  0x80, 0x01, 0xC0, 0x70, 0x03, 0xC0, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x00,
  0xE0, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x0F, 0x00, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x07, 0x80, 0x0E, 0x00, 0x03, 0xC7, 0x80, 0x07, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x0E, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xCF, 0x00,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x0F, 0x00, 0x1E, 0x1E, 0x00,
  0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x00, 0x70, 0xF0, 0x01, 0xF0, 0x1E, 0x1C,
  0x00, 0x1F, 0x03, 0xC7, 0x80, 0x01, 0xE0, 0x70, 0xF0, 0x00, 0x1E, 0x1E,
  0x1E, 0x00, 0x01, 0xE3, 0x83, 0xC0, 0x00, 0x1E, 0xF0, 0x78, 0x00, 0x03,
  0xFC, 0x0F, 0x00, 0x00, 0x3F, 0x81, 0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1F, 0xC0, 0x78, 0x00, 0x07, 0xBC, 0x07,
  0x80, 0x03, 0xE3, 0xC0, 0xFC, 0x01, 0xF8, 0x7C, 0x0F, 0xFF, 0xFE, 0x07,
  0xC0, 0x7F, 0xFF, 0x00, 0x7C, 0x07, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0x77, 0x77, 0x77, 0x66, 0x00, 0xF0,
  0x0E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01,
  0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x78, 0x07, 0x80, 0x78, 0x03,
  0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x3C,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x60, 0x18, 0x07, 0xFC, 0x18, 0x3F, 0xFF, 0xD9, 0xFF,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0xE7, 0x80, 0x01, 0xC3, 0x80, 0x03, 0xC1, 0xC0,
  0x07, 0x81, 0xE0, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF8, 0x1E, 0x00, 0x70,
  0x02, 0x00, 0x40, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C,
  0x3C, 0x3C, 0x38, 0x38, 0x78, 0x70, 0x70, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x27, 0xBF, 0xFF, 0xF9, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x01,
  0xE0, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0x9E, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x70, 0x00,
  0x03, 0x9E, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x38,
  0x00, 0x07, 0x8F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x38,
  0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x7C, 0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFB, 0xC3, 0xE7,
  0x9F, 0x0F, 0x7C, 0x1F, 0xF0, 0x3C, 0xC0, 0x79, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x7E, 0x00, 0xFC, 0x1E, 0x00, 0x0F, 0x03, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x07, 0xFE, 0xFF, 0x0F, 0xC0, 0x07, 0xC7, 0x80, 0x01,
  0xF1, 0x80, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x40, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x1F, 0xF9, 0xFF, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xD0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x0F,
  0x00, 0x01, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x38, 0x03, 0xC0,
  0x01, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0xF0, 0x07, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x3C, 0x07, 0x00, 0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1D, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x01, 0xC0, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x80, 0x00, 0x7C, 0x78, 0x00, 0xFC, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x0F, 0xE0, 0x1C, 0x1F, 0xFC,
  0x0E, 0x3F, 0xFF, 0x87, 0x3E, 0x07, 0xE3, 0xBC, 0x00, 0xF9, 0xD8, 0x00,
  0x3C, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x39, 0xE0, 0x00, 0x1C,
  0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x1F, 0x03, 0xE0, 0x1F,
  0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x70,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xCF, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0x80, 0x07, 0xC3,
  0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x9E, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x8E, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x03,
  0xC0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xE3,
  0xF0, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x03, 0xE0, 0x78, 0x00, 0x7C, 0x3C,
  0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x1E, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC1, 0xF0, 0x03, 0xE0,
  0x3F, 0xC7, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x03, 0xC0, 0x01, 0xE1,
  0xE0, 0x00, 0x38, 0x78, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xCF, 0x00, 0x00,
  0x73, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x70, 0x00, 0x07, 0xDE, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0xFC, 0xF0, 0x00, 0x7F, 0x3E, 0x00, 0x3B, 0xC7, 0xE0,
  0x7C, 0xE0, 0xFF, 0xFE, 0x38, 0x0F, 0xFF, 0x0E, 0x00, 0xFE, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0xF9, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x77, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x7B, 0xFF, 0xFF, 0x98, 0x0E, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x70, 0x70,
  0x70, 0xE0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0x00, 0x3E, 0x20,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xC1, 0xC0, 0x01, 0xFF, 0xC0, 0x1C, 0x3C, 0x00, 0x7F, 0xFE, 0x01,
  0xE3, 0x80, 0x0F, 0x83, 0xE0, 0x0E, 0x38, 0x01, 0xE0, 0x0E, 0x00, 0xE7,
  0x80, 0x3C, 0x00, 0xE0, 0x0E, 0x70, 0x03, 0x80, 0x0E, 0x00, 0xE7, 0x00,
  0x78, 0x00, 0xE0, 0x0E, 0x70, 0x07, 0x00, 0x0E, 0x00, 0xF7, 0x00, 0xF0,
  0x00, 0xE0, 0x07, 0x70, 0x0F, 0x00, 0x0E, 0x00, 0x77, 0x00, 0xE0, 0x01,
  0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xE0, 0x01, 0xE0,
  0x0F, 0xE0, 0x0E, 0x00, 0x1E, 0x00, 0xEE, 0x00, 0xE0, 0x01, 0xC0, 0x0E,
  0xE0, 0x0E, 0x00, 0x1C, 0x00, 0xEF, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x70,
  0x0E, 0x00, 0x3C, 0x00, 0xE7, 0x00, 0xF0, 0x03, 0xE0, 0x1C, 0x70, 0x07,
  0x00, 0x3E, 0x01, 0xC7, 0x00, 0x78, 0x07, 0x60, 0x38, 0x70, 0x03, 0xC0,
  0xE7, 0x07, 0x87, 0x80, 0x3F, 0xFC, 0x7F, 0xF0, 0x38, 0x01, 0xFF, 0x83,
  0xFE, 0x03, 0x80, 0x07, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x07, 0xF0, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x0F,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00,
  0x07, 0x1E, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x00, 0x0E, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x70, 0x01, 0xFF, 0x0E, 0x00, 0x03, 0xF1,
  0xC0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0xE7, 0x00, 0x00, 0x3C, 0xE0, 0x00,
  0x07, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x03, 0xE3, 0x80, 0x00, 0xF8, 0x70,
  0x00, 0xFE, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x07, 0x00, 0x07, 0xF0, 0xE0, 0x00, 0x1F, 0x1C, 0x00, 0x01, 0xF3, 0x80,
  0x00, 0x1E, 0x70, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0x70, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x7C, 0xE0, 0x00,
  0x1F, 0x1C, 0x00, 0x1F, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xB8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x07, 0x01, 0xF0, 0x00,
  0x08, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x1C, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x38, 0x00, 0xFF, 0x80, 0xE0, 0x00, 0x7F,
  0x03, 0x80, 0x00, 0x7E, 0x0E, 0x00, 0x00, 0x7C, 0x38, 0x00, 0x00, 0xF8,
  0xE0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x07, 0xCE, 0x00, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0x3E, 0xE0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x07, 0xB8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x07, 0xB8, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x03,
  0xE3, 0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x7C, 0x38, 0x00, 0x07, 0xE0,
  0xE0, 0x00, 0x7F, 0x03, 0x80, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xB8, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x01, 0xF0,
  0x1F, 0x80, 0x00, 0x30, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0x07, 0x81, 0xF8, 0x00, 0x03, 0xC0, 0x7F, 0x00, 0x07,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0x7F, 0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x3F, 0xEF, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x80, 0xFB, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0x08,
  0x00, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x3E, 0x70,
  0x00, 0x0F, 0x8E, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x1E,
  0x07, 0x00, 0x07, 0x80, 0xE0, 0x01, 0xF0, 0x1C, 0x00, 0x3C, 0x03, 0x80,
  0x0F, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0xF0, 0x01, 0xC0, 0x3E, 0x00,
  0x38, 0x0F, 0x80, 0x07, 0x01, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x1C, 0x1E,
  0x00, 0x03, 0x87, 0x80, 0x00, 0x71, 0xF0, 0x00, 0x0E, 0x3E, 0x00, 0x01,
  0xCF, 0xE0, 0x00, 0x3B, 0xFE, 0x00, 0x07, 0xF3, 0xC0, 0x00, 0xFC, 0x3C,
  0x00, 0x1F, 0x07, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x70, 0x07, 0x80, 0x0E,
  0x00, 0xF8, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xF0, 0x07, 0x00, 0x1E,
  0x00, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x3E, 0x03, 0x80, 0x03, 0xC0, 0x70,
  0x00, 0x3C, 0x0E, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x07,
  0x87, 0x00, 0x00, 0xF8, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x1E, 0x70, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0xFD, 0xC0, 0x00, 0x00,
  0x1D, 0xFB, 0x80, 0x00, 0x00, 0x7F, 0xF7, 0x80, 0x00, 0x00, 0xEF, 0xE7,
  0x00, 0x00, 0x01, 0xDF, 0xCE, 0x00, 0x00, 0x07, 0xBF, 0x9E, 0x00, 0x00,
  0x0E, 0x7F, 0x1C, 0x00, 0x00, 0x3C, 0xFE, 0x3C, 0x00, 0x00, 0x71, 0xFC,
  0x78, 0x00, 0x00, 0xE3, 0xF8, 0x70, 0x00, 0x03, 0xC7, 0xF0, 0xF0, 0x00,
  0x07, 0x0F, 0xE1, 0xE0, 0x00, 0x0E, 0x1F, 0xC1, 0xC0, 0x00, 0x3C, 0x3F,
  0x83, 0xC0, 0x00, 0x70, 0x7F, 0x03, 0x80, 0x00, 0xE0, 0xFE, 0x07, 0x00,
  0x03, 0xC1, 0xFC, 0x0F, 0x00, 0x07, 0x03, 0xF8, 0x0E, 0x00, 0x0E, 0x07,
  0xF0, 0x1C, 0x00, 0x3C, 0x0F, 0xE0, 0x3C, 0x00, 0x70, 0x1F, 0xC0, 0x38,
  0x01, 0xE0, 0x3F, 0x80, 0x78, 0x03, 0x80, 0x7F, 0x00, 0xF0, 0x07, 0x00,
  0xFE, 0x00, 0xE0, 0x1E, 0x01, 0xFC, 0x01, 0xE0, 0x38, 0x03, 0xF8, 0x03,
  0xC0, 0x70, 0x07, 0xF0, 0x03, 0x81, 0xE0, 0x0F, 0xE0, 0x07, 0x83, 0x80,
  0x1F, 0xC0, 0x07, 0x07, 0x00, 0x3F, 0x80, 0x0E, 0x1E, 0x00, 0x7F, 0x00,
  0x1E, 0x38, 0x00, 0xFE, 0x00, 0x1C, 0xF0, 0x01, 0xFC, 0x00, 0x39, 0xC0,
  0x03, 0xF8, 0x00, 0x7B, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFE, 0xF0,
  0x00, 0x03, 0xFB, 0xC0, 0x00, 0x0F, 0xE7, 0x80, 0x00, 0x3F, 0x9E, 0x00,
  0x00, 0xFE, 0x3C, 0x00, 0x03, 0xF8, 0xF0, 0x00, 0x0F, 0xE1, 0xE0, 0x00,
  0x3F, 0x83, 0xC0, 0x00, 0xFE, 0x0F, 0x00, 0x03, 0xF8, 0x1E, 0x00, 0x0F,
  0xE0, 0x78, 0x00, 0x3F, 0x80, 0xF0, 0x00, 0xFE, 0x03, 0xC0, 0x03, 0xF8,
  0x07, 0x80, 0x0F, 0xE0, 0x0F, 0x00, 0x3F, 0x80, 0x3C, 0x00, 0xFE, 0x00,
  0x78, 0x03, 0xF8, 0x01, 0xE0, 0x0F, 0xE0, 0x03, 0xC0, 0x3F, 0x80, 0x0F,
  0x80, 0xFE, 0x00, 0x1E, 0x03, 0xF8, 0x00, 0x3C, 0x0F, 0xE0, 0x00, 0xF0,
  0x3F, 0x80, 0x01, 0xE0, 0xFE, 0x00, 0x07, 0x83, 0xF8, 0x00, 0x0F, 0x0F,
  0xE0, 0x00, 0x1E, 0x3F, 0x80, 0x00, 0x78, 0xFE, 0x00, 0x00, 0xF3, 0xF8,
  0x00, 0x03, 0xCF, 0xE0, 0x00, 0x07, 0xBF, 0x80, 0x00, 0x1E, 0x7E, 0x00,
  0x00, 0x3D, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x07, 0x9C, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0xE0, 0x07, 0xF8, 0xE0, 0x00, 0xFC, 0xE0, 0x00, 0x3E, 0xE0, 0x00, 0x1E,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x3E, 0xE0, 0x00, 0x7C, 0xE0, 0x01, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x78,
  0x7C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x70, 0x03, 0xFC, 0x0E, 0x00, 0x0F, 0xC1, 0xC0, 0x00, 0x7C,
  0x38, 0x00, 0x07, 0x87, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x0F, 0x1C, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x0F, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x78, 0x70, 0x00, 0x1E, 0x0E,
  0x00, 0x07, 0xC1, 0xC0, 0x03, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x3C, 0x01, 0xC0, 0x07, 0x80, 0x38, 0x00, 0x78,
  0x07, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x03, 0x80,
  0x01, 0xE0, 0x70, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x3C,
  0x38, 0x00, 0x07, 0x87, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x0F, 0x1C, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3E,
  0x00, 0x07, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE1, 0xF8, 0x00, 0xF1, 0xF0, 0x00, 0x10, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x40, 0x00, 0x1F, 0x3C,
  0x00, 0x3F, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00,
  0x01, 0xD0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x0E, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x3F,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x1D, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00,
  0x78, 0x1C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00,
  0x1E, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x07, 0x80, 0x1C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x0E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00,
  0x78, 0x03, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x00, 0x78, 0x38, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x00, 0xE7, 0x80,
  0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x78,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x77, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0x3C,
  0x3C, 0x00, 0x07, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xCE, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0xF3, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x38, 0xE0, 0x00,
  0x78, 0x1E, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0x87, 0x00,
  0x07, 0x00, 0xE0, 0x01, 0xE1, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0x70, 0x70,
  0x00, 0xF0, 0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0,
  0x3C, 0x01, 0xE0, 0x07, 0x80, 0x38, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0E,
  0x01, 0xC0, 0x1C, 0x00, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x0E, 0x01,
  0xC0, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x70, 0x07, 0x80, 0xF0, 0x00, 0xF0,
  0x3C, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x0F, 0x00, 0x38, 0x1E, 0x00, 0x07,
  0x03, 0x80, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xE0, 0x03, 0xC1, 0xE0, 0x00,
  0x78, 0x78, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x1E, 0x00, 0x1C, 0x3C, 0x00,
  0x03, 0x87, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1, 0xC0, 0x01, 0xE3, 0xC0,
  0x00, 0x3C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x3C, 0x00, 0x0E, 0x78,
  0x00, 0x01, 0xCE, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x73, 0x80, 0x00, 0xF7,
  0x80, 0x00, 0x1E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0x70, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x38, 0x0F, 0x00, 0x01, 0xE0, 0x1C,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x38, 0x07, 0x80, 0x01, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x3C,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xF0, 0x0F,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x78, 0x07, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x07, 0x07, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x38, 0xF0, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0x70, 0xF0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x1E, 0x03,
  0x80, 0x01, 0xC0, 0x3C, 0x00, 0x3C, 0x01, 0xC0, 0x03, 0x80, 0x1E, 0x00,
  0x78, 0x00, 0xE0, 0x07, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x70, 0x0E, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1C,
  0x38, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x1F, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xF8, 0x07, 0xC0, 0x80,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0x07, 0xFF, 0xFE,
  0x3F, 0xE0, 0x3C, 0xFC, 0x00, 0x7B, 0xE0, 0x00, 0xF7, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xDF, 0x00, 0x73, 0x9F, 0xC7, 0xC7, 0x1F, 0xFF, 0x0E, 0x1F, 0xF8,
  0x1C, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x03, 0xFC, 0x03, 0xC3, 0xFF, 0xC0, 0xF3, 0xFF, 0xF8, 0x3D,
  0xF0, 0x3F, 0x0E, 0x70, 0x03, 0xE3, 0xB8, 0x00, 0x78, 0xFC, 0x00, 0x0F,
  0x3E, 0x00, 0x01, 0xCF, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x7B, 0xE0,
  0x00, 0x1E, 0xF8, 0x00, 0x07, 0x3E, 0x00, 0x03, 0xCF, 0xC0, 0x01, 0xF3,
  0xB8, 0x00, 0x78, 0xE7, 0x00, 0x7C, 0x38, 0xFD, 0xFE, 0x0E, 0x1F, 0xFF,
  0x03, 0x83, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xF8, 0x0E, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0xC1, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x07, 0xF8, 0x1C, 0x07, 0xFF,
  0x87, 0x07, 0xFF, 0xF1, 0xC3, 0xF0, 0x1E, 0x70, 0xF0, 0x01, 0xDC, 0x78,
  0x00, 0x37, 0x3C, 0x00, 0x0F, 0xCF, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x7D,
  0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x07, 0xCF, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0xFC, 0x78, 0x00, 0x77, 0x0F, 0x80, 0x39, 0xC3,
  0xFC, 0xFC, 0x70, 0x3F, 0xFE, 0x1C, 0x07, 0xFF, 0x07, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xF8,
  0x1F, 0x80, 0xF0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x78,
  0x00, 0x1E, 0x38, 0x00, 0x07, 0x3C, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x08, 0x3F,
  0x00, 0x1C, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xF0,
  0x10, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0x81,
  0xC0, 0x7F, 0xF8, 0x70, 0x7F, 0xFF, 0x1C, 0x3F, 0x01, 0xE7, 0x0F, 0x00,
  0x1D, 0xC7, 0x80, 0x03, 0xF3, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x1F, 0x38,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x0F,
  0x70, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x7C, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x0D, 0xC7, 0x80, 0x07, 0x70, 0xF8,
  0x03, 0x9C, 0x1F, 0xCF, 0xC7, 0x03, 0xFF, 0xE1, 0xC0, 0x7F, 0xF0, 0x70,
  0x03, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x30, 0x00, 0x1F, 0x0F,
  0x80, 0x1F, 0x83, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x3F, 0xC0, 0xF0, 0xFF,
  0xF0, 0xF3, 0xFF, 0xF8, 0xF7, 0xC0, 0xFC, 0xE7, 0x00, 0x3C, 0xEE, 0x00,
  0x1E, 0xFC, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xEF, 0xFF, 0xF6, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xD0, 0xFB, 0xFE, 0x7F, 0x8F, 0xE0,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x78, 0x00, 0x3C, 0xF0, 0x00,
  0xF1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x1E, 0x0F, 0x00, 0x78,
  0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x3C, 0x01,
  0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1C,
  0x7C, 0x00, 0x39, 0xFC, 0x00, 0x77, 0xBC, 0x00, 0xEE, 0x78, 0x01, 0xF8,
  0x78, 0x03, 0xE0, 0x70, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01,
  0xE0, 0x3C, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x03,
  0xC3, 0xC0, 0x07, 0x87, 0x80, 0x07, 0x8F, 0x00, 0x07, 0x9E, 0x00, 0x0F,
  0x3C, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x70,
  0xFF, 0xE0, 0x3F, 0xFC, 0x38, 0xFF, 0xF8, 0x3F, 0xFF, 0x1C, 0xF0, 0x3E,
  0x3C, 0x0F, 0xCE, 0xE0, 0x0F, 0xBC, 0x01, 0xF7, 0x60, 0x03, 0xDC, 0x00,
  0x7B, 0xE0, 0x00, 0xFC, 0x00, 0x3D, 0xF0, 0x00, 0x7C, 0x00, 0x0E, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0xF8, 0x00, 0x0E,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0x00, 0x01, 0xFE, 0x00, 0x03, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x70, 0x00, 0x1F, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0xF8, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0xE0, 0x3F, 0xC0, 0xE0, 0xFF, 0xF0, 0xE3, 0xFF, 0xF8, 0xE7, 0xC0,
  0xFC, 0xE7, 0x00, 0x3E, 0xEE, 0x00, 0x1E, 0xFC, 0x00, 0x1E, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0xF0, 0x01, 0xF0,
  0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1C, 0x38, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x1E,
  0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xDF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x3F, 0xC0, 0x38, 0x3F, 0xFC,
  0x0E, 0x3F, 0xFF, 0x83, 0x9F, 0x03, 0xF0, 0xE7, 0x00, 0x3E, 0x3B, 0x80,
  0x07, 0xCE, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0x1C, 0xF8, 0x00, 0x07, 0xBE,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0E,
  0xF0, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x73, 0xF0, 0x00,
  0x3C, 0xEC, 0x00, 0x1F, 0x3B, 0x80, 0x0F, 0x8F, 0x78, 0x07, 0xC3, 0xCF,
  0xFF, 0xE0, 0xF1, 0xFF, 0xF0, 0x3C, 0x3F, 0xF8, 0x0F, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x81, 0xC0, 0x7F, 0xF8, 0x70, 0x7F, 0xFF, 0x1C, 0x3F, 0x01, 0xE7, 0x1F,
  0x00, 0x1D, 0xC7, 0x80, 0x03, 0x73, 0xC0, 0x00, 0xFC, 0xF0, 0x00, 0x1F,
  0x78, 0x00, 0x07, 0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xC0, 0x00,
  0x0F, 0x70, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x7C, 0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x0D, 0xC7, 0x80, 0x07, 0x70,
  0xF8, 0x03, 0x9C, 0x3F, 0xCF, 0xC7, 0x03, 0xFF, 0xE1, 0xC0, 0x7F, 0xF0,
  0x70, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0xE0, 0x7F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC3, 0xE7, 0x00,
  0xEE, 0x00, 0xEC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xFC, 0x7C, 0x03, 0xC7, 0x80, 0x02, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x40, 0x00, 0x7B, 0x80, 0x0F, 0x9F, 0xE7, 0xF8, 0xFF, 0xFF,
  0x81, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1F, 0xFE, 0xFF,
  0xFF, 0x7F, 0xFF, 0x83, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0xCE, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x0C, 0x00,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0x78, 0x00, 0x3F, 0x78, 0x00, 0x7F, 0x7C, 0x01, 0xE7, 0x3F, 0xDF, 0xC7,
  0x1F, 0xFF, 0x87, 0x07, 0xFE, 0x07, 0x00, 0x60, 0x00, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0E, 0x78, 0x00,
  0x07, 0x8E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x3C, 0x1C,
  0x00, 0x0F, 0x07, 0x80, 0x03, 0x81, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0x78,
  0x0F, 0x00, 0x1C, 0x03, 0xC0, 0x0F, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x80, 0x78, 0x00, 0xE0, 0x1E, 0x00, 0x3C, 0x07, 0x00, 0x0F,
  0x03, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0x78, 0x38, 0x00, 0x1E, 0x1E, 0x00,
  0x03, 0x87, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x3C, 0x70, 0x00, 0x07, 0x3C,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xBC, 0x00,
  0x0F, 0x80, 0x03, 0xCE, 0x00, 0x07, 0xC0, 0x01, 0xE7, 0x00, 0x07, 0xE0,
  0x00, 0xF3, 0xC0, 0x03, 0xB8, 0x00, 0x71, 0xE0, 0x01, 0xDC, 0x00, 0x78,
  0x70, 0x01, 0xEE, 0x00, 0x3C, 0x38, 0x00, 0xE7, 0x00, 0x1E, 0x1E, 0x00,
  0x73, 0xC0, 0x0E, 0x0F, 0x00, 0x38, 0xE0, 0x07, 0x03, 0x80, 0x3C, 0x70,
  0x07, 0x81, 0xC0, 0x1C, 0x3C, 0x03, 0x80, 0xF0, 0x0E, 0x0E, 0x01, 0xC0,
  0x78, 0x0F, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x83, 0x80, 0xF0, 0x0E, 0x03,
  0x81, 0xE0, 0x70, 0x07, 0x81, 0xC0, 0x70, 0x38, 0x03, 0xC1, 0xE0, 0x38,
  0x1C, 0x00, 0xE0, 0xE0, 0x1C, 0x1E, 0x00, 0x70, 0x70, 0x0F, 0x0E, 0x00,
  0x3C, 0x78, 0x03, 0x87, 0x00, 0x1E, 0x3C, 0x01, 0xC3, 0x80, 0x07, 0x1C,
  0x00, 0xF3, 0xC0, 0x03, 0x8E, 0x00, 0x39, 0xC0, 0x01, 0xEF, 0x00, 0x1C,
  0xE0, 0x00, 0x77, 0x00, 0x0E, 0x70, 0x00, 0x3B, 0x80, 0x07, 0xF8, 0x00,
  0x1D, 0xC0, 0x01, 0xF8, 0x00, 0x0E, 0xE0, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x9E, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x03,
  0xC0, 0x0F, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0xF0,
  0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0x87, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87,
  0x80, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x1C, 0x00, 0x78, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x00, 0xF0,
  0xF0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x38, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x38, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x38, 0x07,
  0x80, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x0F,
  0x00, 0x3C, 0x01, 0xE0, 0x03, 0x80, 0x38, 0x00, 0x78, 0x0F, 0x00, 0x07,
  0x01, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0x38, 0x38, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E,
  0x38, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x0F, 0xE0, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x1F, 0xC0,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3F, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x05, 0xFF, 0xF0, 0x01, 0xFE, 0xFF, 0x80, 0xFE,
  0x01, 0xFF, 0xFD, 0x00, 0x0F, 0xFF, 0x20, 0x00, 0x3F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Light63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 46, 15, 5, -45 },
  { 30, 14, 16, 22, 4, -45 },
  { 58, 33, 45, 36, 2, -45 },
  { 244, 25, 52, 32, 3, -48 },
  { 407, 41, 47, 47, 3, -46 },
  { 648, 35, 47, 39, 3, -46 },
  { 854, 4, 16, 12, 4, -45 },
  { 862, 12, 55, 17, 3, -45 },
  { 945, 13, 55, 17, 2, -45 },
  { 1035, 24, 24, 30, 3, -48 },
  { 1107, 26, 30, 32, 3, -37 },
  { 1205, 8, 15, 14, 2, -7 },
  { 1220, 15, 4, 19, 2, -19 },
  { 1228, 5, 7, 14, 5, -6 },
  { 1233, 20, 45, 22, 1, -45 },
  { 1346, 26, 47, 32, 3, -46 },
  { 1499, 15, 45, 32, 5, -45 },
  { 1584, 26, 46, 32, 3, -46 },
  { 1734, 25, 47, 32, 3, -46 },
  { 1881, 30, 45, 32, 1, -45 },
  { 2050, 25, 46, 32, 4, -45 },
  { 2194, 25, 47, 32, 4, -46 },
  { 2341, 26, 45, 32, 3, -45 },
  { 2488, 26, 47, 32, 3, -46 },
  { 2641, 26, 47, 32, 3, -46 },
  { 2794, 5, 35, 14, 5, -34 },
  { 2816, 8, 42, 14, 2, -34 },
  { 2858, 27, 29, 32, 3, -37 },
  { 2956, 26, 16, 32, 3, -30 },
  { 3008, 27, 29, 32, 3, -37 },
  { 3106, 21, 47, 24, 1, -46 },
  { 3230, 44, 51, 50, 3, -45 },
  { 3511, 34, 45, 34, 0, -45 },
  { 3703, 27, 45, 36, 6, -45 },
  { 3855, 29, 47, 35, 4, -46 },
  { 4026, 30, 45, 40, 6, -45 },
  { 4195, 22, 45, 31, 6, -45 },
  { 4319, 22, 45, 29, 6, -45 },
  { 4443, 33, 47, 41, 4, -46 },
  { 4637, 29, 45, 41, 6, -45 },
  { 4801, 12, 45, 18, 3, -45 },
  { 4869, 14, 57, 15, -5, -45 },
  { 4969, 27, 45, 33, 6, -45 },
  { 5121, 21, 45, 29, 6, -45 },
  { 5240, 39, 45, 51, 6, -45 },
  { 5460, 30, 45, 41, 6, -45 },
  { 5629, 35, 47, 43, 4, -46 },
  { 5835, 24, 45, 33, 6, -45 },
  { 5970, 35, 57, 43, 4, -46 },
  { 6220, 27, 45, 34, 6, -45 },
  { 6372, 25, 47, 31, 3, -46 },
  { 6519, 29, 45, 29, 0, -45 },
  { 6683, 30, 46, 40, 5, -45 },
  { 6856, 33, 45, 33, 0, -45 },
  { 7042, 50, 45, 52, 1, -45 },
  { 7324, 30, 45, 30, 0, -45 },
  { 7493, 30, 45, 30, 0, -45 },
  { 7662, 27, 45, 31, 2, -45 },
  { 7814, 13, 55, 20, 5, -45 },
  { 7904, 20, 45, 22, 1, -45 },
  { 8017, 13, 55, 20, 2, -45 },
  { 8107, 28, 26, 32, 2, -45 },
  { 8198, 26, 2, 26, 0, 6 },
  { 8205, 11, 10, 16, 3, -48 },
  { 8219, 23, 35, 30, 3, -34 },
  { 8320, 26, 49, 34, 5, -48 },
  { 8480, 22, 35, 27, 3, -34 },
  { 8577, 26, 49, 34, 3, -48 },
  { 8737, 25, 35, 31, 3, -34 },
  { 8847, 19, 48, 18, 1, -48 },
  { 8961, 26, 49, 34, 3, -34 },
  { 9121, 24, 48, 34, 5, -48 },
  { 9265, 4, 46, 14, 5, -46 },
  { 9288, 11, 61, 14, -2, -46 },
  { 9372, 23, 48, 28, 5, -48 },
  { 9510, 4, 48, 14, 5, -48 },
  { 9534, 41, 34, 51, 5, -34 },
  { 9709, 24, 34, 34, 5, -34 },
  { 9811, 27, 35, 33, 3, -34 },
  { 9930, 26, 49, 34, 5, -34 },
  { 10090, 26, 49, 34, 3, -34 },
  { 10250, 16, 34, 22, 5, -34 },
  { 10318, 21, 35, 26, 3, -34 },
  { 10410, 17, 42, 19, 1, -41 },
  { 10500, 24, 35, 34, 5, -34 },
  { 10605, 26, 34, 26, 0, -34 },
  { 10716, 41, 34, 42, 1, -34 },
  { 10891, 26, 34, 28, 1, -34 },
  { 11002, 27, 49, 27, 0, -34 },
  { 11168, 21, 34, 25, 2, -34 },
  { 11258, 18, 55, 22, 2, -45 },
  { 11382, 3, 63, 31, 14, -48 },
  { 11406, 18, 55, 22, 2, -45 },
  { 11530, 27, 7, 32, 3, -26 },
};

const GFXfont NotoSans_SemiCondensed_Light63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light63pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT63PT7B_H_
