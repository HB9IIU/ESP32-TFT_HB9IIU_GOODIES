#ifndef _NOTOSANS_SEMICONDENSED_LIGHT59PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light59pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0x9C, 0xE7, 0x38, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC0, 0x00, 0x00, 0x00,
  0x3D, 0xFF, 0xFB, 0xC8, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x6E,
  0x03, 0x30, 0x19, 0x80, 0xC0, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x30, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x03, 0x80, 0x30, 0x00, 0x07, 0x00, 0x60, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x18, 0x03, 0x80, 0x00, 0x30, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x01, 0xC0, 0x18, 0x00, 0x03, 0x80, 0x30, 0x07, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x03, 0x80, 0x70, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x70,
  0x07, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x01, 0xC0, 0x38, 0x03, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x03,
  0x80, 0x00, 0x70, 0x06, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0x80, 0x38,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x38, 0x03, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xC0, 0x1C, 0x00,
  0x01, 0x80, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3E, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x1F, 0xB9, 0xFC,
  0x3C, 0x38, 0x18, 0x78, 0x38, 0x00, 0x70, 0x38, 0x00, 0xF0, 0x38, 0x00,
  0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00,
  0xF0, 0x38, 0x00, 0x70, 0x38, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x38, 0x00,
  0x1F, 0x38, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x39, 0xF8, 0x00, 0x38, 0x7C,
  0x00, 0x38, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0E,
  0x00, 0x38, 0x0F, 0x00, 0x38, 0x0F, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0E,
  0x00, 0x38, 0x0E, 0x00, 0x38, 0x1E, 0xC0, 0x38, 0x3C, 0xF8, 0x38, 0xF8,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x70, 0x01, 0xFF, 0x00,
  0x01, 0xC0, 0x0E, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x01,
  0xC0, 0x70, 0x01, 0xC0, 0x07, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x38, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x07, 0x00, 0x0E,
  0x00, 0xE0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x0E, 0x03,
  0x80, 0x03, 0x80, 0x38, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x70, 0x00, 0x38,
  0x03, 0x83, 0x80, 0x00, 0xE0, 0x0E, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x70,
  0x3C, 0x0E, 0x00, 0xE1, 0xC3, 0xFC, 0x18, 0x03, 0x87, 0x1F, 0xF8, 0x70,
  0x1C, 0x38, 0xF0, 0xF1, 0xC0, 0x70, 0xE3, 0x81, 0xC7, 0x81, 0xC7, 0x0E,
  0x03, 0x8E, 0x0E, 0x1C, 0x70, 0x0E, 0x1F, 0xF0, 0xE1, 0xC0, 0x38, 0x3F,
  0x83, 0x87, 0x00, 0x60, 0x38, 0x1C, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x60,
  0x07, 0x00, 0x03, 0x81, 0x80, 0x1C, 0x00, 0x0E, 0x06, 0x00, 0x70, 0x00,
  0x70, 0x18, 0x01, 0xC0, 0x01, 0xC0, 0x60, 0x07, 0x00, 0x0E, 0x01, 0x80,
  0x1C, 0x00, 0x38, 0x06, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x07, 0x00,
  0xE0, 0x03, 0x00, 0x0E, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x70,
  0x00, 0x70, 0xF0, 0x03, 0x80, 0x01, 0xFF, 0x80, 0x1E, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x0F, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x07, 0x80, 0x1E, 0x3C, 0x07, 0x80,
  0x1C, 0x78, 0x03, 0xC0, 0x1C, 0x70, 0x01, 0xE0, 0x3C, 0xF0, 0x00, 0xF0,
  0x38, 0xF0, 0x00, 0x78, 0x38, 0xE0, 0x00, 0x3C, 0x78, 0xE0, 0x00, 0x3E,
  0x70, 0xE0, 0x00, 0x1E, 0xF0, 0xE0, 0x00, 0x0F, 0xE0, 0xE0, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x0F,
  0xF0, 0x7C, 0x00, 0x3E, 0xF8, 0x3E, 0x00, 0x7C, 0x78, 0x1F, 0xCF, 0xF8,
  0x3C, 0x0F, 0xFF, 0xE0, 0x1E, 0x03, 0xFF, 0x80, 0x0F, 0x00, 0x30, 0x00,
  0x00, 0xFE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE6, 0x60, 0x00, 0xE0, 0x38,
  0x0F, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0,
  0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x00,
  0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0xF0, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03,
  0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x40, 0x18, 0x02,
  0xF0, 0x30, 0x3D, 0xFE, 0x63, 0xFB, 0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3B, 0x80, 0x00, 0xE7, 0x00, 0x03,
  0x87, 0x00, 0x0F, 0x0F, 0x00, 0x1C, 0x0F, 0x00, 0x78, 0x0E, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x3C, 0x78,
  0xE1, 0xC7, 0x8F, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0C, 0x38, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF7, 0x90, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x07, 0xC3,
  0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x3C, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0x38, 0x00,
  0x1C, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x0F, 0x00,
  0xF0, 0x07, 0xE7, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x38, 0x03, 0xC0, 0x7E, 0x07, 0xF0, 0x7B, 0x87, 0x9C, 0xF8,
  0xEF, 0x87, 0xF8, 0x3B, 0x01, 0xD0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x3F, 0x87, 0xF0, 0x7C, 0x00,
  0xF0, 0x70, 0x00, 0x78, 0x20, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x7F, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x60, 0x00,
  0x78, 0x40, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x80, 0x00, 0x7C, 0xE0, 0x00, 0xF8, 0xFE, 0x07, 0xF0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x78, 0x1C, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x1E, 0x01, 0xC0, 0x01, 0xC0,
  0x1C, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x03, 0xC0,
  0x01, 0xC0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFC, 0xFF, 0x02, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x90, 0x00, 0x1E, 0x38,
  0x00, 0xFC, 0x7F, 0x1F, 0xF0, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x01,
  0xFC, 0x0C, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x7F, 0x80, 0x71, 0xFF, 0xE0, 0x73,
  0xFF, 0xF8, 0xF7, 0x80, 0x7C, 0xFE, 0x00, 0x3C, 0xFC, 0x00, 0x1E, 0xF8,
  0x00, 0x0E, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x78, 0x00, 0x07, 0x38, 0x00, 0x0F, 0x38,
  0x00, 0x0F, 0x3C, 0x00, 0x0E, 0x1C, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x0F,
  0x80, 0x7C, 0x07, 0xE1, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0x81, 0xF8, 0x1E, 0x00, 0x78, 0x3C,
  0x00, 0x3C, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x38,
  0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x1F, 0x00, 0x78, 0x0F,
  0x81, 0xF0, 0x07, 0xE3, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xEF, 0xC0, 0x0F, 0x83, 0xF0, 0x1F, 0x00, 0xF8, 0x3C,
  0x00, 0x7C, 0x38, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x3E, 0x00, 0x7C, 0x1F, 0xC3, 0xF8, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0x83, 0xE0, 0x1E, 0x00, 0xF0, 0x3C,
  0x00, 0x78, 0x78, 0x00, 0x38, 0x70, 0x00, 0x3C, 0x70, 0x00, 0x1C, 0xF0,
  0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x70, 0x00, 0x1F, 0x78,
  0x00, 0x37, 0x3C, 0x00, 0x77, 0x1F, 0x01, 0xEF, 0x1F, 0xFF, 0xCF, 0x07,
  0xFF, 0x8E, 0x01, 0xFC, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x30, 0x3F, 0x80, 0x3F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x73, 0xFF, 0xFF, 0xB8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xEF, 0x20, 0x1C, 0x3C, 0xF9, 0xF3, 0xE3, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x78, 0xF1, 0xC7, 0x8F, 0x1E, 0x38, 0x71, 0xE3,
  0x87, 0x0E, 0x38, 0x70, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0xFC,
  0x3E, 0x0F, 0xC6, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x3C,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x00, 0x01, 0xC3, 0xC0, 0x07, 0xFF, 0x00, 0xE1, 0xC0, 0x07, 0xFF,
  0xC0, 0x38, 0xE0, 0x07, 0x81, 0xE0, 0x1C, 0xE0, 0x07, 0x80, 0x70, 0x0E,
  0x70, 0x07, 0x80, 0x38, 0x07, 0x38, 0x07, 0x80, 0x1C, 0x03, 0x9C, 0x03,
  0x80, 0x0E, 0x00, 0xEC, 0x01, 0xC0, 0x07, 0x00, 0x7E, 0x01, 0xC0, 0x03,
  0x80, 0x3F, 0x00, 0xE0, 0x01, 0xC0, 0x1F, 0x80, 0x70, 0x00, 0xE0, 0x0F,
  0xC0, 0x38, 0x00, 0xE0, 0x07, 0xE0, 0x1C, 0x00, 0x70, 0x03, 0x70, 0x0E,
  0x00, 0x38, 0x01, 0xB8, 0x07, 0x00, 0x1C, 0x01, 0xDC, 0x03, 0x80, 0x0E,
  0x00, 0xEE, 0x01, 0xC0, 0x07, 0x00, 0x77, 0x00, 0xF0, 0x07, 0x80, 0x71,
  0x80, 0x38, 0x03, 0xE0, 0x38, 0xE0, 0x1E, 0x03, 0x30, 0x38, 0x70, 0x07,
  0x87, 0x9C, 0x3C, 0x38, 0x01, 0xFF, 0x87, 0xFC, 0x1C, 0x00, 0x7F, 0x81,
  0xFC, 0x07, 0x00, 0x06, 0x00, 0x10, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x1C, 0x78, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x38, 0x3C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x70, 0x1E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x01, 0xC0, 0x07, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x0F,
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x70, 0x1E,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x38, 0x3C,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x1C, 0x78,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x83, 0xC0, 0x03, 0xF0, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x07, 0xCF, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0x3C, 0x00, 0x01, 0xCF,
  0x00, 0x00, 0x73, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0x3C, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x1C, 0x3C, 0x00,
  0x1F, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3C,
  0x01, 0xFE, 0x0F, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x0F,
  0x3C, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0E, 0xF0, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0E, 0xF0,
  0x00, 0x03, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1C,
  0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x8F, 0x00, 0x0F, 0xC3, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xF0, 0x7E, 0x01, 0xF8,
  0x00, 0x60, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x06, 0x00, 0xFF, 0x8F, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xE0, 0x03, 0xFC, 0x0F, 0x00, 0x03, 0xF0,
  0x78, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01,
  0xDE, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0x9E, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x01,
  0xF1, 0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x3F, 0x03,
  0xC0, 0x0F, 0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDE, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0x81,
  0xFE, 0x01, 0xF8, 0x00, 0x1C, 0x03, 0xE0, 0x00, 0x04, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x70, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x0F, 0x38, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0xFF, 0xCF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x7C,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x81, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E,
  0x01, 0xF4, 0x1F, 0x3F, 0xF1, 0xFF, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x07,
  0xBC, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x70, 0xF0, 0x00,
  0x3C, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0x80, 0xF0,
  0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x00,
  0xF0, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC1, 0xE0,
  0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xCF,
  0xC0, 0x00, 0xF7, 0xF0, 0x00, 0x3F, 0x9E, 0x00, 0x0F, 0xC7, 0x80, 0x03,
  0xF0, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x0F, 0x00,
  0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0xE0, 0x00, 0x00, 0x3F, 0xF7, 0x00, 0x00, 0x01, 0xDF, 0xBC, 0x00, 0x00,
  0x0E, 0xFC, 0xE0, 0x00, 0x00, 0xE7, 0xF7, 0x00, 0x00, 0x07, 0x3F, 0x9C,
  0x00, 0x00, 0x39, 0xFC, 0xE0, 0x00, 0x03, 0x8F, 0xE7, 0x00, 0x00, 0x1C,
  0x7F, 0x1C, 0x00, 0x00, 0xE3, 0xF8, 0xE0, 0x00, 0x0E, 0x1F, 0xC7, 0x80,
  0x00, 0x70, 0xFE, 0x1C, 0x00, 0x07, 0x87, 0xF0, 0xE0, 0x00, 0x38, 0x3F,
  0x87, 0x80, 0x01, 0xC1, 0xFC, 0x1C, 0x00, 0x1E, 0x0F, 0xE0, 0xE0, 0x00,
  0xE0, 0x7F, 0x07, 0x80, 0x07, 0x03, 0xF8, 0x1C, 0x00, 0x70, 0x1F, 0xC0,
  0xE0, 0x03, 0x80, 0xFE, 0x03, 0x80, 0x1C, 0x07, 0xF0, 0x1C, 0x01, 0xC0,
  0x3F, 0x80, 0xE0, 0x0E, 0x01, 0xFC, 0x03, 0x80, 0x70, 0x0F, 0xE0, 0x1C,
  0x07, 0x00, 0x7F, 0x00, 0xF0, 0x38, 0x03, 0xF8, 0x03, 0x83, 0xC0, 0x1F,
  0xC0, 0x1C, 0x1C, 0x00, 0xFE, 0x00, 0xF0, 0xE0, 0x07, 0xF0, 0x03, 0x8F,
  0x00, 0x3F, 0x80, 0x1C, 0x70, 0x01, 0xFC, 0x00, 0xF3, 0x80, 0x0F, 0xE0,
  0x03, 0xB8, 0x00, 0x7F, 0x00, 0x1D, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00,
  0x78, 0x00, 0x3F, 0x80, 0x03, 0x80, 0x01, 0xC0, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7E, 0xE0, 0x00, 0x07, 0xEF, 0x00, 0x00, 0x7E, 0x78, 0x00, 0x07,
  0xE7, 0x80, 0x00, 0x7E, 0x3C, 0x00, 0x07, 0xF1, 0xC0, 0x00, 0x7F, 0x1E,
  0x00, 0x07, 0xF0, 0xE0, 0x00, 0x7F, 0x0F, 0x00, 0x07, 0xF0, 0x78, 0x00,
  0x7F, 0x07, 0x80, 0x07, 0xF0, 0x3C, 0x00, 0x7F, 0x01, 0xC0, 0x07, 0xF0,
  0x1E, 0x00, 0x7F, 0x00, 0xF0, 0x07, 0xF0, 0x0F, 0x00, 0x7F, 0x00, 0x78,
  0x07, 0xF0, 0x07, 0x80, 0x7F, 0x00, 0x3C, 0x07, 0xF0, 0x01, 0xC0, 0x7F,
  0x00, 0x1E, 0x07, 0xF0, 0x00, 0xF0, 0x7F, 0x00, 0x0F, 0x07, 0xF0, 0x00,
  0x78, 0x7F, 0x00, 0x03, 0x87, 0xF0, 0x00, 0x3C, 0x7F, 0x00, 0x01, 0xC7,
  0xF0, 0x00, 0x1E, 0x7F, 0x00, 0x00, 0xF7, 0xF0, 0x00, 0x0F, 0x7F, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x0E, 0x78, 0x00,
  0x00, 0x03, 0x9E, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC7, 0x80, 0x1F, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x07, 0xBC,
  0x00, 0x07, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3B, 0xC0, 0x00,
  0xF7, 0x80, 0x03, 0xCF, 0x00, 0x0F, 0x9E, 0x01, 0xFE, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC0, 0xFF, 0xF8, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x79, 0xC0,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0x70, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x03, 0x9E, 0x00,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x1C, 0x3C,
  0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xE0,
  0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x03, 0xC0, 0x0F, 0xE0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x0F,
  0x0F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x0E, 0x3C, 0x00,
  0x03, 0x8F, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x0E, 0x3C,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E,
  0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xE0, 0xF0, 0x07,
  0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xF0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0xF0, 0x01, 0xC0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x0E, 0x03, 0xC0, 0x03,
  0xC0, 0xF0, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0xFF, 0x1F, 0xE3, 0xE0, 0x01,
  0xC7, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xA0,
  0x00, 0x1F, 0x70, 0x00, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x80, 0xFF,
  0xFC, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x0E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0x78, 0x1F, 0x80, 0x1F, 0x00, 0xFF, 0x9F, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x0E, 0x78, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xC0, 0x3C,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x80,
  0x03, 0x80, 0x0E, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x01, 0xC0, 0x0F, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x38, 0x07, 0x80, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x78, 0x38, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x3C,
  0x70, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0xB8,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x0E,
  0x00, 0x03, 0xF0, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x70, 0x00, 0x3C, 0x3C,
  0x00, 0x1C, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x39, 0xC0, 0x00, 0xE0, 0x70,
  0x00, 0x73, 0x80, 0x03, 0xC0, 0xE0, 0x01, 0xE3, 0x80, 0x07, 0x81, 0xC0,
  0x03, 0x87, 0x00, 0x0E, 0x03, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x03, 0x80,
  0x0E, 0x1E, 0x00, 0x78, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x0E, 0x00,
  0x70, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0xF0, 0x0F, 0x00, 0x38, 0x07, 0x80, 0xE0, 0x1E, 0x00, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x00, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x38,
  0x07, 0x81, 0xE0, 0x01, 0xC0, 0xF0, 0x07, 0x03, 0xC0, 0x03, 0x81, 0xC0,
  0x0E, 0x07, 0x00, 0x07, 0x83, 0x80, 0x1C, 0x0E, 0x00, 0x07, 0x07, 0x00,
  0x3C, 0x3C, 0x00, 0x0E, 0x1E, 0x00, 0x38, 0x78, 0x00, 0x1C, 0x38, 0x00,
  0x70, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0xE0, 0x01,
  0xE7, 0x80, 0x00, 0x73, 0xC0, 0x01, 0xCF, 0x00, 0x00, 0xE7, 0x00, 0x03,
  0x9C, 0x00, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x01, 0xDC, 0x00, 0x0E,
  0x70, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x1E, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x38, 0x0F, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x70, 0x07, 0x80, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xC0, 0x1E, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x07, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x03, 0x9E, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x07,
  0x8E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x1E, 0x03, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x70, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x78, 0x1E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x3C,
  0x3C, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x70, 0x0F, 0x00, 0x0F, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xC0, 0x03, 0x80, 0x3C, 0x00, 0x3C, 0x03, 0x80, 0x01,
  0xC0, 0x78, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x1C,
  0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x0E,
  0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x78, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00,
  0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xF8, 0x3C, 0x07, 0xC1, 0x80, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x03, 0xFF, 0xE0, 0xFF, 0xFF, 0x1F, 0xE0, 0x39, 0xF0, 0x01, 0xDE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x03,
  0x77, 0x80, 0x3B, 0xBF, 0x07, 0x9C, 0xFF, 0xF8, 0xE3, 0xFF, 0x07, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x7F, 0x00, 0xE1, 0xFF, 0xC0, 0xE3,
  0xFF, 0xE0, 0xE7, 0x81, 0xF0, 0xEE, 0x00, 0x78, 0xFC, 0x00, 0x3C, 0xF8,
  0x00, 0x1C, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xF0,
  0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xF0,
  0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1C, 0xF8,
  0x00, 0x3C, 0xFC, 0x00, 0x78, 0xEE, 0x00, 0xF8, 0xE7, 0xC3, 0xF0, 0xC3,
  0xFF, 0xE0, 0xC1, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xC0, 0x1F,
  0xFF, 0x03, 0xFF, 0xF0, 0xFC, 0x07, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x10, 0xFF, 0x3F, 0x03,
  0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0xFE,
  0x07, 0x03, 0xFF, 0x87, 0x07, 0xFF, 0xE7, 0x0F, 0x80, 0xF7, 0x1E, 0x00,
  0x77, 0x3C, 0x00, 0x3F, 0x3C, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x3F, 0x1F, 0x00,
  0x77, 0x0F, 0xC1, 0xE7, 0x07, 0xFF, 0xC7, 0x01, 0xFF, 0x03, 0x00, 0x18,
  0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7C, 0x0F,
  0x81, 0xE0, 0x07, 0x83, 0x80, 0x07, 0x0F, 0x00, 0x0F, 0x1C, 0x00, 0x0E,
  0x78, 0x00, 0x1E, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0xC0, 0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x0E, 0x00,
  0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x87,
  0x07, 0xFF, 0xE7, 0x0F, 0x80, 0xF7, 0x1E, 0x00, 0x37, 0x3C, 0x00, 0x1F,
  0x3C, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F,
  0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x1F,
  0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x37, 0x1F, 0x00, 0x77, 0x0F, 0xC3, 0xE7,
  0x07, 0xFF, 0xC7, 0x01, 0xFF, 0x07, 0x00, 0x10, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x20, 0x00, 0x3C,
  0x3C, 0x00, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x81, 0xFC, 0x0E, 0x1F, 0xFC, 0x39, 0xFF, 0xF8, 0xE7, 0x81, 0xF3, 0xB8,
  0x01, 0xEF, 0xC0, 0x07, 0xBE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1C, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0x01, 0xC0, 0x7C, 0x0F, 0x81,
  0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x0F, 0x3F, 0xE7, 0xF8,
  0xFC, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x03, 0xDC, 0x00, 0x3C, 0xE0, 0x03, 0xC7, 0x00,
  0x3C, 0x38, 0x03, 0xC1, 0xC0, 0x1C, 0x0E, 0x01, 0xE0, 0x70, 0x1E, 0x03,
  0x81, 0xE0, 0x1C, 0x1E, 0x00, 0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0xF0,
  0x01, 0xCF, 0x80, 0x0E, 0xFE, 0x00, 0x77, 0x70, 0x03, 0xF3, 0xC0, 0x1F,
  0x0F, 0x00, 0xF0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x81, 0xC0, 0x3C,
  0x0E, 0x00, 0xF0, 0x70, 0x03, 0x83, 0x80, 0x1E, 0x1C, 0x00, 0x78, 0xE0,
  0x01, 0xC7, 0x00, 0x0F, 0x38, 0x00, 0x3D, 0xC0, 0x01, 0xEE, 0x00, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x03, 0x0F,
  0xFE, 0x03, 0xFF, 0x0E, 0x7F, 0xFC, 0x3F, 0xFE, 0x3B, 0xC0, 0xF9, 0xE0,
  0x7C, 0xEC, 0x01, 0xE7, 0x00, 0x7B, 0xE0, 0x03, 0xF8, 0x01, 0xEF, 0x80,
  0x0F, 0xC0, 0x03, 0xBC, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x00, 0x78, 0x00,
  0x3F, 0x80, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0x00, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00,
  0x70, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x01,
  0xF8, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x01,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x07,
  0xE0, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0x00, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x1F,
  0x80, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x01, 0xF8, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x7F, 0x03, 0x07, 0xFF, 0x0E, 0x3F, 0xFE, 0x39, 0xE0,
  0x7C, 0xEE, 0x00, 0x7B, 0xF0, 0x01, 0xEF, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x03, 0xC1, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0x38, 0x70, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x38, 0x00,
  0x03, 0x9C, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7B,
  0x80, 0x00, 0x3D, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x78, 0x00, 0x0F,
  0x1C, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x07, 0x80, 0xF0, 0x07,
  0xC0, 0x7F, 0x1F, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0xC1, 0xFF, 0xC0, 0xE3, 0xFF, 0xF0, 0xE7,
  0x81, 0xF0, 0xEE, 0x00, 0x78, 0xFC, 0x00, 0x3C, 0xF8, 0x00, 0x1C, 0xF8,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0,
  0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1C, 0xF8, 0x00, 0x3C, 0xFC,
  0x00, 0x78, 0xEE, 0x00, 0xF8, 0xE7, 0xC7, 0xF0, 0xE3, 0xFF, 0xE0, 0xE1,
  0xFF, 0x80, 0xE0, 0x18, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFF, 0x87, 0x07, 0xFF, 0xE7, 0x0F, 0x80, 0xF7, 0x1E, 0x00, 0x77, 0x3C,
  0x00, 0x3F, 0x3C, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x70,
  0x00, 0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78,
  0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x37, 0x1F, 0x00, 0x77, 0x0F,
  0xC3, 0xE7, 0x07, 0xFF, 0xC7, 0x03, 0xFF, 0x07, 0x00, 0x30, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x7F, 0xC3, 0xFF, 0x8F, 0xFF, 0x3C, 0x1E, 0xE0, 0x1D,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0xF3, 0xE0, 0x1E,
  0x38, 0x00, 0x27, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x00, 0x0E,
  0xE0, 0x01, 0xEF, 0xE1, 0xFC, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0xC3, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x70, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xDC, 0x00, 0x07, 0xB8, 0x00, 0x1F, 0x70, 0x00, 0x3E, 0xF0, 0x00, 0xFD,
  0xE0, 0x01, 0xB9, 0xE0, 0x0F, 0x71, 0xF8, 0xFC, 0xE1, 0xFF, 0xF1, 0xC1,
  0xFF, 0x83, 0x80, 0x30, 0x00, 0xF0, 0x00, 0x07, 0xB8, 0x00, 0x07, 0x9C,
  0x00, 0x03, 0xCF, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0xF0,
  0xF0, 0x00, 0x70, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x3C, 0x0F, 0x00, 0x1C,
  0x03, 0x80, 0x0E, 0x01, 0xC0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x03, 0xC0, 0x0F, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0,
  0xF0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x0F,
  0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xCF, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0xC0,
  0x01, 0xE0, 0x00, 0xEF, 0x00, 0x0F, 0xC0, 0x03, 0x9C, 0x00, 0x3F, 0x00,
  0x0E, 0x70, 0x00, 0xFC, 0x00, 0x79, 0xE0, 0x03, 0x70, 0x01, 0xC7, 0x80,
  0x1C, 0xE0, 0x07, 0x0E, 0x00, 0x73, 0x80, 0x1C, 0x38, 0x01, 0xCE, 0x00,
  0xF0, 0xF0, 0x0F, 0x38, 0x03, 0x81, 0xC0, 0x38, 0x70, 0x0E, 0x07, 0x00,
  0xE1, 0xC0, 0x38, 0x1C, 0x03, 0x87, 0x01, 0xE0, 0x78, 0x1C, 0x0E, 0x07,
  0x00, 0xE0, 0x70, 0x38, 0x1C, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x0E, 0x0F,
  0x03, 0x83, 0xC0, 0x3C, 0x38, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x1C, 0x38,
  0x01, 0xC3, 0x80, 0x70, 0xE0, 0x07, 0x1C, 0x01, 0xE7, 0x80, 0x1E, 0x70,
  0x03, 0x9C, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x39, 0xC0,
  0x03, 0xB8, 0x00, 0xF7, 0x00, 0x0E, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x0E, 0x00,
  0x78, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0xE0, 0x03, 0x81, 0xE0, 0x03, 0xC3,
  0xC0, 0x01, 0xC3, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xF7, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xC3,
  0xC0, 0x03, 0xC1, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0x00, 0xE0, 0x0F, 0x00,
  0xF0, 0x0E, 0x00, 0x78, 0x1E, 0x00, 0x38, 0x3C, 0x00, 0x3C, 0x38, 0x00,
  0x1C, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xB8, 0x00,
  0x03, 0x9E, 0x00, 0x03, 0xC7, 0x00, 0x01, 0xE3, 0x80, 0x00, 0xE1, 0xE0,
  0x00, 0xF0, 0x70, 0x00, 0x78, 0x38, 0x00, 0x38, 0x1E, 0x00, 0x3C, 0x07,
  0x00, 0x1E, 0x03, 0x80, 0x0E, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80,
  0x38, 0x03, 0x80, 0x1E, 0x01, 0xC0, 0x07, 0x01, 0xE0, 0x03, 0x80, 0xE0,
  0x01, 0xE0, 0x70, 0x00, 0x70, 0x78, 0x00, 0x38, 0x38, 0x00, 0x1E, 0x1C,
  0x00, 0x07, 0x1E, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x3B, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0xFE, 0x00, 0x7C,
  0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0x80,
  0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0x80, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x7F, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xBF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0xFC, 0x0F, 0xFB, 0xF8, 0x00, 0xFF, 0xF4, 0x00,
  0x1F, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Light59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 5, 43, 14, 4, -42 },
  { 28, 13, 15, 21, 4, -42 },
  { 53, 31, 42, 34, 1, -42 },
  { 216, 24, 48, 30, 3, -45 },
  { 360, 38, 44, 44, 3, -43 },
  { 569, 32, 44, 36, 3, -43 },
  { 745, 4, 15, 11, 4, -42 },
  { 753, 11, 51, 16, 3, -42 },
  { 824, 12, 51, 16, 2, -42 },
  { 901, 23, 22, 29, 3, -45 },
  { 965, 25, 28, 30, 3, -35 },
  { 1053, 7, 15, 13, 2, -7 },
  { 1067, 14, 3, 18, 2, -17 },
  { 1073, 5, 6, 14, 4, -5 },
  { 1077, 19, 42, 21, 1, -42 },
  { 1177, 24, 44, 30, 3, -43 },
  { 1309, 13, 42, 30, 5, -42 },
  { 1378, 24, 43, 30, 3, -43 },
  { 1507, 24, 44, 30, 3, -43 },
  { 1639, 28, 42, 30, 1, -42 },
  { 1786, 23, 43, 30, 4, -42 },
  { 1910, 24, 44, 30, 3, -43 },
  { 2042, 24, 42, 30, 3, -42 },
  { 2168, 24, 44, 30, 3, -43 },
  { 2300, 24, 44, 30, 3, -43 },
  { 2432, 5, 33, 14, 4, -32 },
  { 2453, 7, 40, 14, 2, -32 },
  { 2488, 25, 27, 30, 3, -35 },
  { 2573, 25, 15, 30, 3, -28 },
  { 2620, 25, 27, 30, 3, -35 },
  { 2705, 19, 44, 22, 1, -43 },
  { 2810, 41, 47, 47, 3, -42 },
  { 3051, 32, 42, 32, 0, -42 },
  { 3219, 26, 42, 33, 5, -42 },
  { 3356, 28, 44, 33, 3, -43 },
  { 3510, 29, 42, 37, 5, -42 },
  { 3663, 21, 42, 29, 5, -42 },
  { 3774, 21, 42, 27, 5, -42 },
  { 3885, 32, 44, 39, 3, -43 },
  { 4061, 28, 42, 38, 5, -42 },
  { 4208, 11, 42, 17, 3, -42 },
  { 4266, 13, 53, 14, -4, -42 },
  { 4353, 26, 42, 31, 5, -42 },
  { 4490, 21, 42, 27, 5, -42 },
  { 4601, 37, 42, 47, 5, -42 },
  { 4796, 28, 42, 39, 5, -42 },
  { 4943, 34, 44, 40, 3, -43 },
  { 5130, 23, 42, 31, 5, -42 },
  { 5251, 34, 53, 40, 3, -43 },
  { 5477, 26, 42, 32, 5, -42 },
  { 5614, 23, 44, 29, 3, -43 },
  { 5741, 27, 42, 28, 0, -42 },
  { 5883, 28, 43, 38, 5, -42 },
  { 6034, 30, 42, 30, 0, -42 },
  { 6192, 47, 42, 48, 1, -42 },
  { 6439, 28, 42, 28, 0, -42 },
  { 6586, 28, 42, 28, 0, -42 },
  { 6733, 25, 42, 29, 2, -42 },
  { 6865, 12, 51, 19, 5, -42 },
  { 6942, 19, 42, 21, 1, -42 },
  { 7042, 12, 51, 19, 2, -42 },
  { 7119, 27, 24, 30, 2, -42 },
  { 7200, 25, 3, 25, 0, 5 },
  { 7210, 11, 9, 15, 2, -45 },
  { 7223, 21, 33, 29, 3, -32 },
  { 7310, 24, 46, 32, 5, -45 },
  { 7448, 20, 33, 25, 3, -32 },
  { 7531, 24, 46, 32, 3, -45 },
  { 7669, 23, 33, 29, 3, -32 },
  { 7764, 18, 45, 17, 1, -45 },
  { 7866, 24, 46, 32, 3, -32 },
  { 8004, 22, 45, 32, 5, -45 },
  { 8128, 5, 43, 13, 4, -43 },
  { 8155, 11, 57, 13, -2, -43 },
  { 8234, 21, 45, 26, 5, -45 },
  { 8353, 3, 45, 13, 5, -45 },
  { 8370, 38, 32, 47, 5, -32 },
  { 8522, 22, 32, 32, 5, -32 },
  { 8610, 25, 33, 31, 3, -32 },
  { 8714, 24, 46, 32, 5, -32 },
  { 8852, 24, 46, 32, 3, -32 },
  { 8990, 15, 32, 21, 5, -32 },
  { 9050, 20, 33, 25, 2, -32 },
  { 9133, 16, 40, 18, 1, -39 },
  { 9213, 23, 32, 32, 4, -31 },
  { 9305, 25, 31, 25, 0, -31 },
  { 9402, 38, 31, 40, 1, -31 },
  { 9550, 24, 31, 26, 1, -31 },
  { 9643, 25, 45, 25, 0, -31 },
  { 9784, 19, 31, 23, 2, -31 },
  { 9858, 17, 51, 21, 2, -42 },
  { 9967, 3, 59, 29, 13, -45 },
  { 9990, 17, 51, 21, 2, -42 },
  { 10099, 25, 6, 30, 3, -24 },
};

const GFXfont NotoSans_SemiCondensed_Light59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light59pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT59PT7B_H_
