#ifndef _NOTOSANS_SEMICONDENSED_LIGHT24PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFA, 0xAA, 0x83, 0xC0, 0x9C, 0xE3, 0x18, 0xC4, 0x08, 0x40,
  0x84, 0x08, 0x40, 0x8C, 0x08, 0x8F, 0xFF, 0x10, 0x81, 0x08, 0x10, 0x81,
  0x18, 0x11, 0x0F, 0xFE, 0x21, 0x02, 0x10, 0x21, 0x02, 0x30, 0x22, 0x00,
  0x08, 0x03, 0x03, 0xF9, 0x20, 0xC8, 0x32, 0x0C, 0x81, 0xA0, 0x38, 0x03,
  0x80, 0xB8, 0x22, 0x08, 0xC2, 0x30, 0x8E, 0x26, 0xFF, 0x02, 0x00, 0x80,
  0x78, 0x18, 0x44, 0x10, 0xC4, 0x20, 0x84, 0x20, 0x84, 0x40, 0x84, 0x40,
  0x84, 0x88, 0xC4, 0xBE, 0x45, 0x22, 0x79, 0x22, 0x03, 0x63, 0x02, 0x63,
  0x06, 0x63, 0x04, 0x62, 0x0C, 0x22, 0x08, 0x22, 0x18, 0x1C, 0x1F, 0x01,
  0x88, 0x08, 0x60, 0x43, 0x02, 0x18, 0x18, 0x80, 0x58, 0x01, 0x80, 0x34,
  0x03, 0x30, 0xD0, 0xC5, 0x83, 0x2C, 0x0F, 0x60, 0x33, 0x03, 0x8C, 0x36,
  0x3F, 0x18, 0xFC, 0x19, 0x88, 0xC4, 0x23, 0x18, 0xC4, 0x21, 0x0C, 0x61,
  0x08, 0x43, 0x08, 0x21, 0x80, 0xC2, 0x18, 0x43, 0x08, 0x42, 0x10, 0xC6,
  0x31, 0x08, 0x46, 0x31, 0x18, 0x88, 0x00, 0x08, 0x04, 0x02, 0x1D, 0x71,
  0xE0, 0xE0, 0x48, 0x46, 0x61, 0x00, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x3F, 0xF0, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x69, 0x2D, 0x00, 0xF8,
  0xF0, 0x03, 0x02, 0x02, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x10, 0x10,
  0x30, 0x20, 0x20, 0x60, 0x40, 0xC0, 0x3F, 0x08, 0x66, 0x09, 0x02, 0x40,
  0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x40, 0xD0, 0x26,
  0x08, 0xC6, 0x1F, 0x00, 0x09, 0xDB, 0x90, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x3F, 0x30, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18,
  0x04, 0x03, 0x00, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0xFF,
  0xC0, 0x7F, 0x30, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x38, 0x3F,
  0x00, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0A, 0x06, 0xFF, 0x00, 0x00,
  0x80, 0x18, 0x03, 0x80, 0x28, 0x04, 0x80, 0xC8, 0x08, 0x81, 0x08, 0x30,
  0x82, 0x08, 0x60, 0x84, 0x08, 0xFF, 0xF0, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x7F, 0x98, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0xFC, 0x01,
  0x80, 0x30, 0x0C, 0x01, 0x00, 0x40, 0x30, 0x0A, 0x06, 0x7E, 0x00, 0x0F,
  0x84, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x63, 0x7E, 0xE0, 0xB0, 0x3C,
  0x07, 0x01, 0x40, 0x50, 0x16, 0x0C, 0xC6, 0x1F, 0x00, 0xFF, 0xC0, 0x30,
  0x08, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x02, 0x01, 0x80, 0x40, 0x30,
  0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x00, 0x3F, 0x18, 0x64, 0x09, 0x03,
  0x40, 0xD8, 0x23, 0x10, 0x78, 0x1E, 0x18, 0x64, 0x0F, 0x01, 0xC0, 0x70,
  0x1C, 0x0D, 0x86, 0x3F, 0x00, 0x3F, 0x18, 0x64, 0x0B, 0x02, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0x61, 0x4F, 0xB0, 0x8C, 0x03, 0x00, 0x80, 0x60, 0x10,
  0x0C, 0x7C, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x6C, 0x00, 0x00, 0x01, 0xA5,
  0xB4, 0x00, 0x40, 0x70, 0x70, 0x70, 0x60, 0x30, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x04, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x38, 0x38, 0x38, 0x38,
  0x08, 0x00, 0xFE, 0x43, 0x01, 0x01, 0x01, 0x01, 0x03, 0x06, 0x0C, 0x18,
  0x10, 0x10, 0x10, 0x00, 0x00, 0x18, 0x18, 0x03, 0xF0, 0x06, 0x06, 0x04,
  0x01, 0x84, 0x00, 0x66, 0x00, 0x12, 0x0F, 0x89, 0x08, 0x47, 0x88, 0x21,
  0xC4, 0x10, 0xC2, 0x08, 0x61, 0x0C, 0x78, 0x86, 0x2C, 0x43, 0x12, 0x1E,
  0xF1, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x04, 0x01, 0xFC, 0x00,
  0x02, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0xD8, 0x04, 0x40, 0x22, 0x03,
  0x18, 0x10, 0x40, 0x82, 0x0F, 0xF8, 0x40, 0x42, 0x02, 0x30, 0x19, 0x00,
  0x58, 0x02, 0xC0, 0x18, 0xFF, 0x30, 0x6C, 0x0F, 0x01, 0xC0, 0xF0, 0x3C,
  0x0B, 0xFC, 0xFF, 0x30, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x06,
  0xFF, 0x00, 0x0F, 0xF1, 0x82, 0x30, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x01, 0x82, 0x0F, 0xE0, 0xFF, 0x0C, 0x18, 0xC0, 0xCC, 0x06, 0xC0, 0x2C,
  0x02, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x02, 0xC0, 0x2C,
  0x06, 0xC0, 0xCC, 0x38, 0xFE, 0x00, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0xFE, 0xFF, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xFF, 0x80, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xFF,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x0F, 0xF8,
  0xC0, 0x8C, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0xFE, 0x07, 0xD0, 0x02, 0x80, 0x16, 0x00, 0xB0, 0x04, 0xC0, 0x23, 0x03,
  0x0F, 0xF8, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x20, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0xF8, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0x86, 0xF0, 0xC0, 0xD8, 0x33, 0x04, 0x61, 0x0C, 0x61,
  0x98, 0x36, 0x06, 0xC0, 0xE8, 0x19, 0x83, 0x10, 0x63, 0x0C, 0x31, 0x82,
  0x30, 0x66, 0x06, 0xC0, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xC0, 0x07,
  0xC0, 0x1E, 0x80, 0x2D, 0x80, 0x59, 0x01, 0xB2, 0x02, 0x66, 0x04, 0xC4,
  0x19, 0x88, 0x23, 0x18, 0x46, 0x11, 0x8C, 0x22, 0x18, 0x64, 0x30, 0x50,
  0x60, 0xA0, 0xC1, 0xC1, 0x81, 0x02, 0xC0, 0x3E, 0x03, 0xA0, 0x3B, 0x03,
  0x90, 0x39, 0x83, 0x8C, 0x38, 0x43, 0x86, 0x38, 0x23, 0x83, 0x38, 0x13,
  0x80, 0xB8, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x30, 0x0F, 0xE0, 0xE0, 0xC2,
  0x01, 0x98, 0x02, 0x40, 0x09, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x34, 0x00, 0xD0, 0x03, 0x40, 0x09, 0x80, 0x63, 0x01, 0x06, 0x0C,
  0x0F, 0xC0, 0xFE, 0x30, 0xEC, 0x0B, 0x02, 0xC0, 0xF0, 0x3C, 0x0B, 0x06,
  0xC3, 0x3F, 0x8C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00,
  0x0F, 0xE0, 0xE0, 0xC2, 0x01, 0x98, 0x02, 0x40, 0x09, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x34, 0x00, 0xD0, 0x03, 0x40, 0x09, 0x80,
  0x63, 0x01, 0x06, 0x0C, 0x0F, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0xFE, 0x30, 0xEC, 0x0B, 0x02, 0xC0, 0xF0, 0x2C, 0x0B, 0x06, 0xFF,
  0x3F, 0x0C, 0x63, 0x08, 0xC3, 0x30, 0x6C, 0x0B, 0x03, 0xC0, 0x40, 0x3F,
  0x98, 0x24, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x08, 0x03, 0x00, 0xC0, 0x30, 0x0A, 0x06, 0xFE, 0x00, 0xFF, 0xE0, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x80, 0x50, 0x1B, 0x06, 0x3F, 0x80, 0xC0, 0x14, 0x03,
  0x40, 0x36, 0x02, 0x60, 0x62, 0x06, 0x30, 0x43, 0x04, 0x10, 0xC1, 0x08,
  0x18, 0x80, 0x98, 0x09, 0x00, 0xD0, 0x07, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x60, 0x28, 0x0C, 0x0D, 0x03, 0x81, 0xB0, 0x50, 0x22, 0x0B, 0x04, 0x41,
  0x21, 0x88, 0x64, 0x31, 0x88, 0x84, 0x11, 0x18, 0x82, 0x21, 0x30, 0x4C,
  0x26, 0x0D, 0x04, 0x80, 0xA0, 0xD0, 0x14, 0x0A, 0x02, 0x81, 0xC0, 0x60,
  0x30, 0x0C, 0x06, 0x00, 0x40, 0x6C, 0x08, 0x83, 0x08, 0x41, 0x98, 0x12,
  0x03, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x24, 0x0C, 0x81, 0x08, 0x41, 0x98,
  0x12, 0x03, 0xC0, 0x20, 0xC0, 0x68, 0x09, 0x81, 0x10, 0x63, 0x08, 0x23,
  0x06, 0x40, 0x58, 0x0A, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0xFF, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80,
  0x60, 0x10, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00,
  0xFF, 0xC0, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x0F, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x20, 0x30, 0x10, 0x18,
  0x08, 0x08, 0x0C, 0x04, 0x04, 0x06, 0x02, 0x02, 0x03, 0xF8, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x3F, 0x80, 0x0C,
  0x01, 0x80, 0x68, 0x09, 0x03, 0x10, 0x42, 0x18, 0x22, 0x04, 0xC0, 0x50,
  0x0C, 0xFF, 0xC0, 0xC6, 0x30, 0x3E, 0x31, 0x80, 0x60, 0x30, 0x18, 0x0C,
  0xFE, 0x83, 0xC1, 0xC0, 0xF0, 0x78, 0x57, 0xC8, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x27, 0x8A, 0x33, 0x06, 0xC0, 0xA0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x3C, 0x0B, 0x02, 0xA1, 0xA7, 0xC0, 0x1F, 0x31, 0x60, 0x40, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x31, 0x1F, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x47, 0x93, 0x15, 0x83, 0x40, 0xF0, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x14, 0x0D, 0x03, 0x61, 0x4F, 0x90, 0x1E, 0x0C, 0x46, 0x09, 0x02,
  0xC0, 0xF0, 0x3F, 0xFF, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC2, 0x1F, 0x80,
  0x1F, 0x10, 0x30, 0x30, 0x30, 0xFC, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x1E, 0x4C, 0x56, 0x0D, 0x03, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x50, 0x34, 0x0D, 0x85, 0x3E, 0x40, 0x10,
  0x04, 0x03, 0x00, 0x9C, 0xE3, 0xE0, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0xF2, 0x8D, 0x83, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x40, 0xB8, 0x2A, 0xAA, 0xAA, 0xA0, 0x10, 0xC4, 0x00, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x0A, 0xDC, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x1A, 0x09, 0x08, 0x8C, 0x4C, 0x2C, 0x17,
  0x0C, 0x84, 0x62, 0x11, 0x04, 0x83, 0x40, 0xC0, 0xFF, 0xFF, 0xC0, 0x9E,
  0x3D, 0x46, 0x8F, 0x06, 0x0E, 0x0C, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40,
  0xC0, 0x81, 0x81, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x20,
  0x9E, 0x51, 0xB0, 0x78, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x08, 0x1F, 0x0C, 0x66, 0x0D, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x50, 0x14, 0x0C, 0x86, 0x1F, 0x00, 0x9E, 0x28, 0xCC, 0x1B,
  0x02, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x2C, 0x0A, 0x86, 0x9F,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x1E, 0x4C, 0x56, 0x0D,
  0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x50, 0x34, 0x0D, 0x85, 0x3E,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x9E, 0xDC, 0x30, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x80, 0x3E, 0x63, 0xC0, 0x80, 0xC0, 0x70,
  0x1C, 0x06, 0x03, 0x01, 0x01, 0x83, 0xFE, 0x20, 0x40, 0x87, 0xF2, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0C, 0x0F, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x78, 0x57, 0xC8,
  0xC0, 0xF0, 0x34, 0x09, 0x02, 0x61, 0x88, 0x42, 0x10, 0xCC, 0x12, 0x04,
  0x81, 0xE0, 0x30, 0x0C, 0x00, 0xC1, 0x83, 0x41, 0x83, 0x41, 0x82, 0x43,
  0x42, 0x62, 0x46, 0x22, 0x44, 0x22, 0x64, 0x26, 0x24, 0x34, 0x2C, 0x14,
  0x28, 0x14, 0x38, 0x1C, 0x18, 0x18, 0x18, 0x40, 0xD8, 0x23, 0x18, 0x4C,
  0x1A, 0x03, 0x80, 0xC0, 0x38, 0x1A, 0x04, 0x42, 0x19, 0x82, 0xC0, 0xC0,
  0xC0, 0x50, 0x34, 0x09, 0x82, 0x21, 0x88, 0x43, 0x10, 0x4C, 0x12, 0x06,
  0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x2C, 0x0E, 0x00,
  0xFF, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x30, 0x20, 0x60, 0x40, 0xC0,
  0xFF, 0x0E, 0x30, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xC3, 0x01, 0x03,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0x40, 0xE0, 0x60, 0xFF, 0xFF, 0xFF, 0xE0,
  0x60, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x30, 0x18, 0xC1, 0x02, 0x04,
  0x08, 0x10, 0x20, 0xC3, 0x0C, 0x00, 0x30, 0x77, 0xB8, 0x38,
};

const GFXglyph NotoSans_SemiCondensed_Light24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 17, 6, 2, -17 },
  { 6, 5, 6, 9, 2, -17 },
  { 10, 12, 17, 14, 1, -17 },
  { 36, 10, 19, 12, 1, -18 },
  { 60, 16, 17, 18, 1, -17 },
  { 94, 13, 17, 15, 1, -17 },
  { 122, 1, 6, 5, 2, -17 },
  { 123, 5, 21, 7, 1, -17 },
  { 137, 5, 21, 7, 1, -17 },
  { 151, 9, 9, 12, 1, -18 },
  { 162, 10, 11, 12, 1, -14 },
  { 176, 3, 6, 5, 1, -3 },
  { 179, 5, 1, 7, 1, -7 },
  { 180, 2, 2, 6, 2, -2 },
  { 181, 8, 17, 8, 0, -17 },
  { 198, 10, 17, 12, 1, -17 },
  { 220, 5, 17, 12, 2, -17 },
  { 231, 10, 17, 12, 1, -17 },
  { 253, 10, 17, 12, 1, -17 },
  { 275, 12, 17, 12, 0, -17 },
  { 301, 10, 17, 12, 1, -17 },
  { 323, 10, 17, 12, 1, -17 },
  { 345, 10, 17, 12, 1, -17 },
  { 367, 10, 17, 12, 1, -17 },
  { 389, 10, 17, 12, 1, -17 },
  { 411, 2, 13, 6, 2, -13 },
  { 415, 3, 16, 6, 1, -13 },
  { 421, 10, 11, 12, 1, -14 },
  { 435, 10, 7, 12, 1, -12 },
  { 444, 10, 11, 12, 1, -14 },
  { 458, 8, 17, 9, 0, -17 },
  { 475, 17, 19, 19, 1, -17 },
  { 516, 13, 17, 13, 0, -17 },
  { 544, 10, 17, 14, 2, -17 },
  { 566, 12, 17, 13, 1, -17 },
  { 592, 12, 17, 15, 2, -17 },
  { 618, 9, 17, 12, 2, -17 },
  { 638, 9, 17, 11, 2, -17 },
  { 658, 13, 17, 16, 1, -17 },
  { 686, 11, 17, 15, 2, -17 },
  { 710, 5, 17, 7, 1, -17 },
  { 721, 6, 21, 6, -2, -17 },
  { 737, 11, 17, 13, 2, -17 },
  { 761, 8, 17, 11, 2, -17 },
  { 778, 15, 17, 19, 2, -17 },
  { 810, 12, 17, 16, 2, -17 },
  { 836, 14, 17, 16, 1, -17 },
  { 866, 10, 17, 13, 2, -17 },
  { 888, 14, 21, 16, 1, -17 },
  { 925, 10, 17, 13, 2, -17 },
  { 947, 10, 17, 12, 1, -17 },
  { 969, 11, 17, 11, 0, -17 },
  { 993, 11, 17, 15, 2, -17 },
  { 1017, 12, 17, 12, 0, -17 },
  { 1043, 19, 17, 20, 0, -17 },
  { 1084, 11, 17, 12, 0, -17 },
  { 1108, 11, 17, 11, 0, -17 },
  { 1132, 10, 17, 12, 1, -17 },
  { 1154, 5, 21, 8, 2, -17 },
  { 1168, 8, 17, 8, 0, -17 },
  { 1185, 5, 21, 8, 1, -17 },
  { 1199, 11, 10, 12, 1, -17 },
  { 1213, 10, 1, 10, 0, 2 },
  { 1215, 4, 3, 6, 1, -18 },
  { 1217, 9, 13, 12, 1, -13 },
  { 1232, 10, 18, 13, 2, -18 },
  { 1255, 8, 13, 10, 1, -13 },
  { 1268, 10, 18, 13, 1, -18 },
  { 1291, 10, 13, 12, 1, -13 },
  { 1308, 8, 18, 7, 0, -18 },
  { 1326, 10, 19, 13, 1, -13 },
  { 1350, 9, 18, 13, 2, -18 },
  { 1371, 2, 18, 5, 2, -18 },
  { 1376, 5, 24, 5, -1, -18 },
  { 1391, 9, 18, 11, 2, -18 },
  { 1412, 1, 18, 5, 2, -18 },
  { 1415, 15, 13, 19, 2, -13 },
  { 1440, 9, 13, 13, 2, -13 },
  { 1455, 10, 13, 13, 1, -13 },
  { 1472, 10, 19, 13, 2, -13 },
  { 1496, 10, 19, 13, 1, -13 },
  { 1520, 6, 13, 8, 2, -13 },
  { 1530, 8, 13, 10, 1, -13 },
  { 1543, 7, 16, 7, 0, -16 },
  { 1557, 9, 13, 13, 2, -13 },
  { 1572, 10, 13, 10, 0, -13 },
  { 1589, 16, 13, 16, 0, -13 },
  { 1615, 10, 13, 11, 0, -13 },
  { 1632, 10, 19, 10, 0, -13 },
  { 1656, 8, 13, 10, 1, -13 },
  { 1669, 7, 21, 9, 1, -17 },
  { 1688, 1, 24, 12, 5, -18 },
  { 1691, 7, 21, 9, 1, -17 },
  { 1710, 10, 3, 12, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_Light24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light24pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT24PT7B_H_
