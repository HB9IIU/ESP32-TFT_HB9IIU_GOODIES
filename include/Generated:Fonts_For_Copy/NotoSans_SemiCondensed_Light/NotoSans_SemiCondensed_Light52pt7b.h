#ifndef _NOTOSANS_SEMICONDENSED_LIGHT52PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light52pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF7, 0x77, 0x77, 0x77, 0x77, 0x76, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x60, 0x00, 0x00, 0x6F, 0xFF, 0xF2, 0xF0, 0x77, 0x07, 0x70,
  0x77, 0x07, 0x60, 0x76, 0x07, 0x60, 0x76, 0x07, 0x60, 0x76, 0x07, 0x60,
  0x66, 0x06, 0x60, 0x60, 0x00, 0x38, 0x06, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x38, 0x0E, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x70, 0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x70, 0x1C, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x60, 0x18, 0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF0, 0x0E, 0x01, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x1C,
  0x03, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x18, 0x07, 0x00, 0x01, 0x80, 0x60,
  0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x03,
  0x80, 0xE0, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x60, 0x1C, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x0E, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xC0,
  0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3C, 0x60, 0xE7, 0x06, 0x00, 0xE0, 0x60,
  0x0E, 0x06, 0x00, 0xE0, 0x60, 0x0E, 0x06, 0x00, 0xE0, 0x60, 0x0E, 0x06,
  0x00, 0xE0, 0x60, 0x0F, 0x06, 0x00, 0x78, 0x60, 0x03, 0xE6, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x6F, 0xC0,
  0x06, 0x3E, 0x00, 0x60, 0xE0, 0x06, 0x07, 0x00, 0x60, 0x70, 0x06, 0x03,
  0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0x60, 0x70, 0x06, 0x07, 0x00, 0x60,
  0xEC, 0x06, 0x1E, 0xFC, 0x6F, 0xCF, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xE0, 0x0F, 0xF8, 0x00, 0x70, 0x0E,
  0x0C, 0x00, 0x30, 0x06, 0x07, 0x00, 0x38, 0x07, 0x01, 0x80, 0x18, 0x03,
  0x80, 0xE0, 0x1C, 0x01, 0x80, 0x70, 0x0C, 0x00, 0xC0, 0x38, 0x0E, 0x00,
  0x60, 0x1C, 0x06, 0x00, 0x30, 0x0E, 0x07, 0x00, 0x18, 0x07, 0x03, 0x00,
  0x0C, 0x03, 0x83, 0x80, 0x06, 0x01, 0xC1, 0x80, 0x03, 0x00, 0xE1, 0xC0,
  0x01, 0x80, 0x70, 0xC1, 0xE0, 0xC0, 0x38, 0xE1, 0xFC, 0x70, 0x1C, 0x61,
  0xEF, 0x38, 0x0C, 0x71, 0xC1, 0x8C, 0x0E, 0x38, 0xC0, 0xE7, 0x0E, 0x38,
  0xE0, 0x31, 0xFF, 0x1C, 0x70, 0x18, 0x7F, 0x1C, 0x30, 0x0E, 0x0C, 0x0E,
  0x18, 0x07, 0x00, 0x06, 0x0C, 0x03, 0x80, 0x07, 0x06, 0x01, 0xC0, 0x03,
  0x03, 0x00, 0xE0, 0x03, 0x81, 0x80, 0x70, 0x01, 0x80, 0xC0, 0x38, 0x01,
  0xC0, 0x60, 0x1C, 0x00, 0xC0, 0x30, 0x0E, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0x60, 0x0E, 0x03, 0x00, 0x70, 0x07, 0x03, 0x80, 0x30, 0x01, 0x81, 0xC0,
  0x38, 0x00, 0xE1, 0xC0, 0x18, 0x00, 0x3F, 0xE0, 0x1C, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x03, 0xC0, 0x00,
  0x70, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x39,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x38,
  0xF0, 0x3C, 0x03, 0x87, 0x00, 0xF0, 0x1C, 0x70, 0x03, 0xC0, 0xE3, 0x80,
  0x0F, 0x06, 0x1C, 0x00, 0x38, 0x70, 0xC0, 0x00, 0xE3, 0x8E, 0x00, 0x07,
  0xB8, 0x30, 0x00, 0x1F, 0xC1, 0xC0, 0x00, 0x7C, 0x0E, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x1F, 0x83, 0xC0, 0x01, 0xDC, 0x0F, 0x00, 0x3C, 0x70, 0x3E,
  0x07, 0xC3, 0xC0, 0xFF, 0xFC, 0x0F, 0x03, 0xFF, 0x80, 0x3C, 0x01, 0x80,
  0x00, 0x00, 0xF7, 0x77, 0x66, 0x66, 0x66, 0x66, 0x60, 0x01, 0xE0, 0x30,
  0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1E, 0xE0,
  0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0,
  0x70, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0,
  0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x0E, 0x0E, 0x06, 0x7E, 0x33, 0xF7, 0xFF, 0xFF, 0xC1, 0xFF,
  0xC0, 0x00, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0xEE, 0x00, 0x0E, 0x38, 0x00,
  0x71, 0xC0, 0x07, 0x07, 0x00, 0x70, 0x1C, 0x07, 0x80, 0xF0, 0x08, 0x02,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x1C, 0xF3,
  0xCE, 0x38, 0xE3, 0x1C, 0x71, 0xC6, 0x38, 0xC0, 0xFF, 0xFF, 0xFF, 0x6F,
  0xFF, 0xF4, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0,
  0x3E, 0x0F, 0x01, 0xC0, 0x3C, 0x1C, 0x00, 0xF0, 0xE0, 0x03, 0x8E, 0x00,
  0x1C, 0x70, 0x00, 0x73, 0x80, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x38, 0x00, 0x39, 0xC0,
  0x01, 0xCE, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xE0, 0x0E, 0x07, 0x00, 0xF0,
  0x1E, 0x1F, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x70, 0x0F, 0x03,
  0xF0, 0x7F, 0x0F, 0x71, 0xE7, 0x3C, 0x7F, 0x07, 0x60, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x00, 0x78, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF8,
  0x0F, 0x81, 0xF0, 0x78, 0x01, 0xE0, 0x80, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x78, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xFC, 0x1F, 0x80, 0xF8,
  0xF0, 0x01, 0xE0, 0x80, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xCC, 0x00,
  0x1E, 0x3E, 0x01, 0xF8, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x76, 0x00, 0x00, 0x33, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x38, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x18, 0x00,
  0x0E, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x06, 0x03, 0x00, 0x07, 0x01, 0x80,
  0x07, 0x00, 0xC0, 0x03, 0x80, 0x60, 0x03, 0x80, 0x30, 0x03, 0x80, 0x18,
  0x01, 0xC0, 0x0C, 0x01, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x00, 0xE0, 0x01,
  0x80, 0xE0, 0x00, 0xC0, 0x70, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xC0, 0x7E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE6,
  0x00, 0x1E, 0x3E, 0x03, 0xE1, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xC0, 0x40,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x1F, 0xC0, 0xE3, 0xFF, 0x87, 0x3F, 0xFE,
  0x3B, 0x80, 0x79, 0xF0, 0x01, 0xEF, 0x80, 0x07, 0x78, 0x00, 0x3B, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00,
  0x0E, 0x38, 0x00, 0x71, 0xE0, 0x07, 0x87, 0x80, 0x78, 0x1E, 0x0F, 0x80,
  0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x7C, 0x07,
  0x83, 0x80, 0x1E, 0x38, 0x00, 0x71, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70,
  0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x0E,
  0x1C, 0x00, 0x70, 0xF0, 0x0F, 0x03, 0xE0, 0xF0, 0x07, 0x9F, 0x00, 0x1F,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x00, 0xF0, 0xF0, 0x0F, 0x03, 0xE0,
  0xE0, 0x07, 0x8E, 0x00, 0x1E, 0xF0, 0x00, 0x77, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x73, 0x80, 0x03, 0x9E, 0x00, 0x78, 0x7C, 0x07,
  0x81, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xC0, 0xF0, 0x1C, 0x01, 0xE0, 0xE0,
  0x03, 0x87, 0x80, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x39, 0xC0, 0x00,
  0xE7, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x76,
  0x00, 0x01, 0xDC, 0x00, 0x0F, 0x70, 0x00, 0x3D, 0xC0, 0x00, 0xF3, 0x80,
  0x07, 0xCE, 0x00, 0x37, 0x1E, 0x01, 0xDC, 0x3F, 0xFE, 0x60, 0x7F, 0xE1,
  0x80, 0x7E, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x08, 0x07, 0xC0,
  0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0x40,
  0x1C, 0xF3, 0xCF, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xCF, 0x38, 0xE3, 0x8E, 0x71, 0xC7, 0x18,
  0xE3, 0x8C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x1F, 0xFC, 0x3F, 0xFF, 0x0E, 0x03, 0xC4, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x08, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x1C,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x01, 0xF0, 0x03, 0x18, 0x01,
  0xFF, 0xC0, 0x67, 0x00, 0x7C, 0xF8, 0x0E, 0xE0, 0x1C, 0x07, 0x01, 0xD8,
  0x07, 0x00, 0xE0, 0x1F, 0x00, 0xC0, 0x1C, 0x03, 0xE0, 0x38, 0x03, 0x80,
  0x7C, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xC0, 0x0E, 0x01, 0xE0, 0x38, 0x01,
  0xC0, 0x3C, 0x07, 0x00, 0x38, 0x07, 0x80, 0xE0, 0x07, 0x00, 0xF0, 0x1C,
  0x00, 0xE0, 0x1E, 0x03, 0x80, 0x1C, 0x03, 0xC0, 0x70, 0x07, 0x80, 0xF8,
  0x06, 0x00, 0xF0, 0x1F, 0x80, 0xE0, 0x1E, 0x03, 0x70, 0x1C, 0x06, 0xC0,
  0xEE, 0x01, 0xC1, 0xDC, 0x38, 0xC0, 0x1F, 0xF1, 0xFE, 0x1C, 0x01, 0xF8,
  0x1F, 0x83, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x80, 0x00, 0xF8, 0x00, 0x70,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0,
  0x38, 0x00, 0x18, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x01, 0xC0,
  0x03, 0x80, 0x1C, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x38,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x70,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0E, 0x07, 0xFE, 0x38, 0x00, 0x78, 0xE0,
  0x00, 0xF3, 0x80, 0x01, 0xCE, 0x00, 0x07, 0xB8, 0x00, 0x0E, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x73,
  0x80, 0x01, 0xCE, 0x00, 0x0E, 0x38, 0x00, 0xF0, 0xFF, 0xFF, 0x83, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x38, 0x00, 0xF8, 0xE0, 0x00, 0xF3, 0x80, 0x01,
  0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xB8, 0x00, 0x1E, 0xE0, 0x00, 0xF3, 0x80, 0x07, 0xCF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0xFF, 0x03, 0xF0, 0x0F, 0x07, 0xC0, 0x02, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x01, 0x03, 0xF0, 0x1E, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0x80, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x1C, 0x00, 0x7E, 0x0E, 0x00, 0x0F, 0x87, 0x00, 0x03, 0xE3, 0x80, 0x00,
  0xF1, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0xB8, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03,
  0xB8, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0xF0, 0x70, 0x03,
  0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xB8, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0xFC, 0x03,
  0xF0, 0x3C, 0x00, 0x0C, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x0E, 0x70, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x07, 0x1E,
  0x00, 0x00, 0xE1, 0xF0, 0x00, 0x1C, 0x1F, 0x00, 0x03, 0x81, 0xFC, 0x03,
  0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x30, 0x00, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x7F, 0xFF, 0xFE, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xE8, 0x3C, 0xFF,
  0x8F, 0xF0, 0x18, 0x00, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xEE, 0x00, 0x0F,
  0x38, 0x00, 0x78, 0xE0, 0x01, 0xC3, 0x80, 0x0E, 0x0E, 0x00, 0x70, 0x38,
  0x03, 0xC0, 0xE0, 0x1E, 0x03, 0x80, 0xF0, 0x0E, 0x03, 0x80, 0x38, 0x1C,
  0x00, 0xE0, 0xF0, 0x03, 0x87, 0x80, 0x0E, 0x3C, 0x00, 0x38, 0xE0, 0x00,
  0xE7, 0x80, 0x03, 0xBF, 0x00, 0x0F, 0xDC, 0x00, 0x3E, 0x38, 0x00, 0xF0,
  0xF0, 0x03, 0xC1, 0xC0, 0x0E, 0x07, 0x80, 0x38, 0x0F, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x78, 0x0E, 0x00, 0xF0, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x83,
  0x80, 0x0F, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x78, 0xE0, 0x00, 0xE3, 0x80,
  0x01, 0xCE, 0x00, 0x07, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3C, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xD8, 0x00,
  0x00, 0x3F, 0xDC, 0x00, 0x00, 0x3F, 0xDC, 0x00, 0x00, 0x37, 0xCC, 0x00,
  0x00, 0x77, 0xCE, 0x00, 0x00, 0x77, 0xEE, 0x00, 0x00, 0x67, 0xE7, 0x00,
  0x00, 0xE7, 0xE7, 0x00, 0x00, 0xE7, 0xE7, 0x00, 0x00, 0xC7, 0xE3, 0x80,
  0x01, 0xC7, 0xE3, 0x80, 0x01, 0xC7, 0xE3, 0x80, 0x03, 0x87, 0xE1, 0xC0,
  0x03, 0x87, 0xE1, 0xC0, 0x03, 0x07, 0xE0, 0xC0, 0x07, 0x07, 0xE0, 0xE0,
  0x07, 0x07, 0xE0, 0xE0, 0x06, 0x07, 0xE0, 0x60, 0x0E, 0x07, 0xE0, 0x70,
  0x0E, 0x07, 0xE0, 0x70, 0x0C, 0x07, 0xE0, 0x38, 0x1C, 0x07, 0xE0, 0x38,
  0x1C, 0x07, 0xE0, 0x38, 0x38, 0x07, 0xE0, 0x1C, 0x38, 0x07, 0xE0, 0x1C,
  0x38, 0x07, 0xE0, 0x1C, 0x70, 0x07, 0xE0, 0x0E, 0x70, 0x07, 0xE0, 0x0E,
  0x60, 0x07, 0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03,
  0x80, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xDC, 0x00, 0x03, 0xCE, 0x00, 0x03, 0xCE,
  0x00, 0x03, 0xC7, 0x00, 0x03, 0xE7, 0x80, 0x03, 0xE3, 0x80, 0x03, 0xE1,
  0xC0, 0x03, 0xE1, 0xC0, 0x03, 0xE0, 0xE0, 0x03, 0xE0, 0xF0, 0x03, 0xE0,
  0x70, 0x03, 0xE0, 0x78, 0x03, 0xE0, 0x38, 0x03, 0xE0, 0x1C, 0x03, 0xE0,
  0x1C, 0x03, 0xE0, 0x0E, 0x03, 0xE0, 0x0F, 0x03, 0xE0, 0x07, 0x03, 0xE0,
  0x07, 0x83, 0xE0, 0x03, 0x83, 0xE0, 0x01, 0xC3, 0xE0, 0x01, 0xC3, 0xE0,
  0x00, 0xE3, 0xE0, 0x00, 0xF3, 0xE0, 0x00, 0x73, 0xE0, 0x00, 0x7B, 0xE0,
  0x00, 0x3B, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x00, 0x78, 0x07,
  0x80, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x07, 0x80, 0x00, 0x3C, 0x38, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xE7, 0x80,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x3C, 0x1E, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x1C, 0x01, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0xE0, 0xFF, 0x8E, 0x00,
  0x7C, 0xE0, 0x01, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x01, 0xEE, 0x00, 0x3C,
  0xE0, 0x0F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xC0, 0x7E, 0x00, 0xF8, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00,
  0x07, 0x07, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x1E, 0xE0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x78, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1B, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x38,
  0x01, 0xF0, 0xE0, 0x01, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0F, 0x38, 0x00,
  0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1C,
  0xE0, 0x00, 0x73, 0x80, 0x03, 0xCE, 0x00, 0x0E, 0x38, 0x00, 0x78, 0xE0,
  0x03, 0xC3, 0x80, 0x1E, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8,
  0x03, 0x80, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xE0, 0x0E, 0x03,
  0x80, 0x3C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xE0, 0xE0, 0x03, 0x83, 0x80,
  0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xF3, 0x80, 0x01,
  0xCE, 0x00, 0x07, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x7F, 0xFC, 0x1F, 0xFF, 0xE3, 0xF0, 0x1E, 0x78, 0x00, 0x27, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x80, 0x03,
  0xCF, 0x80, 0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x39,
  0xE0, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x1E,
  0x03, 0xF0, 0x3E, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x38,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0x70,
  0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x07, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0x87, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xBC, 0x00, 0x0F, 0x00, 0x01, 0xCE, 0x00, 0x07,
  0xC0, 0x00, 0xE7, 0x00, 0x03, 0xE0, 0x00, 0x73, 0x80, 0x03, 0xF0, 0x00,
  0x71, 0xE0, 0x01, 0xD8, 0x00, 0x38, 0x70, 0x00, 0xEE, 0x00, 0x1C, 0x38,
  0x00, 0x67, 0x00, 0x0E, 0x1C, 0x00, 0x73, 0x80, 0x0E, 0x0E, 0x00, 0x38,
  0xC0, 0x07, 0x03, 0x80, 0x1C, 0x70, 0x03, 0x81, 0xC0, 0x0C, 0x38, 0x01,
  0xC0, 0xE0, 0x0E, 0x1C, 0x01, 0xC0, 0x70, 0x07, 0x06, 0x00, 0xE0, 0x1C,
  0x03, 0x83, 0x80, 0x70, 0x0E, 0x01, 0x81, 0xC0, 0x38, 0x07, 0x01, 0xC0,
  0xE0, 0x38, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x00, 0xE0, 0x70, 0x1C, 0x0E,
  0x00, 0x70, 0x30, 0x0E, 0x07, 0x00, 0x38, 0x38, 0x07, 0x07, 0x00, 0x1C,
  0x1C, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x03, 0x86, 0x00,
  0x70, 0xE0, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x0C, 0x70,
  0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0x1C, 0xC0, 0x03, 0x9C, 0x00, 0x0E,
  0xE0, 0x01, 0xCC, 0x00, 0x07, 0x70, 0x00, 0x6E, 0x00, 0x01, 0xB8, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x07, 0x00,
  0x03, 0x83, 0x80, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0xE0, 0x70, 0x00,
  0x70, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x9C, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8,
  0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0,
  0xF0, 0x00, 0xE0, 0x38, 0x00, 0xF0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x01, 0xC0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1C,
  0x00, 0x07, 0x0E, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x1E,
  0x38, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x38,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x07, 0x80, 0xE0,
  0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0xC3, 0xC0, 0x01, 0xC3, 0x80,
  0x00, 0xE3, 0x80, 0x00, 0xE7, 0x00, 0x00, 0x77, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x7F, 0xFF, 0xFE, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0x60, 0x00, 0x0E, 0xE0, 0x00, 0x18, 0xC0, 0x00, 0x71, 0xC0, 0x00,
  0xC1, 0x80, 0x03, 0x83, 0x80, 0x06, 0x03, 0x00, 0x1C, 0x07, 0x00, 0x30,
  0x06, 0x00, 0xE0, 0x0E, 0x01, 0x80, 0x1C, 0x07, 0x00, 0x1C, 0x0C, 0x00,
  0x38, 0x38, 0x00, 0x38, 0x60, 0x00, 0x71, 0xC0, 0x00, 0x73, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x38,
  0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xFE, 0x01, 0xFF, 0xE0,
  0x7E, 0x3E, 0x0C, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x0F, 0xFE, 0x0F, 0xFF, 0xC7, 0xF0, 0x39, 0xE0, 0x07, 0x78, 0x00, 0xEE,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x7B, 0x80, 0x1F, 0x70, 0x07, 0x6F, 0x81, 0xCC, 0xFF, 0xF1, 0x87,
  0xFC, 0x30, 0x10, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x0F, 0xE0, 0x71, 0xFF, 0xC3, 0x9F, 0x3F, 0x1D, 0xC0, 0x3C, 0xFC, 0x00,
  0xF7, 0xC0, 0x03, 0xBC, 0x00, 0x1D, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xBE, 0x00, 0x1D,
  0xF0, 0x01, 0xEE, 0xC0, 0x1E, 0x77, 0x83, 0xE3, 0x9F, 0xFE, 0x18, 0x3F,
  0xE0, 0x00, 0x10, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xF0, 0xFE, 0xF8, 0x78,
  0x02, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x60, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x3F, 0xC3, 0x87, 0xFF, 0x1C, 0x7E,
  0x3E, 0xE7, 0xC0, 0x37, 0x38, 0x00, 0xFB, 0xC0, 0x07, 0xDC, 0x00, 0x1E,
  0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7B, 0x80, 0x03, 0xDC, 0x00, 0x1E, 0xF0, 0x01, 0xF3, 0xC0, 0x1B, 0x8F,
  0x03, 0xDC, 0x3F, 0xFC, 0x60, 0xFF, 0x83, 0x00, 0x40, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0xF0, 0x0F, 0x8F, 0x81, 0xE0, 0x3C, 0x38, 0x01, 0xC7, 0x80,
  0x0E, 0x70, 0x00, 0xE7, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x21, 0xF0, 0x1E, 0x0F, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x10, 0x00, 0x00,
  0x7C, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1F,
  0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x03, 0xFC, 0x18, 0x7F, 0xF9,
  0xC7, 0xF3, 0xEE, 0x7C, 0x03, 0x73, 0x80, 0x0F, 0xBC, 0x00, 0x3D, 0xC0,
  0x01, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xB8, 0x00, 0x3D, 0xC0, 0x01, 0xEF, 0x00, 0x1F, 0x3C, 0x01,
  0xB8, 0xF0, 0x3D, 0xC3, 0xFF, 0xCE, 0x0F, 0xF8, 0x70, 0x06, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xE6, 0x00, 0x1E, 0x3E, 0x03, 0xE1, 0xFF,
  0xFE, 0x03, 0xFF, 0xC0, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0xFE,
  0x0E, 0x3F, 0xF8, 0xE7, 0xCF, 0xCE, 0xE0, 0x1E, 0xFC, 0x00, 0xEF, 0x80,
  0x0E, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xEF, 0xFE, 0x60, 0x00,
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0x03, 0x80, 0xF0, 0x3C, 0x0E, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x3A, 0x1C, 0xFF, 0x3F, 0x80, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x1D, 0xC0, 0x07, 0x38, 0x01, 0xC7, 0x00, 0x78, 0xE0, 0x0E, 0x1C, 0x03,
  0x83, 0x80, 0xE0, 0x70, 0x38, 0x0E, 0x0F, 0x01, 0xC3, 0xC0, 0x38, 0x70,
  0x07, 0x1C, 0x00, 0xE7, 0x80, 0x1D, 0xF8, 0x03, 0xB7, 0x80, 0x7C, 0x70,
  0x0F, 0x87, 0x01, 0xE0, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xE0, 0xE0, 0x1C,
  0x1C, 0x01, 0xC3, 0x80, 0x3C, 0x70, 0x03, 0x8E, 0x00, 0x79, 0xC0, 0x07,
  0x38, 0x00, 0x77, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFC, 0x03, 0xFC,
  0x38, 0xFF, 0xC1, 0xFF, 0x8E, 0x79, 0xF8, 0xF3, 0xF3, 0xB0, 0x0E, 0x60,
  0x1E, 0xF8, 0x03, 0xF0, 0x03, 0xBC, 0x00, 0x7C, 0x00, 0xEF, 0x00, 0x1E,
  0x00, 0x1F, 0xC0, 0x07, 0x80, 0x07, 0xE0, 0x00, 0xE0, 0x01, 0xF8, 0x00,
  0x38, 0x00, 0x7E, 0x00, 0x0C, 0x00, 0x1F, 0x80, 0x03, 0x00, 0x07, 0xE0,
  0x00, 0xC0, 0x01, 0xF8, 0x00, 0x30, 0x00, 0x7E, 0x00, 0x0C, 0x00, 0x1F,
  0x80, 0x03, 0x00, 0x07, 0xE0, 0x00, 0xC0, 0x01, 0xF8, 0x00, 0x30, 0x00,
  0x7E, 0x00, 0x0C, 0x00, 0x1F, 0x80, 0x03, 0x00, 0x07, 0xE0, 0x00, 0xC0,
  0x01, 0xF8, 0x00, 0x30, 0x00, 0x7E, 0x00, 0x0C, 0x00, 0x1F, 0x80, 0x03,
  0x00, 0x07, 0xE0, 0x00, 0xC0, 0x01, 0xF8, 0x00, 0x30, 0x00, 0x7E, 0x00,
  0x0C, 0x00, 0x1F, 0x80, 0x03, 0x00, 0x07, 0xE0, 0xFE, 0x0E, 0x3F, 0xF8,
  0xE7, 0x8F, 0xCE, 0xE0, 0x1E, 0xF8, 0x00, 0xEF, 0x80, 0x0E, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xF8,
  0xFC, 0x07, 0x80, 0x78, 0x38, 0x00, 0xF1, 0xE0, 0x01, 0xC7, 0x00, 0x07,
  0x9C, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xB8, 0x00, 0x0E,
  0x70, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00, 0x07, 0x0E, 0x00, 0x3C, 0x3C,
  0x01, 0xE0, 0x7C, 0x0F, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x30,
  0x00, 0xE0, 0xFE, 0x07, 0x1F, 0xFC, 0x39, 0xF3, 0xF1, 0xDC, 0x03, 0xCE,
  0xC0, 0x0F, 0x7C, 0x00, 0x3B, 0xC0, 0x01, 0xDE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3B, 0xE0,
  0x01, 0xDF, 0x00, 0x1E, 0xEC, 0x01, 0xE7, 0x78, 0x3E, 0x39, 0xFF, 0xE1,
  0xC3, 0xFE, 0x0E, 0x03, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFC,
  0x18, 0x7F, 0xF0, 0xC7, 0xE3, 0xEE, 0x7C, 0x03, 0x73, 0x80, 0x0F, 0xBC,
  0x00, 0x7D, 0xC0, 0x01, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xB8, 0x00, 0x3D, 0xC0, 0x01, 0xEF, 0x00,
  0x1F, 0x3C, 0x01, 0xB8, 0xF0, 0x3D, 0xC3, 0xFF, 0xCE, 0x0F, 0xF8, 0x70,
  0x04, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE1, 0xFF, 0x8F, 0xFE, 0x7F,
  0xBB, 0x80, 0xEC, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x07, 0xFC, 0x07, 0xFF,
  0xE3, 0xF1, 0xF9, 0xE0, 0x04, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0E, 0x80, 0x07, 0xBC, 0x07, 0xCF, 0xFF, 0xE0, 0xFF, 0xE0, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70,
  0x03, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC1, 0x07, 0xFC,
  0x0F, 0xF0, 0x04, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xF7, 0x00, 0x1F, 0x78, 0x03, 0x73, 0xC0, 0xE7, 0x3F, 0xFC, 0x70,
  0xFF, 0x87, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xE7, 0x00,
  0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07,
  0x0E, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0,
  0xE0, 0x07, 0x07, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE3, 0x80,
  0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xC0, 0x00, 0x37, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0xF0, 0x00, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x67, 0x00, 0x36, 0x00, 0x73, 0x80, 0x1B, 0x80, 0x39, 0xC0,
  0x1D, 0xC0, 0x1C, 0xE0, 0x0E, 0xE0, 0x0C, 0x38, 0x06, 0x30, 0x0E, 0x1C,
  0x07, 0x1C, 0x07, 0x0E, 0x03, 0x8E, 0x03, 0x83, 0x01, 0xC3, 0x01, 0x81,
  0xC0, 0xC1, 0xC1, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x70,
  0x18, 0x38, 0x18, 0x30, 0x0E, 0x38, 0x0E, 0x38, 0x07, 0x1C, 0x07, 0x1C,
  0x03, 0x8E, 0x03, 0x8E, 0x00, 0xC6, 0x00, 0xC6, 0x00, 0x77, 0x00, 0x77,
  0x00, 0x3B, 0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x0D, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x7B, 0x80, 0x03, 0x8E,
  0x00, 0x38, 0x78, 0x03, 0xC1, 0xC0, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0E,
  0x00, 0xE0, 0xE0, 0x03, 0x8F, 0x00, 0x1C, 0x70, 0x00, 0x77, 0x00, 0x03,
  0xB8, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xDC, 0x00, 0x0E, 0xF0, 0x00, 0xE3, 0x80, 0x0E, 0x0E, 0x00, 0x70,
  0x70, 0x07, 0x01, 0xC0, 0x78, 0x07, 0x03, 0x80, 0x38, 0x38, 0x00, 0xE1,
  0xC0, 0x07, 0x1C, 0x00, 0x1D, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x1D, 0xC0,
  0x00, 0xF7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x38, 0x00, 0x78, 0xE0, 0x01,
  0xC3, 0x80, 0x07, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x80,
  0xE0, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x70,
  0x38, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x1C, 0x00, 0x18, 0x70,
  0x00, 0x71, 0x80, 0x01, 0xCE, 0x00, 0x03, 0x38, 0x00, 0x0E, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x10, 0x00,
  0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xE0, 0x1E, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xE0, 0x1F, 0x80, 0x3C, 0x00, 0x7E, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xF0,
  0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1F, 0xC0, 0x07, 0x80, 0x7F, 0x01, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0x80, 0x00, 0x1F,
  0xC0, 0x05, 0xFF, 0xC0, 0x1F, 0x9F, 0xC1, 0xF0, 0x0F, 0xFF, 0x80, 0x0F,
  0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Light52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 38, 12, 4, -37 },
  { 20, 12, 13, 18, 3, -37 },
  { 40, 28, 37, 30, 1, -37 },
  { 170, 20, 42, 27, 3, -39 },
  { 275, 33, 39, 39, 3, -38 },
  { 436, 29, 39, 32, 2, -38 },
  { 578, 4, 13, 10, 3, -37 },
  { 585, 11, 45, 14, 2, -37 },
  { 647, 10, 45, 14, 2, -37 },
  { 704, 21, 20, 25, 2, -40 },
  { 757, 22, 25, 27, 2, -31 },
  { 826, 6, 13, 11, 2, -6 },
  { 836, 12, 2, 16, 2, -15 },
  { 839, 4, 6, 12, 4, -5 },
  { 842, 16, 37, 18, 1, -37 },
  { 916, 21, 38, 27, 3, -38 },
  { 1016, 12, 37, 27, 4, -37 },
  { 1072, 22, 38, 27, 2, -38 },
  { 1177, 22, 39, 27, 2, -38 },
  { 1285, 25, 37, 27, 1, -37 },
  { 1401, 21, 38, 27, 3, -37 },
  { 1501, 21, 39, 27, 3, -38 },
  { 1604, 22, 37, 27, 2, -37 },
  { 1706, 21, 39, 27, 3, -38 },
  { 1809, 22, 39, 27, 2, -38 },
  { 1917, 4, 29, 12, 4, -28 },
  { 1932, 6, 35, 12, 2, -28 },
  { 1959, 22, 23, 27, 2, -30 },
  { 2023, 22, 13, 27, 2, -25 },
  { 2059, 22, 23, 27, 2, -30 },
  { 2123, 17, 39, 20, 1, -38 },
  { 2206, 35, 42, 41, 3, -37 },
  { 2390, 28, 37, 28, 0, -37 },
  { 2520, 22, 37, 29, 5, -37 },
  { 2622, 24, 39, 29, 3, -38 },
  { 2739, 25, 37, 33, 5, -37 },
  { 2855, 18, 37, 26, 5, -37 },
  { 2939, 18, 37, 24, 5, -37 },
  { 3023, 27, 39, 34, 3, -38 },
  { 3155, 24, 37, 34, 5, -37 },
  { 3266, 11, 37, 15, 2, -37 },
  { 3317, 12, 47, 12, -4, -37 },
  { 3388, 22, 37, 27, 5, -37 },
  { 3490, 18, 37, 24, 5, -37 },
  { 3574, 32, 37, 42, 5, -37 },
  { 3722, 24, 37, 34, 5, -37 },
  { 3833, 29, 39, 35, 3, -38 },
  { 3975, 20, 37, 27, 5, -37 },
  { 4068, 29, 47, 35, 3, -38 },
  { 4239, 22, 37, 28, 5, -37 },
  { 4341, 20, 39, 26, 3, -38 },
  { 4439, 24, 37, 24, 0, -37 },
  { 4550, 25, 38, 33, 4, -37 },
  { 4669, 27, 37, 27, 0, -37 },
  { 4794, 41, 37, 43, 1, -37 },
  { 4984, 25, 37, 25, 0, -37 },
  { 5100, 24, 37, 24, 0, -37 },
  { 5211, 22, 37, 25, 2, -37 },
  { 5313, 11, 45, 16, 4, -37 },
  { 5375, 16, 37, 18, 1, -37 },
  { 5449, 11, 45, 16, 1, -37 },
  { 5511, 23, 21, 27, 2, -37 },
  { 5572, 22, 2, 22, 0, 5 },
  { 5578, 9, 8, 13, 2, -40 },
  { 5587, 19, 29, 25, 2, -28 },
  { 5656, 21, 41, 28, 4, -40 },
  { 5764, 18, 29, 22, 3, -28 },
  { 5830, 21, 41, 28, 3, -40 },
  { 5938, 20, 29, 26, 3, -28 },
  { 6011, 16, 40, 15, 1, -40 },
  { 6091, 21, 40, 28, 3, -28 },
  { 6196, 20, 40, 28, 4, -40 },
  { 6296, 4, 38, 11, 4, -38 },
  { 6315, 10, 50, 11, -2, -38 },
  { 6378, 19, 40, 23, 4, -40 },
  { 6473, 3, 40, 11, 4, -40 },
  { 6488, 34, 28, 42, 4, -28 },
  { 6607, 20, 28, 28, 4, -28 },
  { 6677, 22, 29, 28, 3, -28 },
  { 6757, 21, 40, 28, 4, -28 },
  { 6862, 21, 40, 28, 3, -28 },
  { 6967, 14, 28, 18, 4, -28 },
  { 7016, 18, 29, 22, 2, -28 },
  { 7082, 14, 35, 16, 1, -34 },
  { 7144, 20, 29, 28, 4, -28 },
  { 7217, 22, 28, 22, 0, -28 },
  { 7294, 33, 28, 35, 1, -28 },
  { 7410, 21, 28, 23, 1, -28 },
  { 7484, 22, 41, 22, 0, -28 },
  { 7597, 17, 28, 21, 2, -28 },
  { 7657, 15, 45, 19, 2, -37 },
  { 7742, 3, 53, 25, 11, -40 },
  { 7762, 15, 45, 19, 2, -37 },
  { 7847, 22, 5, 27, 2, -21 },
};

const GFXfont NotoSans_SemiCondensed_Light52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light52pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT52PT7B_H_
