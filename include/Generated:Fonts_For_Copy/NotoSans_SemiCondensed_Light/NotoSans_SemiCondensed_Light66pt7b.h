#ifndef _NOTOSANS_SEMICONDENSED_LIGHT66PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light66pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x01, 0xCF, 0xBE, 0xFF, 0xEF,
  0x8C, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7B, 0x80, 0xF7, 0x01, 0xEE, 0x03,
  0xDC, 0x07, 0xB8, 0x0F, 0x70, 0x1E, 0xE0, 0x3D, 0xC0, 0x7B, 0x80, 0xE7,
  0x01, 0xCE, 0x03, 0x9C, 0x03, 0x38, 0x06, 0x70, 0x0C, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x1F, 0x8E, 0x0F, 0x07,
  0xC1, 0xC0, 0x20, 0xF0, 0x38, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x80, 0x70, 0x00, 0x70,
  0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x3C, 0x07, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x7C, 0x1C, 0x00, 0x07, 0xE3, 0x80, 0x00, 0x7F,
  0x70, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1C, 0xFE, 0x00, 0x03,
  0x87, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x0E, 0x03, 0xC0, 0x01, 0xC0, 0x78,
  0x00, 0x38, 0x07, 0x80, 0x07, 0x00, 0xF0, 0x00, 0xE0, 0x1E, 0x00, 0x1C,
  0x03, 0xC0, 0x03, 0x80, 0x78, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x03, 0xC0,
  0x01, 0xC0, 0x79, 0x00, 0x38, 0x3E, 0x3C, 0x07, 0x0F, 0x87, 0xFE, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0x00,
  0x0F, 0x0F, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0xE0, 0x00, 0x78, 0x00, 0x70,
  0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x3C,
  0x00, 0x70, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xC0, 0x1C, 0x00,
  0x0F, 0x00, 0x38, 0x07, 0x80, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0xE0, 0x3C, 0x00, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0xE0, 0x00, 0x1E, 0x00, 0x70, 0x38, 0x00, 0x03, 0xC0, 0x0E, 0x07,
  0x00, 0x00, 0x38, 0x01, 0xC1, 0xC0, 0x7C, 0x07, 0x00, 0x38, 0x38, 0x3F,
  0xC0, 0xE0, 0x07, 0x0F, 0x0F, 0xFC, 0x1C, 0x01, 0xE1, 0xC3, 0xC3, 0xC3,
  0xC0, 0x38, 0x78, 0xF0, 0x3C, 0x38, 0x0F, 0x0E, 0x1C, 0x03, 0x87, 0x81,
  0xC3, 0xC3, 0x80, 0x78, 0x78, 0x78, 0x70, 0xF0, 0x07, 0x07, 0xFE, 0x1E,
  0x1C, 0x00, 0xE0, 0x7F, 0x83, 0x83, 0x80, 0x1C, 0x03, 0xC0, 0xF0, 0x70,
  0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x81, 0xC0, 0x0F,
  0x00, 0x00, 0xE0, 0x38, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0xE0, 0x07, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0xF0, 0x00, 0x38,
  0x03, 0x80, 0x1E, 0x00, 0x07, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x01, 0xC0, 0x07, 0x80, 0x78, 0x00, 0x78, 0x00, 0x70, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x70,
  0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0x80, 0x03, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x78, 0x3E, 0x03, 0xC0, 0x03, 0xC3, 0xE0, 0x1F, 0x00, 0x1C, 0x1E, 0x00,
  0x7C, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0x0F, 0x0F, 0x00, 0x07, 0xC0, 0x70,
  0x70, 0x00, 0x1E, 0x07, 0x87, 0x80, 0x00, 0x78, 0x3C, 0x3C, 0x00, 0x03,
  0xE3, 0xC1, 0xE0, 0x00, 0x0F, 0x9E, 0x0F, 0x00, 0x00, 0x3F, 0xE0, 0x78,
  0x00, 0x00, 0xFF, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x00, 0xFC, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x0F, 0x00,
  0x00, 0xFF, 0xC0, 0x7C, 0x00, 0x1F, 0x1F, 0x01, 0xF8, 0x03, 0xF0, 0x7C,
  0x07, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0xFF, 0xE0, 0x07, 0x80, 0x3F, 0xFC,
  0x00, 0x3F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xF7, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x70, 0x00, 0x78, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x60, 0x0C, 0x01, 0xBF, 0x03, 0x03, 0xEF, 0xF8, 0xCF, 0xF9, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x73, 0x80, 0x00, 0x38, 0xF0, 0x00, 0x1E, 0x1E, 0x00,
  0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0xC0, 0x1C, 0x00, 0xE0, 0x02, 0x00, 0x20, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x3C, 0xF9,
  0xE3, 0xC7, 0x8F, 0x1C, 0x78, 0xF1, 0xC3, 0x8F, 0x1C, 0x38, 0x60, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0xFF, 0xFF, 0xFD, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x3E,
  0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x70, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1C,
  0xF0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0x7B, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x78, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x07, 0xC0, 0x0F, 0x00, 0x7C, 0x03, 0xE0,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xE1,
  0xFB, 0xC7, 0xC7, 0x9F, 0x0F, 0x7C, 0x1F, 0xF0, 0x3D, 0xC0, 0x7A, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x07, 0xF0, 0x07, 0xE0,
  0x78, 0x00, 0x3E, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFB, 0xFE, 0x0F, 0xE0, 0x03, 0xE0, 0xF0, 0x00, 0x3E, 0x18, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x60, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xE1, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x77, 0x80, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x03, 0x87, 0x80, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x38, 0x07, 0x80, 0x00,
  0x78, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xE0, 0x07, 0x80, 0x01,
  0xE0, 0x07, 0x80, 0x01, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x07, 0x80, 0x1C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x38,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0x80, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xCC,
  0x00, 0x03, 0xE3, 0xE0, 0x03, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xEF, 0x80, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x1F, 0xF0, 0x0F, 0x0F, 0xFF, 0x81, 0xE7, 0xFF, 0xF8, 0x39, 0xF0, 0x1F,
  0x87, 0x38, 0x00, 0xF8, 0xEE, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xF3, 0xE0,
  0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0x77, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x3C, 0x00,
  0x03, 0x87, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x80,
  0xFC, 0x03, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0x1F, 0xE0, 0x0F, 0x80,
  0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C,
  0x3C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x3C, 0x38, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xF0, 0x00, 0xF0, 0x0F,
  0x80, 0x1E, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0x1F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x1E, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E,
  0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0x3C,
  0x00, 0x03, 0xC3, 0xE0, 0x00, 0x78, 0x1F, 0x80, 0x1F, 0x80, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0xF8, 0x07, 0xE0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x38, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x07, 0xDE, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x3F, 0x3C, 0x00, 0x0F,
  0xE3, 0xE0, 0x03, 0xBC, 0x7F, 0x03, 0xE7, 0x87, 0xFF, 0xF8, 0xF0, 0x3F,
  0xFE, 0x1E, 0x01, 0xFF, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x27, 0xFF,
  0xFF, 0xFD, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xDF, 0xFF, 0xFF, 0xF6, 0x00, 0x04, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C,
  0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x78, 0x01, 0xF0, 0x80, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xE0, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x1C,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0xFC, 0x00, 0x70, 0xE0,
  0x00, 0xFF, 0xFC, 0x03, 0xC7, 0x00, 0x1F, 0xFF, 0xE0, 0x0E, 0x78, 0x01,
  0xF0, 0x0F, 0x00, 0x73, 0x80, 0x0F, 0x00, 0x78, 0x03, 0x9C, 0x00, 0xF0,
  0x03, 0xC0, 0x1D, 0xE0, 0x0F, 0x00, 0x1C, 0x00, 0xFE, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0xF0, 0x07, 0x80, 0x07, 0x00, 0x1F, 0x80, 0x3C, 0x00, 0x38,
  0x00, 0xFC, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0xE0, 0x0E, 0x00, 0x0E, 0x00,
  0x3F, 0x00, 0x70, 0x00, 0x70, 0x01, 0xF8, 0x03, 0x80, 0x03, 0x80, 0x0F,
  0xC0, 0x1C, 0x00, 0x1C, 0x00, 0xFE, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0xF0,
  0x07, 0x00, 0x0F, 0x00, 0x3B, 0x80, 0x38, 0x00, 0x78, 0x01, 0xDC, 0x01,
  0xC0, 0x03, 0xC0, 0x0E, 0xE0, 0x0E, 0x00, 0x1E, 0x00, 0xF7, 0x00, 0x78,
  0x01, 0xF0, 0x07, 0x38, 0x01, 0xC0, 0x0D, 0xC0, 0x79, 0xC0, 0x0F, 0x00,
  0xEE, 0x03, 0x8F, 0x00, 0x3E, 0x1E, 0x38, 0x7C, 0x38, 0x00, 0xFF, 0xE1,
  0xFF, 0xC1, 0xC0, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0x80, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00,
  0x3C, 0x38, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x00, 0x3C, 0x0E, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xE0, 0x3C,
  0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xE0,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00,
  0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x78, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x1F, 0x8F, 0x00,
  0x00, 0x7C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x8F,
  0x00, 0x01, 0xF0, 0xF0, 0x01, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x7F, 0x0F, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x1F, 0x8F,
  0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x03, 0xC0, 0x7E, 0x00,
  0x01, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x20, 0x1F, 0xC0, 0x03, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xF0, 0x03, 0xFF, 0x00, 0xF0, 0x00, 0x3F, 0x80, 0xF0, 0x00, 0x0F, 0xC0,
  0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x0F, 0xC0,
  0xF0, 0x00, 0x3F, 0x80, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFB, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0,
  0x00, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0x07, 0xBE, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x1E, 0x7C, 0x00,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x0F, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0x3C, 0x1F, 0x80, 0x00, 0x07,
  0x81, 0xFC, 0x00, 0x00, 0xF0, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xCF, 0xF8, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x71, 0xFC, 0xFF, 0xF1, 0xFF, 0xC1,
  0xFE, 0x00, 0xF0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0x3C, 0x00, 0x01,
  0xF1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x78, 0x07, 0x80,
  0x07, 0x80, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x7C,
  0x00, 0x78, 0x07, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0xF0, 0x3E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x79, 0xF8, 0x00, 0x03, 0xDF, 0xE0,
  0x00, 0x1E, 0xEF, 0x80, 0x00, 0xFE, 0x3C, 0x00, 0x07, 0xF1, 0xF0, 0x00,
  0x3F, 0x07, 0xC0, 0x01, 0xF0, 0x1E, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x78,
  0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0xF0,
  0x0F, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x78, 0x1E,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x3C, 0x00,
  0x01, 0xF1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0xFB, 0xC0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0xE0, 0x00, 0x00, 0x03, 0xBF, 0x78,
  0x00, 0x00, 0x03, 0xFF, 0xBC, 0x00, 0x00, 0x01, 0xFF, 0xCE, 0x00, 0x00,
  0x00, 0xEF, 0xE7, 0x80, 0x00, 0x00, 0xF7, 0xF3, 0xC0, 0x00, 0x00, 0x7B,
  0xFC, 0xE0, 0x00, 0x00, 0x39, 0xFE, 0x78, 0x00, 0x00, 0x3C, 0xFF, 0x3C,
  0x00, 0x00, 0x1C, 0x7F, 0x8E, 0x00, 0x00, 0x0E, 0x3F, 0xC7, 0x80, 0x00,
  0x0F, 0x1F, 0xE3, 0xC0, 0x00, 0x07, 0x0F, 0xF0, 0xF0, 0x00, 0x03, 0x87,
  0xF8, 0x78, 0x00, 0x03, 0xC3, 0xFC, 0x1C, 0x00, 0x01, 0xC1, 0xFE, 0x0F,
  0x00, 0x01, 0xE0, 0xFF, 0x07, 0x80, 0x00, 0xF0, 0x7F, 0x81, 0xC0, 0x00,
  0x70, 0x3F, 0xC0, 0xF0, 0x00, 0x78, 0x1F, 0xE0, 0x78, 0x00, 0x3C, 0x0F,
  0xF0, 0x1C, 0x00, 0x1C, 0x07, 0xF8, 0x0F, 0x00, 0x1E, 0x03, 0xFC, 0x07,
  0x80, 0x0E, 0x01, 0xFE, 0x01, 0xC0, 0x07, 0x00, 0xFF, 0x00, 0xF0, 0x07,
  0x80, 0x7F, 0x80, 0x78, 0x03, 0x80, 0x3F, 0xC0, 0x1E, 0x03, 0xC0, 0x1F,
  0xE0, 0x0F, 0x01, 0xE0, 0x0F, 0xF0, 0x03, 0x80, 0xE0, 0x07, 0xF8, 0x01,
  0xE0, 0xF0, 0x03, 0xFC, 0x00, 0xF0, 0x78, 0x01, 0xFE, 0x00, 0x38, 0x38,
  0x00, 0xFF, 0x00, 0x1E, 0x3C, 0x00, 0x7F, 0x80, 0x0F, 0x1C, 0x00, 0x3F,
  0xC0, 0x03, 0x8E, 0x00, 0x1F, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x00,
  0xF7, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFB, 0xC0, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x07, 0xE7, 0x80, 0x00, 0x0F, 0xC7, 0x80, 0x00,
  0x1F, 0x8F, 0x00, 0x00, 0x3F, 0x0F, 0x00, 0x00, 0x7F, 0x1F, 0x00, 0x00,
  0xFE, 0x1E, 0x00, 0x01, 0xFC, 0x1E, 0x00, 0x03, 0xF8, 0x3C, 0x00, 0x07,
  0xF0, 0x3C, 0x00, 0x0F, 0xE0, 0x78, 0x00, 0x1F, 0xC0, 0x78, 0x00, 0x3F,
  0x80, 0xF8, 0x00, 0x7F, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0xF0, 0x01, 0xFC,
  0x01, 0xE0, 0x03, 0xF8, 0x01, 0xE0, 0x07, 0xF0, 0x03, 0xE0, 0x0F, 0xE0,
  0x03, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0x3F, 0x80, 0x07, 0x80, 0x7F, 0x00,
  0x07, 0x80, 0xFE, 0x00, 0x0F, 0x01, 0xFC, 0x00, 0x0F, 0x03, 0xF8, 0x00,
  0x1F, 0x07, 0xF0, 0x00, 0x1E, 0x0F, 0xE0, 0x00, 0x3E, 0x1F, 0xC0, 0x00,
  0x3C, 0x3F, 0x80, 0x00, 0x3C, 0x7F, 0x00, 0x00, 0x78, 0xFE, 0x00, 0x00,
  0x79, 0xFC, 0x00, 0x00, 0xFB, 0xF8, 0x00, 0x00, 0xF7, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x1E, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x7C,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xC0, 0x0F,
  0xF0, 0xF0, 0x00, 0x7E, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0xCF,
  0x00, 0x03, 0xE3, 0xC0, 0x03, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x78, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0E, 0x78, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x0F,
  0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0x3F, 0xE0, 0xF0, 0x00, 0x7E, 0x0F,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0xF0, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1F, 0x0F, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xC0, 0x07, 0x87, 0xC0, 0x00, 0x43, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFB, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x7E, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x78, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3C, 0x3C, 0x00,
  0x03, 0x9C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x3C, 0x1E,
  0x00, 0x07, 0x9E, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0x78,
  0x1E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0x78, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x00, 0xF0, 0x00, 0xF0, 0xF0,
  0x00, 0xF0, 0x0F, 0x00, 0x0E, 0x07, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xE0,
  0x70, 0x00, 0xF0, 0x07, 0x00, 0x1E, 0x07, 0x80, 0x0E, 0x00, 0x78, 0x01,
  0xE0, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x38, 0x01, 0xE0, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x00,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x38, 0x01, 0xC0, 0x3C,
  0x00, 0x3C, 0x03, 0x80, 0x1C, 0x03, 0xC0, 0x01, 0xC0, 0x78, 0x01, 0xE0,
  0x3C, 0x00, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x70, 0x00,
  0xE0, 0x78, 0x00, 0x1E, 0x07, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0, 0xF0,
  0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x70, 0xF0, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x0F, 0x00, 0x00,
  0x71, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x79, 0xC0, 0x00, 0x39, 0xE0, 0x00, 0x07, 0x9C, 0x00, 0x03, 0x9E,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x39, 0xE0, 0x00, 0x03, 0xBC, 0x00, 0x03,
  0xDC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0,
  0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x38, 0x1E, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0,
  0x0F, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF8,
  0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0,
  0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x3C, 0x03,
  0x80, 0x00, 0x70, 0x1E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x0F, 0x0E, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x00, 0x3F, 0x00, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xE3, 0xFC, 0x0E, 0x00, 0x7C, 0x08, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0x03, 0xFF,
  0xFF, 0x0F, 0xFC, 0x0F, 0x1F, 0x80, 0x0F, 0x3E, 0x00, 0x0F, 0x7C, 0x00,
  0x0F, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0x78, 0x00, 0x77, 0x7C, 0x01, 0xE7, 0x3F, 0xDF,
  0xC7, 0x1F, 0xFF, 0x87, 0x0F, 0xFE, 0x07, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x83, 0xFF, 0x80, 0xF1, 0xFF, 0xFC, 0x1E, 0x7F, 0xFF, 0xC3, 0xDE,
  0x00, 0xFC, 0x7B, 0x80, 0x07, 0x8F, 0xE0, 0x00, 0x79, 0xF8, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x7B, 0xF0, 0x00, 0x0F, 0x7E,
  0x00, 0x03, 0xCF, 0xE0, 0x00, 0xF9, 0xEE, 0x00, 0x3E, 0x3D, 0xE0, 0x0F,
  0x87, 0x1F, 0xFF, 0xF0, 0xE1, 0xFF, 0xF8, 0x1C, 0x0F, 0xFE, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x7E, 0x00, 0x41, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x06, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00,
  0xF4, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x07, 0xC0, 0x38, 0x07, 0xFF, 0x07, 0x03, 0xFF, 0xF8, 0xE0,
  0xFF, 0xFF, 0x9C, 0x3F, 0x00, 0x73, 0x87, 0x80, 0x07, 0x71, 0xE0, 0x00,
  0x7E, 0x7C, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x0F, 0x78,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x77, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C,
  0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x7E, 0x3E, 0x00,
  0x1D, 0xC3, 0xF0, 0x07, 0x38, 0x3F, 0xFF, 0xC7, 0x03, 0xFF, 0xF0, 0xE0,
  0x1F, 0xFC, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xE7, 0xF0, 0x07, 0xC0, 0x3E, 0x03,
  0xC0, 0x07, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x02, 0x07, 0xE0, 0x07, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0x01, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x03, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x1C, 0x0F, 0xFF, 0xE3, 0x83,
  0xFF, 0xFE, 0x70, 0xFC, 0x01, 0xEE, 0x1E, 0x00, 0x1D, 0xC7, 0x80, 0x01,
  0xF9, 0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x3D, 0xE0,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0x78, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xB8, 0xF8, 0x00,
  0x77, 0x0F, 0xC0, 0x3C, 0xE0, 0xFF, 0xFF, 0x1C, 0x0F, 0xFF, 0xC3, 0x80,
  0x7F, 0xF0, 0x70, 0x00, 0xD0, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x88, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0xF8, 0x3F, 0xE0, 0xFF, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0xFF, 0xE0, 0xF1,
  0xFF, 0xFC, 0x79, 0xFF, 0xFF, 0x3D, 0xE0, 0x0F, 0x9E, 0xE0, 0x03, 0xEF,
  0xE0, 0x00, 0xF7, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xC0, 0xF7, 0xFF,
  0xFF, 0x30, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x8F, 0xCF,
  0xF8, 0xFF, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xC0, 0xF0, 0x07,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x3C,
  0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0xF1, 0xE0, 0x00, 0xF3, 0xF0,
  0x00, 0xF3, 0xF8, 0x00, 0xF7, 0x78, 0x00, 0xFF, 0x3C, 0x00, 0xFE, 0x3E,
  0x00, 0xFC, 0x1E, 0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0xF0, 0x01,
  0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x1C, 0x1F, 0xFC, 0x01, 0xFF, 0x83, 0x87, 0xFF,
  0xC0, 0xFF, 0xFC, 0x71, 0xFF, 0xFC, 0x3F, 0xBF, 0xCF, 0x78, 0x07, 0xCF,
  0x00, 0xF9, 0xFC, 0x00, 0x7B, 0xC0, 0x0F, 0xBF, 0x00, 0x07, 0xF0, 0x00,
  0xF7, 0xE0, 0x00, 0xFC, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0x00, 0x01, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xF8, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x70, 0x3F, 0xF8, 0x38, 0x7F, 0xFF, 0x1C, 0x7F,
  0xFF, 0xCF, 0x78, 0x03, 0xE7, 0xB8, 0x00, 0xFB, 0xF8, 0x00, 0x3D, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0xF0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x3C, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x0F, 0x38, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x1C, 0x0F, 0xFE, 0x03, 0x83,
  0xFF, 0xF0, 0x71, 0xFF, 0xFF, 0x0F, 0x38, 0x03, 0xF1, 0xEE, 0x00, 0x1E,
  0x3F, 0x80, 0x01, 0xE7, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xDF, 0x00,
  0x00, 0x7B, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x7C,
  0x00, 0x01, 0xEF, 0xC0, 0x00, 0x3D, 0xF8, 0x00, 0x0F, 0x3F, 0x80, 0x03,
  0xE7, 0xB8, 0x00, 0xF8, 0xF3, 0xC0, 0x3E, 0x1E, 0x7F, 0xFF, 0xC3, 0xC7,
  0xFF, 0xE0, 0x78, 0x3F, 0xF8, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x1C, 0x0F, 0xFF, 0xE3, 0x83, 0xFF,
  0xFE, 0x70, 0xFC, 0x01, 0xCE, 0x1E, 0x00, 0x1D, 0xC7, 0x80, 0x01, 0xF9,
  0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x3D, 0xE0, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x3E, 0x78, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xB8, 0xF8, 0x00, 0x77,
  0x0F, 0x80, 0x3C, 0xE0, 0xFF, 0xFF, 0x1C, 0x0F, 0xFF, 0xC3, 0x80, 0x7F,
  0xE0, 0x70, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x70, 0x3F,
  0xF8, 0x7F, 0xFC, 0x7F, 0xFF, 0x3C, 0x07, 0xB8, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0x8F, 0xF1, 0xFE,
  0x7C, 0x00, 0x31, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0xA0, 0x00, 0x3E, 0xF0, 0x01, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0x3F, 0xE0, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xF7, 0x80, 0x01, 0xFB,
  0xC0, 0x01, 0xDD, 0xF0, 0x01, 0xEE, 0x7C, 0x01, 0xE7, 0x1F, 0xFF, 0xE3,
  0x87, 0xFF, 0xE1, 0xC1, 0xFF, 0xC0, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF7, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C,
  0x38, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0E, 0x00, 0x70, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x03, 0x80, 0x3C, 0x00, 0x3C, 0x03,
  0xC0, 0x03, 0xC0, 0x38, 0x00, 0x1C, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0x9C, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x7B,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x38, 0x00, 0x1F, 0x80, 0x01, 0xE7, 0x80,
  0x03, 0xF8, 0x00, 0x38, 0xF0, 0x00, 0x77, 0x00, 0x0F, 0x0E, 0x00, 0x0E,
  0xE0, 0x01, 0xE1, 0xC0, 0x03, 0xDC, 0x00, 0x3C, 0x3C, 0x00, 0x73, 0xC0,
  0x07, 0x07, 0x80, 0x0E, 0x38, 0x01, 0xE0, 0x70, 0x03, 0xC7, 0x00, 0x3C,
  0x0E, 0x00, 0x78, 0xF0, 0x07, 0x81, 0xE0, 0x0E, 0x1E, 0x00, 0xE0, 0x3C,
  0x01, 0xC1, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x38, 0x07, 0x80, 0x70, 0x0E,
  0x07, 0x80, 0xF0, 0x0F, 0x01, 0xC0, 0xF0, 0x1C, 0x01, 0xE0, 0x78, 0x0E,
  0x07, 0x80, 0x1C, 0x0F, 0x01, 0xC0, 0xF0, 0x03, 0xC1, 0xC0, 0x3C, 0x1E,
  0x00, 0x78, 0x38, 0x03, 0x83, 0x80, 0x0F, 0x0F, 0x00, 0x70, 0xF0, 0x00,
  0xE1, 0xC0, 0x0F, 0x1E, 0x00, 0x1C, 0x38, 0x01, 0xE3, 0xC0, 0x03, 0xCF,
  0x00, 0x1C, 0x70, 0x00, 0x79, 0xE0, 0x03, 0x8E, 0x00, 0x07, 0x38, 0x00,
  0x7B, 0xC0, 0x00, 0xE7, 0x00, 0x0F, 0x70, 0x00, 0x1E, 0xE0, 0x00, 0xEE,
  0x00, 0x03, 0xF8, 0x00, 0x1D, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x01,
  0xE0, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x78, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x3C, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x78,
  0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x01, 0xE0,
  0x1E, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x3C, 0x3C, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1E, 0x3C,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x78, 0x1E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0xF0, 0x07, 0x00, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x38, 0x01, 0xE0, 0x03, 0xC0, 0x1C, 0x00, 0x3C, 0x03, 0xC0,
  0x01, 0xC0, 0x3C, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x03, 0x9E, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x0C, 0x7E, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xE0,
  0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x7F, 0x80, 0x0F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x07, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03,
  0xE0, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x20, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x13, 0xFF, 0x80, 0x01, 0x7F, 0xFE, 0x00, 0x3F, 0xC7, 0xFC,
  0x0F, 0xE0, 0x0F, 0xFF, 0xEC, 0x00, 0x3F, 0xFC, 0x80, 0x00, 0xFF, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Light66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 6, 48, 15, 5, -47 },
  { 37, 15, 17, 23, 4, -47 },
  { 69, 34, 47, 38, 2, -47 },
  { 269, 27, 54, 34, 3, -50 },
  { 452, 43, 49, 49, 3, -48 },
  { 716, 37, 49, 40, 3, -48 },
  { 943, 4, 17, 13, 4, -47 },
  { 952, 13, 57, 18, 3, -47 },
  { 1045, 13, 57, 18, 2, -47 },
  { 1138, 26, 25, 32, 3, -50 },
  { 1220, 28, 31, 34, 3, -39 },
  { 1329, 7, 16, 14, 3, -7 },
  { 1343, 16, 4, 20, 2, -20 },
  { 1351, 5, 7, 15, 5, -6 },
  { 1356, 21, 47, 23, 1, -47 },
  { 1480, 27, 49, 34, 3, -48 },
  { 1646, 15, 47, 34, 6, -47 },
  { 1735, 27, 48, 34, 3, -48 },
  { 1897, 27, 49, 34, 3, -48 },
  { 2063, 32, 47, 34, 1, -47 },
  { 2251, 26, 48, 34, 4, -47 },
  { 2407, 27, 49, 34, 4, -48 },
  { 2573, 27, 47, 34, 3, -47 },
  { 2732, 28, 49, 34, 3, -48 },
  { 2904, 27, 49, 34, 3, -48 },
  { 3070, 5, 37, 15, 5, -36 },
  { 3094, 8, 45, 15, 2, -36 },
  { 3139, 28, 30, 34, 3, -39 },
  { 3244, 28, 17, 34, 3, -32 },
  { 3304, 28, 30, 34, 3, -39 },
  { 3409, 22, 49, 25, 1, -48 },
  { 3544, 45, 53, 52, 4, -47 },
  { 3843, 35, 47, 35, 0, -47 },
  { 4049, 28, 47, 37, 6, -47 },
  { 4214, 31, 49, 36, 4, -48 },
  { 4404, 32, 47, 42, 6, -47 },
  { 4592, 23, 47, 33, 6, -47 },
  { 4728, 23, 47, 30, 6, -47 },
  { 4864, 35, 49, 43, 4, -48 },
  { 5079, 31, 47, 43, 6, -47 },
  { 5262, 13, 47, 19, 3, -47 },
  { 5339, 15, 59, 16, -5, -47 },
  { 5450, 29, 47, 35, 6, -47 },
  { 5621, 23, 47, 30, 6, -47 },
  { 5757, 41, 47, 53, 6, -47 },
  { 5998, 31, 47, 43, 6, -47 },
  { 6181, 37, 49, 45, 4, -48 },
  { 6408, 26, 47, 35, 6, -47 },
  { 6561, 37, 59, 45, 4, -48 },
  { 6834, 28, 47, 36, 6, -47 },
  { 6999, 26, 49, 33, 3, -48 },
  { 7159, 30, 47, 31, 0, -47 },
  { 7336, 31, 48, 42, 6, -47 },
  { 7522, 34, 47, 34, 0, -47 },
  { 7722, 52, 47, 54, 1, -47 },
  { 8028, 32, 47, 32, 0, -47 },
  { 8216, 31, 47, 31, 0, -47 },
  { 8399, 28, 47, 32, 2, -47 },
  { 8564, 14, 58, 21, 5, -47 },
  { 8666, 21, 47, 23, 1, -47 },
  { 8790, 14, 58, 21, 2, -47 },
  { 8892, 30, 27, 34, 2, -47 },
  { 8994, 28, 3, 27, 0, 6 },
  { 9005, 11, 10, 17, 3, -50 },
  { 9019, 24, 37, 32, 3, -36 },
  { 9130, 27, 51, 36, 5, -50 },
  { 9303, 23, 37, 28, 3, -36 },
  { 9410, 27, 51, 36, 3, -50 },
  { 9583, 26, 37, 33, 3, -36 },
  { 9704, 20, 50, 19, 1, -50 },
  { 9829, 27, 52, 36, 3, -36 },
  { 10005, 25, 50, 35, 5, -50 },
  { 10162, 5, 48, 14, 5, -48 },
  { 10192, 12, 64, 14, -2, -48 },
  { 10288, 24, 50, 29, 5, -50 },
  { 10438, 4, 50, 14, 5, -50 },
  { 10463, 43, 36, 53, 5, -36 },
  { 10657, 25, 36, 35, 5, -36 },
  { 10770, 28, 37, 35, 3, -36 },
  { 10900, 27, 52, 36, 5, -36 },
  { 11076, 27, 52, 36, 3, -36 },
  { 11252, 17, 36, 23, 5, -36 },
  { 11329, 22, 37, 27, 3, -36 },
  { 11431, 17, 44, 20, 1, -43 },
  { 11525, 25, 36, 35, 5, -35 },
  { 11638, 28, 35, 28, 0, -35 },
  { 11761, 43, 35, 44, 1, -35 },
  { 11950, 27, 35, 29, 1, -35 },
  { 12069, 28, 51, 28, 0, -35 },
  { 12248, 22, 35, 26, 2, -35 },
  { 12345, 19, 58, 24, 2, -47 },
  { 12483, 4, 66, 32, 14, -50 },
  { 12516, 18, 58, 24, 3, -47 },
  { 12647, 28, 7, 34, 3, -27 },
};

const GFXfont NotoSans_SemiCondensed_Light66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light66pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT66PT7B_H_
