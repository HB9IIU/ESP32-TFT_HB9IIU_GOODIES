#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &NotoSans_SemiCondensed_Light6pt7b, 6, "NotoSans_SemiCondensed_Light6pt7b" },
  { &NotoSans_SemiCondensed_Light7pt7b, 7, "NotoSans_SemiCondensed_Light7pt7b" },
  { &NotoSans_SemiCondensed_Light8pt7b, 8, "NotoSans_SemiCondensed_Light8pt7b" },
  { &NotoSans_SemiCondensed_Light9pt7b, 9, "NotoSans_SemiCondensed_Light9pt7b" },
  { &NotoSans_SemiCondensed_Light10pt7b, 10, "NotoSans_SemiCondensed_Light10pt7b" },
  { &NotoSans_SemiCondensed_Light11pt7b, 11, "NotoSans_SemiCondensed_Light11pt7b" },
  { &NotoSans_SemiCondensed_Light12pt7b, 12, "NotoSans_SemiCondensed_Light12pt7b" },
  { &NotoSans_SemiCondensed_Light13pt7b, 13, "NotoSans_SemiCondensed_Light13pt7b" },
  { &NotoSans_SemiCondensed_Light14pt7b, 14, "NotoSans_SemiCondensed_Light14pt7b" },
  { &NotoSans_SemiCondensed_Light15pt7b, 15, "NotoSans_SemiCondensed_Light15pt7b" },
  { &NotoSans_SemiCondensed_Light16pt7b, 16, "NotoSans_SemiCondensed_Light16pt7b" },
  { &NotoSans_SemiCondensed_Light17pt7b, 17, "NotoSans_SemiCondensed_Light17pt7b" },
  { &NotoSans_SemiCondensed_Light18pt7b, 18, "NotoSans_SemiCondensed_Light18pt7b" },
  { &NotoSans_SemiCondensed_Light19pt7b, 19, "NotoSans_SemiCondensed_Light19pt7b" },
  { &NotoSans_SemiCondensed_Light20pt7b, 20, "NotoSans_SemiCondensed_Light20pt7b" },
  { &NotoSans_SemiCondensed_Light21pt7b, 21, "NotoSans_SemiCondensed_Light21pt7b" },
  { &NotoSans_SemiCondensed_Light22pt7b, 22, "NotoSans_SemiCondensed_Light22pt7b" },
  { &NotoSans_SemiCondensed_Light23pt7b, 23, "NotoSans_SemiCondensed_Light23pt7b" },
  { &NotoSans_SemiCondensed_Light24pt7b, 24, "NotoSans_SemiCondensed_Light24pt7b" },
  { &NotoSans_SemiCondensed_Light25pt7b, 25, "NotoSans_SemiCondensed_Light25pt7b" },
  { &NotoSans_SemiCondensed_Light26pt7b, 26, "NotoSans_SemiCondensed_Light26pt7b" },
  { &NotoSans_SemiCondensed_Light27pt7b, 27, "NotoSans_SemiCondensed_Light27pt7b" },
  { &NotoSans_SemiCondensed_Light28pt7b, 28, "NotoSans_SemiCondensed_Light28pt7b" },
  { &NotoSans_SemiCondensed_Light29pt7b, 29, "NotoSans_SemiCondensed_Light29pt7b" },
  { &NotoSans_SemiCondensed_Light30pt7b, 30, "NotoSans_SemiCondensed_Light30pt7b" },
  { &NotoSans_SemiCondensed_Light31pt7b, 31, "NotoSans_SemiCondensed_Light31pt7b" },
  { &NotoSans_SemiCondensed_Light32pt7b, 32, "NotoSans_SemiCondensed_Light32pt7b" },
  { &NotoSans_SemiCondensed_Light33pt7b, 33, "NotoSans_SemiCondensed_Light33pt7b" },
  { &NotoSans_SemiCondensed_Light34pt7b, 34, "NotoSans_SemiCondensed_Light34pt7b" },
  { &NotoSans_SemiCondensed_Light35pt7b, 35, "NotoSans_SemiCondensed_Light35pt7b" },
  { &NotoSans_SemiCondensed_Light36pt7b, 36, "NotoSans_SemiCondensed_Light36pt7b" },
  { &NotoSans_SemiCondensed_Light37pt7b, 37, "NotoSans_SemiCondensed_Light37pt7b" },
  { &NotoSans_SemiCondensed_Light38pt7b, 38, "NotoSans_SemiCondensed_Light38pt7b" },
  { &NotoSans_SemiCondensed_Light39pt7b, 39, "NotoSans_SemiCondensed_Light39pt7b" },
  { &NotoSans_SemiCondensed_Light40pt7b, 40, "NotoSans_SemiCondensed_Light40pt7b" },
  { &NotoSans_SemiCondensed_Light41pt7b, 41, "NotoSans_SemiCondensed_Light41pt7b" },
  { &NotoSans_SemiCondensed_Light42pt7b, 42, "NotoSans_SemiCondensed_Light42pt7b" },
  { &NotoSans_SemiCondensed_Light43pt7b, 43, "NotoSans_SemiCondensed_Light43pt7b" },
  { &NotoSans_SemiCondensed_Light44pt7b, 44, "NotoSans_SemiCondensed_Light44pt7b" },
  { &NotoSans_SemiCondensed_Light45pt7b, 45, "NotoSans_SemiCondensed_Light45pt7b" },
  { &NotoSans_SemiCondensed_Light46pt7b, 46, "NotoSans_SemiCondensed_Light46pt7b" },
  { &NotoSans_SemiCondensed_Light47pt7b, 47, "NotoSans_SemiCondensed_Light47pt7b" },
  { &NotoSans_SemiCondensed_Light48pt7b, 48, "NotoSans_SemiCondensed_Light48pt7b" },
  { &NotoSans_SemiCondensed_Light49pt7b, 49, "NotoSans_SemiCondensed_Light49pt7b" },
  { &NotoSans_SemiCondensed_Light50pt7b, 50, "NotoSans_SemiCondensed_Light50pt7b" },
  { &NotoSans_SemiCondensed_Light51pt7b, 51, "NotoSans_SemiCondensed_Light51pt7b" },
  { &NotoSans_SemiCondensed_Light52pt7b, 52, "NotoSans_SemiCondensed_Light52pt7b" },
  { &NotoSans_SemiCondensed_Light53pt7b, 53, "NotoSans_SemiCondensed_Light53pt7b" },
  { &NotoSans_SemiCondensed_Light54pt7b, 54, "NotoSans_SemiCondensed_Light54pt7b" },
  { &NotoSans_SemiCondensed_Light55pt7b, 55, "NotoSans_SemiCondensed_Light55pt7b" },
  { &NotoSans_SemiCondensed_Light56pt7b, 56, "NotoSans_SemiCondensed_Light56pt7b" },
  { &NotoSans_SemiCondensed_Light57pt7b, 57, "NotoSans_SemiCondensed_Light57pt7b" },
  { &NotoSans_SemiCondensed_Light58pt7b, 58, "NotoSans_SemiCondensed_Light58pt7b" },
  { &NotoSans_SemiCondensed_Light59pt7b, 59, "NotoSans_SemiCondensed_Light59pt7b" },
  { &NotoSans_SemiCondensed_Light60pt7b, 60, "NotoSans_SemiCondensed_Light60pt7b" },
  { &NotoSans_SemiCondensed_Light61pt7b, 61, "NotoSans_SemiCondensed_Light61pt7b" },
  { &NotoSans_SemiCondensed_Light62pt7b, 62, "NotoSans_SemiCondensed_Light62pt7b" },
  { &NotoSans_SemiCondensed_Light63pt7b, 63, "NotoSans_SemiCondensed_Light63pt7b" },
  { &NotoSans_SemiCondensed_Light64pt7b, 64, "NotoSans_SemiCondensed_Light64pt7b" },
  { &NotoSans_SemiCondensed_Light65pt7b, 65, "NotoSans_SemiCondensed_Light65pt7b" },
  { &NotoSans_SemiCondensed_Light66pt7b, 66, "NotoSans_SemiCondensed_Light66pt7b" },
  { &NotoSans_SemiCondensed_Light67pt7b, 67, "NotoSans_SemiCondensed_Light67pt7b" },
  { &NotoSans_SemiCondensed_Light68pt7b, 68, "NotoSans_SemiCondensed_Light68pt7b" },
  { &NotoSans_SemiCondensed_Light69pt7b, 69, "NotoSans_SemiCondensed_Light69pt7b" },
  { &NotoSans_SemiCondensed_Light70pt7b, 70, "NotoSans_SemiCondensed_Light70pt7b" },
  { &NotoSans_SemiCondensed_Light71pt7b, 71, "NotoSans_SemiCondensed_Light71pt7b" },
  { &NotoSans_SemiCondensed_Light72pt7b, 72, "NotoSans_SemiCondensed_Light72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
