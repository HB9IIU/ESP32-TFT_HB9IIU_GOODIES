#ifndef _NOTOSANS_SEMICONDENSED_LIGHT30PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light30pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0x24, 0x92, 0x49, 0x24, 0x90, 0x01, 0x7E, 0xC7, 0x8F, 0x1E,
  0x2C, 0x58, 0xB1, 0x00, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x40, 0x20, 0x80,
  0x41, 0x00, 0x82, 0x1F, 0xFF, 0x86, 0x18, 0x0C, 0x20, 0x10, 0x40, 0x20,
  0x80, 0x41, 0x00, 0x86, 0x1F, 0xFF, 0x86, 0x18, 0x08, 0x20, 0x10, 0x40,
  0x20, 0x80, 0x43, 0x01, 0x86, 0x03, 0x0C, 0x00, 0x04, 0x00, 0x40, 0x0E,
  0x07, 0xFE, 0xE4, 0x4C, 0x40, 0x84, 0x08, 0x40, 0x84, 0x0C, 0x40, 0x74,
  0x03, 0xC0, 0x0F, 0x00, 0x5C, 0x04, 0x60, 0x42, 0x04, 0x30, 0x42, 0x04,
  0x28, 0x46, 0xF7, 0xC7, 0xF0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x08, 0x00,
  0x03, 0xE0, 0x30, 0x63, 0x02, 0x04, 0x30, 0x60, 0x41, 0x04, 0x04, 0x10,
  0xC0, 0xC1, 0x08, 0x0C, 0x11, 0x80, 0x41, 0x10, 0x04, 0x13, 0x3C, 0x43,
  0x26, 0x66, 0x36, 0x42, 0x3E, 0x4C, 0x20, 0x8C, 0xC3, 0x00, 0x88, 0x30,
  0x18, 0x83, 0x01, 0x08, 0x30, 0x30, 0xC3, 0x02, 0x0C, 0x20, 0x60, 0xC2,
  0x06, 0x06, 0x60, 0xC0, 0x3C, 0x07, 0x80, 0x07, 0xE0, 0x06, 0x18, 0x06,
  0x0C, 0x03, 0x02, 0x01, 0x83, 0x00, 0x41, 0x80, 0x30, 0x80, 0x0C, 0xC0,
  0x07, 0xC0, 0x03, 0x80, 0x03, 0xE0, 0x03, 0x18, 0x33, 0x06, 0x19, 0x81,
  0x8D, 0x80, 0xCC, 0xC0, 0x36, 0x60, 0x0E, 0x18, 0x07, 0x0C, 0x06, 0xC3,
  0x8E, 0x30, 0xFE, 0x1C, 0xFF, 0xFC, 0x0C, 0x61, 0x0C, 0x31, 0x86, 0x18,
  0x41, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x41, 0x86, 0x18, 0x20, 0xC1, 0x06,
  0x08, 0x30, 0xC1, 0x83, 0x0C, 0x18, 0x61, 0x82, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0x86, 0x18, 0xC3, 0x08, 0x63, 0x00, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x20, 0x62, 0x3F, 0xFF, 0x06, 0x00, 0xF0, 0x09, 0x81,
  0x8C, 0x30, 0xC1, 0x08, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x1F, 0xFF, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x36, 0x66, 0x44, 0xC0, 0xFF, 0xFC, 0x5F, 0x80, 0x00,
  0xC0, 0x20, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x00,
  0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80,
  0xC0, 0x00, 0x0E, 0x03, 0xF8, 0x60, 0xC6, 0x06, 0xC0, 0x6C, 0x02, 0xC0,
  0x28, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x3C, 0x03, 0xC0, 0x2C, 0x06, 0x40, 0x66, 0x0C, 0x31, 0xC1, 0xF8, 0x0C,
  0x77, 0x71, 0x84, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x07, 0x01, 0xFE, 0x18, 0x18, 0x80, 0x40, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x07,
  0xFF, 0xFF, 0xFC, 0x0F, 0x01, 0xFE, 0x38, 0x18, 0x80, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x07, 0xE0, 0x3F, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x6E,
  0x0E, 0x3F, 0xC0, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x03, 0x60,
  0x09, 0x80, 0x66, 0x01, 0x18, 0x0C, 0x60, 0x61, 0x81, 0x06, 0x0C, 0x18,
  0x60, 0x61, 0x01, 0x8C, 0x06, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x7F, 0xC6, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xFF, 0x0F, 0xFC, 0x00, 0xE0, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0xEC, 0x1C,
  0xFF, 0x00, 0x03, 0xC0, 0xFE, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x09, 0xF8, 0xB0, 0xCE, 0x06, 0xC0, 0x3C, 0x03, 0x80,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x40, 0x26, 0x06, 0x30, 0xC1, 0xF8, 0xFF,
  0xF8, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x00, 0x07, 0x80,
  0xFF, 0x0C, 0x1C, 0xC0, 0x66, 0x03, 0x30, 0x09, 0x80, 0xC4, 0x06, 0x30,
  0x60, 0xEE, 0x01, 0xC0, 0x1F, 0x83, 0x8E, 0x30, 0x19, 0x80, 0x48, 0x03,
  0xC0, 0x1A, 0x00, 0xD0, 0x06, 0xC0, 0x63, 0x86, 0x0F, 0xE0, 0x07, 0x00,
  0xFE, 0x0C, 0x18, 0xC0, 0x46, 0x03, 0x20, 0x1B, 0x00, 0x58, 0x03, 0xC0,
  0x1A, 0x00, 0xD8, 0x0E, 0xE0, 0xF3, 0xFD, 0x87, 0x88, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x84, 0x18, 0x1F, 0x80, 0xFD, 0x00,
  0x00, 0x00, 0x00, 0xBF, 0x77, 0x20, 0x00, 0x00, 0x00, 0x00, 0x07, 0x66,
  0x64, 0xCC, 0x00, 0x08, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x04, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0x00, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x00, 0x40, 0x00,
  0x3C, 0x7F, 0xA0, 0xE0, 0x30, 0x08, 0x04, 0x02, 0x03, 0x01, 0x81, 0x81,
  0x81, 0x81, 0x80, 0x80, 0x40, 0x20, 0x00, 0x00, 0x00, 0x02, 0x03, 0x81,
  0xC0, 0x03, 0xFE, 0x00, 0xE0, 0x30, 0x18, 0x00, 0xC3, 0x00, 0x04, 0x20,
  0x00, 0x66, 0x00, 0x02, 0x40, 0xFC, 0x3C, 0x10, 0x43, 0x83, 0x04, 0x18,
  0x60, 0x41, 0x86, 0x04, 0x18, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x60, 0xC3,
  0x86, 0x0C, 0x38, 0x21, 0xC2, 0xC3, 0xF7, 0xCC, 0x0C, 0x18, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x20, 0x0F, 0xFE, 0x00, 0x1F,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x02, 0x40, 0x02, 0x60, 0x06,
  0x60, 0x06, 0x20, 0x04, 0x30, 0x0C, 0x30, 0x0C, 0x10, 0x08, 0x18, 0x18,
  0x18, 0x1F, 0xF8, 0x1F, 0xFC, 0x30, 0x0C, 0x30, 0x0C, 0x20, 0x06, 0x60,
  0x06, 0x60, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xC4, 0x07, 0x20, 0x1D,
  0x00, 0x68, 0x03, 0x40, 0x1A, 0x00, 0xD0, 0x0C, 0x80, 0xE7, 0xFC, 0x3F,
  0xF1, 0x00, 0xC8, 0x03, 0x40, 0x0A, 0x00, 0x50, 0x03, 0x80, 0x34, 0x01,
  0xA0, 0x1D, 0xFF, 0xCF, 0xF8, 0x00, 0x01, 0xE0, 0x3F, 0xF1, 0xC0, 0x8C,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x18, 0x1F, 0xE0, 0xFF, 0xC2, 0x07,
  0x88, 0x03, 0x20, 0x06, 0x80, 0x1A, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x06, 0x80, 0x1A, 0x00, 0xC8, 0x07, 0x3F, 0xF0, 0xFF, 0x00, 0xFF, 0xE0,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x0F, 0xFF, 0xFF, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x00, 0x00, 0xF0, 0x07, 0xFE, 0x1C, 0x06, 0x38, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x40, 0x03, 0x60, 0x03, 0x30, 0x03, 0x38, 0x03, 0x1E, 0x0F, 0x07, 0xFC,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0xFC, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x43, 0x1F,
  0xE0, 0x80, 0x34, 0x03, 0x20, 0x31, 0x03, 0x08, 0x30, 0x41, 0x82, 0x18,
  0x11, 0x80, 0x98, 0x05, 0xC0, 0x2B, 0x01, 0x8C, 0x08, 0x60, 0x41, 0x82,
  0x06, 0x10, 0x30, 0x80, 0xC4, 0x07, 0x20, 0x19, 0x00, 0x68, 0x03, 0x80,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03,
  0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0xF8, 0x00, 0x7A, 0x00, 0x16, 0xC0, 0x0D,
  0xB0, 0x03, 0x64, 0x00, 0x99, 0x80, 0x66, 0x60, 0x19, 0x88, 0x04, 0x63,
  0x03, 0x18, 0xC0, 0xC6, 0x18, 0x21, 0x86, 0x18, 0x60, 0x84, 0x18, 0x33,
  0x06, 0x0C, 0xC1, 0x81, 0x20, 0x60, 0x78, 0x18, 0x1E, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x40, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xEC, 0x03, 0x98, 0x0E,
  0x60, 0x38, 0xC0, 0xE3, 0x03, 0x86, 0x0E, 0x18, 0x38, 0x30, 0xE0, 0x63,
  0x81, 0x8E, 0x03, 0x38, 0x0C, 0xE0, 0x1B, 0x80, 0x2E, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0x80, 0x0C, 0x03, 0xC0, 0x07, 0xFC, 0x0E, 0x07, 0x06, 0x00,
  0xC6, 0x00, 0x63, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x01, 0x60,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x05,
  0x80, 0x06, 0xC0, 0x03, 0x30, 0x01, 0x98, 0x01, 0x86, 0x01, 0x81, 0xC3,
  0x80, 0x7F, 0x80, 0xFF, 0x90, 0x3A, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x80, 0x70, 0x1A, 0x1F, 0x7F, 0x88, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x03, 0xC0, 0x07, 0xFC,
  0x06, 0x07, 0x06, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x1B, 0x00, 0x0D, 0x80,
  0x06, 0xC0, 0x01, 0x60, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x05, 0x80, 0x06, 0xC0, 0x03, 0x30, 0x01, 0x98, 0x01,
  0x86, 0x01, 0x81, 0xC3, 0x80, 0x7F, 0x80, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0xFF, 0x84, 0x0E, 0x20, 0x19, 0x00,
  0xC8, 0x02, 0x40, 0x12, 0x00, 0x90, 0x0C, 0x80, 0x64, 0x06, 0x3F, 0xE1,
  0xFC, 0x08, 0x30, 0x40, 0x82, 0x06, 0x10, 0x18, 0x80, 0xC4, 0x03, 0x20,
  0x19, 0x00, 0x68, 0x03, 0x80, 0x07, 0x81, 0xFF, 0x30, 0x16, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x07, 0xF1,
  0xE7, 0xF8, 0xFF, 0xFC, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0B, 0x00, 0x66, 0x03,
  0x9E, 0x1C, 0x1F, 0xC0, 0xC0, 0x06, 0x80, 0x0D, 0x80, 0x1B, 0x00, 0x62,
  0x00, 0xC6, 0x01, 0x8C, 0x06, 0x08, 0x0C, 0x18, 0x18, 0x30, 0x20, 0x60,
  0xC0, 0x61, 0x80, 0xC2, 0x01, 0x8C, 0x01, 0x18, 0x03, 0x20, 0x06, 0xC0,
  0x05, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0xC0, 0x18, 0x03, 0x60,
  0x1C, 0x03, 0x60, 0x1C, 0x02, 0x60, 0x34, 0x06, 0x20, 0x34, 0x06, 0x30,
  0x26, 0x06, 0x30, 0x26, 0x04, 0x30, 0x62, 0x0C, 0x10, 0x62, 0x0C, 0x18,
  0x63, 0x0C, 0x18, 0x43, 0x08, 0x18, 0xC1, 0x18, 0x08, 0xC1, 0x18, 0x0C,
  0xC1, 0x98, 0x0C, 0x81, 0x90, 0x0D, 0x80, 0xB0, 0x05, 0x80, 0xB0, 0x05,
  0x80, 0xF0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x60, 0x03, 0x00, 0x60, 0x60,
  0x0C, 0xC0, 0x63, 0x01, 0x06, 0x0C, 0x18, 0x60, 0x31, 0x80, 0xCC, 0x01,
  0xB0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x06, 0xC0, 0x33, 0x00,
  0xC6, 0x06, 0x08, 0x10, 0x30, 0xC0, 0x46, 0x01, 0x98, 0x03, 0xC0, 0x0C,
  0xC0, 0x0D, 0x80, 0x66, 0x01, 0x8C, 0x0C, 0x30, 0x30, 0x61, 0x81, 0x86,
  0x03, 0x10, 0x0C, 0xC0, 0x12, 0x00, 0x78, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFF, 0xFC, 0xC0,
  0x18, 0x02, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60, 0x08, 0x03, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x02,
  0x00, 0xC0, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xF0, 0x02, 0x00,
  0x18, 0x01, 0xC0, 0x0B, 0x00, 0xC8, 0x04, 0x60, 0x61, 0x02, 0x0C, 0x30,
  0x21, 0x01, 0x98, 0x04, 0x80, 0x3C, 0x00, 0x80, 0xFF, 0xF8, 0xC1, 0x83,
  0x06, 0x0C, 0x1F, 0x86, 0x18, 0x01, 0x80, 0x30, 0x02, 0x00, 0x40, 0x08,
  0xFF, 0x38, 0x2C, 0x07, 0x01, 0xE0, 0x3C, 0x06, 0x81, 0xD8, 0x69, 0xF9,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x19,
  0xF8, 0xD8, 0xE7, 0x01, 0xB8, 0x0D, 0x80, 0x2C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x05, 0xC0, 0x6E, 0x03, 0x6C, 0x73,
  0x3F, 0x00, 0x1F, 0xCE, 0x36, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x0C, 0x7F, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x31, 0xF3, 0x79, 0xB6,
  0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0xC0, 0x3C, 0x03, 0x60, 0x77, 0x1B, 0x3F, 0x30, 0x1F, 0x86, 0x39,
  0x83, 0x60, 0x3C, 0x07, 0x00, 0x60, 0x0F, 0xFF, 0x80, 0x10, 0x02, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x0E, 0x18, 0xFE, 0x07, 0xC3, 0xE1, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x83, 0xFC, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x1F, 0x37, 0x1F, 0x60, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x76, 0x07, 0x71, 0xB3, 0xF3,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x6E, 0x1C, 0x7F, 0x80, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0xFC, 0xD8,
  0xEE, 0x06, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x30, 0xF4, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0xC2, 0x00, 0x00, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC7, 0x7F, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x03, 0xC0, 0xD8,
  0x33, 0x0C, 0x63, 0x0C, 0xC1, 0x98, 0x37, 0x07, 0xB0, 0xE6, 0x18, 0x63,
  0x04, 0x60, 0xCC, 0x0D, 0x81, 0xB0, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xCF, 0x8F, 0xCD, 0x9D, 0x8E, 0xE0, 0x50, 0x6E, 0x06, 0x03, 0xC0,
  0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C,
  0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03,
  0xC0, 0x60, 0x3C, 0x06, 0x03, 0xCF, 0xCD, 0x8E, 0xE0, 0x6E, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x1F, 0x83, 0x8C, 0x60, 0x6C, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x3C, 0x03, 0xC0,
  0x36, 0x06, 0x30, 0xC1, 0xF8, 0xCF, 0xC6, 0xC7, 0x3C, 0x0D, 0xC0, 0x6C,
  0x01, 0x60, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x2E, 0x03, 0x70, 0x3B, 0x63, 0x99, 0xF8, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x1F, 0x37, 0x1B, 0x60, 0x7C,
  0x07, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3C,
  0x03, 0xC0, 0x76, 0x07, 0x71, 0xB3, 0xF3, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0xCF, 0xDD, 0xF0, 0xE0, 0xE0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3F, 0xDC,
  0x34, 0x03, 0x00, 0xC0, 0x18, 0x07, 0x00, 0x78, 0x07, 0x00, 0x70, 0x0C,
  0x01, 0x00, 0x40, 0x3C, 0x19, 0xFC, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x10,
  0x19, 0x0F, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x76, 0x07, 0x71,
  0xB3, 0xF3, 0xC0, 0x1A, 0x01, 0x98, 0x0C, 0xC0, 0x42, 0x06, 0x18, 0x30,
  0xC1, 0x02, 0x18, 0x18, 0xC0, 0xC4, 0x02, 0x60, 0x13, 0x00, 0xD0, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0xC0, 0x60, 0x34, 0x06, 0x02, 0x60, 0x70, 0x66,
  0x0F, 0x06, 0x20, 0xD0, 0x62, 0x09, 0x84, 0x31, 0x98, 0xC3, 0x18, 0x8C,
  0x11, 0x08, 0xC1, 0x10, 0xC8, 0x1B, 0x0D, 0x81, 0xB0, 0x58, 0x0A, 0x05,
  0x80, 0xA0, 0x70, 0x0E, 0x07, 0x00, 0xC0, 0x30, 0xC0, 0x66, 0x06, 0x60,
  0xC3, 0x18, 0x11, 0x81, 0xB0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xB0, 0x19,
  0x03, 0x18, 0x30, 0xC6, 0x0C, 0x40, 0x6C, 0x03, 0xC0, 0x1A, 0x01, 0x98,
  0x0C, 0xC0, 0x42, 0x06, 0x18, 0x30, 0xC1, 0x02, 0x18, 0x18, 0xC0, 0xC4,
  0x02, 0x60, 0x1B, 0x00, 0xD0, 0x02, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x03, 0xC0, 0x00, 0x7F, 0xC0,
  0x30, 0x18, 0x04, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x00,
  0xC0, 0x60, 0x18, 0x0C, 0x03, 0xFF, 0x07, 0x86, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x0E, 0x03, 0x80, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x0F, 0x80, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x1C, 0x06, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x03, 0x01, 0xC0, 0x38, 0x38, 0x30, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0xF0, 0x60, 0x00, 0x7E, 0x0F,
  0x3D, 0xE0, 0x7C,
};

const GFXglyph NotoSans_SemiCondensed_Light30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 21, 7, 2, -21 },
  { 9, 7, 7, 11, 2, -21 },
  { 16, 15, 21, 17, 1, -21 },
  { 56, 12, 25, 15, 2, -23 },
  { 94, 20, 22, 22, 1, -22 },
  { 149, 17, 22, 18, 1, -22 },
  { 196, 2, 7, 6, 2, -21 },
  { 198, 6, 26, 8, 1, -21 },
  { 218, 6, 26, 8, 1, -21 },
  { 238, 12, 12, 15, 1, -23 },
  { 256, 13, 14, 15, 1, -18 },
  { 279, 4, 7, 7, 1, -3 },
  { 283, 7, 2, 9, 1, -9 },
  { 285, 3, 3, 7, 2, -3 },
  { 287, 10, 21, 10, 0, -21 },
  { 314, 12, 22, 15, 2, -22 },
  { 347, 6, 21, 15, 3, -21 },
  { 363, 13, 22, 15, 1, -22 },
  { 399, 13, 22, 15, 1, -22 },
  { 435, 14, 22, 15, 1, -22 },
  { 474, 12, 21, 15, 2, -21 },
  { 506, 12, 22, 15, 2, -22 },
  { 539, 13, 21, 15, 1, -21 },
  { 574, 13, 22, 15, 1, -22 },
  { 610, 13, 22, 15, 1, -22 },
  { 646, 3, 16, 7, 2, -16 },
  { 652, 4, 20, 7, 1, -16 },
  { 662, 13, 14, 15, 1, -18 },
  { 685, 13, 7, 15, 1, -14 },
  { 697, 13, 14, 15, 1, -18 },
  { 720, 9, 22, 11, 1, -22 },
  { 745, 20, 24, 24, 2, -21 },
  { 805, 16, 21, 16, 0, -21 },
  { 847, 13, 21, 17, 3, -21 },
  { 882, 14, 22, 17, 2, -22 },
  { 921, 14, 21, 19, 3, -21 },
  { 958, 10, 21, 15, 3, -21 },
  { 985, 10, 21, 14, 3, -21 },
  { 1012, 16, 22, 20, 2, -22 },
  { 1056, 14, 21, 19, 3, -21 },
  { 1093, 6, 21, 9, 1, -21 },
  { 1109, 6, 26, 7, -2, -21 },
  { 1129, 13, 21, 16, 3, -21 },
  { 1164, 10, 21, 14, 3, -21 },
  { 1191, 18, 21, 24, 3, -21 },
  { 1239, 14, 21, 20, 3, -21 },
  { 1276, 17, 22, 20, 2, -22 },
  { 1323, 11, 21, 16, 3, -21 },
  { 1352, 17, 27, 20, 2, -22 },
  { 1410, 13, 21, 16, 3, -21 },
  { 1445, 12, 22, 15, 1, -22 },
  { 1478, 14, 21, 14, 0, -21 },
  { 1515, 14, 21, 19, 3, -21 },
  { 1552, 15, 21, 15, 0, -21 },
  { 1592, 24, 21, 25, 0, -21 },
  { 1655, 14, 21, 14, 0, -21 },
  { 1692, 14, 21, 14, 0, -21 },
  { 1729, 13, 21, 15, 1, -21 },
  { 1764, 7, 26, 10, 2, -21 },
  { 1787, 10, 21, 10, 0, -21 },
  { 1814, 6, 26, 10, 1, -21 },
  { 1834, 13, 13, 15, 1, -22 },
  { 1856, 13, 1, 12, 0, 3 },
  { 1858, 6, 5, 8, 1, -23 },
  { 1862, 11, 16, 14, 1, -16 },
  { 1884, 13, 23, 16, 2, -23 },
  { 1922, 10, 16, 13, 2, -16 },
  { 1942, 12, 23, 16, 2, -23 },
  { 1977, 11, 16, 15, 2, -16 },
  { 1999, 10, 23, 8, 0, -23 },
  { 2028, 12, 23, 16, 2, -16 },
  { 2063, 12, 23, 16, 2, -23 },
  { 2098, 2, 22, 7, 2, -22 },
  { 2104, 5, 29, 7, -1, -22 },
  { 2123, 11, 23, 13, 2, -23 },
  { 2155, 2, 23, 6, 2, -23 },
  { 2161, 20, 16, 24, 2, -16 },
  { 2201, 12, 16, 16, 2, -16 },
  { 2225, 12, 16, 16, 2, -16 },
  { 2249, 13, 23, 16, 2, -16 },
  { 2287, 12, 23, 16, 2, -16 },
  { 2322, 8, 16, 11, 2, -16 },
  { 2338, 10, 16, 12, 1, -16 },
  { 2358, 8, 20, 9, 0, -20 },
  { 2378, 12, 16, 16, 2, -16 },
  { 2402, 13, 16, 13, 0, -16 },
  { 2428, 20, 16, 20, 0, -16 },
  { 2468, 12, 16, 13, 1, -16 },
  { 2492, 13, 23, 13, 0, -16 },
  { 2530, 10, 16, 12, 1, -16 },
  { 2550, 9, 26, 11, 1, -21 },
  { 2580, 1, 30, 15, 7, -23 },
  { 2584, 9, 26, 11, 1, -21 },
  { 2614, 13, 3, 15, 1, -12 },
};

const GFXfont NotoSans_SemiCondensed_Light30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light30pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT30PT7B_H_
