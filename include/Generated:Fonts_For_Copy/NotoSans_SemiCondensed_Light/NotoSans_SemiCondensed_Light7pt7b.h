#ifndef _NOTOSANS_SEMICONDENSED_LIGHT7PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF8, 0xF0, 0x5F, 0x6F, 0xA0, 0x79, 0x3E, 0xD6, 0xBE, 0x55, 0x80,
  0x66, 0x4B, 0xF0, 0xC0, 0x6A, 0x90, 0x95, 0x60, 0xCC, 0x5D, 0x00, 0xC0,
  0xC0, 0x80, 0x56, 0x80, 0xF6, 0xDE, 0xF8, 0xE4, 0xAE, 0xE5, 0x1E, 0x26,
  0xAF, 0x20, 0xF1, 0x9E, 0x73, 0xD6, 0xE4, 0xA4, 0xF5, 0x5E, 0xF7, 0x96,
  0x90, 0x98, 0x71, 0x80, 0xE0, 0xC7, 0x00, 0xD5, 0x40, 0x7D, 0xF7, 0xBA,
  0x38, 0x46, 0x69, 0x90, 0xD7, 0x5E, 0x78, 0x88, 0x70, 0xD6, 0xDC, 0xEE,
  0xC0, 0xEE, 0x80, 0x78, 0xB9, 0x70, 0xB7, 0xDA, 0xD5, 0xC0, 0x55, 0x70,
  0xF2, 0x6A, 0xAA, 0xC0, 0x99, 0xBB, 0xD0, 0xB7, 0xFA, 0x79, 0x99, 0x70,
  0xFE, 0x80, 0x79, 0x99, 0x71, 0xD7, 0x6A, 0xF1, 0x1E, 0xE9, 0x24, 0xB6,
  0xDE, 0x9A, 0xA4, 0x40, 0xA6, 0x9B, 0x92, 0x48, 0xA9, 0x3A, 0xB5, 0x24,
  0xE5, 0x2E, 0xFC, 0xA5, 0x40, 0xD5, 0x70, 0x4E, 0x80, 0xE0, 0xC0, 0x67,
  0xF0, 0xBF, 0xC0, 0x72, 0x70, 0x2E, 0xDE, 0x77, 0x70, 0xFA, 0x80, 0x76,
  0xF2, 0xC0, 0xBF, 0xC0, 0xF8, 0xFE, 0xBA, 0xC0, 0xF8, 0xFD, 0xDD, 0xFF,
  0x76, 0xF0, 0xFF, 0xA0, 0x76, 0xF2, 0x40, 0xF0, 0x71, 0xF0, 0xBA, 0xC0,
  0xFF, 0xB7, 0x20, 0xAF, 0x74, 0xA0, 0xA9, 0x50, 0xB6, 0xA5, 0x00, 0xE9,
  0x70, 0x57, 0x50, 0xFE, 0xD5, 0x70, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Light7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 5, 2, 0, -5 },
  { 2, 2, 2, 2, 0, -5 },
  { 3, 4, 5, 4, 0, -5 },
  { 6, 3, 5, 4, 0, -5 },
  { 8, 5, 5, 5, 0, -5 },
  { 12, 4, 5, 4, 0, -5 },
  { 15, 1, 2, 1, 0, -5 },
  { 16, 2, 6, 2, 0, -5 },
  { 18, 2, 6, 2, 0, -5 },
  { 20, 3, 2, 3, 0, -5 },
  { 21, 3, 3, 4, 0, -4 },
  { 23, 1, 2, 2, 0, -1 },
  { 24, 2, 1, 2, 0, -2 },
  { 25, 1, 1, 2, 0, -1 },
  { 26, 2, 5, 2, 0, -5 },
  { 28, 3, 5, 4, 0, -5 },
  { 30, 1, 5, 4, 1, -5 },
  { 31, 3, 5, 4, 0, -5 },
  { 33, 3, 5, 4, 0, -5 },
  { 35, 4, 5, 4, 0, -5 },
  { 38, 3, 5, 4, 0, -5 },
  { 40, 3, 5, 4, 0, -5 },
  { 42, 3, 5, 4, 0, -5 },
  { 44, 3, 5, 4, 0, -5 },
  { 46, 3, 5, 4, 0, -5 },
  { 48, 1, 4, 2, 0, -4 },
  { 49, 1, 5, 2, 0, -4 },
  { 50, 3, 3, 4, 0, -4 },
  { 52, 3, 1, 4, 0, -3 },
  { 53, 3, 3, 4, 0, -4 },
  { 55, 2, 5, 3, 0, -5 },
  { 57, 5, 6, 6, 0, -5 },
  { 61, 4, 5, 4, 0, -5 },
  { 64, 3, 5, 4, 1, -5 },
  { 66, 4, 5, 4, 0, -5 },
  { 69, 3, 5, 4, 1, -5 },
  { 71, 2, 5, 3, 1, -5 },
  { 73, 2, 5, 3, 1, -5 },
  { 75, 4, 5, 5, 0, -5 },
  { 78, 3, 5, 5, 1, -5 },
  { 80, 2, 5, 2, 0, -5 },
  { 82, 2, 6, 2, -1, -5 },
  { 84, 3, 5, 4, 1, -5 },
  { 86, 2, 5, 3, 1, -5 },
  { 88, 4, 5, 6, 1, -5 },
  { 91, 3, 5, 5, 1, -5 },
  { 93, 4, 5, 5, 0, -5 },
  { 96, 2, 5, 4, 1, -5 },
  { 98, 4, 6, 5, 0, -5 },
  { 101, 3, 5, 4, 1, -5 },
  { 103, 3, 5, 3, 0, -5 },
  { 105, 3, 5, 3, 0, -5 },
  { 107, 3, 5, 5, 1, -5 },
  { 109, 4, 5, 4, 0, -5 },
  { 112, 6, 5, 6, 0, -5 },
  { 116, 3, 5, 3, 0, -5 },
  { 118, 3, 5, 3, 0, -5 },
  { 120, 3, 5, 3, 0, -5 },
  { 122, 1, 6, 2, 1, -5 },
  { 123, 2, 5, 2, 0, -5 },
  { 125, 2, 6, 2, 0, -5 },
  { 127, 3, 3, 4, 0, -5 },
  { 129, 3, 1, 3, 0, 0 },
  { 130, 2, 1, 2, 0, -5 },
  { 131, 3, 4, 3, 0, -4 },
  { 133, 2, 5, 4, 1, -5 },
  { 135, 3, 4, 3, 0, -4 },
  { 137, 3, 5, 4, 0, -5 },
  { 139, 3, 4, 3, 0, -4 },
  { 141, 2, 5, 2, 0, -5 },
  { 143, 3, 6, 4, 0, -4 },
  { 146, 2, 5, 4, 1, -5 },
  { 148, 1, 5, 2, 0, -5 },
  { 149, 1, 7, 2, 0, -5 },
  { 150, 2, 5, 3, 1, -5 },
  { 152, 1, 5, 2, 0, -5 },
  { 153, 4, 4, 6, 1, -4 },
  { 155, 2, 4, 4, 1, -4 },
  { 156, 3, 4, 4, 0, -4 },
  { 158, 2, 6, 4, 1, -4 },
  { 160, 3, 6, 4, 0, -4 },
  { 163, 1, 4, 2, 1, -4 },
  { 164, 3, 4, 3, 0, -4 },
  { 166, 2, 5, 2, 0, -5 },
  { 168, 2, 4, 4, 1, -4 },
  { 169, 3, 4, 3, 0, -4 },
  { 171, 5, 4, 5, 0, -4 },
  { 174, 3, 4, 3, 0, -4 },
  { 176, 3, 6, 3, 0, -4 },
  { 179, 3, 4, 3, 0, -4 },
  { 181, 2, 6, 3, 0, -5 },
  { 183, 1, 7, 3, 1, -5 },
  { 184, 2, 6, 3, 0, -5 },
  { 186, 3, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_Light7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light7pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT7PT7B_H_
