#ifndef _NOTOSANS_SEMICONDENSED_LIGHT31PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light31pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x49, 0x24, 0x92, 0x00, 0x2F, 0xC0, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x02, 0x08, 0x02, 0x08, 0x06, 0x08, 0x06,
  0x18, 0x06, 0x18, 0x04, 0x10, 0x04, 0x10, 0x7F, 0xFF, 0x0C, 0x10, 0x0C,
  0x30, 0x0C, 0x30, 0x08, 0x30, 0x08, 0x20, 0x08, 0x20, 0xFF, 0xFE, 0x18,
  0x60, 0x18, 0x60, 0x10, 0x60, 0x10, 0x40, 0x10, 0x40, 0x30, 0x40, 0x30,
  0xC0, 0x04, 0x00, 0x40, 0x04, 0x03, 0xFE, 0x74, 0x6C, 0x40, 0xC4, 0x08,
  0x40, 0x84, 0x0C, 0x40, 0xE4, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x04, 0xE0,
  0x46, 0x04, 0x30, 0x43, 0x04, 0x30, 0x43, 0x84, 0x6F, 0xFC, 0x7F, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x7C, 0x03, 0x18, 0xC0, 0xC3, 0x08, 0x10, 0x41,
  0x06, 0x08, 0x20, 0x81, 0x06, 0x30, 0x20, 0xC4, 0x04, 0x19, 0x80, 0x82,
  0x21, 0x10, 0x4C, 0xFB, 0x19, 0x31, 0xE3, 0x64, 0x37, 0xCC, 0x82, 0x03,
  0x30, 0x40, 0x66, 0x08, 0x08, 0xC1, 0x03, 0x18, 0x20, 0x41, 0x04, 0x18,
  0x20, 0x82, 0x06, 0x30, 0xC0, 0xC4, 0x30, 0x0F, 0x80, 0x0F, 0xC0, 0x06,
  0x18, 0x01, 0x82, 0x00, 0x40, 0xC0, 0x30, 0x30, 0x04, 0x08, 0x01, 0x86,
  0x00, 0x63, 0x80, 0x0D, 0xC0, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x6E, 0x00,
  0x31, 0xC1, 0x98, 0x30, 0x46, 0x06, 0x31, 0x00, 0xCC, 0xC0, 0x1E, 0x10,
  0x03, 0x86, 0x00, 0xE1, 0x80, 0xF8, 0x38, 0xF3, 0x07, 0xF0, 0x70, 0xFF,
  0xFF, 0x0E, 0x10, 0x60, 0x83, 0x04, 0x18, 0x30, 0x60, 0x81, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0x40, 0x81, 0x83, 0x06, 0x06, 0x0C, 0x08, 0x18, 0x18,
  0x18, 0xC1, 0x83, 0x0C, 0x18, 0x61, 0x83, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC2, 0x18, 0x61, 0x0C, 0x21, 0x8C, 0x00, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x42, 0x1F, 0xAF, 0x0F, 0x80, 0x70, 0x0D, 0x81,
  0x88, 0x18, 0xC3, 0x06, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x33, 0x66, 0x64, 0x4C, 0xFE, 0x5F, 0x80,
  0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x06, 0x01,
  0x80, 0x40, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x01,
  0x80, 0x60, 0x30, 0x00, 0x1F, 0x83, 0x0C, 0x60, 0x64, 0x06, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80, 0x38,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x02, 0x60, 0x66, 0x06, 0x39, 0xC1,
  0xF8, 0x0E, 0x3C, 0xDB, 0x3C, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x1F, 0xC3, 0x87,
  0x10, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xC7, 0x83,
  0x10, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x0E, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x07, 0x00, 0x6F, 0x0E, 0x3F, 0xE0, 0x00, 0x60, 0x03,
  0x80, 0x0A, 0x00, 0x68, 0x03, 0x60, 0x09, 0x80, 0x66, 0x03, 0x18, 0x0C,
  0x60, 0x61, 0x81, 0x06, 0x0C, 0x18, 0x60, 0x61, 0x01, 0x8C, 0x06, 0x3F,
  0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x7F, 0xE6, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x0F, 0xF8, 0x40, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x38, 0x06, 0xE1, 0xCF, 0xF8, 0x0F, 0xE1, 0xC0,
  0x30, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC7, 0x0D, 0xFC,
  0xB0, 0x6E, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0x60, 0x36, 0x06, 0x38, 0xE1, 0xF8, 0xFF, 0xF8, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x3F, 0xC7, 0x0E, 0x60, 0x6C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x26, 0x06, 0x30, 0xC1, 0xF8, 0x0F, 0x03, 0x9C,
  0x60, 0xEC, 0x07, 0xC0, 0x38, 0x03, 0x80, 0x18, 0x03, 0xC0, 0x3C, 0x07,
  0x70, 0xE3, 0xF8, 0x1F, 0xC1, 0xC7, 0x18, 0x0C, 0xC0, 0x64, 0x01, 0x60,
  0x0F, 0x00, 0x78, 0x03, 0x40, 0x1B, 0x00, 0xD8, 0x0E, 0x60, 0xF1, 0xFD,
  0x83, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0xC4,
  0x1C, 0x1F, 0x80, 0x5F, 0x80, 0x00, 0x00, 0x00, 0x17, 0xE0, 0x27, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x36, 0x66, 0x4C, 0xC0, 0x00, 0x0C, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x02, 0x00, 0x00,
  0xFF, 0x30, 0xE0, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x06, 0x01, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x38, 0x0E, 0x00, 0x01, 0xFE, 0x00, 0x3C, 0x3C, 0x03, 0x00, 0x30,
  0x30, 0x00, 0xC3, 0x00, 0x02, 0x30, 0x00, 0x19, 0x81, 0xF0, 0x48, 0x39,
  0xC3, 0xC3, 0x06, 0x1E, 0x18, 0x30, 0xE0, 0x81, 0x87, 0x0C, 0x0C, 0x38,
  0x60, 0x61, 0xC3, 0x02, 0x0E, 0x18, 0x10, 0x70, 0x41, 0xC2, 0x83, 0x0A,
  0x36, 0x0F, 0x9F, 0x30, 0x38, 0x60, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x04, 0x01, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x50, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x13, 0x00, 0x18,
  0xC0, 0x0C, 0x60, 0x04, 0x30, 0x06, 0x0C, 0x03, 0x06, 0x01, 0x03, 0x01,
  0x80, 0x80, 0xFF, 0xE0, 0x40, 0x30, 0x60, 0x08, 0x30, 0x06, 0x10, 0x03,
  0x18, 0x00, 0x8C, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x0C, 0xFF, 0xC6, 0x1F,
  0x30, 0x0D, 0x80, 0x6C, 0x01, 0x60, 0x0B, 0x00, 0x58, 0x06, 0xC0, 0x76,
  0x0F, 0x3F, 0xE1, 0x81, 0xCC, 0x03, 0x60, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x6F, 0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0x78,
  0x33, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1E, 0x1C, 0x1F, 0xF0,
  0xFF, 0x81, 0x8F, 0xC3, 0x01, 0xC6, 0x00, 0xCC, 0x01, 0xD8, 0x01, 0xB0,
  0x03, 0x60, 0x02, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x33, 0x00, 0xE6,
  0x03, 0x8F, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0xF8, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0xFF, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xF8, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x7F, 0xEC, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x07, 0xFE, 0x0E, 0x07,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x7F, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x60, 0x03, 0x60, 0x03, 0x30, 0x03, 0x38, 0x03,
  0x0F, 0x0F, 0x07, 0xFE, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x30, 0xFE, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x1F, 0xC0, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82,
  0x0C, 0x1B, 0xE7, 0x00, 0xC0, 0x3E, 0x01, 0xB0, 0x19, 0x81, 0x8C, 0x18,
  0x61, 0x83, 0x1C, 0x18, 0xC0, 0xCC, 0x06, 0xC0, 0x3F, 0x01, 0xDC, 0x0C,
  0x60, 0x61, 0x83, 0x0C, 0x18, 0x30, 0xC0, 0xC6, 0x06, 0x30, 0x19, 0x80,
  0x6C, 0x03, 0x60, 0x0C, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xC0, 0xE0,
  0x00, 0xFC, 0x00, 0x1E, 0x80, 0x03, 0xD8, 0x00, 0xFB, 0x00, 0x17, 0x20,
  0x06, 0xF6, 0x00, 0xDE, 0xC0, 0x13, 0xCC, 0x06, 0x79, 0x80, 0xCF, 0x10,
  0x11, 0xE3, 0x06, 0x3C, 0x60, 0xC7, 0x84, 0x10, 0xF0, 0xC6, 0x1E, 0x18,
  0xC3, 0xC1, 0x10, 0x78, 0x36, 0x0F, 0x06, 0x81, 0xE0, 0x70, 0x3C, 0x0E,
  0x07, 0x81, 0x80, 0xC0, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1D, 0x80, 0x39,
  0x80, 0x73, 0x00, 0xE3, 0x01, 0xC6, 0x03, 0xC6, 0x07, 0x8C, 0x0F, 0x0C,
  0x1E, 0x0C, 0x3C, 0x18, 0x78, 0x18, 0xF0, 0x31, 0xE0, 0x33, 0xC0, 0x67,
  0x80, 0x6F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xC0, 0x0F, 0xF8,
  0x0E, 0x0E, 0x0C, 0x01, 0x8E, 0x00, 0x66, 0x00, 0x32, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x60, 0x01, 0x30, 0x01,
  0x8C, 0x01, 0xC7, 0x01, 0xC1, 0xE3, 0xC0, 0x3F, 0x80, 0xFF, 0x0C, 0x7C,
  0xC0, 0x6C, 0x06, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x06,
  0xC0, 0xEF, 0xFC, 0xFF, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x0F, 0xF8, 0x0E, 0x0E, 0x0C, 0x01,
  0x8E, 0x00, 0x66, 0x00, 0x32, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x60, 0x01, 0x30, 0x01, 0x8C, 0x01, 0xC7, 0x01,
  0xC1, 0xE3, 0xC0, 0x3F, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x80, 0xFF, 0x86, 0x3E, 0x30, 0x19, 0x80, 0x6C, 0x03,
  0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x26, 0x03, 0x30, 0x71, 0xFF, 0x0C,
  0x30, 0x60, 0x83, 0x06, 0x18, 0x18, 0xC0, 0xC6, 0x03, 0x30, 0x19, 0x80,
  0x6C, 0x03, 0x60, 0x0C, 0x3F, 0xE7, 0x06, 0xE0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0xE1, 0xCF,
  0xF8, 0xFF, 0xFC, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xD8, 0x06, 0x3C, 0x70, 0x7F, 0x80, 0xC0, 0x03, 0x40, 0x02, 0x60,
  0x06, 0x60, 0x06, 0x60, 0x06, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x08, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x04,
  0x20, 0x06, 0x60, 0x06, 0x60, 0x02, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0xC0, 0x0C, 0x01, 0xB0, 0x0E, 0x00, 0xD8, 0x07, 0x00,
  0xCC, 0x02, 0x80, 0x62, 0x01, 0x60, 0x31, 0x81, 0xB0, 0x18, 0xC0, 0xC8,
  0x18, 0x60, 0x64, 0x0C, 0x10, 0x23, 0x06, 0x0C, 0x31, 0x83, 0x06, 0x18,
  0x43, 0x03, 0x0C, 0x31, 0x80, 0x84, 0x18, 0xC0, 0x66, 0x0C, 0x60, 0x33,
  0x02, 0x20, 0x19, 0x81, 0xB0, 0x04, 0x80, 0xD8, 0x03, 0xC0, 0x6C, 0x01,
  0xE0, 0x14, 0x00, 0xF0, 0x0E, 0x00, 0x30, 0x07, 0x00, 0x18, 0x03, 0x80,
  0x60, 0x0C, 0x60, 0x18, 0xC0, 0x60, 0xC0, 0x81, 0x83, 0x01, 0x8C, 0x03,
  0x18, 0x03, 0x60, 0x06, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x6C,
  0x00, 0xD8, 0x03, 0x18, 0x06, 0x30, 0x18, 0x30, 0x20, 0x60, 0xC0, 0x63,
  0x00, 0x46, 0x00, 0xD8, 0x00, 0xC0, 0xC0, 0x0E, 0xC0, 0x19, 0x80, 0x61,
  0x80, 0xC3, 0x03, 0x03, 0x06, 0x06, 0x08, 0x04, 0x30, 0x0C, 0x40, 0x09,
  0x80, 0x1B, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x7F, 0xF8, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC,
  0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83, 0xFF, 0xC0, 0xC0, 0x18, 0x06,
  0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x02, 0x00, 0xC0,
  0x30, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x07, 0xFF, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x78, 0x01, 0x20, 0x0C, 0xC0, 0x21, 0x01, 0x86, 0x04, 0x08,
  0x30, 0x30, 0x80, 0x46, 0x01, 0x90, 0x02, 0xC0, 0x0C, 0xFF, 0xF8, 0xC1,
  0x83, 0x06, 0x0C, 0x07, 0x03, 0xFC, 0x20, 0x60, 0x02, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x1F, 0x1F, 0xF7, 0x03, 0x60, 0x3C, 0x03, 0xC0, 0x3C, 0x07,
  0x60, 0x77, 0x1B, 0x3F, 0x30, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0xF0, 0xCF, 0xE6, 0x83, 0xB8, 0x0D, 0xC0,
  0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0xC0, 0x3E, 0x01, 0x78, 0x1B, 0x63, 0x99, 0xF8, 0x07, 0x8F, 0xF7, 0x01,
  0x80, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0,
  0x30, 0x06, 0x00, 0xE1, 0x1F, 0xC0, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0xE1, 0x3F, 0x97, 0x05, 0x60, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x36, 0x05, 0x70, 0xD1, 0xF9, 0x0F, 0x03, 0xFC, 0x70, 0xC6, 0x06,
  0xC0, 0x2C, 0x03, 0xC0, 0x38, 0x03, 0xFF, 0xF8, 0x00, 0x80, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x03, 0x86, 0x1F, 0xE0, 0x03, 0x83, 0xF0, 0xC0,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0xFF, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x0F, 0x03, 0xF9, 0x70, 0x56, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x60,
  0x57, 0x1D, 0x1F, 0x90, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x06, 0x60,
  0xE7, 0xFC, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x38, 0xCF, 0xED, 0x07, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0x5F, 0x00, 0x02, 0x49, 0x24, 0x92, 0x49, 0x24, 0x90, 0x08,
  0x71, 0x80, 0x00, 0x00, 0x02, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x21, 0x86, 0x1B, 0xC0, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x02, 0xC0, 0xCC,
  0x0C, 0xC1, 0x8C, 0x30, 0xC6, 0x0C, 0xC0, 0xCC, 0x0D, 0xC0, 0xF6, 0x0E,
  0x30, 0xC3, 0x0C, 0x18, 0xC0, 0xCC, 0x0C, 0xC0, 0x6C, 0x07, 0xFF, 0xFF,
  0xFF, 0x07, 0x83, 0xC6, 0xFE, 0x7F, 0x34, 0x1E, 0x0D, 0xC0, 0xE0, 0x6E,
  0x03, 0x01, 0x60, 0x10, 0x0F, 0x00, 0x80, 0x78, 0x04, 0x03, 0xC0, 0x20,
  0x1E, 0x01, 0x00, 0xF0, 0x08, 0x07, 0x80, 0x40, 0x3C, 0x02, 0x01, 0xE0,
  0x10, 0x0F, 0x00, 0x80, 0x78, 0x04, 0x03, 0xC0, 0x20, 0x18, 0x03, 0x8C,
  0xFE, 0xD0, 0x7E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x10,
  0x0F, 0x01, 0xFE, 0x1C, 0x18, 0xC0, 0x6C, 0x03, 0x60, 0x0B, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x03, 0x60, 0x19, 0x81,
  0x87, 0x1C, 0x1F, 0x80, 0x07, 0x09, 0xFC, 0xA0, 0xEC, 0x06, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x3C,
  0x06, 0xE0, 0x6B, 0x1C, 0x9F, 0x88, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x0F, 0x03, 0xF9, 0x70, 0x56, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0x60, 0x57, 0x0D, 0x1F, 0x90, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x0F, 0x9E, 0xB0, 0xE0, 0xC0, 0xC0, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x0F, 0x07, 0xF9,
  0x81, 0x20, 0x0C, 0x00, 0x80, 0x18, 0x01, 0xC0, 0x1E, 0x00, 0x70, 0x03,
  0x00, 0x20, 0x06, 0x00, 0xC0, 0x37, 0x0E, 0x7F, 0x80, 0x10, 0x08, 0x04,
  0x06, 0x0F, 0xF8, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x0C, 0x06, 0x21, 0xF0, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x36, 0x07, 0x71, 0xD3, 0xF1, 0xC0, 0x1B, 0x01, 0x98,
  0x0C, 0xC0, 0x62, 0x06, 0x18, 0x30, 0xC1, 0x82, 0x08, 0x18, 0xC0, 0xC6,
  0x02, 0x20, 0x1B, 0x00, 0xD8, 0x02, 0x80, 0x1C, 0x00, 0xE0, 0xC0, 0x70,
  0x36, 0x07, 0x03, 0x60, 0x50, 0x36, 0x0D, 0x82, 0x20, 0xD8, 0x63, 0x0D,
  0x86, 0x30, 0x88, 0x63, 0x18, 0xC4, 0x11, 0x8C, 0xC1, 0x90, 0x4C, 0x1B,
  0x04, 0xC1, 0xB0, 0x68, 0x0B, 0x06, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0x60, 0x30, 0xC0, 0x76, 0x06, 0x30, 0xC3, 0x08, 0x19, 0x80, 0xB0, 0x0F,
  0x00, 0x60, 0x0F, 0x00, 0xB0, 0x19, 0x83, 0x18, 0x30, 0xC6, 0x06, 0x40,
  0x6C, 0x03, 0xC0, 0x1B, 0x00, 0x98, 0x0C, 0x40, 0x63, 0x02, 0x18, 0x30,
  0x41, 0x83, 0x08, 0x18, 0xC0, 0x46, 0x03, 0x20, 0x1B, 0x00, 0x58, 0x03,
  0x80, 0x1C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x0C, 0x03, 0xE0, 0x00, 0x7F, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80,
  0x60, 0x30, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0xFF,
  0x03, 0x87, 0x83, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x07, 0x07, 0x00, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x10, 0x0C, 0x03, 0xC0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x70, 0x1C, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x10, 0x18, 0x78, 0x38, 0x00, 0x18, 0x01, 0xFC, 0x3C, 0x3F, 0xA0,
  0x38,
};

const GFXglyph NotoSans_SemiCondensed_Light31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 22, 7, 2, -22 },
  { 10, 7, 8, 11, 2, -22 },
  { 17, 16, 22, 18, 1, -22 },
  { 61, 12, 26, 16, 2, -24 },
  { 100, 19, 22, 23, 2, -22 },
  { 153, 18, 22, 19, 1, -22 },
  { 203, 2, 8, 6, 2, -22 },
  { 205, 7, 27, 9, 1, -22 },
  { 229, 6, 27, 9, 1, -22 },
  { 250, 12, 12, 15, 1, -24 },
  { 268, 14, 14, 16, 1, -18 },
  { 293, 4, 8, 7, 1, -4 },
  { 297, 7, 1, 9, 1, -9 },
  { 298, 3, 3, 7, 2, -3 },
  { 300, 10, 22, 11, 0, -22 },
  { 328, 12, 22, 16, 2, -22 },
  { 361, 7, 22, 16, 3, -22 },
  { 381, 13, 22, 16, 1, -22 },
  { 417, 13, 22, 16, 1, -22 },
  { 453, 14, 22, 16, 1, -22 },
  { 492, 12, 22, 16, 2, -22 },
  { 525, 12, 22, 16, 2, -22 },
  { 558, 13, 22, 16, 1, -22 },
  { 594, 12, 22, 16, 2, -22 },
  { 627, 13, 22, 16, 1, -22 },
  { 663, 3, 17, 7, 2, -17 },
  { 670, 4, 21, 7, 1, -17 },
  { 681, 14, 14, 16, 1, -18 },
  { 706, 13, 8, 16, 1, -15 },
  { 719, 14, 14, 16, 1, -18 },
  { 744, 10, 22, 12, 1, -22 },
  { 772, 21, 25, 25, 2, -22 },
  { 838, 17, 22, 17, 0, -22 },
  { 885, 13, 22, 18, 3, -22 },
  { 921, 14, 22, 17, 2, -22 },
  { 960, 15, 22, 20, 3, -22 },
  { 1002, 11, 22, 15, 3, -22 },
  { 1033, 11, 22, 14, 3, -22 },
  { 1064, 16, 22, 20, 2, -22 },
  { 1108, 14, 22, 20, 3, -22 },
  { 1147, 7, 22, 9, 1, -22 },
  { 1167, 7, 28, 7, -2, -22 },
  { 1192, 13, 22, 16, 3, -22 },
  { 1228, 11, 22, 14, 3, -22 },
  { 1259, 19, 22, 25, 3, -22 },
  { 1312, 15, 22, 20, 3, -22 },
  { 1354, 17, 22, 21, 2, -22 },
  { 1401, 12, 22, 16, 3, -22 },
  { 1434, 17, 27, 21, 2, -22 },
  { 1492, 13, 22, 17, 3, -22 },
  { 1528, 12, 22, 15, 2, -22 },
  { 1561, 14, 22, 14, 0, -22 },
  { 1600, 14, 22, 20, 3, -22 },
  { 1639, 16, 22, 16, 0, -22 },
  { 1683, 25, 22, 25, 0, -22 },
  { 1752, 15, 22, 15, 0, -22 },
  { 1794, 15, 22, 15, 0, -22 },
  { 1836, 13, 22, 15, 1, -22 },
  { 1872, 6, 27, 10, 3, -22 },
  { 1893, 10, 22, 11, 0, -22 },
  { 1921, 6, 27, 10, 1, -22 },
  { 1942, 14, 13, 16, 1, -22 },
  { 1965, 13, 1, 13, 0, 3 },
  { 1967, 6, 5, 8, 1, -24 },
  { 1971, 12, 17, 15, 1, -17 },
  { 1997, 13, 24, 17, 2, -24 },
  { 2036, 10, 17, 13, 2, -17 },
  { 2058, 12, 24, 17, 2, -24 },
  { 2094, 12, 17, 15, 2, -17 },
  { 2120, 10, 24, 9, 0, -24 },
  { 2150, 12, 24, 17, 2, -17 },
  { 2186, 12, 24, 17, 2, -24 },
  { 2222, 3, 23, 7, 2, -23 },
  { 2231, 6, 30, 7, -1, -23 },
  { 2254, 12, 24, 14, 2, -24 },
  { 2290, 1, 24, 7, 3, -24 },
  { 2293, 21, 17, 25, 2, -17 },
  { 2338, 12, 17, 17, 2, -17 },
  { 2364, 13, 17, 16, 2, -17 },
  { 2392, 12, 24, 17, 3, -17 },
  { 2428, 12, 24, 17, 2, -17 },
  { 2464, 8, 17, 11, 3, -17 },
  { 2481, 11, 17, 13, 1, -17 },
  { 2505, 9, 20, 9, 0, -20 },
  { 2528, 12, 16, 17, 2, -16 },
  { 2552, 13, 16, 13, 0, -16 },
  { 2578, 20, 16, 21, 0, -16 },
  { 2618, 12, 16, 14, 1, -16 },
  { 2642, 13, 23, 13, 0, -16 },
  { 2680, 10, 16, 12, 1, -16 },
  { 2700, 9, 27, 11, 1, -22 },
  { 2731, 1, 32, 15, 7, -24 },
  { 2735, 9, 27, 11, 1, -22 },
  { 2766, 14, 4, 16, 1, -13 },
};

const GFXfont NotoSans_SemiCondensed_Light31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light31pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT31PT7B_H_
