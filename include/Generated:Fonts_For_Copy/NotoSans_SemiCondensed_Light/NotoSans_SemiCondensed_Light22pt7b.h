#ifndef _NOTOSANS_SEMICONDENSED_LIGHT22PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light22pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0x0B, 0xCA, 0x52, 0x94, 0xA4, 0x08, 0x81, 0x10,
  0x22, 0x08, 0x41, 0x09, 0xFF, 0xC4, 0x40, 0x88, 0x11, 0x04, 0x23, 0xFF,
  0x11, 0x02, 0x20, 0x44, 0x08, 0x82, 0x10, 0x08, 0x04, 0x0F, 0xC9, 0x2C,
  0x84, 0x43, 0x20, 0x90, 0x38, 0x07, 0x02, 0xC1, 0x30, 0x88, 0x46, 0x25,
  0xFC, 0x08, 0x04, 0x00, 0x30, 0x21, 0x20, 0x88, 0xC4, 0x21, 0x10, 0x84,
  0x82, 0x12, 0x08, 0x53, 0x23, 0x5A, 0x4B, 0x44, 0xC9, 0x10, 0x64, 0x41,
  0x11, 0x04, 0x44, 0x21, 0x10, 0x84, 0x44, 0x0E, 0x1E, 0x02, 0x30, 0x21,
  0x06, 0x10, 0x21, 0x02, 0x20, 0x14, 0x01, 0x80, 0x2C, 0x14, 0x62, 0xC3,
  0x28, 0x16, 0x80, 0xCC, 0x0C, 0x41, 0x63, 0xE3, 0xD5, 0x50, 0x13, 0x24,
  0x44, 0xC8, 0x88, 0x88, 0x8C, 0x44, 0x62, 0x30, 0x84, 0x42, 0x23, 0x11,
  0x11, 0x11, 0x13, 0x32, 0x24, 0xC0, 0x08, 0x04, 0x02, 0x19, 0x23, 0xE8,
  0xC0, 0xD0, 0xC4, 0x22, 0x00, 0x08, 0x04, 0x02, 0x01, 0x00, 0x87, 0xFC,
  0x20, 0x10, 0x08, 0x04, 0x00, 0x5E, 0x80, 0xFF, 0xC0, 0xC0, 0x02, 0x04,
  0x18, 0x20, 0x41, 0x02, 0x0C, 0x10, 0x20, 0xC1, 0x02, 0x08, 0x10, 0x60,
  0x1E, 0x11, 0x90, 0x48, 0x3C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x38, 0x14, 0x1A, 0x09, 0x8C, 0x7C, 0x09, 0xDB, 0x90, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x3C, 0x71, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x06, 0x02, 0x02, 0x02, 0x02, 0x03, 0x03, 0x03, 0x01, 0xFF, 0x3E, 0x61,
  0x80, 0x40, 0x30, 0x18, 0x08, 0x0C, 0x78, 0x06, 0x00, 0x80, 0x60, 0x10,
  0x08, 0x0E, 0x0D, 0xFC, 0x01, 0x80, 0x30, 0x0E, 0x02, 0xC0, 0x58, 0x13,
  0x06, 0x60, 0x8C, 0x21, 0x8C, 0x31, 0x06, 0x7F, 0xF0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x7F, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x20, 0xFE, 0x01,
  0x00, 0x40, 0x20, 0x10, 0x08, 0x0E, 0x0D, 0xFC, 0x0F, 0x1C, 0x08, 0x08,
  0x04, 0x02, 0x03, 0x39, 0x66, 0xC1, 0xE0, 0x70, 0x38, 0x14, 0x0A, 0x05,
  0x84, 0x7C, 0xFF, 0x80, 0x40, 0x60, 0x20, 0x10, 0x10, 0x08, 0x0C, 0x04,
  0x02, 0x03, 0x01, 0x01, 0x80, 0x80, 0x40, 0x60, 0x1E, 0x31, 0x90, 0x68,
  0x34, 0x1A, 0x08, 0x88, 0x38, 0x36, 0x20, 0xB0, 0x30, 0x18, 0x0E, 0x05,
  0x04, 0x7C, 0x3C, 0x31, 0x90, 0x50, 0x38, 0x0C, 0x06, 0x03, 0x83, 0x62,
  0x9E, 0x40, 0x20, 0x30, 0x10, 0x18, 0x18, 0xF8, 0xC0, 0x30, 0x50, 0x00,
  0x05, 0xE8, 0x00, 0x80, 0xC1, 0x83, 0x06, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x40, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x80, 0x70, 0x06,
  0x00, 0xC0, 0x18, 0x0C, 0x18, 0x30, 0x60, 0x40, 0x00, 0xFC, 0x46, 0x02,
  0x03, 0x03, 0x02, 0x06, 0x0C, 0x18, 0x10, 0x10, 0x10, 0x00, 0x00, 0x30,
  0x30, 0x03, 0xC0, 0x18, 0x60, 0x40, 0x21, 0x00, 0x26, 0x00, 0x68, 0x7C,
  0x51, 0x08, 0xC2, 0x11, 0x88, 0x23, 0x10, 0x46, 0x21, 0x8C, 0x63, 0x1C,
  0x6A, 0x48, 0x63, 0x10, 0x00, 0x10, 0x00, 0x18, 0x20, 0x1F, 0xC0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xB0, 0x09, 0x00, 0x90, 0x11, 0x81, 0x08, 0x10,
  0x83, 0xFC, 0x3F, 0xC2, 0x04, 0x40, 0x64, 0x02, 0x40, 0x28, 0x03, 0xFC,
  0x43, 0xA0, 0x70, 0x18, 0x0C, 0x0E, 0x05, 0xFC, 0x83, 0x40, 0xE0, 0x30,
  0x18, 0x0C, 0x06, 0x0D, 0xFC, 0x0F, 0xE3, 0x08, 0xC0, 0x30, 0x04, 0x00,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x0C, 0x08, 0x7E, 0xFC, 0x10, 0xE2, 0x06, 0x40, 0x68, 0x05, 0x00, 0xA0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x40, 0x28, 0x0D, 0x01, 0x20, 0xC7,
  0xF0, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFE, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x07, 0xC1, 0x83,
  0x30, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC1, 0xFC, 0x01,
  0xC0, 0x14, 0x01, 0x60, 0x12, 0x01, 0x38, 0x10, 0xFF, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0xFF, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0xF2, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22,
  0x2F, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x47, 0xE0, 0x80, 0xA0, 0x48, 0x32, 0x18, 0x8C, 0x22, 0x09, 0x02, 0xC0,
  0xD8, 0x32, 0x08, 0x42, 0x18, 0x82, 0x20, 0xC8, 0x1A, 0x03, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xFF, 0xC0, 0x0F, 0x00, 0x7E, 0x01, 0xE8, 0x07, 0xA0, 0x2E, 0xC0,
  0xB9, 0x02, 0xE4, 0x13, 0x88, 0x4E, 0x21, 0x38, 0xC8, 0xE1, 0x23, 0x85,
  0x8E, 0x1C, 0x38, 0x30, 0xE0, 0xC3, 0xC0, 0x70, 0x1E, 0x06, 0x81, 0xB0,
  0x64, 0x18, 0x86, 0x31, 0x84, 0x61, 0x98, 0x26, 0x0D, 0x81, 0x60, 0x38,
  0x0E, 0x01, 0x0F, 0x80, 0xC6, 0x08, 0x08, 0xC0, 0x64, 0x01, 0x20, 0x0B,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x04, 0x80, 0x24, 0x01, 0x10,
  0x10, 0xC1, 0x81, 0xF0, 0xF8, 0x43, 0x20, 0x50, 0x28, 0x1C, 0x0E, 0x05,
  0x06, 0xFE, 0x78, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x0F, 0x80,
  0xC7, 0x08, 0x08, 0xC0, 0x64, 0x01, 0x20, 0x0B, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x06, 0x80, 0x24, 0x01, 0x10, 0x10, 0xC1, 0x83, 0xF0,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0xF8, 0x43, 0xA0, 0x50, 0x28,
  0x1C, 0x0E, 0x05, 0x06, 0xFC, 0x42, 0x21, 0x10, 0x48, 0x24, 0x0A, 0x07,
  0x01, 0x1F, 0xB0, 0x90, 0x18, 0x0C, 0x06, 0x01, 0x80, 0x70, 0x0E, 0x01,
  0x80, 0x60, 0x10, 0x18, 0x0E, 0x0D, 0xFC, 0xFF, 0xC1, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x70, 0x36, 0x18, 0xFC, 0x80,
  0x38, 0x05, 0x01, 0xA0, 0x26, 0x04, 0x41, 0x88, 0x21, 0x84, 0x11, 0x82,
  0x20, 0x64, 0x04, 0x80, 0xA0, 0x14, 0x01, 0x80, 0x30, 0xC0, 0xC0, 0xD0,
  0x30, 0x24, 0x0C, 0x09, 0x03, 0x02, 0x61, 0x21, 0x88, 0x48, 0x42, 0x12,
  0x10, 0x84, 0x84, 0x32, 0x13, 0x04, 0x84, 0x81, 0x21, 0x20, 0x48, 0x48,
  0x1C, 0x0E, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x40, 0x4C, 0x18,
  0x82, 0x18, 0x81, 0x10, 0x34, 0x02, 0x80, 0x60, 0x0C, 0x01, 0x40, 0x4C,
  0x08, 0x82, 0x18, 0xC1, 0x10, 0x36, 0x03, 0x80, 0x50, 0x34, 0x08, 0x86,
  0x21, 0x0C, 0x41, 0x20, 0x68, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0xFF, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x20, 0x10, 0x10,
  0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x02, 0x01, 0xFF, 0xF8, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xFF, 0xC0, 0x81, 0x01, 0x02, 0x04,
  0x04, 0x08, 0x18, 0x10, 0x20, 0x60, 0x40, 0x80, 0x81, 0xF1, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xFF, 0x08, 0x03, 0x01, 0x40, 0x48,
  0x22, 0x08, 0x44, 0x11, 0x02, 0x80, 0xC0, 0xFF, 0x80, 0xC4, 0x21, 0x3C,
  0x42, 0x01, 0x01, 0x01, 0x1F, 0x61, 0xC1, 0x81, 0x83, 0xC3, 0x7D, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0xE3, 0x8D, 0x82, 0x81, 0xC0, 0xE0, 0x30,
  0x18, 0x1C, 0x0F, 0x05, 0x86, 0xBE, 0x00, 0x1E, 0x31, 0x40, 0x40, 0xC0,
  0x80, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x3F, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0xE5, 0x8E, 0x83, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0E, 0x05, 0x06,
  0xC3, 0x3E, 0x80, 0x1E, 0x11, 0x90, 0x48, 0x3C, 0x0F, 0xFE, 0x01, 0x00,
  0xC0, 0x20, 0x18, 0x27, 0xE0, 0x0E, 0x24, 0xC1, 0x02, 0x1F, 0x88, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x1C, 0xB1, 0xD0, 0x78,
  0x1C, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0xA0, 0xD8, 0x67, 0xD0, 0x08, 0x04,
  0x03, 0x02, 0x7E, 0x00, 0x80, 0x80, 0x80, 0x80, 0x80, 0x9C, 0xE2, 0xC1,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xCF, 0xFF, 0x11,
  0x00, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xE0, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x82, 0x84, 0x8C, 0x98, 0x90, 0xB0, 0xD0, 0x88, 0x8C,
  0x84, 0x86, 0x83, 0xFF, 0xFF, 0x80, 0xBC, 0x73, 0x9A, 0x2C, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x08, 0x18, 0x20, 0x60, 0x81, 0x82, 0x06, 0x08, 0x18,
  0x20, 0x60, 0x81, 0x9C, 0xE2, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x1E, 0x08, 0xC4, 0x1B, 0x02, 0xC0, 0xA0, 0x28, 0x0F,
  0x02, 0xC0, 0x90, 0x26, 0x10, 0xF8, 0x9C, 0x51, 0xB0, 0x50, 0x38, 0x1C,
  0x06, 0x03, 0x03, 0x81, 0xE0, 0xB0, 0xD7, 0xC8, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x00, 0x1C, 0xB1, 0x50, 0x78, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0xC0,
  0xA0, 0xD8, 0x67, 0xD0, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x9D, 0x31,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x00, 0x3D, 0x86, 0x04, 0x0C, 0x0E, 0x07,
  0x03, 0x02, 0x06, 0x1F, 0xE0, 0x20, 0x8F, 0xC8, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x70, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x83, 0xC7, 0x7D, 0x80, 0xE0, 0xD0, 0x48, 0x26, 0x11, 0x10, 0x88,
  0x64, 0x14, 0x0A, 0x07, 0x01, 0x00, 0xC1, 0x06, 0x86, 0x09, 0x0A, 0x12,
  0x14, 0x66, 0x28, 0x84, 0x99, 0x09, 0x12, 0x12, 0x2C, 0x3C, 0x50, 0x30,
  0xE0, 0x60, 0xC0, 0xC1, 0x80, 0x40, 0xB0, 0x88, 0xC2, 0x41, 0xE0, 0x60,
  0x30, 0x3C, 0x12, 0x11, 0x98, 0x58, 0x10, 0x80, 0xA0, 0x50, 0x68, 0x22,
  0x11, 0x18, 0x88, 0x24, 0x16, 0x0A, 0x03, 0x01, 0x80, 0x80, 0x40, 0x40,
  0x20, 0xE0, 0x00, 0xFE, 0x0C, 0x10, 0x60, 0x82, 0x0C, 0x10, 0x60, 0x82,
  0x07, 0xF0, 0x0C, 0x63, 0x08, 0x20, 0x82, 0x08, 0x23, 0x06, 0x08, 0x20,
  0x82, 0x08, 0x20, 0xC1, 0xC1, 0xFF, 0xFF, 0xFC, 0xC1, 0x83, 0x0C, 0x30,
  0xC3, 0x0C, 0x10, 0x71, 0x84, 0x30, 0xC3, 0x0C, 0x30, 0x8E, 0x20, 0x70,
  0xC7, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Light22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 16, 5, 2, -16 },
  { 5, 5, 6, 8, 1, -16 },
  { 9, 11, 16, 13, 1, -16 },
  { 31, 9, 18, 11, 1, -17 },
  { 52, 14, 16, 16, 1, -16 },
  { 80, 12, 16, 13, 1, -16 },
  { 104, 2, 6, 4, 1, -16 },
  { 106, 4, 19, 6, 1, -16 },
  { 116, 4, 19, 6, 1, -16 },
  { 126, 9, 9, 11, 1, -17 },
  { 137, 9, 10, 11, 1, -13 },
  { 149, 2, 5, 5, 1, -2 },
  { 151, 5, 2, 7, 1, -7 },
  { 153, 1, 2, 5, 2, -2 },
  { 154, 7, 16, 8, 0, -16 },
  { 168, 9, 16, 11, 1, -16 },
  { 186, 5, 16, 11, 2, -16 },
  { 196, 9, 16, 11, 1, -16 },
  { 214, 9, 16, 11, 1, -16 },
  { 232, 11, 16, 11, 0, -16 },
  { 254, 9, 16, 11, 1, -16 },
  { 272, 9, 16, 11, 1, -16 },
  { 290, 9, 16, 11, 1, -16 },
  { 308, 9, 16, 11, 1, -16 },
  { 326, 9, 16, 11, 1, -16 },
  { 344, 1, 12, 5, 2, -12 },
  { 346, 2, 15, 5, 1, -12 },
  { 350, 9, 10, 11, 1, -13 },
  { 362, 9, 6, 11, 1, -11 },
  { 369, 9, 10, 11, 1, -13 },
  { 381, 8, 16, 8, 0, -16 },
  { 397, 15, 18, 17, 1, -16 },
  { 431, 12, 16, 12, 0, -16 },
  { 455, 9, 16, 12, 2, -16 },
  { 473, 11, 16, 12, 1, -16 },
  { 495, 11, 16, 14, 2, -16 },
  { 517, 8, 16, 11, 2, -16 },
  { 533, 8, 16, 10, 2, -16 },
  { 549, 12, 16, 14, 1, -16 },
  { 573, 10, 16, 14, 2, -16 },
  { 593, 4, 16, 6, 1, -16 },
  { 601, 5, 20, 5, -2, -16 },
  { 614, 10, 16, 12, 2, -16 },
  { 634, 8, 16, 10, 2, -16 },
  { 650, 14, 16, 18, 2, -16 },
  { 678, 10, 16, 14, 2, -16 },
  { 698, 13, 16, 15, 1, -16 },
  { 724, 9, 16, 12, 2, -16 },
  { 742, 13, 20, 15, 1, -16 },
  { 775, 9, 16, 12, 2, -16 },
  { 793, 9, 16, 11, 1, -16 },
  { 811, 10, 16, 10, 0, -16 },
  { 831, 10, 16, 14, 2, -16 },
  { 851, 11, 16, 11, 0, -16 },
  { 873, 18, 16, 18, 0, -16 },
  { 909, 11, 16, 11, 0, -16 },
  { 931, 10, 16, 10, 0, -16 },
  { 951, 9, 16, 11, 1, -16 },
  { 969, 4, 20, 7, 2, -16 },
  { 979, 7, 16, 8, 0, -16 },
  { 993, 4, 20, 7, 1, -16 },
  { 1003, 10, 9, 11, 1, -16 },
  { 1015, 9, 1, 9, 0, 2 },
  { 1017, 4, 4, 6, 1, -17 },
  { 1019, 8, 12, 11, 1, -12 },
  { 1031, 9, 17, 12, 2, -17 },
  { 1051, 8, 12, 9, 1, -12 },
  { 1063, 9, 17, 12, 1, -17 },
  { 1083, 9, 12, 11, 1, -12 },
  { 1097, 7, 17, 6, 0, -17 },
  { 1112, 9, 17, 12, 1, -12 },
  { 1132, 8, 17, 12, 2, -17 },
  { 1149, 1, 16, 5, 2, -16 },
  { 1151, 4, 21, 5, -1, -16 },
  { 1162, 8, 17, 10, 2, -17 },
  { 1179, 1, 17, 5, 2, -17 },
  { 1182, 14, 12, 18, 2, -12 },
  { 1203, 8, 12, 12, 2, -12 },
  { 1215, 10, 12, 12, 1, -12 },
  { 1230, 9, 17, 12, 2, -12 },
  { 1250, 9, 17, 12, 1, -12 },
  { 1270, 5, 12, 8, 2, -12 },
  { 1278, 7, 12, 9, 1, -12 },
  { 1289, 6, 14, 7, 0, -14 },
  { 1300, 8, 12, 12, 2, -12 },
  { 1312, 9, 12, 9, 0, -12 },
  { 1326, 15, 12, 15, 0, -12 },
  { 1349, 9, 12, 10, 0, -12 },
  { 1363, 9, 17, 9, 0, -12 },
  { 1383, 7, 12, 9, 1, -12 },
  { 1394, 6, 20, 8, 1, -16 },
  { 1409, 1, 22, 11, 5, -17 },
  { 1412, 6, 20, 8, 1, -16 },
  { 1427, 9, 2, 11, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_Light22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light22pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT22PT7B_H_
