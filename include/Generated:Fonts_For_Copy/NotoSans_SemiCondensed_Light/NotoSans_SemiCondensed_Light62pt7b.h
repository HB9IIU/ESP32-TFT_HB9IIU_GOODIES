#ifndef _NOTOSANS_SEMICONDENSED_LIGHT62PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light62pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBC, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x00, 0x00, 0x00,
  0x00, 0x9E, 0xFF, 0xFF, 0xE6, 0x00, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x39, 0xC0, 0xE6,
  0x03, 0x98, 0x06, 0x60, 0x19, 0x80, 0x66, 0x01, 0x98, 0x06, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x30, 0x00, 0x03, 0x80, 0x18, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x01, 0xC0, 0x1C, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x70, 0x00, 0x07, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x38, 0x01,
  0x80, 0x00, 0x1C, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0x80, 0x38, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x01, 0xC0,
  0x0C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x3F, 0xBB,
  0xFC, 0x3E, 0x1C, 0x0E, 0x1E, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x0E, 0x03,
  0x80, 0x0F, 0x01, 0xC0, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0x70, 0x01, 0xE0,
  0x38, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x0F,
  0x83, 0x80, 0x03, 0xE1, 0xC0, 0x00, 0xFC, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0x9F, 0x80, 0x01, 0xC3, 0xE0, 0x00, 0xE0, 0xF8, 0x00, 0x70,
  0x3C, 0x00, 0x38, 0x0F, 0x00, 0x1C, 0x07, 0x80, 0x0E, 0x03, 0xC0, 0x07,
  0x00, 0xE0, 0x03, 0x80, 0xF0, 0x01, 0xC0, 0x78, 0x00, 0xE0, 0x38, 0x00,
  0x70, 0x3C, 0x00, 0x38, 0x1E, 0xE0, 0x1C, 0x3E, 0x7F, 0x0E, 0x7E, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0x00, 0x1F, 0xF8, 0x00, 0x0E, 0x00, 0x3C, 0x3C, 0x00, 0x0E, 0x00,
  0x38, 0x1E, 0x00, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x00, 0xE0,
  0x07, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x01,
  0xC0, 0x00, 0xE0, 0x07, 0x03, 0xC0, 0x00, 0xE0, 0x07, 0x03, 0x80, 0x00,
  0xE0, 0x07, 0x07, 0x80, 0x00, 0xE0, 0x07, 0x07, 0x00, 0x00, 0xE0, 0x07,
  0x0F, 0x07, 0xE0, 0x60, 0x07, 0x0E, 0x1F, 0xF0, 0x70, 0x0E, 0x0E, 0x3E,
  0xF8, 0x70, 0x0E, 0x1C, 0x38, 0x3C, 0x70, 0x0E, 0x1C, 0x78, 0x1C, 0x38,
  0x1C, 0x38, 0x70, 0x0E, 0x3C, 0x3C, 0x38, 0x70, 0x0E, 0x1F, 0xF8, 0x70,
  0xE0, 0x0E, 0x0F, 0xF0, 0x70, 0xE0, 0x0E, 0x03, 0xE0, 0xE0, 0xE0, 0x07,
  0x00, 0x00, 0xE0, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x07, 0x00, 0x01,
  0xC0, 0xE0, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x07, 0x00, 0x03, 0x80, 0xE0,
  0x07, 0x00, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x07, 0x00,
  0x0F, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x1E, 0x00,
  0xE0, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x1E, 0x00, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x70,
  0x00, 0x3C, 0x3C, 0x00, 0x70, 0x00, 0x1F, 0xF8, 0x00, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0E, 0x03,
  0xC0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x0F,
  0x7C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00,
  0x0F, 0x8F, 0x80, 0x07, 0x87, 0x81, 0xF0, 0x01, 0xC3, 0xC0, 0x3C, 0x00,
  0x71, 0xF0, 0x07, 0x80, 0x3C, 0x78, 0x00, 0xF0, 0x0E, 0x1C, 0x00, 0x1E,
  0x03, 0x8F, 0x00, 0x03, 0xC1, 0xE3, 0xC0, 0x00, 0xF8, 0x70, 0xF0, 0x00,
  0x1F, 0x3C, 0x3C, 0x00, 0x03, 0xCE, 0x0F, 0x00, 0x00, 0x7F, 0x83, 0xC0,
  0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x07,
  0x80, 0x00, 0x3F, 0x81, 0xE0, 0x00, 0x3F, 0xF0, 0x3C, 0x00, 0x1F, 0x3C,
  0x0F, 0xC0, 0x1F, 0x87, 0x81, 0xFF, 0xFF, 0xC0, 0xF0, 0x3F, 0xFF, 0xC0,
  0x1E, 0x03, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0x66, 0x66, 0x66, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C,
  0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0x70, 0x07, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E,
  0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78,
  0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x80, 0x18, 0x02,
  0xF0, 0x18, 0x0E, 0xFE, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xE7, 0x00,
  0x01, 0xC7, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0x81, 0xC0, 0x07, 0x81, 0xE0,
  0x0F, 0x00, 0xF0, 0x1F, 0x00, 0xF8, 0x06, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x11, 0xE7, 0xFF, 0x7D, 0xE3, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0x87, 0xE0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x0F, 0x01, 0xE0, 0x01, 0xE0,
  0xF0, 0x00, 0x38, 0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x71, 0xE0, 0x00, 0x1C, 0x78, 0x00, 0x07, 0x9C, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x1E, 0x70, 0x00, 0x07,
  0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0x81, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x0F,
  0x00, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x0F,
  0xC0, 0x7F, 0x07, 0xDC, 0x3E, 0x71, 0xF1, 0xCF, 0x87, 0xF8, 0x1D, 0xC0,
  0x72, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x7E, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x07, 0xF0, 0x7F,
  0x07, 0xC0, 0x07, 0xC1, 0x80, 0x01, 0xE0, 0x80, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0x0F, 0xC0, 0x07,
  0xC3, 0x80, 0x01, 0xF1, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x80, 0x00, 0x3E, 0x78, 0x00, 0x7E, 0x3F, 0xE3, 0xFE, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x78, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x78,
  0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x38, 0x0E,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80,
  0x01, 0xC0, 0x0E, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x01, 0xE0,
  0x00, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x38, 0x07, 0x00, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x71, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7E, 0x07,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x80, 0x00, 0x7C, 0xE0, 0x01,
  0xF8, 0xFF, 0xBF, 0xF0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03,
  0xF8, 0x18, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x07, 0xFE, 0x01, 0xC3, 0xFF, 0xE0, 0x73, 0xFF, 0xFC, 0x1D, 0xE0, 0x0F,
  0x87, 0x70, 0x01, 0xF3, 0xF8, 0x00, 0x3C, 0xFC, 0x00, 0x07, 0xBE, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x0E, 0x38, 0x00,
  0x03, 0x8F, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x3C, 0x0F,
  0x00, 0x1E, 0x01, 0xE0, 0x0F, 0x80, 0x7F, 0xBF, 0xC0, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x03, 0xF0, 0x1F, 0x00, 0x3E, 0x0F, 0x80,
  0x07, 0x83, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x1E,
  0x00, 0x01, 0xC7, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x1C, 0x78, 0x00, 0x07,
  0x0E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x1E, 0x00,
  0x3C, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0xCF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xDF, 0x80,
  0x07, 0xC1, 0xF8, 0x03, 0xC0, 0x1F, 0x01, 0xE0, 0x03, 0xE0, 0xF0, 0x00,
  0x7C, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x0E, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x79, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x81, 0xFE,
  0x1F, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x0B, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xF8, 0x7E,
  0x01, 0xE0, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0xF0, 0x00,
  0x3C, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x6E,
  0x78, 0x00, 0x77, 0x1F, 0x00, 0xF3, 0x87, 0xFF, 0xF1, 0xC1, 0xFF, 0xF1,
  0xE0, 0x3F, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x0F,
  0x1F, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF7, 0xFF, 0xFF, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x4F, 0x7F, 0xFF, 0xF3, 0x00, 0x1E, 0x1F,
  0x1F, 0x1F, 0x1E, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x70,
  0x70, 0x70, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xE1, 0xFC, 0x70, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xFF,
  0x00, 0x38, 0x38, 0x00, 0x7F, 0xFC, 0x03, 0x8E, 0x00, 0x3F, 0xFF, 0x80,
  0x71, 0xC0, 0x0F, 0x80, 0xE0, 0x0E, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xCE,
  0x00, 0x70, 0x03, 0x80, 0x1D, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xB8, 0x03,
  0x80, 0x0E, 0x00, 0x77, 0x00, 0xF0, 0x01, 0xC0, 0x0E, 0xE0, 0x1C, 0x00,
  0x38, 0x01, 0xFC, 0x03, 0x80, 0x07, 0x00, 0x3F, 0x00, 0x70, 0x00, 0xE0,
  0x07, 0xE0, 0x0E, 0x00, 0x1C, 0x00, 0xFC, 0x01, 0xC0, 0x03, 0x80, 0x1F,
  0x80, 0x38, 0x00, 0x70, 0x03, 0xF0, 0x07, 0x00, 0x0E, 0x00, 0xEE, 0x00,
  0xE0, 0x03, 0xC0, 0x1D, 0xC0, 0x1C, 0x00, 0x78, 0x03, 0x9C, 0x03, 0x80,
  0x0F, 0x00, 0x73, 0x80, 0x78, 0x03, 0xE0, 0x1C, 0x70, 0x07, 0x00, 0x6E,
  0x03, 0x8E, 0x00, 0xF0, 0x1D, 0xC0, 0xE1, 0xC0, 0x0F, 0xDF, 0x1F, 0xFC,
  0x3C, 0x00, 0xFF, 0xC1, 0xFF, 0x03, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x07, 0x87, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00,
  0x70, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x1C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x03, 0xBC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0x80, 0x03, 0xF8,
  0xE0, 0x00, 0x3E, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x1E, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x1E, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x0F, 0x8E, 0x00, 0x0F,
  0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0E, 0x00,
  0x7F, 0xC3, 0x80, 0x00, 0xF8, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xB8,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0xFC, 0xE0, 0x00, 0xFE,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xF0, 0x7F,
  0x03, 0xF0, 0x00, 0x70, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x0E, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x38, 0x00, 0x7F, 0x80, 0xE0, 0x00, 0x3F, 0x03, 0x80, 0x00,
  0x3E, 0x0E, 0x00, 0x00, 0x7C, 0x38, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x07, 0xB8,
  0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x1E,
  0xE0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x07, 0x8E, 0x00,
  0x00, 0x1E, 0x38, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0xC3, 0x80, 0x00,
  0x3E, 0x0E, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x1F, 0x80, 0xE0, 0x07, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x81, 0xFE, 0x01, 0xF8, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0x04, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07,
  0x78, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x07,
  0x3C, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x07, 0x1F, 0x00, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x07, 0x07, 0xE0, 0x00, 0x07,
  0x03, 0xF8, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x1F, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x03, 0xFC, 0xFF, 0xFF, 0xFF,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0xA0, 0x3E, 0xFF, 0xF3, 0xFF, 0x8F, 0xF8,
  0x00, 0xE0, 0x00, 0x07, 0xDC, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x3C, 0x70,
  0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x3C,
  0x07, 0x00, 0x0F, 0x80, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x78, 0x03, 0x80,
  0x1E, 0x00, 0x70, 0x07, 0x80, 0x0E, 0x01, 0xF0, 0x01, 0xC0, 0x3C, 0x00,
  0x38, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x1C, 0x3E,
  0x00, 0x03, 0x87, 0x80, 0x00, 0x71, 0xF0, 0x00, 0x0E, 0x7F, 0x00, 0x01,
  0xDF, 0xE0, 0x00, 0x3F, 0x9E, 0x00, 0x07, 0xE3, 0xC0, 0x00, 0xF8, 0x3C,
  0x00, 0x1E, 0x03, 0xC0, 0x03, 0x80, 0x78, 0x00, 0x70, 0x07, 0x80, 0x0E,
  0x00, 0xF8, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xF0, 0x07, 0x00, 0x1F,
  0x00, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x1E, 0x03, 0x80, 0x03, 0xC0, 0x70,
  0x00, 0x3C, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x07,
  0x87, 0x00, 0x00, 0xF8, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x1F, 0x70, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0x7E, 0xE0, 0x00, 0x00, 0x1D, 0xFB,
  0xC0, 0x00, 0x00, 0xE7, 0xE7, 0x00, 0x00, 0x03, 0x9F, 0x9C, 0x00, 0x00,
  0x1E, 0x7E, 0x78, 0x00, 0x00, 0x71, 0xF8, 0xE0, 0x00, 0x01, 0xC7, 0xE3,
  0x80, 0x00, 0x0F, 0x1F, 0x8F, 0x00, 0x00, 0x38, 0x7E, 0x1C, 0x00, 0x00,
  0xE1, 0xF8, 0x78, 0x00, 0x07, 0x87, 0xE1, 0xE0, 0x00, 0x1C, 0x1F, 0x83,
  0x80, 0x00, 0x70, 0x7E, 0x0F, 0x00, 0x03, 0xC1, 0xF8, 0x3C, 0x00, 0x0E,
  0x07, 0xE0, 0x70, 0x00, 0x38, 0x1F, 0x81, 0xE0, 0x01, 0xC0, 0x7E, 0x03,
  0x80, 0x07, 0x01, 0xF8, 0x0E, 0x00, 0x3C, 0x07, 0xE0, 0x3C, 0x00, 0xE0,
  0x1F, 0x80, 0x70, 0x03, 0x80, 0x7E, 0x01, 0xC0, 0x1E, 0x01, 0xF8, 0x07,
  0x80, 0x70, 0x07, 0xE0, 0x0E, 0x01, 0xC0, 0x1F, 0x80, 0x3C, 0x0F, 0x00,
  0x7E, 0x00, 0xF0, 0x38, 0x01, 0xF8, 0x01, 0xC0, 0xE0, 0x07, 0xE0, 0x07,
  0x87, 0x80, 0x1F, 0x80, 0x0E, 0x1C, 0x00, 0x7E, 0x00, 0x38, 0xF0, 0x01,
  0xF8, 0x00, 0xF3, 0x80, 0x07, 0xE0, 0x01, 0xCE, 0x00, 0x1F, 0x80, 0x07,
  0x78, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0x80, 0x01, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xBC, 0x00, 0x00, 0xFD, 0xE0, 0x00, 0x07,
  0xE7, 0x80, 0x00, 0x3F, 0x3C, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x0F, 0xC3,
  0x80, 0x00, 0x7E, 0x1E, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x1F, 0x83, 0xC0,
  0x00, 0xFC, 0x0F, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x3F, 0x01, 0xE0, 0x01,
  0xF8, 0x07, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x7E, 0x00, 0xF0, 0x03, 0xF0,
  0x07, 0x80, 0x1F, 0x80, 0x1E, 0x00, 0xFC, 0x00, 0xF0, 0x07, 0xE0, 0x03,
  0xC0, 0x3F, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x78, 0x0F, 0xC0, 0x01, 0xE0,
  0x7E, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0x3C, 0x1F, 0x80, 0x01, 0xE0, 0xFC,
  0x00, 0x07, 0x87, 0xE0, 0x00, 0x1E, 0x3F, 0x00, 0x00, 0xF1, 0xF8, 0x00,
  0x03, 0xCF, 0xC0, 0x00, 0x1E, 0x7E, 0x00, 0x00, 0x7B, 0xF0, 0x00, 0x01,
  0xDF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00,
  0xF8, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x1C, 0x3C,
  0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x07,
  0x3C, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x00, 0xF3, 0x80, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x03, 0x8F,
  0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x7C, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xE0, 0x03, 0xF8, 0xE0, 0x00, 0x7C,
  0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x7C,
  0xE0, 0x01, 0xF8, 0xE0, 0x0F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80,
  0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0x0F, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0xF8, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x03, 0x8F, 0x00, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x7C, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03,
  0x80, 0x0F, 0xE0, 0xE0, 0x00, 0x7C, 0x38, 0x00, 0x0F, 0x8E, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0xF3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x07,
  0x8E, 0x00, 0x03, 0xC3, 0x80, 0x01, 0xF0, 0xE0, 0x00, 0xF8, 0x38, 0x01,
  0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x38,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0x80, 0x1E, 0x00, 0xE0, 0x03, 0xC0,
  0x38, 0x00, 0xF0, 0x0E, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x00,
  0xF0, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x00, 0xF0, 0xE0,
  0x00, 0x3C, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x3C,
  0xE0, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x0F, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC1, 0xFE,
  0x1F, 0xC1, 0xF0, 0x00, 0xE1, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x80, 0x00, 0x3E, 0x78, 0x00, 0x7E,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF8, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0x0E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x38, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x3C, 0x1C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x78, 0x0E, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0xF0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80,
  0x01, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x70, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x0E,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x70, 0x00, 0x1E, 0x1E, 0x00, 0x07,
  0x3C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x9E, 0x00, 0x07, 0x03, 0xC0, 0x01,
  0xC7, 0x00, 0x07, 0x81, 0xE0, 0x01, 0xE3, 0x80, 0x03, 0xC0, 0xF0, 0x00,
  0xE1, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x07, 0x80,
  0x1C, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x01, 0xC0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0xE0, 0x0F, 0x00, 0x3C,
  0x03, 0x80, 0x78, 0x07, 0x80, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x07,
  0x00, 0xE0, 0x0E, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x07, 0x01, 0xE0, 0x01,
  0xE0, 0x70, 0x03, 0xC0, 0xF0, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x00,
  0x38, 0x1C, 0x00, 0x70, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x38, 0x3C, 0x00,
  0x0F, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0xC3, 0x80, 0x03, 0x8F, 0x00, 0x00, 0xF3, 0xC0, 0x01, 0xC7, 0x80,
  0x00, 0x79, 0xC0, 0x00, 0xF3, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0,
  0x00, 0x0E, 0x70, 0x00, 0x1D, 0xE0, 0x00, 0x07, 0x78, 0x00, 0x0E, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0x78, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x78, 0x0F,
  0x00, 0x03, 0xC0, 0x1C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x38, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x03, 0x87, 0x80, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x1C, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xC0, 0x0E, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x01, 0xE0, 0x01, 0xE0, 0x0F,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1E, 0x0E,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x70, 0x0F, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x38, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1C, 0x03, 0x80,
  0x03, 0xC0, 0x3C, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x00, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x70, 0x1E, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1C, 0x78,
  0x00, 0x01, 0xE7, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x0F, 0xFF,
  0x01, 0xFF, 0xFE, 0x07, 0xF1, 0xFC, 0x1C, 0x00, 0xF8, 0x40, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xF0, 0x73, 0xF0, 0x01, 0xDF,
  0x00, 0x07, 0x78, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x03, 0x77, 0x80, 0x3D, 0xDF, 0xC3, 0xE7, 0x3F,
  0xFF, 0x1C, 0x3F, 0xF0, 0x30, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x20, 0x03, 0x83, 0xFF, 0x81, 0xC3, 0xFF, 0xE0, 0xE3, 0xF7,
  0xF8, 0x73, 0x80, 0x3E, 0x3B, 0x80, 0x0F, 0x9D, 0x80, 0x03, 0xCF, 0x80,
  0x00, 0xF7, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1D, 0xF0, 0x00,
  0x1E, 0xF8, 0x00, 0x0F, 0x7E, 0x00, 0x0F, 0x3B, 0x80, 0x0F, 0x9C, 0xE0,
  0x0F, 0x8E, 0x7F, 0x7F, 0x87, 0x1F, 0xFF, 0x83, 0x83, 0xFF, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xF0, 0xFC, 0x01, 0x87, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x20,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x05, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x03, 0x00, 0xF0, 0x1F, 0xFC, 0x3C, 0x0F,
  0xFF, 0x8F, 0x07, 0xFB, 0xF3, 0xC3, 0xE0, 0x0E, 0xF1, 0xF0, 0x01, 0xFC,
  0xF8, 0x00, 0x3F, 0x3C, 0x00, 0x0F, 0xCE, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x7D, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x7D, 0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0xCF,
  0x00, 0x03, 0xF1, 0xE0, 0x01, 0xFC, 0x7C, 0x00, 0xE7, 0x0F, 0xF3, 0xF1,
  0xC1, 0xFF, 0xF8, 0x70, 0x1F, 0xFC, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0xF8,
  0x07, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x78, 0x00, 0x1C, 0x38,
  0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x08, 0x3E, 0x00, 0x18, 0x0F,
  0xF1, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0x87,
  0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xF0, 0x70, 0x3F,
  0xFE, 0x1C, 0x1F, 0xEF, 0xC7, 0x0F, 0x80, 0x3B, 0xC7, 0xC0, 0x07, 0xF3,
  0xE0, 0x00, 0xFC, 0xF0, 0x00, 0x3F, 0x38, 0x00, 0x07, 0xDE, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x78, 0x00,
  0x03, 0xDE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x7C, 0xF0, 0x00, 0x3F, 0x3C,
  0x00, 0x0F, 0xC7, 0x80, 0x06, 0xF0, 0xF0, 0x03, 0xBC, 0x3F, 0x8F, 0xCF,
  0x03, 0xFF, 0xE3, 0xC0, 0x7F, 0xF0, 0xF0, 0x01, 0x80, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x80, 0x00, 0x7C, 0x38, 0x00, 0x3E, 0x0F, 0xC0, 0x3F, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0x80,
  0x38, 0x3F, 0xF8, 0x70, 0xFF, 0xF8, 0xE3, 0xF3, 0xF9, 0xCE, 0x00, 0xFB,
  0xB8, 0x00, 0xF7, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0x80,
  0x7B, 0xFE, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x07, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD,
  0xEF, 0x7B, 0xDE, 0xF7, 0x80, 0x01, 0xE0, 0x3C, 0x0F, 0x80, 0xF0, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x87, 0x9F,
  0xF3, 0xFC, 0x7E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x07, 0xB8, 0x00, 0x3C,
  0xE0, 0x01, 0xE3, 0x80, 0x07, 0x8E, 0x00, 0x3C, 0x38, 0x01, 0xE0, 0xE0,
  0x0F, 0x03, 0x80, 0x78, 0x0E, 0x01, 0xE0, 0x38, 0x0F, 0x00, 0xE0, 0x78,
  0x03, 0x83, 0xC0, 0x0E, 0x1E, 0x00, 0x38, 0x70, 0x00, 0xE3, 0xE0, 0x03,
  0x9F, 0xC0, 0x0E, 0xFF, 0x00, 0x3B, 0x9E, 0x00, 0xFC, 0x78, 0x03, 0xE0,
  0xF0, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x80, 0xE0, 0x0F, 0x03, 0x80, 0x1E,
  0x0E, 0x00, 0x78, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x8E,
  0x00, 0x0F, 0x38, 0x00, 0x3C, 0xE0, 0x00, 0x7B, 0x80, 0x00, 0xEE, 0x00,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x18, 0x00, 0x03,
  0x00, 0xE0, 0xFF, 0x80, 0x3F, 0xF0, 0xE3, 0xFF, 0xE0, 0xFF, 0xF8, 0xE7,
  0xEF, 0xF1, 0xF9, 0xFC, 0xEF, 0x00, 0xF3, 0xC0, 0x3E, 0xEC, 0x00, 0x7B,
  0x80, 0x1E, 0xFC, 0x00, 0x7F, 0x00, 0x0E, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x0E,
  0x01, 0xC1, 0xFF, 0xC3, 0x87, 0xFF, 0xC7, 0x1F, 0x9F, 0xCE, 0x70, 0x07,
  0xDD, 0xC0, 0x07, 0xBB, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFD,
  0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xC1,
  0xE0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x71, 0xE0, 0x00,
  0x0F, 0x38, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1D, 0xE0,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xDF, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x70, 0x7F, 0xF0, 0x38, 0x7F, 0xFC, 0x1C, 0x7E, 0xFF, 0x0E,
  0x70, 0x07, 0xC7, 0x70, 0x01, 0xF3, 0xB0, 0x00, 0x79, 0xF0, 0x00, 0x1E,
  0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xBE, 0x00, 0x03, 0xDF,
  0x00, 0x01, 0xEE, 0xC0, 0x01, 0xE7, 0x70, 0x01, 0xF3, 0x9C, 0x01, 0xF1,
  0xC7, 0xEF, 0xF0, 0xE1, 0xFF, 0xF0, 0x70, 0x7F, 0xE0, 0x38, 0x03, 0x80,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x7F, 0xF0, 0x70, 0x3F, 0xFE, 0x1C, 0x1F, 0xCF, 0xC7, 0x0F, 0x80,
  0x7B, 0xC7, 0x80, 0x07, 0xF3, 0xE0, 0x00, 0xFC, 0xF0, 0x00, 0x3F, 0x38,
  0x00, 0x07, 0xDE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x7D, 0xC0, 0x00, 0x0F,
  0x70, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x7C, 0xF0, 0x00, 0x3F, 0x3C, 0x00, 0x0F, 0xC7, 0x80, 0x06, 0xF1, 0xF0,
  0x07, 0xBC, 0x3F, 0x8F, 0xCF, 0x07, 0xFF, 0xE3, 0xC0, 0x7F, 0xE0, 0xF0,
  0x01, 0x80, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x18, 0xE0, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0x80, 0xEE,
  0x00, 0xEC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x7F, 0xFC, 0x1F, 0xFF, 0xF3, 0xF8, 0xFE, 0x7C, 0x00, 0x67, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x00, 0x1E,
  0xE0, 0x03, 0xEF, 0xF3, 0xFC, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0xF3, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0x3C, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xF7, 0x80, 0x0E,
  0xEF, 0x80, 0x39, 0xCF, 0xE7, 0xF3, 0x8F, 0xFF, 0xC7, 0x0F, 0xFE, 0x0E,
  0x00, 0xC0, 0x00, 0xF0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x79, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0xF0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x80,
  0xE0, 0x01, 0xC0, 0x38, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1E, 0x01, 0xE0, 0x03, 0x80, 0x70, 0x00, 0xE0,
  0x1C, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00,
  0x78, 0x78, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00,
  0x0E, 0xF0, 0x00, 0x7E, 0x00, 0x0E, 0x70, 0x00, 0x7E, 0x00, 0x0E, 0x70,
  0x00, 0x7E, 0x00, 0x1E, 0x78, 0x00, 0x7E, 0x00, 0x1C, 0x78, 0x00, 0xE7,
  0x00, 0x1C, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0x38, 0x00, 0xE7, 0x00, 0x3C,
  0x3C, 0x01, 0xE7, 0x00, 0x38, 0x3C, 0x01, 0xC3, 0x80, 0x38, 0x1C, 0x01,
  0xC3, 0x80, 0x38, 0x1C, 0x01, 0xC3, 0x80, 0x78, 0x1E, 0x03, 0xC3, 0xC0,
  0x70, 0x1E, 0x03, 0x81, 0xC0, 0x70, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x0E,
  0x07, 0x81, 0xC0, 0xF0, 0x0F, 0x07, 0x01, 0xE0, 0xE0, 0x07, 0x07, 0x00,
  0xE0, 0xE0, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x07, 0x0F, 0x00, 0xF1, 0xE0,
  0x07, 0x8E, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x03, 0x8E,
  0x00, 0x71, 0xC0, 0x03, 0x9C, 0x00, 0x7B, 0xC0, 0x03, 0xDC, 0x00, 0x3B,
  0x80, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x01,
  0xF8, 0x00, 0x3B, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0x07, 0x9E, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x83, 0xC0, 0x03,
  0xC0, 0xE0, 0x03, 0xC0, 0x78, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x01,
  0xE0, 0x03, 0xC0, 0xF0, 0x00, 0xE0, 0xF0, 0x00, 0x78, 0x70, 0x00, 0x1E,
  0x78, 0x00, 0x07, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0E, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x07, 0x80,
  0x07, 0x81, 0xC0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1E,
  0x01, 0xC0, 0x07, 0x81, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x07,
  0x8F, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x1E, 0x00,
  0x0E, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x70, 0x07,
  0x00, 0x3C, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x0E, 0x01, 0xE0,
  0x03, 0x80, 0x78, 0x00, 0xF0, 0x1C, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x03,
  0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x1E, 0x00, 0x03,
  0xC7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0xB8, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x87, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xF0,
  0x07, 0xFC, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x0F, 0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x5F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0x80, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xA0, 0x00, 0x7F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Light62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 5, 45, 15, 5, -44 },
  { 30, 14, 16, 22, 4, -44 },
  { 58, 33, 44, 35, 1, -44 },
  { 240, 25, 51, 32, 3, -47 },
  { 400, 40, 46, 46, 3, -45 },
  { 630, 34, 46, 38, 3, -45 },
  { 826, 4, 16, 12, 4, -44 },
  { 834, 12, 54, 17, 3, -44 },
  { 915, 12, 54, 17, 2, -44 },
  { 996, 24, 23, 30, 3, -47 },
  { 1065, 26, 29, 32, 3, -36 },
  { 1160, 8, 15, 13, 2, -7 },
  { 1175, 15, 3, 19, 2, -18 },
  { 1181, 6, 7, 14, 4, -6 },
  { 1187, 20, 44, 22, 1, -44 },
  { 1297, 26, 46, 32, 3, -45 },
  { 1447, 14, 44, 32, 5, -44 },
  { 1524, 25, 45, 32, 3, -45 },
  { 1665, 25, 46, 32, 3, -45 },
  { 1809, 30, 45, 32, 1, -45 },
  { 1978, 24, 45, 32, 4, -44 },
  { 2113, 26, 46, 32, 3, -45 },
  { 2263, 26, 44, 32, 3, -44 },
  { 2406, 26, 46, 32, 3, -45 },
  { 2556, 25, 46, 32, 3, -45 },
  { 2700, 5, 34, 14, 5, -33 },
  { 2722, 8, 41, 14, 2, -33 },
  { 2763, 26, 28, 32, 3, -36 },
  { 2854, 26, 16, 32, 3, -30 },
  { 2906, 26, 28, 32, 3, -36 },
  { 2997, 20, 46, 23, 1, -45 },
  { 3112, 43, 50, 49, 3, -44 },
  { 3381, 33, 44, 33, 0, -44 },
  { 3563, 26, 44, 35, 6, -44 },
  { 3706, 28, 46, 34, 4, -45 },
  { 3867, 30, 44, 39, 6, -44 },
  { 4032, 21, 44, 31, 6, -44 },
  { 4148, 21, 44, 28, 6, -44 },
  { 4264, 32, 46, 41, 4, -45 },
  { 4448, 28, 44, 40, 6, -44 },
  { 4602, 12, 44, 18, 3, -44 },
  { 4668, 14, 55, 15, -5, -44 },
  { 4765, 27, 44, 32, 6, -44 },
  { 4914, 21, 44, 28, 6, -44 },
  { 5030, 38, 44, 50, 6, -44 },
  { 5239, 29, 44, 41, 6, -44 },
  { 5399, 35, 46, 42, 4, -45 },
  { 5601, 24, 44, 33, 6, -44 },
  { 5733, 35, 56, 42, 4, -45 },
  { 5978, 26, 44, 33, 6, -44 },
  { 6121, 25, 46, 31, 3, -45 },
  { 6265, 29, 44, 29, 0, -44 },
  { 6425, 30, 45, 40, 5, -44 },
  { 6594, 32, 44, 32, 0, -44 },
  { 6770, 49, 44, 51, 1, -44 },
  { 7040, 30, 44, 30, 0, -44 },
  { 7205, 29, 44, 29, 0, -44 },
  { 7365, 26, 44, 30, 2, -44 },
  { 7508, 13, 54, 20, 5, -44 },
  { 7596, 20, 44, 22, 1, -44 },
  { 7706, 13, 54, 20, 2, -44 },
  { 7794, 28, 25, 32, 2, -44 },
  { 7882, 26, 2, 26, 0, 6 },
  { 7889, 12, 9, 16, 2, -47 },
  { 7903, 22, 35, 30, 3, -34 },
  { 8000, 25, 48, 34, 5, -47 },
  { 8150, 21, 35, 26, 3, -34 },
  { 8242, 26, 48, 34, 3, -47 },
  { 8398, 25, 35, 31, 3, -34 },
  { 8508, 19, 47, 17, 1, -47 },
  { 8620, 26, 49, 34, 3, -34 },
  { 8780, 23, 47, 33, 5, -47 },
  { 8916, 5, 45, 14, 4, -45 },
  { 8945, 11, 60, 14, -2, -45 },
  { 9028, 22, 47, 28, 5, -47 },
  { 9158, 3, 47, 13, 5, -47 },
  { 9176, 40, 34, 50, 5, -34 },
  { 9346, 23, 34, 33, 5, -34 },
  { 9444, 27, 35, 33, 3, -34 },
  { 9563, 25, 49, 34, 5, -34 },
  { 9717, 26, 49, 34, 3, -34 },
  { 9877, 16, 34, 22, 5, -34 },
  { 9945, 20, 35, 26, 3, -34 },
  { 10033, 16, 42, 19, 1, -41 },
  { 10117, 23, 34, 33, 5, -33 },
  { 10215, 26, 33, 26, 0, -33 },
  { 10323, 40, 33, 42, 1, -33 },
  { 10488, 25, 33, 28, 1, -33 },
  { 10592, 26, 48, 26, 0, -33 },
  { 10748, 20, 33, 25, 2, -33 },
  { 10831, 18, 54, 22, 2, -44 },
  { 10953, 3, 62, 30, 14, -47 },
  { 10977, 18, 54, 22, 2, -44 },
  { 11099, 26, 6, 32, 3, -25 },
};

const GFXfont NotoSans_SemiCondensed_Light62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light62pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT62PT7B_H_
