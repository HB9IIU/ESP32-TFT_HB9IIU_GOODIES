#ifndef _NOTOSANS_SEMICONDENSED_LIGHT39PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHT39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Light.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Light39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xED, 0xB6, 0xDB, 0x49, 0x24, 0x00, 0x1F, 0xF0,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x00, 0x81,
  0x80, 0x18, 0x18, 0x01, 0x81, 0x80, 0x18, 0x18, 0x01, 0x81, 0x00, 0x18,
  0x30, 0x01, 0x03, 0x00, 0x30, 0x30, 0x03, 0x03, 0x07, 0xFF, 0xFF, 0x03,
  0x02, 0x00, 0x30, 0x60, 0x02, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00,
  0x60, 0x60, 0x06, 0x04, 0x00, 0x60, 0xC0, 0xFF, 0xFF, 0xE0, 0xC0, 0xC0,
  0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x08, 0x00, 0xC1, 0x80, 0x08, 0x18,
  0x01, 0x81, 0x80, 0x18, 0x18, 0x01, 0x81, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x07, 0xE0, 0x1F, 0xFE, 0x39, 0x1C, 0x61, 0x00, 0xE1, 0x00,
  0xC1, 0x00, 0xC1, 0x00, 0xC1, 0x00, 0xE1, 0x00, 0x61, 0x00, 0x79, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0x78, 0x01, 0x1C, 0x01, 0x0E,
  0x01, 0x06, 0x01, 0x07, 0x01, 0x07, 0x01, 0x06, 0x01, 0x06, 0x81, 0x0E,
  0xF1, 0x3C, 0xFF, 0xF0, 0x0F, 0xC0, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x1E, 0x00, 0x30, 0x1F, 0x80, 0x30, 0x18, 0x60, 0x18, 0x08, 0x30, 0x18,
  0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x03, 0x03, 0x06, 0x01, 0x81, 0x83,
  0x00, 0xC0, 0xC3, 0x00, 0x60, 0x61, 0x80, 0x30, 0x31, 0x80, 0x18, 0x18,
  0xC7, 0x8C, 0x0C, 0xC7, 0xE2, 0x0C, 0x66, 0x19, 0x86, 0x62, 0x0C, 0x7E,
  0x33, 0x03, 0x1E, 0x31, 0x81, 0x80, 0x18, 0xC0, 0xC0, 0x18, 0x60, 0x60,
  0x0C, 0x30, 0x30, 0x0C, 0x18, 0x18, 0x06, 0x0C, 0x0C, 0x06, 0x06, 0x06,
  0x03, 0x03, 0x03, 0x01, 0x01, 0x83, 0x01, 0x80, 0x61, 0x80, 0xC0, 0x3B,
  0x80, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0x06, 0x00,
  0x30, 0x38, 0x03, 0x80, 0xC0, 0x1C, 0x06, 0x00, 0xE0, 0x30, 0x03, 0x03,
  0x80, 0x18, 0x18, 0x00, 0xE1, 0xC0, 0x03, 0x1C, 0x00, 0x0D, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x77, 0x00, 0x07, 0x1C, 0x06, 0x70, 0x70,
  0x33, 0x01, 0x81, 0xB0, 0x06, 0x19, 0x80, 0x38, 0xCC, 0x00, 0xEE, 0x60,
  0x03, 0xE3, 0x00, 0x0E, 0x1C, 0x00, 0x78, 0x60, 0x07, 0xC3, 0x80, 0xF3,
  0x0F, 0xFE, 0x1C, 0x3F, 0xE0, 0x70, 0xFF, 0xFF, 0xF0, 0x07, 0x0C, 0x0C,
  0x18, 0x18, 0x30, 0x30, 0x70, 0x60, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x60,
  0x30, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x07, 0xE0, 0x70, 0x30, 0x38, 0x18,
  0x1C, 0x0C, 0x0E, 0x06, 0x06, 0x06, 0x07, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C,
  0x18, 0x18, 0x30, 0x70, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x10, 0x18, 0x20, 0xFE, 0x4F, 0xBF, 0xFC, 0x03, 0x80, 0x0D, 0x00,
  0x1B, 0x00, 0x63, 0x01, 0x87, 0x07, 0x07, 0x04, 0x0C, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x77, 0x66,
  0x6E, 0xCC, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x30, 0x07, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03,
  0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18,
  0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x0C, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x38, 0x18, 0x30, 0x0C, 0x70, 0x0E,
  0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06,
  0x70, 0x0E, 0x30, 0x0C, 0x38, 0x1C, 0x1F, 0xF8, 0x07, 0xE0, 0x01, 0x81,
  0xC3, 0xE3, 0xB3, 0x9F, 0x8D, 0x86, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x0F, 0xE0, 0x3F, 0xF8, 0xF0, 0x38,
  0x40, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xE0, 0x7F, 0xF8, 0xE0, 0x1C, 0x40, 0x0C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x38, 0x01, 0xF0, 0x1F, 0xC0, 0x1F, 0xF8, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x80, 0x1C, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x6C, 0x00, 0x1B, 0x00,
  0x0C, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0xC3, 0x00, 0x70, 0xC0, 0x18,
  0x30, 0x0C, 0x0C, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x30, 0x30, 0x0C,
  0x18, 0x03, 0x0C, 0x00, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x3F, 0xFC, 0x3F, 0xFC, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x6F,
  0xC0, 0x7F, 0xF8, 0x20, 0x3C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0xC0, 0x3C, 0xFF, 0xF8, 0x7F, 0xE0, 0x01, 0xFC, 0x07,
  0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE7, 0xF0, 0xCF, 0xFC, 0xD8,
  0x0E, 0xF0, 0x06, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xE0,
  0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x07, 0x70, 0x06, 0x30, 0x06, 0x18,
  0x0C, 0x1F, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x38, 0x1C, 0x70, 0x0E, 0x60, 0x06, 0x60,
  0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x30, 0x0C, 0x38, 0x1C, 0x1C,
  0x78, 0x0F, 0xE0, 0x03, 0xC0, 0x0E, 0xF0, 0x38, 0x38, 0x70, 0x0C, 0x60,
  0x06, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x07, 0x60, 0x06, 0x70, 0x0E, 0x3F, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F,
  0xF0, 0x38, 0x38, 0x70, 0x1C, 0x60, 0x0C, 0xE0, 0x06, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0x60,
  0x0F, 0x70, 0x1B, 0x3E, 0xF7, 0x1F, 0xE6, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x7F, 0xE0, 0x7F, 0x80, 0xFF, 0xA0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x39, 0xCE, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xCE, 0x63, 0x39, 0x8C, 0x66, 0x00, 0x00, 0x01, 0x00, 0x03, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0xE0, 0x00,
  0x80, 0x00, 0x3F, 0x87, 0xFF, 0x30, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0x00, 0xF0, 0x03, 0x80,
  0x07, 0x00, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x06, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x06, 0x30, 0x0F, 0xE0, 0xCC, 0x07, 0xFC, 0x19, 0x81, 0xC1,
  0x81, 0xB0, 0x70, 0x30, 0x3C, 0x0C, 0x06, 0x07, 0x81, 0x80, 0xC0, 0xF0,
  0x60, 0x18, 0x1E, 0x0C, 0x03, 0x03, 0xC1, 0x80, 0x60, 0x78, 0x30, 0x0C,
  0x0F, 0x06, 0x03, 0x83, 0x60, 0xE0, 0x70, 0x6C, 0x0C, 0x0E, 0x0C, 0x81,
  0xC3, 0x63, 0x18, 0x1F, 0xCF, 0xC3, 0x00, 0xE0, 0x70, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x01, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x16, 0x00, 0x01, 0xB0, 0x00, 0x0D,
  0x80, 0x00, 0x6C, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00,
  0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x60, 0x30, 0x03, 0x01,
  0x80, 0x18, 0x0C, 0x01, 0x80, 0x30, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x06,
  0x00, 0x70, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x18, 0x00, 0x70, 0xC0, 0x01,
  0x86, 0x00, 0x0C, 0x60, 0x00, 0x73, 0x00, 0x01, 0xB8, 0x00, 0x0D, 0x80,
  0x00, 0x70, 0xFF, 0xC0, 0xFF, 0xF8, 0xC0, 0x3C, 0xC0, 0x0E, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0E,
  0xC0, 0x1C, 0xFF, 0xF8, 0xFF, 0xE0, 0xC0, 0xFC, 0xC0, 0x0E, 0xC0, 0x06,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x0E, 0xC0, 0x1C, 0xFF, 0xF8, 0xFF, 0xE0, 0x00, 0xFF,
  0x80, 0xFF, 0xF0, 0x70, 0x0C, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x10, 0x7F, 0xFC, 0x07,
  0xFE, 0xFF, 0xC0, 0x3F, 0xFE, 0x0C, 0x07, 0xC3, 0x00, 0x38, 0xC0, 0x07,
  0x30, 0x00, 0xEC, 0x00, 0x3B, 0x00, 0x06, 0xC0, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xB0, 0x00, 0xEC, 0x00, 0x33, 0x00, 0x1C, 0xC0, 0x0E, 0x30, 0x1F, 0x0F,
  0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0F,
  0xFF, 0x7F, 0xFB, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0xFF, 0xDF, 0xFE, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x81, 0xE0, 0x0C, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xD8,
  0x00, 0x06, 0xC0, 0x00, 0x37, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xE0, 0x00,
  0x63, 0x00, 0x03, 0x1E, 0x00, 0x18, 0x78, 0x01, 0xC0, 0xFF, 0xFE, 0x03,
  0xFF, 0xC0, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x7E, 0xFF, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x07, 0x7F, 0x3F,
  0x00, 0xC0, 0x07, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x38, 0xC0,
  0x70, 0xC0, 0xE0, 0xC0, 0xC0, 0xC1, 0x80, 0xC3, 0x80, 0xC7, 0x00, 0xCE,
  0x00, 0xDE, 0x00, 0xDE, 0x00, 0xF7, 0x00, 0xE3, 0x00, 0xC3, 0x80, 0xC1,
  0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xC0, 0x70, 0xC0, 0x30, 0xC0, 0x38, 0xC0,
  0x1C, 0xC0, 0x0C, 0xC0, 0x0E, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1B, 0xF0, 0x00, 0x1B, 0xD8, 0x00,
  0x1B, 0xD8, 0x00, 0x33, 0xD8, 0x00, 0x33, 0xCC, 0x00, 0x33, 0xCC, 0x00,
  0x63, 0xCE, 0x00, 0x63, 0xC6, 0x00, 0xE3, 0xC6, 0x00, 0xC3, 0xC7, 0x00,
  0xC3, 0xC3, 0x01, 0x83, 0xC3, 0x01, 0x83, 0xC1, 0x81, 0x83, 0xC1, 0x83,
  0x03, 0xC1, 0x83, 0x03, 0xC0, 0xC3, 0x03, 0xC0, 0xC6, 0x03, 0xC0, 0xC6,
  0x03, 0xC0, 0x6E, 0x03, 0xC0, 0x6C, 0x03, 0xC0, 0x7C, 0x03, 0xC0, 0x38,
  0x03, 0xC0, 0x38, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xF6, 0x00, 0x3D, 0xC0, 0x0F, 0x30,
  0x03, 0xCE, 0x00, 0xF1, 0x80, 0x3C, 0x30, 0x0F, 0x0E, 0x03, 0xC1, 0x80,
  0xF0, 0x70, 0x3C, 0x0C, 0x0F, 0x03, 0x83, 0xC0, 0x70, 0xF0, 0x0C, 0x3C,
  0x03, 0x8F, 0x00, 0x63, 0xC0, 0x1C, 0xF0, 0x03, 0x3C, 0x00, 0xEF, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0x01, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0xF0, 0x1E, 0x07, 0x00, 0x38, 0x38, 0x00, 0x70,
  0xC0, 0x00, 0xE7, 0x00, 0x01, 0x9C, 0x00, 0x06, 0x60, 0x00, 0x1D, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x36,
  0x00, 0x00, 0xD8, 0x00, 0x07, 0x70, 0x00, 0x19, 0xC0, 0x00, 0x63, 0x00,
  0x03, 0x8E, 0x00, 0x0C, 0x1C, 0x00, 0x60, 0x38, 0x07, 0x80, 0x7F, 0xFC,
  0x00, 0x7F, 0xC0, 0xFF, 0x01, 0xFF, 0xE3, 0x01, 0xE6, 0x00, 0xEC, 0x00,
  0xD8, 0x01, 0xB0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x6C, 0x01, 0xD8, 0x07, 0x30, 0x7C, 0x7F, 0xF0, 0xFE, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0xF0, 0x1E, 0x07, 0x00, 0x18, 0x38, 0x00, 0x70, 0xC0, 0x00,
  0xE7, 0x00, 0x01, 0x9C, 0x00, 0x06, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x36, 0x00, 0x00,
  0xD8, 0x00, 0x07, 0x60, 0x00, 0x19, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x8E,
  0x00, 0x0C, 0x1C, 0x00, 0x60, 0x38, 0x07, 0x80, 0x7F, 0xF8, 0x00, 0x7F,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0xFF, 0x80, 0xFF,
  0xF0, 0xC0, 0xF8, 0xC0, 0x1C, 0xC0, 0x0C, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0,
  0x0E, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0xC0,
  0x78, 0xFF, 0xE0, 0xFF, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0xC0,
  0x70, 0xC0, 0x30, 0xC0, 0x38, 0xC0, 0x18, 0xC0, 0x1C, 0xC0, 0x0C, 0xC0,
  0x0E, 0xC0, 0x06, 0xC0, 0x07, 0x0F, 0xF8, 0x3F, 0xFC, 0xE0, 0x13, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0F, 0x00, 0x3B, 0xFF, 0xE3, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0E, 0xC0, 0x01, 0xD8, 0x00, 0x33, 0x80, 0x0E, 0x30, 0x01,
  0x87, 0x80, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0xC0, 0x00, 0x3E, 0x00,
  0x07, 0x60, 0x00, 0x66, 0x00, 0x06, 0x70, 0x00, 0xE3, 0x00, 0x0C, 0x30,
  0x00, 0xC3, 0x80, 0x1C, 0x18, 0x01, 0x81, 0x80, 0x18, 0x1C, 0x01, 0x80,
  0xC0, 0x38, 0x0C, 0x03, 0x00, 0xE0, 0x30, 0x06, 0x07, 0x00, 0x60, 0x60,
  0x06, 0x06, 0x00, 0x30, 0xE0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x9C,
  0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x1D, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x60, 0x07, 0x80,
  0x19, 0x80, 0x36, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x9C, 0x03, 0x30, 0x0E,
  0x30, 0x0C, 0xC0, 0x30, 0xC0, 0x73, 0x00, 0xC3, 0x01, 0x86, 0x03, 0x0E,
  0x06, 0x18, 0x1C, 0x18, 0x18, 0x60, 0x60, 0x60, 0xE1, 0x81, 0x81, 0x83,
  0x03, 0x06, 0x07, 0x0C, 0x0C, 0x38, 0x0C, 0x30, 0x30, 0xC0, 0x31, 0xC0,
  0xC3, 0x00, 0xC6, 0x01, 0x8C, 0x03, 0x98, 0x06, 0x70, 0x06, 0x60, 0x19,
  0x80, 0x1B, 0x80, 0x66, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x70, 0x00, 0xC6, 0x00, 0x30, 0xE0, 0x0E, 0x0C, 0x01,
  0x81, 0xC0, 0x70, 0x18, 0x0C, 0x03, 0x83, 0x80, 0x30, 0x60, 0x07, 0x1C,
  0x00, 0x63, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0D, 0x80, 0x03, 0xB0, 0x00, 0x63, 0x00, 0x1C, 0x60,
  0x03, 0x06, 0x00, 0xE0, 0xE0, 0x18, 0x0C, 0x07, 0x01, 0xC0, 0xC0, 0x18,
  0x30, 0x03, 0x8E, 0x00, 0x31, 0x80, 0x07, 0x70, 0x00, 0x70, 0xE0, 0x00,
  0xD8, 0x00, 0x77, 0x00, 0x18, 0xC0, 0x0E, 0x30, 0x03, 0x06, 0x01, 0xC1,
  0x80, 0x60, 0x70, 0x18, 0x0C, 0x0C, 0x03, 0x83, 0x00, 0x61, 0x80, 0x1C,
  0x60, 0x03, 0x30, 0x00, 0xEC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0,
  0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x06, 0xC0,
  0x03, 0x30, 0x00, 0xCE, 0x00, 0x61, 0x80, 0x18, 0x70, 0x0C, 0x0C, 0x03,
  0x03, 0x81, 0x80, 0x60, 0x60, 0x18, 0x30, 0x03, 0x0C, 0x00, 0xC6, 0x00,
  0x1B, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC1, 0xC1, 0x81, 0x81,
  0xC0, 0x0F, 0xE0, 0xFF, 0xC3, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x1F, 0xF3, 0xFE, 0xDE, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFE, 0x06, 0xDE, 0xF3,
  0x3F, 0x8C, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC7, 0xF0, 0xCF, 0xF8,
  0xD8, 0x1C, 0xF0, 0x0E, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0xF0, 0x0E, 0xD8, 0x1C, 0xCF, 0xF8,
  0xC7, 0xF0, 0x07, 0xF8, 0x7F, 0xC7, 0x02, 0x70, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x02, 0x3F, 0xF0, 0xFF,
  0x80, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x07, 0xE3, 0x1F, 0xF3, 0x38,
  0x1B, 0x30, 0x0F, 0x70, 0x07, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x03, 0x60, 0x07, 0x60, 0x07, 0x70, 0x0F, 0x38, 0x1B, 0x1F, 0xF3, 0x0F,
  0xE3, 0x07, 0xE0, 0x3F, 0xF0, 0xE0, 0x61, 0x80, 0x66, 0x00, 0xEC, 0x00,
  0xD8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0,
  0x08, 0xFF, 0xF0, 0x7F, 0xC0, 0x01, 0xF8, 0x3F, 0x81, 0xC2, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x01, 0xFE, 0x3F, 0xF0, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x07, 0xE3, 0x1F, 0xF3, 0x38, 0x1B,
  0x30, 0x0F, 0x60, 0x07, 0x60, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03,
  0x60, 0x07, 0x60, 0x07, 0x70, 0x0F, 0x38, 0x1B, 0x1F, 0xF3, 0x0F, 0xE3,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x60, 0x1C, 0x7F, 0xFC, 0x3F, 0xF0, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x8F,
  0xE3, 0x3F, 0xE6, 0xC0, 0xEF, 0x00, 0xDC, 0x01, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xC0, 0xFF, 0x00, 0x06, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0xDB, 0x60, 0x0E, 0x1C, 0x30, 0x00, 0x00, 0x00, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x37, 0xEF, 0x80, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x7C, 0x03, 0xB0, 0x1C, 0xC0, 0x63, 0x03, 0x0C,
  0x18, 0x30, 0xE0, 0xC7, 0x03, 0x38, 0x0C, 0xE0, 0x37, 0xC0, 0xF3, 0x03,
  0x8E, 0x0C, 0x1C, 0x30, 0x30, 0xC0, 0xE3, 0x01, 0x8C, 0x03, 0x30, 0x0E,
  0xC0, 0x1B, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC7, 0xE0, 0xFC, 0x67, 0xF8, 0xFF, 0xB6, 0x0E, 0xC1, 0xDE, 0x03, 0x40,
  0x7E, 0x01, 0xE0, 0x1F, 0x00, 0x60, 0x0F, 0x80, 0x30, 0x07, 0x80, 0x18,
  0x03, 0xC0, 0x0C, 0x01, 0xE0, 0x06, 0x00, 0xF0, 0x03, 0x00, 0x78, 0x01,
  0x80, 0x3C, 0x00, 0xC0, 0x1E, 0x00, 0x60, 0x0F, 0x00, 0x30, 0x07, 0x80,
  0x18, 0x03, 0xC0, 0x0C, 0x01, 0xE0, 0x06, 0x00, 0xF0, 0x03, 0x00, 0x78,
  0x01, 0x80, 0x3C, 0x00, 0xC0, 0x18, 0xC3, 0xF1, 0x9F, 0xF3, 0x60, 0x77,
  0x80, 0x6E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x60, 0x07, 0xF0,
  0x0F, 0xFC, 0x0E, 0x07, 0x06, 0x01, 0xC7, 0x00, 0x73, 0x00, 0x1B, 0x80,
  0x0D, 0xC0, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1B, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x07, 0x18, 0x03,
  0x0E, 0x03, 0x03, 0xFF, 0x80, 0xFF, 0x00, 0xC3, 0xF0, 0xCF, 0xF8, 0xD8,
  0x1C, 0xD0, 0x0E, 0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x06, 0xF0, 0x0E, 0xD8, 0x1C, 0xCF, 0xF8, 0xC7,
  0xF0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x07, 0xE3, 0x1F, 0xF3, 0x38,
  0x1B, 0x30, 0x0F, 0x70, 0x07, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x07, 0x60, 0x07, 0x60, 0x07, 0x70, 0x0F, 0x38, 0x1B, 0x1F, 0xF3, 0x0F,
  0xE3, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xC7, 0xF3, 0xFD, 0xC3, 0x40,
  0xF0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x1F, 0xE3,
  0xFF, 0x98, 0x05, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x18, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xA0, 0x1D, 0xFF, 0xCF, 0xFC, 0x00, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x30, 0x1F, 0xFF, 0xFC, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x80, 0x60, 0x1E, 0xC3, 0xF0, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x3D, 0xC0, 0xDB, 0xFF, 0x31, 0xFC, 0x60, 0xC0, 0x03,
  0xE0, 0x03, 0x60, 0x07, 0x60, 0x06, 0x70, 0x06, 0x30, 0x0E, 0x30, 0x0C,
  0x38, 0x0C, 0x18, 0x1C, 0x18, 0x18, 0x1C, 0x18, 0x0C, 0x38, 0x0C, 0x30,
  0x0E, 0x30, 0x06, 0x70, 0x06, 0x60, 0x07, 0x60, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xC0, 0xE0, 0x0C, 0x01, 0xD8, 0x03, 0x80, 0x66, 0x01,
  0xE0, 0x19, 0xC0, 0x78, 0x06, 0x30, 0x1B, 0x03, 0x8C, 0x06, 0xC0, 0xC3,
  0x03, 0x30, 0x30, 0xE0, 0xCC, 0x0C, 0x18, 0x31, 0x87, 0x06, 0x18, 0x61,
  0x81, 0x86, 0x18, 0x60, 0x71, 0x86, 0x18, 0x0C, 0x60, 0xCE, 0x03, 0x30,
  0x33, 0x00, 0xCC, 0x0C, 0xC0, 0x3B, 0x01, 0xB0, 0x06, 0xC0, 0x6C, 0x01,
  0xE0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x00, 0xE0, 0x03, 0x00, 0x38,
  0x00, 0xE0, 0x06, 0x60, 0x0C, 0x70, 0x1C, 0x38, 0x18, 0x18, 0x38, 0x1C,
  0x30, 0x0C, 0x60, 0x06, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0xC0, 0x06, 0xC0, 0x0E, 0x60, 0x0C, 0x70, 0x1C, 0x30, 0x18, 0x38, 0x30,
  0x18, 0x70, 0x0C, 0x60, 0x0E, 0xE0, 0x07, 0xE0, 0x03, 0x60, 0x03, 0x60,
  0x07, 0x70, 0x06, 0x30, 0x06, 0x30, 0x0E, 0x38, 0x0C, 0x18, 0x0C, 0x18,
  0x1C, 0x1C, 0x18, 0x0C, 0x18, 0x0C, 0x38, 0x0E, 0x30, 0x06, 0x30, 0x06,
  0x70, 0x07, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x0E,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00,
  0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x60, 0x7C, 0x1E, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x1C, 0x03, 0x00, 0xE0, 0xF8, 0x1E, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x38, 0x03, 0xE0, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0xF0, 0x0F, 0x03, 0x80, 0x70, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0xFC, 0x0F, 0x00, 0x3C, 0x01, 0xFF, 0x81, 0xC3, 0xFF,
  0x80, 0xFE,
};

const GFXglyph NotoSans_SemiCondensed_Light39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 28, 9, 3, -28 },
  { 12, 8, 10, 14, 3, -28 },
  { 22, 20, 28, 22, 1, -28 },
  { 92, 16, 32, 20, 2, -30 },
  { 156, 25, 28, 29, 2, -28 },
  { 244, 21, 28, 24, 2, -28 },
  { 318, 2, 10, 8, 3, -28 },
  { 321, 8, 34, 11, 2, -28 },
  { 355, 8, 34, 11, 1, -28 },
  { 389, 15, 15, 19, 2, -30 },
  { 418, 16, 18, 20, 2, -23 },
  { 454, 4, 9, 8, 2, -4 },
  { 459, 9, 2, 12, 1, -12 },
  { 462, 3, 3, 9, 3, -3 },
  { 464, 12, 28, 14, 1, -28 },
  { 506, 16, 28, 20, 2, -28 },
  { 562, 9, 28, 20, 3, -28 },
  { 594, 16, 28, 20, 2, -28 },
  { 650, 16, 28, 20, 2, -28 },
  { 706, 18, 28, 20, 1, -28 },
  { 769, 16, 28, 20, 2, -28 },
  { 825, 16, 28, 20, 2, -28 },
  { 881, 16, 28, 20, 2, -28 },
  { 937, 16, 28, 20, 2, -28 },
  { 993, 16, 28, 20, 2, -28 },
  { 1049, 3, 21, 9, 3, -21 },
  { 1057, 5, 26, 9, 1, -21 },
  { 1074, 16, 18, 20, 2, -23 },
  { 1110, 16, 10, 20, 2, -19 },
  { 1130, 16, 18, 20, 2, -23 },
  { 1166, 13, 28, 15, 1, -28 },
  { 1212, 27, 32, 31, 2, -28 },
  { 1320, 21, 28, 21, 0, -28 },
  { 1394, 16, 28, 22, 4, -28 },
  { 1450, 18, 28, 22, 2, -28 },
  { 1513, 18, 28, 25, 4, -28 },
  { 1576, 13, 28, 19, 4, -28 },
  { 1622, 13, 28, 18, 4, -28 },
  { 1668, 21, 28, 26, 2, -28 },
  { 1742, 18, 28, 25, 4, -28 },
  { 1805, 8, 28, 11, 2, -28 },
  { 1833, 9, 35, 9, -3, -28 },
  { 1873, 16, 28, 20, 4, -28 },
  { 1929, 13, 28, 18, 4, -28 },
  { 1975, 24, 28, 31, 4, -28 },
  { 2059, 18, 28, 26, 4, -28 },
  { 2122, 22, 28, 27, 2, -28 },
  { 2199, 15, 28, 21, 4, -28 },
  { 2252, 22, 35, 27, 2, -28 },
  { 2349, 16, 28, 21, 4, -28 },
  { 2405, 15, 28, 19, 2, -28 },
  { 2458, 18, 28, 18, 0, -28 },
  { 2521, 19, 28, 25, 3, -28 },
  { 2588, 20, 28, 20, 0, -28 },
  { 2658, 30, 28, 32, 1, -28 },
  { 2763, 19, 28, 19, 0, -28 },
  { 2830, 18, 28, 18, 0, -28 },
  { 2893, 17, 28, 19, 1, -28 },
  { 2953, 8, 34, 12, 3, -28 },
  { 2987, 12, 28, 14, 1, -28 },
  { 3029, 8, 34, 12, 1, -28 },
  { 3063, 18, 16, 20, 1, -28 },
  { 3099, 16, 2, 16, 0, 3 },
  { 3103, 7, 6, 10, 2, -30 },
  { 3109, 14, 21, 19, 2, -21 },
  { 3146, 16, 30, 21, 3, -30 },
  { 3206, 13, 21, 16, 2, -21 },
  { 3241, 16, 30, 21, 2, -30 },
  { 3301, 15, 21, 19, 2, -21 },
  { 3341, 13, 30, 11, 0, -30 },
  { 3390, 16, 30, 21, 2, -21 },
  { 3450, 15, 30, 21, 3, -30 },
  { 3507, 3, 28, 9, 3, -28 },
  { 3518, 7, 37, 9, -1, -28 },
  { 3551, 14, 30, 17, 3, -30 },
  { 3604, 2, 30, 8, 3, -30 },
  { 3612, 25, 21, 31, 3, -21 },
  { 3678, 15, 21, 21, 3, -21 },
  { 3718, 17, 21, 21, 2, -21 },
  { 3763, 16, 30, 21, 3, -21 },
  { 3823, 16, 30, 21, 2, -21 },
  { 3883, 10, 21, 14, 3, -21 },
  { 3910, 13, 21, 16, 2, -21 },
  { 3945, 10, 26, 12, 1, -26 },
  { 3978, 15, 21, 21, 3, -21 },
  { 4018, 16, 21, 16, 0, -21 },
  { 4060, 26, 21, 26, 0, -21 },
  { 4129, 16, 21, 17, 1, -21 },
  { 4171, 16, 30, 17, 0, -21 },
  { 4231, 13, 21, 15, 1, -21 },
  { 4266, 11, 34, 14, 1, -28 },
  { 4313, 2, 40, 19, 8, -30 },
  { 4323, 12, 34, 14, 1, -28 },
  { 4374, 16, 4, 20, 2, -16 },
};

const GFXfont NotoSans_SemiCondensed_Light39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Light39pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Light39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHT39PT7B_H_
