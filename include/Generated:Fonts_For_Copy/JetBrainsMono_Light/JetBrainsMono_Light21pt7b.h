#ifndef _JETBRAINSMONO_LIGHT21PT7B_H_
#define _JETBRAINSMONO_LIGHT21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light21pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0x92, 0x49, 0x01, 0xF8, 0xCF, 0x3C, 0x71, 0xC7, 0x10,
  0x18, 0xC3, 0x10, 0x42, 0x08, 0x4F, 0xFE, 0x23, 0x0C, 0x61, 0x88, 0x21,
  0x1F, 0xFB, 0xFF, 0x31, 0x86, 0x20, 0x84, 0x10, 0x80, 0x08, 0x04, 0x02,
  0x0F, 0xEE, 0xB6, 0x4F, 0x27, 0x90, 0xE8, 0x3C, 0x07, 0x81, 0x60, 0x98,
  0x4E, 0x27, 0x93, 0xEB, 0x3F, 0x02, 0x01, 0x00, 0x80, 0x7C, 0x34, 0x42,
  0xC4, 0x4C, 0x4C, 0x44, 0x87, 0xD0, 0x33, 0x00, 0x60, 0x04, 0xE0, 0xDB,
  0x1B, 0x11, 0x31, 0x23, 0x16, 0x13, 0xC1, 0xE0, 0x0C, 0x07, 0xE1, 0x8C,
  0x30, 0xC6, 0x00, 0x40, 0x0C, 0x01, 0xC0, 0x68, 0x79, 0x9B, 0x1B, 0x61,
  0xCC, 0x31, 0x87, 0x19, 0xB3, 0xE3, 0xFF, 0xF0, 0x04, 0x33, 0x98, 0x63,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x61, 0xC3, 0x83, 0x04,
  0x81, 0xC0, 0xC0, 0xC0, 0xC1, 0x81, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x06, 0x0C, 0x30, 0xC7, 0x08, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x42,
  0x2F, 0x5E, 0x7F, 0x03, 0x00, 0xD0, 0x33, 0x0E, 0x30, 0x82, 0x00, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x76, 0x6C, 0xC8, 0xFF, 0xFC, 0xFF, 0x80, 0x01, 0x81, 0x80, 0xC0, 0x40,
  0x60, 0x30, 0x10, 0x18, 0x0C, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80, 0x80,
  0xC0, 0x60, 0x60, 0x30, 0x00, 0x08, 0x3F, 0x30, 0xD8, 0x38, 0x1C, 0x0E,
  0x07, 0x33, 0x9D, 0xC4, 0xE0, 0x70, 0x38, 0x1E, 0x0D, 0x8C, 0x7C, 0x3C,
  0x3E, 0x33, 0x11, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC7, 0xFF, 0xFE, 0x18, 0x3F, 0x30, 0xD8, 0x38, 0x18, 0x0C, 0x04,
  0x06, 0x06, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0x01,
  0x81, 0x81, 0x81, 0x80, 0xE0, 0x78, 0x06, 0x01, 0x00, 0xC0, 0x70, 0x3C,
  0x17, 0x39, 0xF8, 0x07, 0x04, 0x0C, 0x18, 0x18, 0x30, 0x61, 0x61, 0xC1,
  0x81, 0xFF, 0xFF, 0x01, 0x01, 0x01, 0xFF, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0xF3, 0xDD, 0x82, 0x01, 0x80, 0xC0, 0x60, 0x3C, 0x13, 0x18, 0xF8, 0x0E,
  0x04, 0x06, 0x06, 0x03, 0x03, 0x01, 0xFD, 0x86, 0xC1, 0xC0, 0xE0, 0x70,
  0x3C, 0x1B, 0x18, 0xF8, 0xFF, 0xC0, 0xE0, 0x70, 0x20, 0x30, 0x18, 0x18,
  0x0C, 0x04, 0x06, 0x03, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x18, 0x3F, 0x30,
  0xD8, 0x3C, 0x1E, 0x09, 0x8C, 0x7C, 0x3E, 0x31, 0xB0, 0x70, 0x38, 0x1E,
  0x0F, 0x8C, 0xFC, 0x08, 0x3F, 0x30, 0xD8, 0x38, 0x1C, 0x0E, 0x07, 0x83,
  0xE3, 0x3F, 0x81, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0xDF, 0x80, 0x00,
  0x1F, 0xF0, 0x67, 0x70, 0x00, 0x00, 0x07, 0x66, 0xCC, 0x80, 0x01, 0x83,
  0x87, 0x0E, 0x0C, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x20, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38,
  0x0C, 0x1C, 0x38, 0x70, 0x60, 0x20, 0x00, 0xFC, 0x1C, 0x18, 0x10, 0x20,
  0xC3, 0x9E, 0x20, 0x40, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x04, 0x07, 0xF1,
  0x83, 0x20, 0x2C, 0x07, 0x80, 0xF1, 0xFE, 0x63, 0xCC, 0x79, 0x8F, 0x31,
  0xE6, 0x3C, 0xC7, 0x9D, 0xF1, 0xDE, 0x00, 0x40, 0x0C, 0x00, 0xF8, 0x07,
  0x00, 0x0E, 0x03, 0x81, 0xA0, 0x68, 0x1B, 0x04, 0xC3, 0x10, 0xC4, 0x21,
  0x8F, 0xE7, 0xF9, 0x83, 0x40, 0xD0, 0x3C, 0x04, 0xFE, 0x61, 0xB0, 0x78,
  0x3C, 0x1E, 0x1B, 0xF9, 0xFE, 0xC1, 0x60, 0xF0, 0x78, 0x3C, 0x1F, 0xFB,
  0xF8, 0x08, 0x3F, 0x38, 0xD8, 0x3C, 0x1E, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x1E, 0x0D, 0x8C, 0x7C, 0xFE, 0x63, 0xB0, 0x58, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x36, 0x7B, 0xF0,
  0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFD, 0xFE, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x07, 0xFF, 0xFE, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0xFE, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x08, 0x3F,
  0x38, 0xD8, 0x3C, 0x1E, 0x03, 0x01, 0x80, 0xCF, 0xE7, 0xF0, 0x78, 0x3C,
  0x1E, 0x0D, 0x8C, 0x7C, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF,
  0xFF, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x06, 0xFF, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF,
  0x0F, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x38, 0x1C, 0x1B, 0x18, 0xF8, 0xC1, 0xB0, 0x6C, 0x33, 0x08, 0xC6, 0x31,
  0x0F, 0xC3, 0xF0, 0xC4, 0x31, 0x8C, 0x23, 0x0C, 0xC3, 0x30, 0x6C, 0x1C,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x07, 0xFF, 0xFE, 0xC3, 0xF1, 0x78, 0xB4, 0xDB, 0x5C, 0xAE,
  0x57, 0x33, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0xE1, 0xF0,
  0xF8, 0x7E, 0x3D, 0x1E, 0x8F, 0x67, 0x93, 0xC9, 0xE6, 0xF1, 0x78, 0xFC,
  0x7E, 0x1F, 0x0E, 0x08, 0x3F, 0x38, 0xD8, 0x2C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x09, 0x8C, 0x7C, 0xFF, 0x61, 0xF0,
  0x78, 0x1C, 0x0E, 0x0F, 0x07, 0xFE, 0xFC, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x00, 0x08, 0x3F, 0x38, 0xD8, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x3C, 0x1E, 0x09, 0x8C, 0x7C, 0x06, 0x01, 0x80, 0xC0,
  0x30, 0xFE, 0x61, 0xB0, 0x78, 0x3C, 0x1E, 0x0F, 0x0D, 0xFE, 0xCC, 0x63,
  0x31, 0x98, 0x6C, 0x36, 0x0F, 0x06, 0x08, 0x3F, 0xB0, 0xD8, 0x3C, 0x1E,
  0x03, 0x80, 0xF0, 0x1E, 0x01, 0x80, 0x60, 0x38, 0x1E, 0x0F, 0x8C, 0xFC,
  0xFF, 0xC3, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x13, 0x18, 0xF8,
  0xC0, 0x50, 0x36, 0x0D, 0x82, 0x60, 0x88, 0x63, 0x18, 0xC4, 0x31, 0x04,
  0xC1, 0xB0, 0x68, 0x0A, 0x03, 0x80, 0xE0, 0x8C, 0x71, 0x8E, 0x29, 0xE5,
  0x3C, 0xA5, 0x94, 0xB2, 0x92, 0xD2, 0x52, 0x4A, 0x59, 0x4F, 0x28, 0xE7,
  0x18, 0xE3, 0x1C, 0x60, 0xE0, 0xCC, 0x10, 0xC6, 0x18, 0x81, 0xB0, 0x3C,
  0x03, 0x80, 0x60, 0x0E, 0x03, 0x60, 0xCC, 0x18, 0xC6, 0x18, 0xC1, 0xB0,
  0x18, 0xC0, 0x68, 0x19, 0x82, 0x10, 0xC3, 0x10, 0x26, 0x06, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xFF, 0x80,
  0x80, 0xC0, 0x40, 0x60, 0x60, 0x30, 0x30, 0x10, 0x18, 0x18, 0x0C, 0x0C,
  0x07, 0xFF, 0xFE, 0xFE, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x3E, 0xC0, 0x60, 0x18, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x20,
  0x18, 0x0C, 0x03, 0x01, 0x80, 0x40, 0x30, 0x18, 0x04, 0x03, 0x01, 0x80,
  0x60, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x7E, 0x18, 0x0A, 0x0D, 0x04, 0xC6, 0x22, 0x1B, 0x05, 0x83, 0xFF, 0xC0,
  0xE3, 0x0E, 0x0F, 0xE6, 0x19, 0x83, 0x00, 0xC7, 0xF7, 0xFD, 0x03, 0xC0,
  0xD0, 0x36, 0x1C, 0xFB, 0xC0, 0x60, 0x30, 0x1B, 0x8F, 0xF6, 0x1B, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x1B, 0x78, 0x1C, 0x3F, 0xB0,
  0xD8, 0x3C, 0x06, 0x03, 0x01, 0x80, 0xC1, 0xE0, 0xD8, 0xC7, 0xC0, 0x01,
  0x80, 0xC0, 0x67, 0x37, 0xDE, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1B, 0x1D, 0xF6, 0x1C, 0x3F, 0xB0, 0xD8, 0x3C, 0x1F, 0xFF, 0xFF,
  0x80, 0xC0, 0x60, 0xD8, 0xC7, 0xC0, 0x0F, 0xC3, 0x00, 0x80, 0x20, 0x08,
  0x3F, 0xF0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x39, 0xBF, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xB1,
  0xDF, 0x60, 0x30, 0x18, 0x09, 0xFC, 0xFC, 0xC0, 0x60, 0x30, 0x1B, 0x8F,
  0xF6, 0x1B, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x06,
  0x1C, 0x07, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x0F, 0xFF, 0xFF, 0x06, 0x07, 0x00, 0x00,
  0xFE, 0xFE, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0xFC, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x02, 0xC1, 0xB0, 0xCC,
  0x63, 0x18, 0xFC, 0x3F, 0x0C, 0x63, 0x18, 0xC3, 0x30, 0x6C, 0x1C, 0xF8,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x03, 0xF0, 0x7C, 0xD9, 0xBF, 0xFC, 0x47, 0x11, 0xC4,
  0x71, 0x1C, 0x47, 0x11, 0xC4, 0x71, 0x1C, 0x47, 0x11, 0xDC, 0x7F, 0xB0,
  0xD8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x30, 0x1C,
  0x3F, 0xB0, 0xD8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x98, 0xC7,
  0xC0, 0xDC, 0x7F, 0xB0, 0xD8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xB8, 0xDB, 0xCC, 0x06, 0x03, 0x01, 0x80, 0x39, 0xBE, 0xF0, 0xF8, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xD8, 0xEF, 0xB0, 0x18, 0x0C, 0x06,
  0x03, 0xCE, 0x7F, 0xB8, 0x78, 0x3C, 0x1E, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x00, 0x3E, 0x3F, 0xB0, 0x78, 0x0C, 0x03, 0xE0, 0x7C, 0x03,
  0x01, 0xE0, 0xF8, 0xCF, 0xE0, 0x08, 0x02, 0x00, 0x83, 0xFF, 0xFF, 0xC2,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0xF0, 0x7C,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x99,
  0xC7, 0xC0, 0xC0, 0x50, 0x36, 0x0D, 0x82, 0x21, 0x8C, 0x63, 0x10, 0x4C,
  0x1B, 0x06, 0x80, 0xE0, 0x38, 0x8C, 0x71, 0x8F, 0x31, 0x65, 0x2C, 0xA4,
  0x94, 0x96, 0xB2, 0x96, 0x72, 0x8E, 0x31, 0xC6, 0x18, 0xC0, 0xC0, 0xD8,
  0x23, 0x18, 0x4C, 0x1A, 0x03, 0x80, 0xE0, 0x68, 0x13, 0x0C, 0x66, 0x1B,
  0x03, 0xC0, 0x58, 0x36, 0x0D, 0x86, 0x31, 0x8C, 0x41, 0x30, 0x6C, 0x1A,
  0x03, 0x80, 0xE0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0xFF, 0x7F, 0x80,
  0xC0, 0xC0, 0x40, 0x60, 0x60, 0x60, 0x60, 0x30, 0x3F, 0xFF, 0xF0, 0x07,
  0x86, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x78, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x01, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF0, 0x18, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x18,
  0x07, 0xC6, 0x02, 0x01, 0x00, 0x80, 0x40, 0x30, 0x18, 0x18, 0x3C, 0x00,
  0x78, 0x53, 0x1C, 0x7F, 0x0E,
};

const GFXglyph JetBrainsMono_Light21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 15, 13, 5, -15 },
  { 7, 6, 6, 13, 3, -15 },
  { 12, 11, 15, 13, 1, -15 },
  { 33, 9, 21, 13, 2, -18 },
  { 57, 12, 15, 13, 0, -15 },
  { 80, 11, 16, 13, 1, -16 },
  { 102, 2, 6, 13, 5, -15 },
  { 104, 6, 21, 13, 4, -18 },
  { 120, 7, 21, 13, 2, -18 },
  { 139, 11, 11, 13, 1, -13 },
  { 155, 10, 10, 13, 1, -12 },
  { 168, 4, 6, 13, 4, -3 },
  { 171, 7, 2, 13, 3, -8 },
  { 173, 3, 3, 13, 5, -3 },
  { 175, 9, 19, 13, 2, -17 },
  { 197, 9, 16, 13, 2, -16 },
  { 215, 9, 15, 13, 2, -15 },
  { 232, 9, 16, 13, 2, -16 },
  { 250, 9, 15, 13, 2, -15 },
  { 267, 8, 15, 13, 2, -15 },
  { 282, 9, 15, 13, 2, -15 },
  { 299, 9, 15, 13, 2, -15 },
  { 316, 9, 15, 13, 2, -15 },
  { 333, 9, 16, 13, 2, -16 },
  { 351, 9, 16, 13, 2, -16 },
  { 369, 3, 12, 13, 5, -12 },
  { 374, 4, 15, 13, 4, -12 },
  { 382, 9, 11, 13, 2, -12 },
  { 395, 9, 6, 13, 2, -10 },
  { 402, 9, 11, 13, 2, -12 },
  { 415, 7, 15, 13, 3, -15 },
  { 429, 11, 20, 13, 1, -16 },
  { 457, 10, 15, 13, 1, -15 },
  { 476, 9, 15, 13, 2, -15 },
  { 493, 9, 16, 13, 2, -16 },
  { 511, 9, 15, 13, 2, -15 },
  { 528, 9, 15, 13, 2, -15 },
  { 545, 9, 15, 13, 2, -15 },
  { 562, 9, 16, 13, 2, -16 },
  { 580, 9, 15, 13, 2, -15 },
  { 597, 8, 15, 13, 2, -15 },
  { 612, 9, 15, 13, 1, -15 },
  { 629, 10, 15, 13, 2, -15 },
  { 648, 9, 15, 13, 2, -15 },
  { 665, 9, 15, 13, 2, -15 },
  { 682, 9, 15, 13, 2, -15 },
  { 699, 9, 16, 13, 2, -16 },
  { 717, 9, 15, 13, 2, -15 },
  { 734, 9, 20, 13, 2, -16 },
  { 757, 9, 15, 13, 2, -15 },
  { 774, 9, 16, 13, 2, -16 },
  { 792, 10, 15, 13, 1, -15 },
  { 811, 9, 15, 13, 2, -15 },
  { 828, 10, 15, 13, 1, -15 },
  { 847, 11, 15, 13, 1, -15 },
  { 868, 11, 15, 13, 1, -15 },
  { 889, 11, 15, 13, 1, -15 },
  { 910, 9, 15, 13, 2, -15 },
  { 927, 5, 19, 13, 4, -17 },
  { 939, 9, 19, 13, 2, -17 },
  { 961, 5, 19, 13, 3, -17 },
  { 973, 9, 8, 13, 2, -15 },
  { 982, 10, 1, 13, 1, 1 },
  { 984, 4, 2, 13, 4, -16 },
  { 985, 10, 12, 13, 1, -12 },
  { 1000, 9, 15, 13, 2, -15 },
  { 1017, 9, 12, 13, 2, -12 },
  { 1031, 9, 15, 13, 2, -15 },
  { 1048, 9, 12, 13, 2, -12 },
  { 1062, 10, 15, 13, 1, -15 },
  { 1081, 9, 16, 13, 2, -12 },
  { 1099, 9, 15, 13, 2, -15 },
  { 1116, 10, 16, 13, 2, -16 },
  { 1136, 8, 20, 13, 2, -16 },
  { 1156, 10, 15, 13, 2, -15 },
  { 1175, 10, 15, 13, 1, -15 },
  { 1194, 10, 12, 13, 1, -12 },
  { 1209, 9, 12, 13, 2, -12 },
  { 1223, 9, 12, 13, 2, -12 },
  { 1237, 9, 16, 13, 2, -12 },
  { 1255, 9, 16, 13, 2, -12 },
  { 1273, 9, 12, 13, 2, -12 },
  { 1287, 9, 12, 13, 2, -12 },
  { 1301, 10, 15, 13, 1, -15 },
  { 1320, 9, 12, 13, 2, -12 },
  { 1334, 10, 12, 13, 1, -12 },
  { 1349, 11, 12, 13, 1, -12 },
  { 1366, 10, 12, 13, 1, -12 },
  { 1381, 10, 16, 13, 1, -12 },
  { 1401, 9, 12, 13, 2, -12 },
  { 1415, 9, 19, 13, 2, -17 },
  { 1437, 2, 19, 13, 5, -17 },
  { 1442, 9, 19, 13, 2, -17 },
  { 1464, 10, 4, 13, 1, -9 },
};

const GFXfont JetBrainsMono_Light21pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light21pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light21pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _JETBRAINSMONO_LIGHT21PT7B_H_
