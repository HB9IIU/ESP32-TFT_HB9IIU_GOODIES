#ifndef _JETBRAINSMONO_LIGHT20PT7B_H_
#define _JETBRAINSMONO_LIGHT20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFC, 0x3C, 0xCF, 0x3C, 0xF3, 0xCF, 0x30, 0x18, 0x84,
  0x21, 0x08, 0x46, 0xFF, 0xFF, 0xF3, 0x10, 0x84, 0x21, 0x08, 0xCF, 0xFD,
  0x88, 0x42, 0x10, 0x84, 0x60, 0x04, 0x01, 0x01, 0xE0, 0xFC, 0x65, 0x99,
  0x26, 0x41, 0x90, 0x34, 0x07, 0x80, 0x78, 0x16, 0x04, 0xB1, 0x34, 0x49,
  0xD6, 0x3F, 0x01, 0x00, 0x40, 0x10, 0x30, 0x37, 0x82, 0xCC, 0x4C, 0x4C,
  0xC4, 0x84, 0xD0, 0x7A, 0x00, 0x60, 0x04, 0xC0, 0x9E, 0x1B, 0x31, 0x23,
  0x22, 0x36, 0x32, 0xC1, 0xE0, 0x1C, 0x0F, 0xC6, 0x31, 0x84, 0x60, 0x08,
  0x03, 0x01, 0xE0, 0xCC, 0xF1, 0x2C, 0x7B, 0x0C, 0xC3, 0x39, 0xE7, 0xCC,
  0xFF, 0xF0, 0x04, 0x73, 0x18, 0xC3, 0x0C, 0x20, 0x82, 0x08, 0x20, 0x83,
  0x0C, 0x10, 0x60, 0xE1, 0xC0, 0x83, 0x83, 0x06, 0x0C, 0x30, 0xC1, 0x04,
  0x10, 0x41, 0x04, 0x30, 0xC2, 0x19, 0xCE, 0x00, 0x0C, 0x03, 0x00, 0xC3,
  0xB7, 0x7B, 0x83, 0x01, 0xE0, 0xCC, 0x33, 0x18, 0x60, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0xFF, 0xC3, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x33, 0x66, 0x6C,
  0xFC, 0x6F, 0x60, 0x01, 0x03, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x0C, 0x08,
  0x18, 0x18, 0x10, 0x30, 0x20, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0x3C, 0x7E,
  0xC3, 0x81, 0x81, 0x81, 0x91, 0x99, 0x99, 0x81, 0x81, 0x81, 0xC3, 0xE7,
  0x7E, 0x18, 0x1C, 0x3A, 0x11, 0x08, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x43, 0xFE, 0x1E, 0x0F, 0xC6, 0x19, 0x02, 0x80,
  0x80, 0x20, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x07,
  0xFC, 0x7F, 0xBF, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x78, 0x06, 0x01, 0x80,
  0xC0, 0x78, 0x34, 0x1B, 0x18, 0xF8, 0x06, 0x06, 0x0C, 0x18, 0x18, 0x30,
  0x60, 0x63, 0xC3, 0x83, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0xC0,
  0xC0, 0xC0, 0xCC, 0xFE, 0xC3, 0x01, 0x01, 0x01, 0x01, 0xC3, 0xE7, 0x7E,
  0x06, 0x01, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x02, 0xF1, 0xCE, 0x61, 0x90,
  0x2C, 0x0D, 0x02, 0x61, 0x9C, 0xE3, 0xF0, 0xFF, 0xFF, 0xE0, 0x50, 0x60,
  0x30, 0x10, 0x18, 0x08, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x81, 0x80, 0xC0,
  0x3C, 0x7E, 0xC3, 0xC3, 0xC3, 0xC3, 0x66, 0x18, 0x66, 0xC3, 0x81, 0x81,
  0x81, 0xE7, 0x7E, 0x1E, 0x0F, 0xC6, 0x19, 0x02, 0xC0, 0xF0, 0x34, 0x09,
  0x86, 0x3F, 0x80, 0xC0, 0x20, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x6F, 0x60,
  0x00, 0x00, 0x6F, 0x60, 0x33, 0xCC, 0x00, 0x00, 0x00, 0x31, 0x98, 0xC6,
  0x60, 0x01, 0x03, 0x0E, 0x38, 0xE0, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0x07, 0x1C, 0x70, 0xC0, 0x80, 0xE1, 0xF8, 0x30, 0x30, 0x60, 0xC1, 0x3E,
  0x70, 0xC1, 0x80, 0x00, 0x0E, 0x18, 0x00, 0x1E, 0x0E, 0xE6, 0x0F, 0x03,
  0xC0, 0x61, 0xD8, 0xDE, 0x21, 0x88, 0x62, 0x18, 0x86, 0x21, 0x8C, 0xE1,
  0xDC, 0x01, 0x00, 0x60, 0x0F, 0x80, 0xE0, 0x0C, 0x03, 0x01, 0xE0, 0x78,
  0x12, 0x04, 0x83, 0x30, 0xCC, 0x21, 0x08, 0x47, 0xF9, 0x86, 0x40, 0xB0,
  0x3C, 0x0C, 0xF8, 0x7F, 0x30, 0xD8, 0x6C, 0x16, 0x1B, 0x19, 0xF8, 0xC3,
  0x60, 0xB0, 0x78, 0x2C, 0x36, 0x3B, 0xF8, 0x3C, 0x7E, 0xC3, 0xC1, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x81, 0xC3, 0x67, 0x3E, 0xF8, 0xFE,
  0xC3, 0xC3, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC3, 0xC3, 0xCE,
  0xFC, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0xFE, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x3C, 0x7E, 0xC3,
  0xC1, 0x80, 0x80, 0x80, 0x80, 0x8F, 0x81, 0x81, 0x81, 0xC3, 0x67, 0x3E,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x0F, 0x87, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x78, 0x3C, 0x1B, 0x18, 0xF8, 0xC1,
  0xE0, 0xB0, 0xD8, 0x4C, 0x66, 0x23, 0x31, 0xF0, 0xCC, 0x62, 0x31, 0x98,
  0x4C, 0x36, 0x0B, 0x06, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFE, 0xC3, 0xC3, 0xC3,
  0xE7, 0xA5, 0xA5, 0xBD, 0x99, 0x99, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0xC1, 0xC1, 0xE1, 0xA1, 0xB1, 0xB1, 0x91, 0x99, 0x89, 0x89, 0x8D, 0x85,
  0x85, 0x87, 0x83, 0x3C, 0x7E, 0xC3, 0xC3, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0xC3, 0xE7, 0x7E, 0xFC, 0x7F, 0xB0, 0xD8, 0x3C, 0x1E,
  0x0F, 0x07, 0xFE, 0xFE, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x3C,
  0x7E, 0xC3, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC3,
  0xE7, 0x7E, 0x06, 0x06, 0x03, 0x01, 0xF8, 0x7F, 0x30, 0xD8, 0x3C, 0x1E,
  0x0F, 0x0D, 0xFE, 0xFC, 0x66, 0x31, 0x98, 0xCC, 0x36, 0x1B, 0x06, 0x1E,
  0x0F, 0xC6, 0x19, 0x82, 0x60, 0x18, 0x03, 0x00, 0x78, 0x07, 0x80, 0x60,
  0x0B, 0x03, 0x40, 0x9C, 0x63, 0xF0, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0xC3, 0xC3, 0x66, 0x7E, 0xC0, 0xF0, 0x34, 0x09, 0x82, 0x61, 0x98, 0x62,
  0x10, 0xCC, 0x33, 0x0C, 0xC1, 0x20, 0x78, 0x1E, 0x03, 0x00, 0xC0, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0xCC, 0x72, 0xBD, 0x2F, 0x4B, 0x52, 0x94, 0xA5,
  0x29, 0x4A, 0x52, 0x94, 0xA6, 0x18, 0xC0, 0xD8, 0x26, 0x18, 0xCC, 0x33,
  0x07, 0x80, 0xC0, 0x30, 0x0E, 0x07, 0x83, 0x30, 0xCC, 0x61, 0x90, 0x2C,
  0x0C, 0x80, 0x70, 0x34, 0x09, 0x86, 0x21, 0x0C, 0xC1, 0x20, 0x78, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xFF, 0xFF, 0x03, 0x06,
  0x06, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x60, 0x60, 0xC0, 0x80, 0xFF, 0xFF,
  0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x3E, 0x80,
  0xC0, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x30, 0x10, 0x18, 0x18, 0x08, 0x0C,
  0x04, 0x06, 0x06, 0x02, 0x03, 0x03, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xFE, 0x18, 0x18, 0x3C, 0x24, 0x66, 0x42,
  0xC3, 0xC3, 0xFF, 0xFF, 0xF0, 0xC4, 0x30, 0x3F, 0x39, 0xD8, 0x60, 0x10,
  0x0B, 0xFD, 0x03, 0x81, 0xC1, 0xB1, 0x4F, 0xA0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xFE, 0xE7, 0xC3, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC3, 0xE7, 0xFE, 0x7E,
  0xE7, 0xC3, 0x81, 0x80, 0x80, 0x80, 0x81, 0xC3, 0xE7, 0x7E, 0x03, 0x03,
  0x03, 0x03, 0x7F, 0xE7, 0xC3, 0x83, 0x83, 0x83, 0x83, 0x83, 0xC3, 0xE7,
  0x7F, 0x7E, 0xE3, 0xC3, 0x81, 0x81, 0xFF, 0x80, 0x80, 0xC3, 0xE3, 0x7E,
  0x03, 0xC3, 0xF0, 0x80, 0x60, 0x18, 0x3F, 0xFF, 0xFC, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x7F, 0xE7, 0xC3, 0x83, 0x83,
  0x83, 0x83, 0xC3, 0xC7, 0x7F, 0x03, 0x03, 0x03, 0x7E, 0x7C, 0xC0, 0xC0,
  0xC0, 0xC0, 0xFE, 0xE7, 0xC3, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1,
  0xC1, 0x1C, 0x0C, 0x00, 0x00, 0x0F, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x43, 0xFE, 0x0E, 0x0C, 0x00, 0x0F, 0xE0, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0D, 0xF3, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x1E, 0x1B, 0x19, 0x88, 0xCC, 0x7C, 0x33, 0x18,
  0xCC, 0x66, 0x1B, 0x06, 0xF8, 0x3E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00, 0x7C, 0xFB,
  0xB3, 0x2C, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x33, 0xCC, 0xF3, 0x3C,
  0xCC, 0xFE, 0xE7, 0xC3, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1,
  0x7E, 0xE7, 0xC3, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC3, 0xE7, 0x7E, 0xFE,
  0xE7, 0xC3, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC3, 0xE7, 0xFE, 0xC0, 0xC0,
  0xC0, 0xC0, 0x7F, 0xE7, 0xC3, 0x83, 0x83, 0x83, 0x83, 0x83, 0xC3, 0xE7,
  0x7F, 0x03, 0x03, 0x03, 0x03, 0xDE, 0x71, 0xB0, 0x58, 0x3C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x00, 0x7E, 0xC3, 0xC1, 0xC0, 0xE0, 0x3E,
  0x03, 0x01, 0x81, 0xC3, 0x7E, 0x18, 0x0C, 0x06, 0x1F, 0xF1, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x7C, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0xC3, 0xC3, 0x66, 0x3C, 0xC0, 0xD0, 0x26, 0x19,
  0x86, 0x21, 0x0C, 0xC3, 0x30, 0x48, 0x1E, 0x07, 0x80, 0xC0, 0x8C, 0x63,
  0x1C, 0xCF, 0x33, 0x52, 0x94, 0xA5, 0x29, 0x4A, 0x52, 0x9C, 0xE6, 0x30,
  0xE1, 0xD8, 0x63, 0x30, 0x68, 0x1E, 0x03, 0x01, 0xE0, 0x48, 0x33, 0x18,
  0x6C, 0x0C, 0xC0, 0xD8, 0x26, 0x18, 0x84, 0x33, 0x0C, 0xC1, 0x20, 0x78,
  0x0E, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x00, 0xFF, 0x03, 0x06,
  0x04, 0x0C, 0x18, 0x30, 0x60, 0x40, 0xC0, 0xFF, 0x03, 0x0F, 0x0C, 0x08,
  0x08, 0x08, 0x0C, 0x0C, 0x08, 0xF0, 0xF8, 0x08, 0x0C, 0x08, 0x08, 0x08,
  0x08, 0x0C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0xF0, 0x30, 0x10,
  0x10, 0x10, 0x30, 0x30, 0x10, 0x0F, 0x1F, 0x10, 0x30, 0x10, 0x10, 0x10,
  0x10, 0x30, 0xE0, 0x78, 0xD3, 0x3C, 0x6B, 0x0E,
};

const GFXglyph JetBrainsMono_Light20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 2, 15, 12, 5, -15 },
  { 5, 6, 6, 12, 3, -15 },
  { 10, 10, 15, 12, 1, -15 },
  { 29, 10, 20, 12, 1, -17 },
  { 54, 12, 15, 12, 0, -15 },
  { 77, 10, 15, 12, 1, -15 },
  { 96, 2, 6, 12, 5, -15 },
  { 98, 6, 19, 12, 4, -17 },
  { 113, 6, 19, 12, 2, -17 },
  { 128, 10, 10, 12, 1, -12 },
  { 141, 10, 9, 12, 1, -11 },
  { 153, 4, 6, 12, 3, -3 },
  { 156, 6, 1, 12, 3, -7 },
  { 157, 4, 3, 12, 4, -3 },
  { 159, 8, 19, 12, 2, -17 },
  { 178, 8, 15, 12, 2, -15 },
  { 193, 9, 15, 12, 2, -15 },
  { 210, 10, 15, 12, 1, -15 },
  { 229, 9, 15, 12, 1, -15 },
  { 246, 8, 15, 12, 2, -15 },
  { 261, 8, 15, 12, 2, -15 },
  { 276, 10, 15, 12, 1, -15 },
  { 295, 9, 15, 12, 2, -15 },
  { 312, 8, 15, 12, 2, -15 },
  { 327, 10, 15, 12, 1, -15 },
  { 346, 4, 11, 12, 4, -11 },
  { 352, 5, 14, 12, 3, -11 },
  { 361, 8, 11, 12, 2, -12 },
  { 372, 8, 6, 12, 2, -10 },
  { 378, 8, 11, 12, 2, -12 },
  { 389, 7, 15, 12, 3, -15 },
  { 403, 10, 19, 12, 1, -15 },
  { 427, 10, 15, 12, 1, -15 },
  { 446, 9, 15, 12, 2, -15 },
  { 463, 8, 15, 12, 2, -15 },
  { 478, 8, 15, 12, 2, -15 },
  { 493, 8, 15, 12, 2, -15 },
  { 508, 9, 15, 12, 2, -15 },
  { 525, 8, 15, 12, 2, -15 },
  { 540, 8, 15, 12, 2, -15 },
  { 555, 8, 15, 12, 2, -15 },
  { 570, 9, 15, 12, 1, -15 },
  { 587, 9, 15, 12, 2, -15 },
  { 604, 9, 15, 12, 2, -15 },
  { 621, 8, 15, 12, 2, -15 },
  { 636, 8, 15, 12, 2, -15 },
  { 651, 8, 15, 12, 2, -15 },
  { 666, 9, 15, 12, 2, -15 },
  { 683, 8, 19, 12, 2, -15 },
  { 702, 9, 15, 12, 2, -15 },
  { 719, 10, 15, 12, 1, -15 },
  { 738, 10, 15, 12, 1, -15 },
  { 757, 8, 15, 12, 2, -15 },
  { 772, 10, 15, 12, 1, -15 },
  { 791, 10, 15, 12, 1, -15 },
  { 810, 10, 15, 12, 1, -15 },
  { 829, 10, 15, 12, 1, -15 },
  { 848, 8, 15, 12, 2, -15 },
  { 863, 5, 19, 12, 4, -17 },
  { 875, 8, 19, 12, 2, -17 },
  { 894, 5, 19, 12, 3, -17 },
  { 906, 8, 8, 12, 2, -15 },
  { 914, 10, 2, 12, 1, 0 },
  { 917, 4, 3, 12, 4, -16 },
  { 919, 9, 11, 12, 1, -11 },
  { 932, 8, 15, 12, 2, -15 },
  { 947, 8, 11, 12, 2, -11 },
  { 958, 8, 15, 12, 2, -15 },
  { 973, 8, 11, 12, 2, -11 },
  { 984, 10, 15, 12, 1, -15 },
  { 1003, 8, 15, 12, 2, -11 },
  { 1018, 8, 15, 12, 2, -15 },
  { 1033, 9, 15, 12, 2, -15 },
  { 1050, 7, 19, 12, 2, -15 },
  { 1067, 9, 15, 12, 2, -15 },
  { 1084, 10, 15, 12, 1, -15 },
  { 1103, 10, 11, 12, 1, -11 },
  { 1117, 8, 11, 12, 2, -11 },
  { 1128, 8, 11, 12, 2, -11 },
  { 1139, 8, 15, 12, 2, -11 },
  { 1154, 8, 15, 12, 2, -11 },
  { 1169, 9, 11, 12, 2, -11 },
  { 1182, 8, 11, 12, 2, -11 },
  { 1193, 9, 14, 12, 1, -14 },
  { 1209, 8, 11, 12, 2, -11 },
  { 1220, 10, 11, 12, 1, -11 },
  { 1234, 10, 11, 12, 1, -11 },
  { 1248, 10, 11, 12, 1, -11 },
  { 1262, 10, 15, 12, 1, -11 },
  { 1281, 8, 11, 12, 2, -11 },
  { 1292, 8, 19, 12, 2, -17 },
  { 1311, 2, 19, 12, 5, -17 },
  { 1316, 8, 19, 12, 2, -17 },
  { 1335, 10, 4, 12, 1, -9 },
};

const GFXfont JetBrainsMono_Light20pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light20pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _JETBRAINSMONO_LIGHT20PT7B_H_
