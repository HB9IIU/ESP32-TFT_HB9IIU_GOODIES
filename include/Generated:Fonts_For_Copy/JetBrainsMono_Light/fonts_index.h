#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &JetBrainsMono_Light6pt7b, 6, "JetBrainsMono_Light6pt7b" },
  { &JetBrainsMono_Light7pt7b, 7, "JetBrainsMono_Light7pt7b" },
  { &JetBrainsMono_Light8pt7b, 8, "JetBrainsMono_Light8pt7b" },
  { &JetBrainsMono_Light9pt7b, 9, "JetBrainsMono_Light9pt7b" },
  { &JetBrainsMono_Light10pt7b, 10, "JetBrainsMono_Light10pt7b" },
  { &JetBrainsMono_Light11pt7b, 11, "JetBrainsMono_Light11pt7b" },
  { &JetBrainsMono_Light12pt7b, 12, "JetBrainsMono_Light12pt7b" },
  { &JetBrainsMono_Light13pt7b, 13, "JetBrainsMono_Light13pt7b" },
  { &JetBrainsMono_Light14pt7b, 14, "JetBrainsMono_Light14pt7b" },
  { &JetBrainsMono_Light15pt7b, 15, "JetBrainsMono_Light15pt7b" },
  { &JetBrainsMono_Light16pt7b, 16, "JetBrainsMono_Light16pt7b" },
  { &JetBrainsMono_Light17pt7b, 17, "JetBrainsMono_Light17pt7b" },
  { &JetBrainsMono_Light18pt7b, 18, "JetBrainsMono_Light18pt7b" },
  { &JetBrainsMono_Light19pt7b, 19, "JetBrainsMono_Light19pt7b" },
  { &JetBrainsMono_Light20pt7b, 20, "JetBrainsMono_Light20pt7b" },
  { &JetBrainsMono_Light21pt7b, 21, "JetBrainsMono_Light21pt7b" },
  { &JetBrainsMono_Light22pt7b, 22, "JetBrainsMono_Light22pt7b" },
  { &JetBrainsMono_Light23pt7b, 23, "JetBrainsMono_Light23pt7b" },
  { &JetBrainsMono_Light24pt7b, 24, "JetBrainsMono_Light24pt7b" },
  { &JetBrainsMono_Light25pt7b, 25, "JetBrainsMono_Light25pt7b" },
  { &JetBrainsMono_Light26pt7b, 26, "JetBrainsMono_Light26pt7b" },
  { &JetBrainsMono_Light27pt7b, 27, "JetBrainsMono_Light27pt7b" },
  { &JetBrainsMono_Light28pt7b, 28, "JetBrainsMono_Light28pt7b" },
  { &JetBrainsMono_Light29pt7b, 29, "JetBrainsMono_Light29pt7b" },
  { &JetBrainsMono_Light30pt7b, 30, "JetBrainsMono_Light30pt7b" },
  { &JetBrainsMono_Light31pt7b, 31, "JetBrainsMono_Light31pt7b" },
  { &JetBrainsMono_Light32pt7b, 32, "JetBrainsMono_Light32pt7b" },
  { &JetBrainsMono_Light33pt7b, 33, "JetBrainsMono_Light33pt7b" },
  { &JetBrainsMono_Light34pt7b, 34, "JetBrainsMono_Light34pt7b" },
  { &JetBrainsMono_Light35pt7b, 35, "JetBrainsMono_Light35pt7b" },
  { &JetBrainsMono_Light36pt7b, 36, "JetBrainsMono_Light36pt7b" },
  { &JetBrainsMono_Light37pt7b, 37, "JetBrainsMono_Light37pt7b" },
  { &JetBrainsMono_Light38pt7b, 38, "JetBrainsMono_Light38pt7b" },
  { &JetBrainsMono_Light39pt7b, 39, "JetBrainsMono_Light39pt7b" },
  { &JetBrainsMono_Light40pt7b, 40, "JetBrainsMono_Light40pt7b" },
  { &JetBrainsMono_Light41pt7b, 41, "JetBrainsMono_Light41pt7b" },
  { &JetBrainsMono_Light42pt7b, 42, "JetBrainsMono_Light42pt7b" },
  { &JetBrainsMono_Light43pt7b, 43, "JetBrainsMono_Light43pt7b" },
  { &JetBrainsMono_Light44pt7b, 44, "JetBrainsMono_Light44pt7b" },
  { &JetBrainsMono_Light45pt7b, 45, "JetBrainsMono_Light45pt7b" },
  { &JetBrainsMono_Light46pt7b, 46, "JetBrainsMono_Light46pt7b" },
  { &JetBrainsMono_Light47pt7b, 47, "JetBrainsMono_Light47pt7b" },
  { &JetBrainsMono_Light48pt7b, 48, "JetBrainsMono_Light48pt7b" },
  { &JetBrainsMono_Light49pt7b, 49, "JetBrainsMono_Light49pt7b" },
  { &JetBrainsMono_Light50pt7b, 50, "JetBrainsMono_Light50pt7b" },
  { &JetBrainsMono_Light51pt7b, 51, "JetBrainsMono_Light51pt7b" },
  { &JetBrainsMono_Light52pt7b, 52, "JetBrainsMono_Light52pt7b" },
  { &JetBrainsMono_Light53pt7b, 53, "JetBrainsMono_Light53pt7b" },
  { &JetBrainsMono_Light54pt7b, 54, "JetBrainsMono_Light54pt7b" },
  { &JetBrainsMono_Light55pt7b, 55, "JetBrainsMono_Light55pt7b" },
  { &JetBrainsMono_Light56pt7b, 56, "JetBrainsMono_Light56pt7b" },
  { &JetBrainsMono_Light57pt7b, 57, "JetBrainsMono_Light57pt7b" },
  { &JetBrainsMono_Light58pt7b, 58, "JetBrainsMono_Light58pt7b" },
  { &JetBrainsMono_Light59pt7b, 59, "JetBrainsMono_Light59pt7b" },
  { &JetBrainsMono_Light60pt7b, 60, "JetBrainsMono_Light60pt7b" },
  { &JetBrainsMono_Light61pt7b, 61, "JetBrainsMono_Light61pt7b" },
  { &JetBrainsMono_Light62pt7b, 62, "JetBrainsMono_Light62pt7b" },
  { &JetBrainsMono_Light63pt7b, 63, "JetBrainsMono_Light63pt7b" },
  { &JetBrainsMono_Light64pt7b, 64, "JetBrainsMono_Light64pt7b" },
  { &JetBrainsMono_Light65pt7b, 65, "JetBrainsMono_Light65pt7b" },
  { &JetBrainsMono_Light66pt7b, 66, "JetBrainsMono_Light66pt7b" },
  { &JetBrainsMono_Light67pt7b, 67, "JetBrainsMono_Light67pt7b" },
  { &JetBrainsMono_Light68pt7b, 68, "JetBrainsMono_Light68pt7b" },
  { &JetBrainsMono_Light69pt7b, 69, "JetBrainsMono_Light69pt7b" },
  { &JetBrainsMono_Light70pt7b, 70, "JetBrainsMono_Light70pt7b" },
  { &JetBrainsMono_Light71pt7b, 71, "JetBrainsMono_Light71pt7b" },
  { &JetBrainsMono_Light72pt7b, 72, "JetBrainsMono_Light72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
