#ifndef _JETBRAINSMONO_LIGHT39PT7B_H_
#define _JETBRAINSMONO_LIGHT39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light39pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xB9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x71,
  0x8C, 0x60, 0x00, 0x00, 0xFF, 0xFE, 0xF0, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0x80, 0x01,
  0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x03, 0x01, 0x80, 0x18, 0x0C,
  0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xC0, 0xC0, 0x60, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x03, 0x81, 0x80,
  0x18, 0x0C, 0x00, 0xC0, 0x60, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x3F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xE0, 0xC0, 0x60, 0x06, 0x07, 0x00, 0x70, 0x38, 0x03,
  0x81, 0xC0, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x70, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x1F, 0x80, 0x3F, 0xF0, 0x3F, 0xFC, 0x3C, 0xCF, 0x3C, 0x63, 0x9C, 0x30,
  0xEE, 0x18, 0x77, 0x0C, 0x3B, 0x86, 0x01, 0xC3, 0x00, 0xF1, 0x80, 0x3C,
  0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8,
  0x03, 0x3C, 0x01, 0x8F, 0x00, 0xC3, 0x80, 0x61, 0xC0, 0x30, 0xFC, 0x18,
  0x7E, 0x0C, 0x3F, 0x86, 0x1D, 0xE3, 0x1E, 0x7D, 0xFE, 0x1F, 0xFE, 0x07,
  0xFC, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x05, 0xFE, 0x00, 0x67, 0xFC, 0x03, 0x38, 0x70, 0x1C, 0xE0,
  0xC0, 0xE3, 0x03, 0x03, 0x0C, 0x0C, 0x1C, 0x30, 0x30, 0xE0, 0xC0, 0xC3,
  0x03, 0x83, 0x1C, 0x0E, 0x1C, 0xE0, 0x1F, 0xE3, 0x00, 0x3F, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE3, 0xE0, 0x03,
  0x3F, 0xC0, 0x18, 0xFF, 0x80, 0xE7, 0x06, 0x07, 0x1C, 0x1C, 0x18, 0x70,
  0x70, 0xE1, 0xC1, 0xC7, 0x07, 0x07, 0x18, 0x1C, 0x1C, 0xE0, 0x70, 0x67,
  0x00, 0xE3, 0x98, 0x03, 0xFC, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xFF,
  0xC0, 0x1F, 0xFE, 0x01, 0xC1, 0xE0, 0x3C, 0x0F, 0x03, 0x80, 0x70, 0x38,
  0x07, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0x1C, 0x0F,
  0xF1, 0xE0, 0xEE, 0x0F, 0x1C, 0xE0, 0x71, 0xCE, 0x03, 0xB8, 0xE0, 0x3F,
  0x8E, 0x01, 0xF0, 0xE0, 0x0F, 0x0E, 0x00, 0xF0, 0xF0, 0x1F, 0x87, 0x03,
  0xF8, 0x7C, 0xF9, 0xC3, 0xFF, 0x0E, 0x1F, 0xC0, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x10, 0x0F, 0x01, 0xF0, 0x7E, 0x0F, 0x80, 0xE0, 0x1E,
  0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0x00, 0x70, 0x01, 0x80,
  0x0F, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x07,
  0x81, 0xF0, 0x7E, 0x0F, 0xC0, 0xF0, 0x08, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x01,
  0x81, 0xC0, 0xCF, 0x86, 0x3F, 0xFF, 0x37, 0xF8, 0xFD, 0x7F, 0x01, 0xFF,
  0xC0, 0x00, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0xEE, 0x00, 0x0F, 0x38, 0x00,
  0xF1, 0xE0, 0x07, 0x07, 0x80, 0x78, 0x1C, 0x07, 0x80, 0xF0, 0x08, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x7C, 0xF1, 0xE3, 0xCF, 0x1E,
  0x38, 0x71, 0xE3, 0x87, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x73, 0xEF,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xFE,
  0x0F, 0xFF, 0x87, 0x83, 0xE7, 0x80, 0x73, 0x80, 0x3F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x08, 0x3F,
  0x0F, 0x1F, 0x8F, 0x8F, 0xC3, 0xC7, 0xE1, 0xC3, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0E, 0xE0, 0x07, 0x70,
  0x07, 0xBC, 0x07, 0x8F, 0xCF, 0x83, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xE0,
  0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0xBC, 0x0F, 0x1E, 0x07, 0x0F, 0x03, 0x07,
  0x81, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0,
  0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xF0, 0x7C, 0x70, 0x07, 0x3C, 0x01, 0xEE,
  0x00, 0x3B, 0x80, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xFD, 0xFF,
  0xFF, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x3F, 0xFF, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1D, 0xE0, 0x0E, 0x78, 0x0F, 0x1F, 0xBF, 0x07,
  0xFF, 0x01, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x78, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x7F, 0xFF, 0x3F, 0xFF, 0x9C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x78, 0x1C, 0xFF, 0x0E,
  0xFF, 0xC7, 0xE1, 0xF3, 0xC0, 0x39, 0xC0, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1D, 0xC0,
  0x1E, 0xE0, 0x0E, 0x78, 0x0F, 0x1F, 0xBF, 0x07, 0xFF, 0x01, 0xFF, 0x00,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC4,
  0x00, 0xEF, 0xF0, 0x3F, 0xFE, 0x1F, 0x07, 0xC7, 0x80, 0x7B, 0xC0, 0x1E,
  0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xB8,
  0x00, 0xEF, 0x00, 0x39, 0xC0, 0x1E, 0x78, 0x0F, 0x0F, 0xDF, 0xC1, 0xFF,
  0xC0, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x0E,
  0xE0, 0x03, 0xB8, 0x01, 0xEE, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0xFF,
  0x87, 0x83, 0xE7, 0x80, 0x73, 0x80, 0x39, 0xC0, 0x0E, 0xE0, 0x07, 0x70,
  0x07, 0xB8, 0x03, 0x8E, 0x03, 0xC7, 0x83, 0xC1, 0xF3, 0xC0, 0x3F, 0xC0,
  0x0F, 0xC0, 0x1F, 0xF8, 0x1E, 0x1E, 0x1C, 0x07, 0x9C, 0x01, 0xCE, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0x70, 0x07, 0xBC,
  0x07, 0x8F, 0xCF, 0xC3, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0xE0, 0x03, 0xFF,
  0x03, 0xFF, 0xE0, 0xF0, 0x7C, 0x78, 0x07, 0x3C, 0x00, 0xEE, 0x00, 0x3B,
  0x80, 0x0E, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3B, 0x80, 0x0E, 0xF0,
  0x03, 0x9C, 0x01, 0xE7, 0x80, 0xF8, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xF3,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x00, 0x73, 0xEF, 0xFF, 0xF9, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xEF, 0xFF, 0xFF, 0xE0, 0x1C, 0x3E, 0x7F, 0x7F, 0x3F,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x1E, 0x3E, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x70, 0x70, 0xE0, 0xE0, 0x00,
  0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x70, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x01, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x3C, 0x00,
  0x18, 0x00, 0x00, 0xFF, 0x87, 0xFF, 0x01, 0xFC, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x1F,
  0x0F, 0xF0, 0x7F, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x1F, 0x80, 0x78,
  0x00, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xE0, 0x3C, 0x38,
  0x01, 0xC7, 0x00, 0x0E, 0x70, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x3E, 0x7E, 0x07, 0xF7, 0xE0, 0xF9, 0xFE, 0x0E, 0x0F,
  0xE1, 0xC0, 0x7E, 0x1C, 0x07, 0xE1, 0xC0, 0x7E, 0x1C, 0x07, 0xE1, 0xC0,
  0x7E, 0x1C, 0x07, 0xE1, 0xC0, 0x7E, 0x1C, 0x07, 0xE0, 0xC0, 0x7E, 0x0E,
  0x0F, 0xE0, 0xFB, 0xFE, 0x07, 0xF7, 0xE0, 0x3E, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xE7, 0x00,
  0x18, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x38, 0x07, 0x07, 0x00,
  0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03,
  0x80, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x8E,
  0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x3D, 0xC0, 0x03, 0xF0,
  0x00, 0x70, 0xFF, 0xF0, 0x7F, 0xFE, 0x38, 0x1F, 0x9C, 0x03, 0xCE, 0x00,
  0xF7, 0x00, 0x7B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x07, 0x38,
  0x07, 0x9C, 0x07, 0x8F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xF1, 0xC0, 0x3C,
  0xE0, 0x0F, 0x70, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x7F, 0x00,
  0x3B, 0x80, 0x1D, 0xC0, 0x1E, 0xE0, 0x1E, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F,
  0xFC, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x78, 0x3E, 0xF0, 0x0E,
  0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x0F, 0x70, 0x1E, 0x7E, 0x7C, 0x3F, 0xFC, 0x0F, 0xF0,
  0xFF, 0xE0, 0xFF, 0xF8, 0xE0, 0xFC, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E,
  0xE0, 0x3C, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x78, 0x3E, 0xF0, 0x0E,
  0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE1, 0xFF, 0xE1, 0xFF,
  0xE1, 0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x0F, 0x70, 0x1E, 0x7E, 0x7C, 0x3F, 0xFC, 0x0F, 0xF0,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x0E, 0xE0, 0x0F, 0x78, 0x0F, 0x1F, 0xBF, 0x07, 0xFF, 0x01, 0xFF,
  0x00, 0xE0, 0x07, 0xB8, 0x01, 0xCE, 0x00, 0xF3, 0x80, 0x38, 0xE0, 0x1E,
  0x38, 0x07, 0x0E, 0x03, 0xC3, 0x80, 0xE0, 0xE0, 0x78, 0x38, 0x1C, 0x0E,
  0x0F, 0x03, 0x83, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0x83,
  0x80, 0xE0, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x83, 0x80, 0xE0, 0xE0, 0x3C,
  0x38, 0x07, 0x0E, 0x01, 0xE3, 0x80, 0x38, 0xE0, 0x0F, 0x38, 0x01, 0xCE,
  0x00, 0x7B, 0x80, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFC, 0x07, 0xF6, 0x03, 0xFF, 0x81, 0xBF, 0xC1, 0xDF, 0x60,
  0xEF, 0xB8, 0x67, 0xDC, 0x33, 0xE6, 0x39, 0xF3, 0x99, 0xF9, 0xCC, 0xFC,
  0x6E, 0x7E, 0x3E, 0x3F, 0x1F, 0x1F, 0x87, 0x8F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x70,
  0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xD8, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xEC, 0x07, 0xEE, 0x07, 0xEE, 0x07, 0xE7, 0x07, 0xE7, 0x07, 0xE7, 0x07,
  0xE3, 0x87, 0xE3, 0x87, 0xE1, 0x87, 0xE1, 0xC7, 0xE1, 0xC7, 0xE0, 0xC7,
  0xE0, 0xE7, 0xE0, 0xE7, 0xE0, 0x77, 0xE0, 0x77, 0xE0, 0x37, 0xE0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x78, 0x3E, 0xF0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0x70, 0x1E,
  0x7E, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0xFF, 0xF8, 0x7F, 0xFF, 0x38, 0x0F,
  0xDC, 0x01, 0xEE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xF7, 0xFF, 0xF3,
  0xFF, 0xF1, 0xFF, 0xE0, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xFE, 0x0F, 0xFF,
  0x87, 0x83, 0xE7, 0x80, 0x73, 0x80, 0x3D, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x07, 0x3C,
  0x07, 0x8F, 0xDF, 0x83, 0xFF, 0x80, 0x7F, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0xFF,
  0xF8, 0x7F, 0xFE, 0x38, 0x1F, 0x9C, 0x01, 0xEE, 0x00, 0x77, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xDC, 0x01,
  0xEE, 0x01, 0xE7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xC0, 0xE0, 0xE0, 0x70,
  0x38, 0x38, 0x1C, 0x1C, 0x0F, 0x0E, 0x03, 0x87, 0x01, 0xE3, 0x80, 0x71,
  0xC0, 0x3C, 0xE0, 0x0E, 0x70, 0x07, 0xB8, 0x01, 0xDC, 0x00, 0xF0, 0x03,
  0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0x81, 0xE7, 0x80, 0x73, 0x80, 0x1D,
  0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xF0, 0x03, 0xBC, 0x03, 0xCF, 0xCF, 0xC3, 0xFF, 0xC0, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xF0, 0x0E, 0x70, 0x1E,
  0x7E, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0xF0, 0x00, 0xEE, 0x00, 0x1D, 0xC0,
  0x07, 0x38, 0x00, 0xE7, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0xE1, 0xC0,
  0x1C, 0x3C, 0x03, 0x83, 0x80, 0x70, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0,
  0x70, 0x1C, 0x0E, 0x03, 0x83, 0x80, 0x70, 0x70, 0x07, 0x0E, 0x00, 0xE1,
  0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x39, 0xC0, 0x07, 0x30, 0x00, 0xEE,
  0x00, 0x1D, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0xE0, 0x78, 0x3F, 0x03, 0xC1, 0xF8, 0x1E, 0x0E, 0xC0, 0xF0, 0x77,
  0x0D, 0x83, 0xB8, 0x6C, 0x1D, 0xC3, 0x60, 0xCE, 0x1B, 0x06, 0x70, 0xCC,
  0x73, 0x86, 0x63, 0x9C, 0x33, 0x1C, 0x61, 0x98, 0xE3, 0x18, 0xC7, 0x1C,
  0xC6, 0x38, 0xE6, 0x31, 0xC7, 0x31, 0x8C, 0x39, 0x84, 0x61, 0xCC, 0x37,
  0x0E, 0x61, 0xB8, 0x73, 0x0D, 0xC1, 0xB0, 0x6E, 0x0D, 0x83, 0x70, 0x7C,
  0x1B, 0x83, 0xE0, 0xD8, 0x1F, 0x06, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0,
  0x3E, 0x07, 0x80, 0xF0, 0x01, 0xE7, 0x80, 0x1C, 0x38, 0x03, 0xC3, 0xC0,
  0x38, 0x1C, 0x07, 0x01, 0xE0, 0x70, 0x0E, 0x0E, 0x00, 0x70, 0xE0, 0x07,
  0x1C, 0x00, 0x3B, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xB8, 0x00, 0x39, 0xC0,
  0x07, 0x1C, 0x00, 0xF0, 0xE0, 0x0E, 0x0F, 0x01, 0xE0, 0x70, 0x1C, 0x07,
  0x83, 0xC0, 0x38, 0x38, 0x03, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xEE, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0E, 0x70, 0x01, 0xC7, 0x80, 0x1C, 0x38,
  0x03, 0x83, 0xC0, 0x38, 0x1C, 0x07, 0x81, 0xE0, 0x70, 0x0E, 0x0F, 0x00,
  0xF0, 0xE0, 0x07, 0x1E, 0x00, 0x79, 0xC0, 0x03, 0xBC, 0x00, 0x3B, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x7F,
  0xFF, 0xBF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0xEE, 0x00, 0x73, 0x00, 0x31, 0xC0, 0x38, 0x60, 0x18, 0x38, 0x1C,
  0x1C, 0x0E, 0x07, 0x0E, 0x03, 0x87, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x1F,
  0x80, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x78,
  0x38, 0x1C, 0x0E, 0x0F, 0x03, 0xE0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0x81,
  0xE7, 0x80, 0x73, 0x80, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC7, 0xFF, 0xEF, 0xFF, 0xF7, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x03, 0xEF, 0x07, 0x77, 0xFF,
  0x38, 0xFF, 0x1C, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE1, 0xE0, 0xE7, 0xF8, 0xEF, 0xFC, 0xF8, 0x3E, 0xF0,
  0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0xFE, 0x7E, 0xEF, 0xFC, 0xE7, 0xF0, 0x07,
  0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x78, 0x1E, 0xF0, 0x0E, 0xE0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0,
  0x1E, 0x7E, 0x7E, 0x3F, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x0F, 0x87, 0x3F, 0xE7, 0x7F,
  0xF7, 0x78, 0x37, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x17, 0x7C, 0x77, 0x3F,
  0xE7, 0x1F, 0xC7, 0x07, 0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x78, 0x1E, 0xF0,
  0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x0F, 0xF0, 0x0E, 0x7C, 0x3E, 0x3F, 0xFC, 0x0F, 0xF0, 0x00,
  0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x3F, 0xE7, 0x7F, 0xF7,
  0x78, 0x37, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x17, 0x78, 0x37, 0x3F, 0xF7, 0x1F, 0xE7, 0x02, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x3F, 0xFE,
  0x3F, 0xFC, 0x3F, 0xF0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE3, 0xE0, 0xEF, 0xF8, 0xEF, 0xFC, 0xF8, 0x1E,
  0xF0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x7C,
  0x01, 0xF8, 0x01, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x01, 0xF3,
  0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x0F, 0xE0,
  0x0F, 0x70, 0x07, 0x38, 0x07, 0x9C, 0x07, 0x8E, 0x03, 0x87, 0x03, 0x83,
  0x83, 0xC1, 0xC3, 0xC0, 0xFF, 0xC0, 0x7F, 0xF0, 0x38, 0x38, 0x1C, 0x1E,
  0x0E, 0x07, 0x87, 0x01, 0xC3, 0x80, 0xF1, 0xC0, 0x3C, 0xE0, 0x0E, 0x70,
  0x07, 0xB8, 0x01, 0xDC, 0x00, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x0F, 0x0E, 0x37, 0xE7, 0xCD, 0xFF, 0xFB, 0x87,
  0x8E, 0xE1, 0xC1, 0xF8, 0x70, 0x7E, 0x1C, 0x1F, 0x87, 0x07, 0xE1, 0xC1,
  0xF8, 0x70, 0x7E, 0x1C, 0x1F, 0x87, 0x07, 0xE1, 0xC1, 0xF8, 0x70, 0x7E,
  0x1C, 0x1F, 0x87, 0x07, 0xE1, 0xC1, 0xF8, 0x70, 0x7E, 0x1C, 0x1F, 0x87,
  0x07, 0xE1, 0xC1, 0xF8, 0x70, 0x70, 0x03, 0xE0, 0xEF, 0xF8, 0xEF, 0xFC,
  0xF8, 0x3E, 0xF0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0x07, 0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x78, 0x3E, 0xF0, 0x0E,
  0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0E, 0xF0, 0x1E, 0x7E, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0x01, 0xE0,
  0xE7, 0xF8, 0xEF, 0xFC, 0xF8, 0x3E, 0xF0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E,
  0xFE, 0x7C, 0xEF, 0xFC, 0xE7, 0xF0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x3F, 0xE7,
  0x7F, 0xF7, 0x78, 0x37, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x17, 0x7C, 0x77,
  0x3F, 0xE7, 0x1F, 0xC7, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x01, 0xF0, 0x7B, 0xFE, 0x3F, 0xFF,
  0x9F, 0x83, 0xEF, 0x80, 0xF7, 0x80, 0x3B, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0xF8, 0x7F, 0xFE, 0x78,
  0x1E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x7F,
  0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0x7C, 0x7E, 0x7F, 0xFC, 0x1F,
  0xF8, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E,
  0xF0, 0x0E, 0x70, 0x1E, 0x7E, 0x7C, 0x3F, 0xF8, 0x0F, 0xF0, 0xF0, 0x00,
  0xEE, 0x00, 0x39, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x38, 0x78, 0x07,
  0x07, 0x00, 0xE0, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x38,
  0x07, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x38, 0x01, 0xE7, 0x00, 0x1C, 0xE0,
  0x03, 0xB8, 0x00, 0x77, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0xC0, 0xE0, 0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x6E, 0x0B, 0x06, 0xE1, 0xB0,
  0xEE, 0x1B, 0x0E, 0x61, 0xB0, 0xE6, 0x19, 0x8E, 0x71, 0x98, 0xC7, 0x11,
  0x8C, 0x73, 0x18, 0xC7, 0x31, 0x9C, 0x33, 0x19, 0xC3, 0x30, 0xDC, 0x3B,
  0x0D, 0x83, 0xA0, 0xD8, 0x3E, 0x0D, 0x83, 0xE0, 0xF8, 0x1E, 0x0F, 0x81,
  0xE0, 0xF8, 0x1E, 0x07, 0x00, 0x78, 0x01, 0xE7, 0x80, 0x70, 0x70, 0x1E,
  0x0F, 0x03, 0x80, 0xF0, 0xE0, 0x0E, 0x3C, 0x01, 0xE7, 0x00, 0x1D, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x3B, 0x80,
  0x0F, 0x38, 0x01, 0xC7, 0x80, 0x70, 0x70, 0x1E, 0x07, 0x03, 0x80, 0xF0,
  0xE0, 0x0E, 0x3C, 0x00, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x38,
  0xE0, 0x07, 0x1C, 0x01, 0xE3, 0xC0, 0x38, 0x38, 0x07, 0x07, 0x01, 0xC0,
  0x70, 0x38, 0x0E, 0x07, 0x01, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x8F, 0x00,
  0x79, 0xC0, 0x07, 0x38, 0x00, 0xEE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x1F, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xE0, 0x7F, 0xC0, 0x3F, 0xF0,
  0x00, 0x7C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x3C, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x1F, 0x80, 0x3F, 0xC0, 0x1F, 0x80, 0x00, 0x0C, 0x01, 0xDF, 0xC0,
  0x7F, 0xF8, 0x1F, 0x8F, 0x07, 0xE1, 0xE1, 0xF8, 0x3D, 0xEE, 0x07, 0xFB,
  0x80, 0xFC,
};

const GFXglyph JetBrainsMono_Light39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 5, 28, 23, 9, -28 },
  { 19, 11, 11, 23, 6, -28 },
  { 35, 21, 28, 23, 1, -28 },
  { 109, 17, 39, 23, 3, -34 },
  { 192, 22, 29, 23, 1, -29 },
  { 272, 20, 29, 23, 2, -29 },
  { 345, 3, 11, 23, 10, -28 },
  { 350, 12, 38, 23, 7, -33 },
  { 407, 12, 38, 23, 4, -33 },
  { 464, 21, 20, 23, 1, -24 },
  { 517, 18, 18, 23, 3, -22 },
  { 558, 7, 12, 23, 7, -6 },
  { 569, 13, 3, 23, 5, -14 },
  { 574, 6, 6, 23, 9, -6 },
  { 579, 17, 36, 23, 3, -32 },
  { 656, 17, 29, 23, 3, -29 },
  { 718, 17, 28, 23, 4, -28 },
  { 778, 18, 29, 23, 3, -29 },
  { 844, 17, 28, 23, 3, -28 },
  { 904, 16, 28, 23, 3, -28 },
  { 960, 17, 28, 23, 3, -28 },
  { 1020, 18, 28, 23, 3, -28 },
  { 1083, 18, 28, 23, 3, -28 },
  { 1146, 17, 29, 23, 3, -29 },
  { 1208, 18, 29, 23, 3, -29 },
  { 1274, 6, 22, 23, 9, -22 },
  { 1291, 8, 28, 23, 7, -22 },
  { 1319, 17, 20, 23, 3, -23 },
  { 1362, 17, 12, 23, 3, -19 },
  { 1388, 17, 20, 23, 3, -23 },
  { 1431, 13, 28, 23, 6, -28 },
  { 1477, 20, 36, 23, 2, -29 },
  { 1567, 19, 28, 23, 2, -28 },
  { 1634, 17, 28, 23, 4, -28 },
  { 1694, 16, 29, 23, 4, -29 },
  { 1752, 16, 28, 23, 4, -28 },
  { 1808, 16, 28, 23, 4, -28 },
  { 1864, 16, 29, 23, 4, -29 },
  { 1922, 16, 29, 23, 4, -29 },
  { 1980, 16, 28, 23, 4, -28 },
  { 2036, 15, 28, 23, 4, -28 },
  { 2089, 17, 28, 23, 2, -28 },
  { 2149, 18, 28, 23, 4, -28 },
  { 2212, 16, 28, 23, 5, -28 },
  { 2268, 17, 28, 23, 3, -28 },
  { 2328, 16, 28, 23, 4, -28 },
  { 2384, 16, 29, 23, 4, -29 },
  { 2442, 17, 28, 23, 4, -28 },
  { 2502, 17, 36, 23, 3, -29 },
  { 2579, 17, 28, 23, 4, -28 },
  { 2639, 17, 29, 23, 3, -29 },
  { 2701, 19, 29, 23, 2, -29 },
  { 2770, 16, 28, 23, 4, -28 },
  { 2826, 19, 28, 23, 2, -28 },
  { 2893, 21, 28, 23, 1, -28 },
  { 2967, 20, 28, 23, 2, -28 },
  { 3037, 20, 28, 23, 2, -28 },
  { 3107, 17, 28, 23, 3, -28 },
  { 3167, 10, 36, 23, 8, -32 },
  { 3212, 17, 36, 23, 3, -32 },
  { 3289, 9, 36, 23, 6, -32 },
  { 3330, 17, 15, 23, 3, -28 },
  { 3362, 19, 3, 23, 2, 1 },
  { 3370, 8, 6, 23, 7, -31 },
  { 3376, 17, 22, 23, 3, -22 },
  { 3423, 16, 28, 23, 4, -28 },
  { 3479, 16, 22, 23, 4, -22 },
  { 3523, 16, 28, 23, 4, -28 },
  { 3579, 16, 22, 23, 4, -22 },
  { 3623, 19, 28, 23, 2, -28 },
  { 3690, 16, 29, 23, 4, -22 },
  { 3748, 16, 28, 23, 4, -28 },
  { 3804, 18, 30, 23, 3, -30 },
  { 3872, 15, 37, 23, 3, -30 },
  { 3942, 17, 28, 23, 4, -28 },
  { 4002, 20, 28, 23, 1, -28 },
  { 4072, 18, 22, 23, 3, -22 },
  { 4122, 16, 22, 23, 4, -22 },
  { 4166, 16, 22, 23, 4, -22 },
  { 4210, 16, 29, 23, 4, -22 },
  { 4268, 16, 29, 23, 4, -22 },
  { 4326, 17, 22, 23, 4, -22 },
  { 4373, 16, 22, 23, 4, -22 },
  { 4417, 18, 28, 23, 2, -28 },
  { 4480, 16, 21, 23, 4, -21 },
  { 4522, 19, 21, 23, 2, -21 },
  { 4572, 20, 21, 23, 2, -21 },
  { 4625, 19, 21, 23, 2, -21 },
  { 4675, 19, 28, 23, 2, -21 },
  { 4742, 16, 21, 23, 4, -21 },
  { 4784, 17, 36, 23, 3, -32 },
  { 4861, 3, 36, 23, 10, -32 },
  { 4875, 17, 36, 23, 3, -32 },
  { 4952, 18, 8, 23, 3, -18 },
};

const GFXfont JetBrainsMono_Light39pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light39pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _JETBRAINSMONO_LIGHT39PT7B_H_
