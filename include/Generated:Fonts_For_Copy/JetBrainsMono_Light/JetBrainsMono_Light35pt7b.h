#ifndef _JETBRAINSMONO_LIGHT35PT7B_H_
#define _JETBRAINSMONO_LIGHT35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light35pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x71,
  0x88, 0x00, 0x01, 0xDF, 0xFB, 0x80, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFE,
  0x0E, 0xC1, 0x98, 0x33, 0x06, 0x60, 0xCC, 0x19, 0x83, 0x00, 0x01, 0x81,
  0x80, 0x30, 0x30, 0x0E, 0x0E, 0x01, 0x81, 0x80, 0x30, 0x30, 0x06, 0x06,
  0x00, 0xC0, 0xC0, 0x38, 0x38, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x18, 0x18,
  0x03, 0x03, 0x00, 0xE0, 0x60, 0x1C, 0x1C, 0x03, 0x03, 0x00, 0x60, 0x60,
  0x0C, 0x0C, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x0C, 0x0C, 0x01, 0x81, 0x80,
  0x30, 0x30, 0x06, 0x06, 0x01, 0xC0, 0xC0, 0x38, 0x38, 0x06, 0x06, 0x00,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x7C, 0x03, 0xFE, 0x0F,
  0xFF, 0x38, 0xCE, 0x71, 0x8F, 0xC3, 0x1F, 0x86, 0x3F, 0x0C, 0x0F, 0x18,
  0x0E, 0x30, 0x1E, 0x60, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x0D, 0xE0, 0x18, 0xE0, 0x31, 0xC0, 0x63, 0xE0, 0xC3, 0xE1, 0x8F, 0xC3,
  0x1F, 0xC6, 0x7B, 0xED, 0xE3, 0xFF, 0x83, 0xFE, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x6F, 0xE0, 0x1F, 0xDE,
  0x03, 0x60, 0xC0, 0xCC, 0x18, 0x39, 0x83, 0x06, 0x30, 0x61, 0x86, 0x0C,
  0x70, 0xC1, 0x8C, 0x1C, 0x73, 0x01, 0xFC, 0xE0, 0x1F, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x80, 0x0C, 0xFE, 0x03, 0x3F, 0xE0, 0xE6,
  0x0C, 0x18, 0xC1, 0x86, 0x18, 0x31, 0xC3, 0x06, 0x30, 0x60, 0xCC, 0x0C,
  0x1B, 0x81, 0xC7, 0x60, 0x1F, 0xD8, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xFC,
  0x03, 0xFF, 0x80, 0xE0, 0xF0, 0x38, 0x1C, 0x0C, 0x07, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x7F,
  0x00, 0x1C, 0xE0, 0x7E, 0x38, 0x3B, 0x87, 0x1C, 0xE0, 0xE7, 0x38, 0x3F,
  0x8E, 0x07, 0xE3, 0x80, 0xF0, 0xE0, 0x1C, 0x38, 0x0F, 0x0E, 0x07, 0xE1,
  0xC3, 0xDC, 0x7F, 0xE3, 0x8F, 0xE0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xC0, 0xF0, 0xF8, 0x78, 0x3C, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x3C,
  0x07, 0xC0, 0xFC, 0x0F, 0x00, 0xC0, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F,
  0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x0F, 0x07, 0x8F, 0xC3, 0xC0, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0xE1, 0xC1, 0x9F, 0x11, 0xF7, 0xFA, 0xFF, 0x0F, 0xFE, 0x00, 0x1C, 0x00,
  0x06, 0xC0, 0x01, 0xDC, 0x00, 0x7B, 0x80, 0x0E, 0x38, 0x03, 0x83, 0x80,
  0xF0, 0x78, 0x0C, 0x06, 0x00, 0x80, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x1E, 0x78, 0xF1, 0xC3,
  0x8F, 0x1C, 0x38, 0x61, 0xC3, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC1,
  0xEF, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x1C, 0x7E, 0x38, 0xFC, 0xF9, 0xF8, 0xE3, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xDC, 0x07,
  0x3C, 0x1E, 0x3F, 0xF8, 0x1F, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x1F, 0xC0,
  0x3D, 0xC0, 0x79, 0xC0, 0xF1, 0xC0, 0xC1, 0xC0, 0x81, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0,
  0x3F, 0xE1, 0xFF, 0xE3, 0x81, 0xEE, 0x01, 0xDC, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFC, 0xFF, 0xF9, 0xFF, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x0F, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0xFC, 0x03, 0xBC, 0x07, 0x3C, 0x3C, 0x3F, 0xF0, 0x3F, 0xC0,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x03, 0x38, 0x0D, 0xE0,
  0x37, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x7F, 0xFC,
  0xFF, 0xF9, 0xFF, 0xF3, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC7, 0xC1, 0xBF, 0xE3, 0x7F, 0xC7, 0x83, 0xCE, 0x03,
  0x98, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xDC, 0x07, 0x3C, 0x1E, 0x3F, 0xF8, 0x1F, 0xC0, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE7, 0x83, 0xBF, 0xC7, 0xFF, 0xDE,
  0x03, 0xB8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xDC, 0x07, 0x3E, 0x1E, 0x3F, 0xF8, 0x1F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC0, 0xE7,
  0x01, 0xDC, 0x01, 0xF8, 0x03, 0xB0, 0x07, 0x70, 0x1C, 0xE0, 0x38, 0xE0,
  0xE0, 0xF7, 0x80, 0x7C, 0x01, 0xFC, 0x0F, 0x1E, 0x3C, 0x1E, 0x70, 0x1D,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xBC,
  0x1E, 0x3F, 0xF8, 0x3F, 0xE0, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0x80,
  0xEE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x80, 0x3F, 0x00, 0x7F, 0x01, 0xEF, 0x07, 0x8F, 0xFF, 0x0F, 0xDC, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x27, 0xFF, 0xFF, 0x90, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0xFF, 0xFF, 0xF0, 0x18, 0x7C, 0xF9, 0xF3, 0xE1,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x3C, 0x78, 0xF1,
  0xC7, 0x8E, 0x1C, 0x30, 0xE1, 0xC0, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x78,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x01, 0x80,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0C, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0x78,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x01, 0x80,
  0x02, 0x00, 0x00, 0xFC, 0x0F, 0xF8, 0xFF, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x07, 0xE1, 0xFC,
  0x1F, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0x87,
  0x87, 0x00, 0xE7, 0x00, 0x3B, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x3C, 0xF0, 0x3F, 0x78, 0x38, 0x7C, 0x18, 0x1E, 0x1C, 0x0F,
  0x0E, 0x07, 0x87, 0x03, 0xC3, 0x81, 0xE1, 0xC0, 0xF0, 0xE0, 0x78, 0x70,
  0x3C, 0x18, 0x1E, 0x0E, 0x1F, 0x07, 0xFF, 0x80, 0xF3, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x00, 0x7F, 0xC0,
  0x0F, 0xE0, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x6C, 0x00, 0x36,
  0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x07, 0x1C, 0x03,
  0x8E, 0x01, 0x83, 0x01, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x30, 0x18,
  0x38, 0x0E, 0x1F, 0xFF, 0x0F, 0xFF, 0x86, 0x00, 0xC7, 0x00, 0x73, 0x80,
  0x39, 0xC0, 0x1C, 0xC0, 0x06, 0xE0, 0x03, 0xF0, 0x01, 0xC0, 0xFF, 0x81,
  0xFF, 0xE3, 0xFF, 0xE7, 0x01, 0xEE, 0x01, 0xDC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x3B, 0x80, 0x77, 0x07, 0xCF, 0xFE, 0x1F, 0xFF,
  0x38, 0x0F, 0x70, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xFF, 0xFE, 0xFF, 0xF9, 0xFF, 0xC0, 0x07,
  0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC0, 0xE7, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x7E, 0x00, 0xEC, 0x01, 0xDC, 0x07, 0x3E, 0x1E, 0x3F, 0xF8, 0x1F, 0xC0,
  0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0xE7, 0x03, 0xCE, 0x01, 0xDC, 0x03, 0xB8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x03, 0xB8, 0x0F, 0x70, 0xFC, 0xFF, 0xF1, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xFE, 0xFF, 0xFB,
  0xFF, 0xEC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0xFF, 0xDF,
  0xFF, 0xB8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00,
  0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC0, 0xE7, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xEC, 0x01, 0xDC, 0x07, 0x3E, 0x1E, 0x3F, 0xF8, 0x1F,
  0xC0, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xDC, 0x07, 0x3C, 0x1E, 0x3F, 0xF8, 0x3F, 0xE0, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x38,
  0xE0, 0x70, 0xE0, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE1, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x38,
  0xE0, 0x38, 0xE0, 0x3C, 0xE0, 0x1C, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0F,
  0xE0, 0x07, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC1, 0xFD, 0x83,
  0x7B, 0x06, 0xF7, 0x1D, 0xE6, 0x33, 0xCC, 0x67, 0x9C, 0xCF, 0x1B, 0x1E,
  0x36, 0x3C, 0x6C, 0xFC, 0x71, 0xF8, 0xE3, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1C, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFB, 0x03, 0xF7, 0x07, 0xE6, 0x0F, 0xCC, 0x1F, 0x9C,
  0x3F, 0x18, 0x7E, 0x30, 0xFC, 0x71, 0xF8, 0x63, 0xF0, 0xE7, 0xE1, 0xCF,
  0xC1, 0x9F, 0x83, 0xBF, 0x03, 0x7E, 0x06, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x3C, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC1,
  0xE7, 0x01, 0xDC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xEC, 0x01, 0x9C, 0x07,
  0x3E, 0x1E, 0x3F, 0xF8, 0x1F, 0xC0, 0xFF, 0xC0, 0xFF, 0xF8, 0xFF, 0xFC,
  0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x3E, 0xFF, 0xFC, 0xFF, 0xF0,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0xC0,
  0x3F, 0xE0, 0xFF, 0xE3, 0xC1, 0xE7, 0x01, 0xDC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xDC, 0x07, 0x3E, 0x3E, 0x3F, 0xF8, 0x1F, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0xFF, 0xFC, 0xE0, 0x3C, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1E, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0xE0, 0x70,
  0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1E, 0xE0, 0x0E,
  0xE0, 0x0F, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xC0, 0xE7, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xF8,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xBC, 0x1E, 0x3F,
  0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xEE, 0x03, 0x9C, 0x07, 0x3E, 0x3E, 0x3F, 0xF8, 0x1F, 0xC0,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xEE, 0x00, 0xE7, 0x00, 0x73, 0x80,
  0x38, 0xC0, 0x1C, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x06, 0x03, 0x03,
  0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x30, 0x60, 0x1C, 0x70, 0x0E, 0x38,
  0x07, 0x1C, 0x01, 0x8C, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x0D,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xE0, 0xE0, 0xFC, 0x1C,
  0x1F, 0x83, 0x83, 0xF0, 0x50, 0x7E, 0x0B, 0x0E, 0xC3, 0x61, 0x98, 0x6C,
  0x33, 0x0D, 0x86, 0x71, 0xB0, 0xCE, 0x36, 0x39, 0xC6, 0x47, 0x38, 0x88,
  0xE7, 0x11, 0x9C, 0x66, 0x33, 0x0C, 0xC6, 0x61, 0x98, 0xCC, 0x33, 0x19,
  0x86, 0x63, 0x30, 0xEC, 0x6E, 0x1D, 0x05, 0xC3, 0xE0, 0xF8, 0x7C, 0x1E,
  0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x70, 0x01,
  0xC7, 0x00, 0x70, 0xE0, 0x0E, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x1C,
  0x03, 0x83, 0x80, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0x77, 0x00, 0x06, 0xC0,
  0x00, 0xF8, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x1D, 0xC0,
  0x03, 0xB8, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x07, 0x07, 0x00, 0xE0, 0xE0,
  0x38, 0x0E, 0x0F, 0x01, 0xE1, 0xC0, 0x1C, 0x70, 0x03, 0xDE, 0x00, 0x3C,
  0xE0, 0x00, 0xEE, 0x00, 0x39, 0xC0, 0x07, 0x1C, 0x01, 0xC3, 0x80, 0x38,
  0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x70, 0x0E, 0x0E, 0x00, 0xE3, 0x80,
  0x1C, 0x70, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x03, 0x60, 0x00, 0x7C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0xFF, 0xFF, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x1F, 0x00, 0x36, 0x00, 0xEE, 0x01, 0x8C, 0x07, 0x1C, 0x0E, 0x18,
  0x18, 0x38, 0x70, 0x70, 0xC0, 0x63, 0x80, 0xE6, 0x00, 0xDC, 0x01, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0xE0, 0xE0, 0xF0, 0x00, 0x80, 0x0F,
  0xF8, 0x1F, 0xFC, 0x3C, 0x1E, 0x38, 0x0E, 0x70, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x0F, 0xFF, 0x3F, 0xFF, 0x78, 0x07, 0x70, 0x07, 0x60,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x0F, 0x78, 0x1F, 0x3F, 0xF7, 0x1F,
  0xE7, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x20, 0x73, 0xF8, 0xEF, 0xF9, 0xF0, 0x7B, 0xC0, 0x77, 0x80, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0x7E, 0x1E, 0xEF, 0xF9,
  0xCF, 0xE0, 0x01, 0x00, 0x3F, 0xE0, 0xFF, 0xE3, 0xC1, 0xE7, 0x01, 0xDC,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x03, 0xF0, 0x07, 0x70, 0x1C, 0xF8, 0x78,
  0xFF, 0xE0, 0x7F, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x83, 0x8F, 0xE7, 0x3F, 0xEE, 0xF0, 0x7D, 0xC0,
  0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xDC, 0x07, 0xBC,
  0x3F, 0x3F, 0xEE, 0x3F, 0x9C, 0x01, 0x00, 0x3F, 0xE0, 0xFF, 0xE3, 0xC1,
  0xE7, 0x01, 0xDC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x07, 0x70,
  0x1C, 0xF0, 0x78, 0xFF, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0xC0,
  0x7F, 0xE0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x3F, 0x9C, 0xFF, 0xBB, 0xC1, 0xF7, 0x01,
  0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xDC, 0x07, 0xBC, 0x1F, 0x3F, 0xEE, 0x3F,
  0x9C, 0x1E, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1E,
  0x1F, 0xF8, 0x3F, 0xE0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x20, 0x73, 0xF8, 0xEF, 0xF9, 0xF0, 0x7B, 0xC0,
  0x77, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1C, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x70, 0x07, 0xC0, 0x3E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF3, 0xFF, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x0F, 0x9F, 0xF8, 0xFF, 0x80, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0,
  0x1C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x70, 0xE0, 0xE0, 0xE1, 0xE0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xE1, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0xE0, 0x78, 0xE0,
  0x38, 0xE0, 0x1C, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x07, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x02, 0x08, 0x77, 0xDF,
  0x3F, 0xEF, 0xDC, 0x38, 0x6E, 0x1C, 0x3F, 0x0E, 0x1F, 0x87, 0x0F, 0xC3,
  0x87, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0x70, 0xFC, 0x38, 0x7E, 0x1C, 0x3F,
  0x0E, 0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0x70,
  0xFC, 0x38, 0x70, 0x00, 0x81, 0xCF, 0xE3, 0xBF, 0xE7, 0xC1, 0xEF, 0x01,
  0xDE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x70, 0x03, 0x00, 0x3F, 0xE0, 0xFF, 0xE3, 0xC1,
  0xE7, 0x01, 0xDC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0x70,
  0x1C, 0xF8, 0xF8, 0xFF, 0xE0, 0x7F, 0x00, 0x00, 0x81, 0xCF, 0xE3, 0xBF,
  0xE7, 0xC1, 0xEF, 0x01, 0xDE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8,
  0x07, 0xF0, 0x1D, 0xF8, 0x7B, 0xBF, 0xE7, 0x3F, 0x8E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x3F, 0x9C,
  0xFF, 0xBB, 0xC1, 0xF7, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0x70, 0x1E, 0xF0, 0xFC, 0xFF, 0xB8, 0xFE, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x01, 0x01, 0xDF,
  0xE3, 0xFF, 0xE7, 0xC1, 0xEF, 0x01, 0xDC, 0x03, 0xB8, 0x03, 0x70, 0x07,
  0xE0, 0x0F, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x3F, 0xF0, 0xFF, 0xF3, 0xC0, 0xE7, 0x00, 0xEC, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0xF0, 0x07, 0xF0, 0x0E, 0xF0, 0x78, 0xFF, 0xF0, 0xFF,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xDC, 0x07, 0x38, 0x0E, 0x38, 0x78, 0x7F,
  0xF0, 0x3F, 0x80, 0xE0, 0x03, 0xB8, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE3,
  0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0x38, 0x18, 0x1C, 0x1C, 0x0E, 0x0E,
  0x03, 0x86, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x39, 0x80, 0x1D, 0xC0, 0x0E,
  0xE0, 0x03, 0x60, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xE0, 0xE0, 0xEC, 0x1C,
  0x19, 0x82, 0x83, 0x30, 0x50, 0x67, 0x1B, 0x0C, 0xE3, 0x63, 0x9C, 0x6C,
  0x71, 0x8D, 0x8C, 0x31, 0x11, 0x86, 0x22, 0x30, 0xCC, 0x66, 0x1D, 0x8D,
  0xC3, 0xB1, 0xB0, 0x36, 0x36, 0x06, 0x82, 0xC0, 0xD0, 0x58, 0x1E, 0x0F,
  0x03, 0xC1, 0xE0, 0x78, 0x38, 0x00, 0xF0, 0x07, 0x9C, 0x07, 0x0E, 0x03,
  0x83, 0x83, 0x80, 0xE3, 0x80, 0x71, 0xC0, 0x1D, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xEE, 0x00, 0xF7, 0x80, 0x71, 0xC0,
  0x70, 0x70, 0x78, 0x3C, 0x38, 0x0E, 0x38, 0x03, 0xBC, 0x01, 0xE0, 0xF0,
  0x03, 0xB8, 0x03, 0x9C, 0x01, 0xC7, 0x00, 0xC3, 0x80, 0xE1, 0xC0, 0x70,
  0x70, 0x70, 0x38, 0x38, 0x0E, 0x1C, 0x07, 0x1C, 0x03, 0x8E, 0x00, 0xE7,
  0x00, 0x77, 0x00, 0x1B, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0x70, 0x01,
  0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xE0, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x7F, 0xC0, 0xFE,
  0x01, 0xFF, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0xFF, 0x00, 0xFE, 0x07, 0xFC, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xF0, 0x00, 0x1C, 0x03,
  0xBF, 0x81, 0xDF, 0xE0, 0xEC, 0x38, 0x7E, 0x0E, 0x77, 0x07, 0xFB, 0x80,
  0xF8,
};

const GFXglyph JetBrainsMono_Light35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 5, 26, 21, 8, -26 },
  { 18, 11, 11, 21, 5, -26 },
  { 34, 19, 26, 21, 1, -26 },
  { 96, 15, 35, 21, 3, -30 },
  { 162, 19, 26, 21, 1, -26 },
  { 224, 18, 26, 21, 2, -26 },
  { 283, 3, 11, 21, 9, -26 },
  { 288, 10, 33, 21, 7, -29 },
  { 330, 10, 33, 21, 4, -29 },
  { 372, 19, 18, 21, 1, -21 },
  { 415, 17, 17, 21, 2, -20 },
  { 452, 7, 11, 21, 6, -5 },
  { 462, 11, 3, 21, 5, -13 },
  { 467, 5, 5, 21, 8, -5 },
  { 471, 15, 33, 21, 3, -29 },
  { 533, 15, 26, 21, 3, -26 },
  { 582, 16, 26, 21, 3, -26 },
  { 634, 15, 26, 21, 3, -26 },
  { 683, 15, 26, 21, 3, -26 },
  { 732, 14, 26, 21, 3, -26 },
  { 778, 15, 26, 21, 3, -26 },
  { 827, 15, 26, 21, 3, -26 },
  { 876, 16, 26, 21, 3, -26 },
  { 928, 15, 26, 21, 3, -26 },
  { 977, 15, 26, 21, 3, -26 },
  { 1026, 5, 20, 21, 8, -20 },
  { 1039, 7, 26, 21, 6, -20 },
  { 1062, 15, 19, 21, 3, -21 },
  { 1098, 15, 11, 21, 3, -17 },
  { 1119, 15, 19, 21, 3, -21 },
  { 1155, 12, 26, 21, 5, -26 },
  { 1194, 17, 32, 21, 2, -26 },
  { 1262, 17, 26, 21, 2, -26 },
  { 1318, 15, 26, 21, 3, -26 },
  { 1367, 15, 26, 21, 3, -26 },
  { 1416, 15, 26, 21, 3, -26 },
  { 1465, 14, 26, 21, 4, -26 },
  { 1511, 15, 26, 21, 3, -26 },
  { 1560, 15, 26, 21, 3, -26 },
  { 1609, 15, 26, 21, 3, -26 },
  { 1658, 13, 26, 21, 4, -26 },
  { 1701, 15, 26, 21, 2, -26 },
  { 1750, 16, 26, 21, 3, -26 },
  { 1802, 15, 26, 21, 4, -26 },
  { 1851, 15, 26, 21, 3, -26 },
  { 1900, 15, 26, 21, 3, -26 },
  { 1949, 15, 26, 21, 3, -26 },
  { 1998, 16, 26, 21, 3, -26 },
  { 2050, 15, 32, 21, 3, -26 },
  { 2110, 16, 26, 21, 3, -26 },
  { 2162, 15, 26, 21, 3, -26 },
  { 2211, 17, 26, 21, 2, -26 },
  { 2267, 15, 26, 21, 3, -26 },
  { 2316, 17, 26, 21, 2, -26 },
  { 2372, 19, 26, 21, 1, -26 },
  { 2434, 19, 26, 21, 1, -26 },
  { 2496, 19, 26, 21, 1, -26 },
  { 2558, 15, 26, 21, 3, -26 },
  { 2607, 9, 33, 21, 7, -29 },
  { 2645, 15, 33, 21, 3, -29 },
  { 2707, 9, 33, 21, 5, -29 },
  { 2745, 15, 14, 21, 3, -26 },
  { 2772, 17, 2, 21, 2, 1 },
  { 2777, 7, 4, 21, 7, -27 },
  { 2781, 16, 20, 21, 2, -20 },
  { 2821, 15, 26, 21, 3, -26 },
  { 2870, 15, 20, 21, 3, -20 },
  { 2908, 15, 26, 21, 3, -26 },
  { 2957, 15, 20, 21, 3, -20 },
  { 2995, 17, 26, 21, 2, -26 },
  { 3051, 15, 26, 21, 3, -20 },
  { 3100, 15, 26, 21, 3, -26 },
  { 3149, 16, 27, 21, 3, -27 },
  { 3203, 13, 33, 21, 3, -27 },
  { 3257, 16, 26, 21, 3, -26 },
  { 3309, 18, 26, 21, 1, -26 },
  { 3368, 17, 20, 21, 2, -20 },
  { 3411, 15, 20, 21, 3, -20 },
  { 3449, 15, 20, 21, 3, -20 },
  { 3487, 15, 26, 21, 3, -20 },
  { 3536, 15, 26, 21, 3, -20 },
  { 3585, 15, 20, 21, 4, -20 },
  { 3623, 15, 20, 21, 3, -20 },
  { 3661, 16, 25, 21, 2, -25 },
  { 3711, 15, 19, 21, 3, -19 },
  { 3747, 17, 19, 21, 2, -19 },
  { 3788, 19, 19, 21, 1, -19 },
  { 3834, 17, 19, 21, 2, -19 },
  { 3875, 17, 25, 21, 2, -19 },
  { 3929, 15, 19, 21, 3, -19 },
  { 3965, 15, 33, 21, 3, -29 },
  { 4027, 3, 33, 21, 9, -29 },
  { 4040, 15, 33, 21, 3, -29 },
  { 4102, 17, 7, 21, 2, -16 },
};

const GFXfont JetBrainsMono_Light35pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light35pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _JETBRAINSMONO_LIGHT35PT7B_H_
