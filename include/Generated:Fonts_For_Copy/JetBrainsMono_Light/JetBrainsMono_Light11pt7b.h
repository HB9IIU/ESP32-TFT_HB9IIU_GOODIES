#ifndef _JETBRAINSMONO_LIGHT11PT7B_H_
#define _JETBRAINSMONO_LIGHT11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xB6, 0x80, 0x24, 0x97, 0xCA, 0x4B, 0xF4, 0x94, 0x21, 0x1D,
  0x5A, 0x30, 0xC5, 0xAB, 0x88, 0x40, 0xE6, 0x9A, 0x94, 0x2C, 0xD5, 0x63,
  0x74, 0xA1, 0x8A, 0xDA, 0x5D, 0xE0, 0x2A, 0x49, 0x24, 0x44, 0xC2, 0x21,
  0x11, 0x12, 0x2C, 0x10, 0x4F, 0xC4, 0x29, 0x20, 0x21, 0x3E, 0x42, 0x00,
  0x7A, 0xE0, 0x70, 0x08, 0x84, 0x42, 0x11, 0x08, 0x84, 0x00, 0x74, 0x63,
  0x5A, 0xC6, 0x2E, 0x65, 0x08, 0x42, 0x10, 0x9F, 0x74, 0x42, 0x23, 0x11,
  0x1F, 0xF0, 0x88, 0xE0, 0x86, 0x3E, 0x12, 0x45, 0x9F, 0x11, 0xF4, 0x21,
  0xE0, 0x86, 0x2E, 0x21, 0x11, 0xE8, 0xC6, 0x2E, 0xFC, 0x44, 0x22, 0x10,
  0x88, 0x74, 0x64, 0xE5, 0x46, 0x2E, 0x74, 0x63, 0x17, 0x08, 0x88, 0xC0,
  0x70, 0xC0, 0x5A, 0x08, 0x99, 0x06, 0x0C, 0xF8, 0x3E, 0x86, 0x0C, 0x13,
  0x60, 0xE4, 0x9D, 0x06, 0x74, 0x63, 0x7A, 0xD6, 0xB2, 0x83, 0x00, 0x23,
  0x14, 0xA9, 0x7A, 0x31, 0xF4, 0x63, 0xE9, 0x46, 0x3E, 0x74, 0x61, 0x08,
  0x42, 0x2E, 0xF4, 0xA3, 0x18, 0xC6, 0x5E, 0xFC, 0x21, 0xE8, 0x42, 0x1F,
  0xFC, 0x21, 0xE8, 0x42, 0x10, 0x74, 0x61, 0x0B, 0xC6, 0x2E, 0x8C, 0x63,
  0xF8, 0xC6, 0x31, 0xF2, 0x22, 0x22, 0x2F, 0x31, 0x11, 0x11, 0x9F, 0x8C,
  0xA5, 0xCA, 0x4A, 0x51, 0x84, 0x21, 0x08, 0x42, 0x1F, 0x9E, 0xF7, 0x58,
  0xC6, 0x31, 0x8E, 0x73, 0x5A, 0xD6, 0x73, 0x74, 0x63, 0x18, 0xC6, 0x2E,
  0xF4, 0x63, 0x1F, 0x42, 0x10, 0x74, 0x63, 0x18, 0xC6, 0x2E, 0x10, 0xC0,
  0xF4, 0x63, 0x3E, 0x4A, 0x51, 0x74, 0x60, 0xC1, 0x06, 0x3E, 0xF9, 0x08,
  0x42, 0x10, 0x84, 0x8C, 0x63, 0x18, 0xC6, 0x2E, 0x8C, 0x65, 0x25, 0x29,
  0x84, 0x96, 0x57, 0x5D, 0x6D, 0xB6, 0xD2, 0x45, 0x22, 0x84, 0x30, 0xA4,
  0xB1, 0xC5, 0x22, 0x8A, 0x10, 0x41, 0x04, 0xF8, 0x84, 0x44, 0x22, 0x1F,
  0xF2, 0x49, 0x24, 0x9C, 0x84, 0x10, 0x82, 0x10, 0x82, 0x10, 0xC0, 0xD5,
  0x55, 0x70, 0x22, 0x95, 0x30, 0xF8, 0x90, 0x74, 0x5F, 0x18, 0xFC, 0x84,
  0x3D, 0x18, 0xC6, 0x3E, 0x74, 0x61, 0x08, 0xB8, 0x08, 0x7B, 0x38, 0xC6,
  0x2F, 0x74, 0x7F, 0x08, 0xB8, 0x3A, 0x3E, 0x84, 0x21, 0x08, 0x6C, 0xE3,
  0x19, 0xB4, 0x2E, 0x84, 0x3D, 0x18, 0xC6, 0x31, 0x21, 0x01, 0xC2, 0x10,
  0x84, 0xF8, 0x13, 0x0F, 0x11, 0x11, 0x11, 0xE0, 0x84, 0x23, 0x2E, 0x52,
  0x51, 0xE0, 0x82, 0x08, 0x20, 0x82, 0x07, 0xFD, 0x6B, 0x5A, 0xD4, 0xF4,
  0x63, 0x18, 0xC4, 0x74, 0x63, 0x18, 0xB8, 0xF4, 0x63, 0x18, 0xFA, 0x10,
  0x6C, 0xE3, 0x18, 0xBC, 0x21, 0xF4, 0x61, 0x08, 0x40, 0xF4, 0x78, 0x30,
  0xF8, 0x42, 0x3E, 0x84, 0x21, 0x07, 0x8C, 0x63, 0x18, 0xB8, 0x8C, 0xA4,
  0xA6, 0x10, 0x95, 0x57, 0x5B, 0x69, 0x20, 0x9A, 0x98, 0xC5, 0x44, 0x8C,
  0x94, 0xA6, 0x10, 0x88, 0xF0, 0x88, 0x84, 0x7C, 0x39, 0x08, 0x42, 0x70,
  0x84, 0x21, 0xC0, 0xFF, 0xC0, 0xC2, 0x10, 0x82, 0x1D, 0x08, 0x46, 0x00,
  0xCD, 0xC0,
};

const GFXglyph JetBrainsMono_Light11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 8, 7, 3, -8 },
  { 2, 3, 3, 7, 2, -8 },
  { 4, 6, 8, 7, 0, -8 },
  { 10, 5, 12, 7, 1, -10 },
  { 18, 6, 8, 7, 0, -8 },
  { 24, 5, 8, 7, 1, -8 },
  { 29, 1, 3, 7, 3, -8 },
  { 30, 3, 10, 7, 2, -9 },
  { 34, 4, 10, 7, 1, -9 },
  { 39, 6, 6, 7, 0, -7 },
  { 44, 5, 5, 7, 1, -6 },
  { 48, 2, 4, 7, 2, -2 },
  { 49, 3, 1, 7, 2, -4 },
  { 50, 2, 2, 7, 2, -2 },
  { 51, 5, 10, 7, 1, -9 },
  { 58, 5, 8, 7, 1, -8 },
  { 63, 5, 8, 7, 1, -8 },
  { 68, 5, 8, 7, 1, -8 },
  { 73, 5, 8, 7, 1, -8 },
  { 78, 4, 8, 7, 1, -8 },
  { 82, 5, 8, 7, 1, -8 },
  { 87, 5, 8, 7, 1, -8 },
  { 92, 5, 8, 7, 1, -8 },
  { 97, 5, 8, 7, 1, -8 },
  { 102, 5, 8, 7, 1, -8 },
  { 107, 2, 6, 7, 2, -6 },
  { 109, 2, 8, 7, 2, -6 },
  { 111, 5, 6, 7, 1, -7 },
  { 115, 5, 3, 7, 1, -5 },
  { 117, 5, 6, 7, 1, -7 },
  { 121, 3, 8, 7, 2, -8 },
  { 124, 5, 10, 7, 1, -8 },
  { 131, 5, 8, 7, 1, -8 },
  { 136, 5, 8, 7, 1, -8 },
  { 141, 5, 8, 7, 1, -8 },
  { 146, 5, 8, 7, 1, -8 },
  { 151, 5, 8, 7, 1, -8 },
  { 156, 5, 8, 7, 1, -8 },
  { 161, 5, 8, 7, 1, -8 },
  { 166, 5, 8, 7, 1, -8 },
  { 171, 4, 8, 7, 1, -8 },
  { 175, 4, 8, 7, 1, -8 },
  { 179, 5, 8, 7, 1, -8 },
  { 184, 5, 8, 7, 1, -8 },
  { 189, 5, 8, 7, 1, -8 },
  { 194, 5, 8, 7, 1, -8 },
  { 199, 5, 8, 7, 1, -8 },
  { 204, 5, 8, 7, 1, -8 },
  { 209, 5, 10, 7, 1, -8 },
  { 216, 5, 8, 7, 1, -8 },
  { 221, 5, 8, 7, 1, -8 },
  { 226, 5, 8, 7, 1, -8 },
  { 231, 5, 8, 7, 1, -8 },
  { 236, 5, 8, 7, 1, -8 },
  { 241, 6, 8, 7, 0, -8 },
  { 247, 6, 8, 7, 0, -8 },
  { 253, 6, 8, 7, 0, -8 },
  { 259, 5, 8, 7, 1, -8 },
  { 264, 3, 10, 7, 2, -9 },
  { 268, 5, 10, 7, 1, -9 },
  { 275, 2, 10, 7, 2, -9 },
  { 278, 5, 4, 7, 1, -8 },
  { 281, 5, 1, 7, 1, 0 },
  { 282, 2, 2, 7, 2, -9 },
  { 283, 5, 6, 7, 1, -6 },
  { 287, 5, 8, 7, 1, -8 },
  { 292, 5, 6, 7, 1, -6 },
  { 296, 5, 8, 7, 1, -8 },
  { 301, 5, 6, 7, 1, -6 },
  { 305, 5, 8, 7, 1, -8 },
  { 310, 5, 8, 7, 1, -6 },
  { 315, 5, 8, 7, 1, -8 },
  { 320, 5, 9, 7, 1, -9 },
  { 326, 4, 11, 7, 1, -9 },
  { 332, 5, 8, 7, 1, -8 },
  { 337, 6, 8, 7, 0, -8 },
  { 343, 5, 6, 7, 1, -6 },
  { 347, 5, 6, 7, 1, -6 },
  { 351, 5, 6, 7, 1, -6 },
  { 355, 5, 8, 7, 1, -6 },
  { 360, 5, 8, 7, 1, -6 },
  { 365, 5, 6, 7, 1, -6 },
  { 369, 5, 6, 7, 1, -6 },
  { 373, 5, 8, 7, 1, -8 },
  { 378, 5, 6, 7, 1, -6 },
  { 382, 5, 6, 7, 1, -6 },
  { 386, 6, 6, 7, 0, -6 },
  { 391, 5, 6, 7, 1, -6 },
  { 395, 5, 8, 7, 1, -6 },
  { 400, 5, 6, 7, 1, -6 },
  { 404, 5, 10, 7, 1, -9 },
  { 411, 1, 10, 7, 3, -9 },
  { 413, 5, 10, 7, 1, -9 },
  { 420, 5, 2, 7, 1, -5 },
};

const GFXfont JetBrainsMono_Light11pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light11pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _JETBRAINSMONO_LIGHT11PT7B_H_
