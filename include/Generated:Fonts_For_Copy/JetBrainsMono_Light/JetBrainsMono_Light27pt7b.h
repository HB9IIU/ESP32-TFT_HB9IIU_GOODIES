#ifndef _JETBRAINSMONO_LIGHT27PT7B_H_
#define _JETBRAINSMONO_LIGHT27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light27pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x07, 0xF7, 0xE3,
  0xE3, 0xE3, 0xE3, 0xE3, 0xC3, 0xC3, 0xC3, 0x06, 0x18, 0x10, 0x60, 0x41,
  0x83, 0x04, 0x0C, 0x30, 0x30, 0xC7, 0xFF, 0xC2, 0x0C, 0x18, 0x20, 0x61,
  0x81, 0x86, 0x06, 0x18, 0x10, 0x63, 0xFF, 0xEF, 0xFF, 0x8C, 0x30, 0x30,
  0xC0, 0x83, 0x02, 0x0C, 0x18, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0xF8,
  0x3F, 0xC7, 0x6E, 0x66, 0x76, 0x63, 0x66, 0x06, 0x60, 0x76, 0x03, 0xE0,
  0x1F, 0x00, 0xFC, 0x06, 0xE0, 0x67, 0x06, 0x30, 0x63, 0xC6, 0x3E, 0x63,
  0x66, 0x77, 0xFE, 0x1F, 0xC0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x3C,
  0x03, 0x7E, 0x06, 0x63, 0x0C, 0x43, 0x0C, 0x43, 0x18, 0x43, 0x30, 0x43,
  0x30, 0x7E, 0x60, 0x3E, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x3C, 0x02,
  0x7E, 0x06, 0xC2, 0x0C, 0xC3, 0x08, 0xC3, 0x18, 0xC3, 0x30, 0xC3, 0x60,
  0x7E, 0xE0, 0x3C, 0x1F, 0x01, 0xFC, 0x1C, 0x70, 0xC1, 0x86, 0x0C, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x03, 0xE0, 0x3B, 0x07, 0x8C, 0x6C, 0x73,
  0x61, 0xF3, 0x07, 0x98, 0x18, 0xC1, 0xE6, 0x1F, 0x3F, 0xCC, 0xFC, 0x30,
  0xFF, 0xFF, 0x01, 0x07, 0x0F, 0x1C, 0x30, 0x70, 0x60, 0x60, 0xE0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x70,
  0x38, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0C, 0x0E, 0x06, 0x07,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07,
  0x06, 0x0E, 0x1C, 0x38, 0xF0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x20,
  0xC1, 0xF3, 0x3F, 0xFD, 0xF1, 0xFE, 0x00, 0xC0, 0x07, 0x80, 0x33, 0x01,
  0xCE, 0x0E, 0x1C, 0x30, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x3B,
  0x9C, 0xE6, 0x73, 0x18, 0xFF, 0xFF, 0x7F, 0xFF, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03,
  0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18,
  0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x00, 0x1F, 0x83,
  0xFC, 0x70, 0xE6, 0x07, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x73, 0xC7, 0x3C, 0x23, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x77,
  0x06, 0x3F, 0xE1, 0xF8, 0x0E, 0x01, 0xE0, 0x76, 0x0E, 0x60, 0xC6, 0x08,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x1F, 0x83,
  0xFC, 0x70, 0xEE, 0x07, 0xC0, 0x3C, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60,
  0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xE7, 0xFE, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x0F, 0x80, 0x3C, 0x00, 0x60, 0x06, 0x00, 0x70,
  0x07, 0x00, 0x7C, 0x07, 0xE0, 0x66, 0x0E, 0x7F, 0xC1, 0xF8, 0x00, 0xC0,
  0x38, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x0D,
  0xC1, 0xB0, 0x3E, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x7F, 0xE7, 0xFE, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x78, 0x7F, 0xC7, 0x0E, 0x60, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x38, 0x03, 0x60, 0x76, 0x06, 0x3F, 0xE1, 0xF8, 0x03, 0x80, 0x30, 0x07,
  0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x3F, 0xC7, 0xFE, 0x70,
  0x6E, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x77, 0x06, 0x3F,
  0xE1, 0xF8, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1F, 0x83, 0xFC, 0x70,
  0xE6, 0x06, 0x60, 0x76, 0x07, 0x60, 0x67, 0x0E, 0x39, 0xC0, 0xF0, 0x1F,
  0x83, 0x0C, 0x60, 0x6E, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x36, 0x06, 0x7F,
  0xE1, 0xFC, 0x1F, 0x83, 0xFC, 0x70, 0xEE, 0x07, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xE0, 0x36, 0x07, 0x79, 0xE3, 0xF6, 0x00, 0xC0, 0x1C, 0x01,
  0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0xFF, 0xF6, 0x00, 0x00,
  0x00, 0x06, 0xFF, 0xF0, 0x7B, 0xDE, 0x60, 0x00, 0x00, 0x00, 0x00, 0x77,
  0x39, 0xCC, 0xE6, 0x30, 0x00, 0x10, 0x07, 0x01, 0xE0, 0x78, 0x1E, 0x07,
  0x80, 0xE0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x07, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x0C, 0x00, 0xF8, 0x7F,
  0x01, 0xC0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x87, 0x8F, 0x86, 0x03,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x0F, 0x00, 0x07, 0xC0, 0x7F,
  0xC3, 0x83, 0x9C, 0x06, 0x60, 0x0D, 0x80, 0x3C, 0x00, 0xF0, 0x7B, 0xC3,
  0xFF, 0x0C, 0x3C, 0x60, 0xF1, 0x83, 0xC6, 0x0F, 0x18, 0x3C, 0x60, 0xF0,
  0xC3, 0xC3, 0x1F, 0x0F, 0xFC, 0x04, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0xF0, 0x07, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x06, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x30, 0x0C, 0x60, 0x61, 0x81, 0x86,
  0x06, 0x18, 0x38, 0x30, 0xFF, 0xC3, 0xFF, 0x0C, 0x0E, 0x70, 0x19, 0x80,
  0x66, 0x01, 0xB8, 0x07, 0xFE, 0x1F, 0xF3, 0x07, 0x60, 0x6C, 0x0F, 0x80,
  0xF0, 0x3E, 0x06, 0xC1, 0xDF, 0xE3, 0xFE, 0x60, 0x6C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x3B, 0xFF, 0x7F, 0x80, 0x1F, 0x0F, 0xF3, 0x87,
  0x60, 0x7C, 0x07, 0x80, 0xF0, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x03, 0xC0, 0xFC, 0x19, 0xFF, 0x1F, 0x80,
  0xFC, 0x1F, 0xF3, 0x0F, 0x60, 0x6C, 0x0D, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xD8,
  0x3B, 0xFE, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x1F, 0xFB, 0xFF, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xFB, 0xFF, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x00,
  0x1F, 0x0F, 0xF3, 0x87, 0x60, 0x7C, 0x07, 0x80, 0xF0, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x1F, 0xE3, 0xFC, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xFC,
  0x19, 0xFF, 0x1F, 0x80, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x70, 0xFF, 0xFF, 0xF0, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x0F, 0xFF, 0xFF, 0x07, 0xF0, 0x7F,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xE0, 0x3E, 0x03, 0x60, 0x37, 0x07,
  0x3F, 0xE1, 0xFC, 0xC0, 0x7C, 0x06, 0xC0, 0xEC, 0x0C, 0xC1, 0xCC, 0x18,
  0xC3, 0x8C, 0x30, 0xC7, 0x0F, 0xE0, 0xFE, 0x0C, 0x70, 0xC3, 0x0C, 0x38,
  0xC1, 0x8C, 0x1C, 0xC0, 0xCC, 0x0E, 0xC0, 0x6C, 0x07, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0xFF, 0xFF,
  0xF0, 0xE0, 0x7E, 0x07, 0xF0, 0xFF, 0x0F, 0xD0, 0xFD, 0x9B, 0xD9, 0xBC,
  0x9B, 0xCD, 0x3C, 0xF3, 0xC7, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8,
  0x3F, 0x07, 0xE0, 0xF6, 0x1E, 0xC3, 0xC8, 0x79, 0x8F, 0x31, 0xE3, 0x3C,
  0x67, 0x8C, 0xF0, 0xDE, 0x1B, 0xC3, 0x78, 0x3F, 0x07, 0xE0, 0x70, 0x1F,
  0x0F, 0xF3, 0x87, 0x60, 0x6C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xDC, 0x19,
  0xFE, 0x1F, 0x80, 0xFF, 0x0F, 0xFC, 0xC1, 0xEC, 0x06, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x6C, 0x1E, 0xFF, 0xCF, 0xF0, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x0F, 0x83, 0xFC,
  0x70, 0xE6, 0x06, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x03, 0x60, 0x77, 0x06,
  0x3F, 0xC1, 0xF8, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0xFE,
  0x0F, 0xF8, 0xC1, 0xCC, 0x0E, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x06, 0xC0,
  0xEC, 0x3C, 0xFF, 0x8F, 0xE0, 0xC3, 0x0C, 0x30, 0xC1, 0x8C, 0x18, 0xC1,
  0xCC, 0x0C, 0xC0, 0xEC, 0x07, 0x0F, 0x83, 0xFC, 0x70, 0xE6, 0x07, 0x60,
  0x36, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xF0, 0x0F, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x3C, 0x03, 0xE0, 0x36, 0x07, 0x7F, 0xE1, 0xFC, 0xFF,
  0xFF, 0xFF, 0xC1, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xDC, 0x39, 0xFE, 0x1F, 0x80,
  0xE0, 0x1D, 0x80, 0x66, 0x01, 0x9C, 0x06, 0x30, 0x38, 0xC0, 0xC3, 0x03,
  0x0E, 0x0C, 0x18, 0x70, 0x61, 0x81, 0x86, 0x07, 0x18, 0x0C, 0xE0, 0x33,
  0x00, 0xCC, 0x03, 0xB0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0xC3,
  0x0F, 0x0C, 0x3C, 0x38, 0xF0, 0xE3, 0xC7, 0x8F, 0x1A, 0x34, 0x68, 0xD9,
  0x23, 0x64, 0x89, 0x92, 0x66, 0x4D, 0x99, 0x36, 0x6C, 0xD9, 0xB1, 0x66,
  0xC5, 0x8A, 0x16, 0x38, 0x50, 0xE1, 0x43, 0x87, 0x0E, 0x1C, 0x60, 0x1D,
  0xC0, 0x63, 0x03, 0x0E, 0x0C, 0x18, 0x60, 0x71, 0x80, 0xCC, 0x01, 0xF0,
  0x07, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x0E, 0xC0, 0x33, 0x01, 0xC6,
  0x06, 0x1C, 0x30, 0x30, 0xC0, 0xE6, 0x01, 0xB8, 0x07, 0xC0, 0x0D, 0x80,
  0x76, 0x01, 0x8C, 0x0E, 0x30, 0x30, 0x61, 0xC1, 0x86, 0x03, 0x38, 0x0C,
  0xC0, 0x1B, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0x00,
  0x70, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x60, 0x06, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xFC, 0xE0, 0x06, 0x00,
  0x70, 0x03, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x0E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x30, 0xFF,
  0xFC, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0xFF, 0xFE, 0x06, 0x00, 0x70,
  0x0F, 0x00, 0xD8, 0x19, 0x81, 0x8C, 0x30, 0xC3, 0x0C, 0x60, 0x66, 0x06,
  0xC0, 0x30, 0xFF, 0xF8, 0xE3, 0x8E, 0x30, 0x1F, 0x83, 0xFC, 0x70, 0x66,
  0x06, 0x00, 0x70, 0x07, 0x0F, 0xF7, 0xFF, 0xE0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xE0, 0xB7, 0xBB, 0x3F, 0x30, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0xBE, 0x3F, 0xF7, 0x0E, 0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xFC, 0x1B, 0xFF, 0x6F, 0xC0, 0x1F, 0x83,
  0xFC, 0x70, 0x66, 0x07, 0xE0, 0x3E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x36, 0x07, 0x70, 0x63, 0xFE, 0x1F, 0x80, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x71, 0xF7, 0x3F, 0xF7, 0x0F, 0x60, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x60, 0x77, 0x0F,
  0x3F, 0xF1, 0xF7, 0x1F, 0x83, 0xFC, 0x70, 0x66, 0x06, 0xE0, 0x3E, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x07, 0x60, 0x63, 0xFE,
  0x1F, 0x80, 0x01, 0xF0, 0x7F, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x0F, 0xFF, 0xFF, 0xF0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x3E, 0xEF, 0xFF, 0x87,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0,
  0xF7, 0xFE, 0x7D, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x19, 0xFF, 0x3F, 0x80,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xBE, 0x3F, 0xF7, 0x0E, 0xC0,
  0xD8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC1, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x07, 0xFD,
  0xFF, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x0E, 0xFF, 0x3F, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x07, 0xC0, 0xEC, 0x0C,
  0xC1, 0x8C, 0x38, 0xC3, 0x0F, 0xE0, 0xFE, 0x0C, 0x70, 0xC3, 0x0C, 0x38,
  0xC1, 0xCC, 0x0C, 0xC0, 0xEC, 0x07, 0xFE, 0x03, 0xF8, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x3F, 0xC0, 0x7F, 0xDC, 0xEF, 0xFF, 0xC6, 0x3C, 0x63, 0xC6,
  0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6,
  0x3C, 0x63, 0xC6, 0x30, 0xDF, 0x1F, 0xFB, 0x87, 0x60, 0x6C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x38, 0x1F, 0x83, 0xFC, 0x70, 0xE6, 0x06, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x36, 0x07, 0x70, 0x63, 0xFC, 0x1F, 0x80,
  0xDF, 0x1F, 0xFB, 0x87, 0x60, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x7E, 0x0D, 0xFF, 0xB7, 0xE6, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x00, 0x3E, 0xEF, 0xFF, 0x87, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x1E, 0xFF, 0xCF,
  0xB8, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0xCF, 0x9B, 0xFB, 0x83,
  0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x00, 0x1F, 0xC3, 0xFE, 0x70, 0x66, 0x03, 0x60,
  0x07, 0x00, 0x3E, 0x01, 0xFC, 0x01, 0xE0, 0x07, 0x00, 0x3E, 0x03, 0x60,
  0x77, 0xFE, 0x3F, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0x07, 0xF0, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x6E, 0x1C, 0xFF, 0x0F, 0xC0, 0xC0, 0x3E, 0x01, 0xB8, 0x0C, 0xC0,
  0xC6, 0x06, 0x38, 0x30, 0xC3, 0x06, 0x18, 0x38, 0xC0, 0xCC, 0x06, 0x60,
  0x3B, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xC3, 0x0F, 0x0C, 0x3C, 0x38,
  0xD1, 0xE3, 0x66, 0x89, 0x9A, 0x66, 0x49, 0x99, 0x26, 0x64, 0xD8, 0xB3,
  0x63, 0xCD, 0x0F, 0x14, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x00, 0xE0, 0x33,
  0x03, 0x1C, 0x38, 0x71, 0x81, 0x98, 0x07, 0xC0, 0x3C, 0x00, 0xE0, 0x0F,
  0x00, 0xEC, 0x06, 0x70, 0x61, 0x87, 0x06, 0x30, 0x3B, 0x00, 0xE0, 0xC0,
  0x3F, 0x01, 0x98, 0x1C, 0xC0, 0xC7, 0x06, 0x18, 0x70, 0xC3, 0x03, 0x18,
  0x19, 0x80, 0xEC, 0x03, 0x60, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x00, 0xFF, 0xDF, 0xF8, 0x03,
  0x00, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x30,
  0x0C, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x3F, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x0F, 0xE0, 0xFC,
  0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x80, 0x1F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF8, 0x0F, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x7F, 0x03, 0xF0, 0x60, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x0F, 0xC0, 0xF0, 0x00, 0x78, 0x3F, 0xE3, 0xC6, 0x3C, 0x3F, 0xC1, 0xE0,
};

const GFXglyph JetBrainsMono_Light27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 20, 16, 6, -20 },
  { 11, 8, 8, 16, 4, -20 },
  { 19, 14, 20, 16, 1, -20 },
  { 54, 12, 27, 16, 2, -23 },
  { 95, 16, 20, 16, 0, -20 },
  { 135, 13, 20, 16, 2, -20 },
  { 168, 2, 8, 16, 7, -20 },
  { 170, 8, 26, 16, 5, -23 },
  { 196, 8, 26, 16, 3, -23 },
  { 222, 14, 13, 16, 1, -16 },
  { 245, 12, 12, 16, 2, -15 },
  { 263, 5, 8, 16, 5, -4 },
  { 268, 8, 2, 16, 4, -10 },
  { 270, 4, 4, 16, 6, -4 },
  { 272, 12, 25, 16, 2, -22 },
  { 310, 12, 20, 16, 2, -20 },
  { 340, 12, 20, 16, 3, -20 },
  { 370, 12, 20, 16, 2, -20 },
  { 400, 12, 20, 16, 2, -20 },
  { 430, 11, 20, 16, 2, -20 },
  { 458, 12, 20, 16, 2, -20 },
  { 488, 12, 20, 16, 2, -20 },
  { 518, 12, 20, 16, 2, -20 },
  { 548, 12, 20, 16, 2, -20 },
  { 578, 12, 20, 16, 2, -20 },
  { 608, 4, 15, 16, 6, -15 },
  { 616, 5, 19, 16, 5, -15 },
  { 628, 12, 14, 16, 2, -16 },
  { 649, 12, 8, 16, 2, -13 },
  { 661, 12, 14, 16, 2, -16 },
  { 682, 9, 20, 16, 4, -20 },
  { 705, 14, 25, 16, 1, -20 },
  { 749, 14, 20, 16, 1, -20 },
  { 784, 11, 20, 16, 3, -20 },
  { 812, 11, 20, 16, 3, -20 },
  { 840, 11, 20, 16, 3, -20 },
  { 868, 11, 20, 16, 3, -20 },
  { 896, 11, 20, 16, 3, -20 },
  { 924, 11, 20, 16, 3, -20 },
  { 952, 11, 20, 16, 3, -20 },
  { 980, 10, 20, 16, 3, -20 },
  { 1005, 12, 20, 16, 1, -20 },
  { 1035, 12, 20, 16, 3, -20 },
  { 1065, 11, 20, 16, 3, -20 },
  { 1093, 12, 20, 16, 2, -20 },
  { 1123, 11, 20, 16, 3, -20 },
  { 1151, 11, 20, 16, 3, -20 },
  { 1179, 12, 20, 16, 3, -20 },
  { 1209, 12, 25, 16, 2, -20 },
  { 1247, 12, 20, 16, 3, -20 },
  { 1277, 12, 20, 16, 2, -20 },
  { 1307, 13, 20, 16, 2, -20 },
  { 1340, 11, 20, 16, 3, -20 },
  { 1368, 14, 20, 16, 1, -20 },
  { 1403, 14, 20, 16, 1, -20 },
  { 1438, 14, 20, 16, 1, -20 },
  { 1473, 14, 20, 16, 1, -20 },
  { 1508, 12, 20, 16, 2, -20 },
  { 1538, 6, 25, 16, 6, -22 },
  { 1557, 12, 25, 16, 2, -22 },
  { 1595, 7, 25, 16, 4, -22 },
  { 1617, 12, 11, 16, 2, -20 },
  { 1634, 13, 1, 16, 2, 1 },
  { 1636, 5, 4, 16, 5, -21 },
  { 1639, 12, 15, 16, 2, -15 },
  { 1662, 11, 20, 16, 3, -20 },
  { 1690, 12, 15, 16, 2, -15 },
  { 1713, 12, 20, 16, 2, -20 },
  { 1743, 12, 15, 16, 2, -15 },
  { 1766, 12, 20, 16, 2, -20 },
  { 1796, 11, 20, 16, 3, -15 },
  { 1824, 11, 20, 16, 3, -20 },
  { 1852, 13, 21, 16, 2, -21 },
  { 1887, 10, 26, 16, 2, -21 },
  { 1920, 12, 20, 16, 3, -20 },
  { 1950, 14, 20, 16, 1, -20 },
  { 1985, 12, 15, 16, 2, -15 },
  { 2008, 11, 15, 16, 3, -15 },
  { 2029, 12, 15, 16, 2, -15 },
  { 2052, 11, 20, 16, 3, -15 },
  { 2080, 11, 20, 16, 3, -15 },
  { 2108, 11, 15, 16, 3, -15 },
  { 2129, 12, 15, 16, 2, -15 },
  { 2152, 12, 19, 16, 2, -19 },
  { 2181, 11, 15, 16, 3, -15 },
  { 2202, 13, 15, 16, 2, -15 },
  { 2227, 14, 15, 16, 1, -15 },
  { 2254, 13, 15, 16, 2, -15 },
  { 2279, 13, 20, 16, 2, -15 },
  { 2312, 11, 15, 16, 3, -15 },
  { 2333, 12, 25, 16, 2, -22 },
  { 2371, 2, 25, 16, 7, -22 },
  { 2378, 12, 25, 16, 2, -22 },
  { 2416, 12, 5, 16, 2, -12 },
};

const GFXfont JetBrainsMono_Light27pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light27pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light27pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _JETBRAINSMONO_LIGHT27PT7B_H_
