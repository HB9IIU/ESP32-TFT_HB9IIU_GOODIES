#ifndef _JETBRAINSMONO_LIGHT62PT7B_H_
#define _JETBRAINSMONO_LIGHT62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light62pt7bBitmaps[] PROGMEM = {
  0x00, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xF3, 0xF0, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3E, 0xF8, 0x0F,
  0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x07, 0xBE, 0x01, 0xEF,
  0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x07, 0xBE, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x03, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x0F,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x01, 0xF8, 0xF3, 0xF8, 0x3F, 0x0F, 0x0F, 0xC3, 0xE0, 0xF0, 0x7C, 0x7C,
  0x0F, 0x07, 0xC7, 0xC0, 0xF0, 0x3E, 0x7C, 0x0F, 0x03, 0xE7, 0xC0, 0xF0,
  0x3E, 0x7C, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x07,
  0xE0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x1F, 0x8F,
  0x00, 0x01, 0xFE, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0x7F, 0x80, 0x00, 0xF1, 0xFC, 0x00, 0x0F, 0x0F,
  0xC0, 0x00, 0xF0, 0x7E, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF0, 0x3E, 0x00,
  0x0F, 0x03, 0xE0, 0x00, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0,
  0x1F, 0xF8, 0x0F, 0x03, 0xEF, 0x80, 0xF0, 0x3E, 0xFC, 0x0F, 0x03, 0xE7,
  0xE0, 0xF0, 0x7E, 0x7F, 0x0F, 0x0F, 0xC3, 0xFC, 0xF3, 0xF8, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3C, 0x7F, 0xF8, 0x00, 0x0F, 0x1F, 0xFF, 0x80,
  0x03, 0xC7, 0xE3, 0xF0, 0x00, 0x78, 0xF0, 0x1F, 0x00, 0x1E, 0x3E, 0x01,
  0xE0, 0x07, 0x87, 0x80, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0x80, 0x3C, 0x1E,
  0x00, 0xF0, 0x0F, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x78,
  0x0F, 0x00, 0x78, 0x1E, 0x01, 0xE0, 0x0F, 0x07, 0x80, 0x3E, 0x01, 0xE0,
  0xF0, 0x03, 0xC0, 0x7C, 0x3C, 0x00, 0x7C, 0x0F, 0x0F, 0x00, 0x0F, 0xFF,
  0xE1, 0xE0, 0x00, 0xFF, 0xF8, 0x78, 0x00, 0x0F, 0xFE, 0x1E, 0x00, 0x00,
  0x7F, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x0F, 0xF8, 0x00, 0x03, 0xC3, 0xFF, 0x80, 0x00,
  0xF0, 0xFF, 0xF8, 0x00, 0x3C, 0x3F, 0x1F, 0x80, 0x07, 0x87, 0x80, 0xF0,
  0x01, 0xE1, 0xF0, 0x1F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x0F, 0x07, 0x80,
  0x3C, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0x03,
  0xC0, 0x1E, 0x07, 0x80, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x00, 0x78, 0x7C,
  0x01, 0xE0, 0x0F, 0x0F, 0x00, 0x3E, 0x03, 0xE3, 0xC0, 0x03, 0xC0, 0x78,
  0xF0, 0x00, 0x7F, 0xFF, 0x1E, 0x00, 0x07, 0xFF, 0xC7, 0x80, 0x00, 0x7F,
  0xF1, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0x3F,
  0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xBF, 0x00, 0x01, 0xFC, 0x3E, 0x00, 0x7D, 0xF0, 0x3E, 0x00, 0xFB, 0xE0,
  0x7E, 0x03, 0xE7, 0xC0, 0x7C, 0x0F, 0x8F, 0x80, 0x7C, 0x1F, 0x1F, 0x00,
  0xFC, 0x7C, 0x3E, 0x00, 0xFC, 0xF8, 0x7C, 0x00, 0xFB, 0xE0, 0xF8, 0x00,
  0xFF, 0xC1, 0xF0, 0x01, 0xFF, 0x03, 0xE0, 0x01, 0xFE, 0x07, 0xC0, 0x01,
  0xF8, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x1F,
  0xF0, 0x7C, 0x00, 0x7F, 0xE0, 0xFC, 0x01, 0xFB, 0xE0, 0xFC, 0x0F, 0xE7,
  0xE1, 0xFF, 0xFF, 0x87, 0xC1, 0xFF, 0xFE, 0x07, 0xC1, 0xFF, 0xF8, 0x07,
  0xC0, 0xFF, 0xC0, 0x0F, 0xC0, 0x38, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0,
  0x01, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x3F,
  0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x1C, 0xC0, 0x00,
  0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x10, 0x01, 0xF0, 0x01, 0x1F, 0x00, 0x78, 0x07, 0xCF, 0xF0, 0x3C, 0x0F,
  0xE7, 0xFE, 0x1C, 0x3F, 0xF7, 0xFF, 0x8E, 0x3F, 0xFC, 0xFF, 0xF7, 0x7F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xFC,
  0x3E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x07, 0x00, 0x07, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0xFE,
  0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0,
  0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0x1F, 0xEF, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFE, 0x7F, 0x02, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xBF,
  0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x7C,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x81, 0xF0, 0x3F, 0xF0, 0x7F, 0x07, 0xFE, 0x0F,
  0xE0, 0xFF, 0xC1, 0xFC, 0x1F, 0xF8, 0x3F, 0x83, 0xFF, 0x03, 0xE0, 0x7F,
  0xE0, 0x38, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3E, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0x87, 0xF8, 0x0F, 0xF0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFE, 0xF8, 0x00, 0x3F, 0x9F, 0x00, 0x1F, 0xE3, 0xE0, 0x07, 0xF0,
  0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0x80, 0x3E, 0x00,
  0x60, 0x07, 0xC0, 0x08, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFB, 0xFF,
  0x03, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xFC, 0xFC,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x3E, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xF7, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0xFE, 0x3F, 0x80,
  0x7F, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x0F,
  0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x1F,
  0x3E, 0x00, 0x07, 0xDF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x3E,
  0x00, 0x78, 0x7F, 0xF0, 0x1E, 0x7F, 0xFE, 0x07, 0xBF, 0xFF, 0xE3, 0xEF,
  0xFF, 0xF8, 0xFF, 0x80, 0x7F, 0x3F, 0x80, 0x0F, 0xCF, 0xE0, 0x01, 0xFB,
  0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03,
  0xEF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0xFE, 0x00, 0x1F, 0xBF, 0xF8, 0x01, 0xF7, 0xFF,
  0xE0, 0x3E, 0xFF, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xC7,
  0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xF8, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xFC, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x3F,
  0xC0, 0x7F, 0x81, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E,
  0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xBF, 0xF0, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE1, 0xF0, 0x00,
  0x7E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x8F, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x83, 0xF0, 0x03, 0xE0, 0x3F,
  0x01, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFE,
  0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x00, 0xF8,
  0xFC, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x3E, 0x7F, 0x00, 0x1F, 0xC7, 0xF8, 0x07, 0xF0, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xF8, 0x03, 0xF8, 0x3F, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3E,
  0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xFC,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x03,
  0xFC, 0x1F, 0xFB, 0xFF, 0x81, 0xFF, 0xFE, 0xF8, 0x07, 0xFF, 0xDF, 0x00,
  0x3F, 0xF9, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1C, 0x1F, 0xCF, 0xFB, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC1, 0xFC, 0xFF, 0xBF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xE7, 0xF0, 0x20, 0x03, 0x80, 0x7F, 0x07, 0xFC, 0x3F, 0xE3, 0xFF, 0x9F,
  0xFC, 0x7F, 0xC3, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E,
  0x01, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x01, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0x1F, 0xF0, 0x03, 0xFF, 0x3F, 0xE0, 0x0F, 0xFF, 0x7F,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7C, 0x07, 0xFF, 0x01, 0xF0, 0x07, 0xFE,
  0x03, 0xE0, 0x07, 0xFC, 0x07, 0xC0, 0x0F, 0xF8, 0x0F, 0x00, 0x1F, 0xF0,
  0x1E, 0x00, 0x3F, 0xE0, 0x3C, 0x00, 0x7F, 0xC0, 0x78, 0x00, 0xFF, 0x80,
  0xF0, 0x01, 0xFF, 0x01, 0xE0, 0x03, 0xFE, 0x03, 0xC0, 0x07, 0xFC, 0x07,
  0x80, 0x0F, 0xF8, 0x0F, 0x00, 0x1F, 0xF0, 0x1E, 0x00, 0x3F, 0xE0, 0x3C,
  0x00, 0x7F, 0xC0, 0x7C, 0x00, 0xFF, 0x80, 0xF8, 0x03, 0xFF, 0x00, 0xF8,
  0x07, 0xFE, 0x01, 0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0xEF, 0xF8, 0x03, 0xFF,
  0xDF, 0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x60, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3E,
  0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x01, 0xE0, 0x3E,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0x3C, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0,
  0x03, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3C, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3E,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x03, 0xE0, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F,
  0x80, 0x1F, 0xF1, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x7C,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xE3, 0xE0,
  0x01, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x7F, 0x1F, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7D,
  0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xE7, 0xC0, 0x01,
  0xFC, 0xF8, 0x07, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xC0,
  0x1F, 0xC7, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xBE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xF9, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x1F, 0xC1, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x8F, 0x80, 0x3F, 0xE7, 0xC0, 0x03, 0xF3, 0xE0, 0x00,
  0xFD, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFB, 0xE0, 0x00, 0xFD, 0xF0, 0x01, 0xFC, 0xF8, 0x07, 0xFC, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xC0, 0x1F,
  0xC7, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xBE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xF9,
  0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x1F, 0xC1, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0xFE,
  0x1F, 0xC0, 0x3F, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFC, 0xF8,
  0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03,
  0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x7C, 0x0F,
  0x80, 0x0F, 0xC0, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0xF8, 0x01,
  0xF0, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x00,
  0xF8, 0x07, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xF8, 0x07, 0xC0,
  0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xF8,
  0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x0F,
  0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x3E, 0x0F,
  0x80, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF8, 0xF8, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7E,
  0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0x7F, 0xF0, 0x01, 0xEF, 0xFF, 0x00, 0x3D, 0xFD, 0xE0,
  0x0F, 0x7F, 0xBC, 0x01, 0xEF, 0xF7, 0xC0, 0x3D, 0xFE, 0x78, 0x0F, 0x3F,
  0xCF, 0x01, 0xE7, 0xF9, 0xF0, 0x3C, 0xFF, 0x1E, 0x07, 0x1F, 0xE3, 0xC1,
  0xE3, 0xFC, 0x7C, 0x3C, 0x7F, 0x87, 0x87, 0x0F, 0xF0, 0xF1, 0xE1, 0xFF,
  0x0F, 0x3C, 0x3F, 0xE1, 0xE7, 0x07, 0xFC, 0x3D, 0xE0, 0xFF, 0x83, 0xBC,
  0x1F, 0xF0, 0x7F, 0x07, 0xFE, 0x0F, 0xE0, 0xFF, 0xC0, 0xFC, 0x1F, 0xF8,
  0x1F, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xDE, 0x00, 0x1F, 0xEF, 0x00, 0x0F, 0xF7,
  0xC0, 0x07, 0xF9, 0xE0, 0x03, 0xFC, 0xF0, 0x01, 0xFF, 0x7C, 0x00, 0xFF,
  0x9E, 0x00, 0x7F, 0xCF, 0x80, 0x3F, 0xE3, 0xC0, 0x1F, 0xF1, 0xE0, 0x0F,
  0xF8, 0xF8, 0x07, 0xFC, 0x3C, 0x03, 0xFE, 0x1E, 0x01, 0xFF, 0x0F, 0x80,
  0xFF, 0x83, 0xC0, 0x7F, 0xC1, 0xE0, 0x3F, 0xE0, 0xF8, 0x1F, 0xF0, 0x3C,
  0x0F, 0xF8, 0x1F, 0x07, 0xFC, 0x07, 0x83, 0xFE, 0x03, 0xC1, 0xFF, 0x01,
  0xF0, 0xFF, 0x80, 0x78, 0x7F, 0xC0, 0x3C, 0x3F, 0xE0, 0x1F, 0x1F, 0xF0,
  0x07, 0x8F, 0xF8, 0x03, 0xE7, 0xFC, 0x01, 0xF3, 0xFE, 0x00, 0x79, 0xFF,
  0x00, 0x3E, 0xFF, 0x80, 0x0F, 0x7F, 0xC0, 0x07, 0xBF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xF8,
  0x03, 0xF9, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0x7E, 0x00, 0x3F, 0x1F, 0xC0, 0x7F, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0,
  0xF8, 0x00, 0x7F, 0x8F, 0x80, 0x01, 0xFC, 0xF8, 0x00, 0x0F, 0xCF, 0x80,
  0x00, 0x7E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x3E, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0xCF,
  0x80, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE3,
  0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x01, 0xF1,
  0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x83, 0xF8, 0x0F, 0xF0, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0xFF, 0x0F, 0x80, 0x03, 0xF8, 0xF8, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E,
  0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF8, 0xF8,
  0x00, 0x7F, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x07, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01,
  0xF0, 0x0F, 0x80, 0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0xC0,
  0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80,
  0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7E, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xF8, 0x03, 0xF8,
  0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7E, 0x7F,
  0x00, 0x0F, 0xC3, 0xFC, 0x03, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFB, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x7E,
  0x3F, 0x80, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x03,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x1E, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x01,
  0xF3, 0xC0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x07,
  0xBE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xFC, 0x01, 0xF8, 0x03, 0xFE, 0x00,
  0xFC, 0x01, 0xFF, 0x00, 0x7E, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xC0,
  0x3B, 0x80, 0x7D, 0xE0, 0x1D, 0xC0, 0x3E, 0xF0, 0x0E, 0xE0, 0x1E, 0x78,
  0x07, 0x70, 0x0F, 0x3E, 0x03, 0xBC, 0x07, 0x9F, 0x01, 0xCE, 0x03, 0xCF,
  0x80, 0xE7, 0x01, 0xE7, 0xC0, 0xF3, 0x81, 0xF3, 0xE0, 0x79, 0xC0, 0xF8,
  0xF0, 0x38, 0xE0, 0x7C, 0x78, 0x1C, 0x70, 0x3E, 0x3C, 0x0E, 0x38, 0x1E,
  0x1E, 0x07, 0x1E, 0x0F, 0x0F, 0x03, 0x87, 0x07, 0x87, 0xC1, 0xC3, 0x83,
  0xC3, 0xE1, 0xE1, 0xC1, 0xE1, 0xF0, 0xE0, 0xE0, 0xF0, 0xF8, 0x70, 0x70,
  0xF8, 0x3C, 0x38, 0x38, 0x7C, 0x1E, 0x1C, 0x1C, 0x3C, 0x0F, 0x0E, 0x0E,
  0x1E, 0x07, 0x87, 0x07, 0x8F, 0x03, 0xC3, 0x81, 0xC7, 0x81, 0xF3, 0xC0,
  0xE3, 0xC0, 0xF9, 0xC0, 0x71, 0xE0, 0x7C, 0xE0, 0x38, 0xF0, 0x1E, 0x70,
  0x1C, 0xF8, 0x0F, 0x38, 0x0E, 0x7C, 0x07, 0x9C, 0x07, 0x3C, 0x03, 0xCE,
  0x03, 0xDE, 0x01, 0xEF, 0x00, 0xEF, 0x00, 0xF7, 0x80, 0x77, 0x80, 0x7F,
  0x80, 0x3B, 0xC0, 0x3F, 0xC0, 0x1D, 0xE0, 0x1F, 0xE0, 0x0E, 0xF0, 0x07,
  0xF0, 0x07, 0x78, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0xC0, 0x03, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80,
  0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x3F, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xFC, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x03, 0xE0, 0x0F, 0x80,
  0x03, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x00, 0x01, 0xF0,
  0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xBE, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03,
  0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF8, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0xC0,
  0x00, 0x3E, 0x78, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x3C,
  0x1E, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x7C, 0x07, 0xC0,
  0x0F, 0x80, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x00, 0xF0, 0x0F, 0x00,
  0x1F, 0x03, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0xC3,
  0xC0, 0x00, 0x78, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF7, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F,
  0x80, 0x3F, 0x87, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x9F, 0xC0,
  0x01, 0xF7, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xCF,
  0xC0, 0x0F, 0xF9, 0xFF, 0x8F, 0xDF, 0x1F, 0xFF, 0xFB, 0xE1, 0xFF, 0xFE,
  0x7C, 0x0F, 0xFF, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x03, 0xE1, 0xFF, 0xC0, 0xF8,
  0xFF, 0xF8, 0x3E, 0x7F, 0xFF, 0x0F, 0xBF, 0xFF, 0xE3, 0xFE, 0x01, 0xFC,
  0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFB, 0xE0, 0x00,
  0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xEF,
  0xE0, 0x01, 0xFB, 0xF8, 0x00, 0xFC, 0xFF, 0x80, 0x7F, 0x3E, 0xFF, 0xFF,
  0x8F, 0x9F, 0xFF, 0xC3, 0xE3, 0xFF, 0xE0, 0xF8, 0x7F, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xE0, 0x1F, 0xC7, 0xE0, 0x03,
  0xF9, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F,
  0x9F, 0x80, 0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xB0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x7F, 0xE1,
  0xF0, 0xFF, 0xFC, 0xF8, 0xFF, 0xFF, 0x7C, 0xFF, 0xFF, 0xBE, 0xFE, 0x01,
  0xFF, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7E, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0xFF, 0x9F, 0xFF, 0xF7, 0xC7, 0xFF,
  0xFB, 0xE1, 0xFF, 0xF9, 0xF0, 0x3F, 0xF0, 0xF8, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x3F, 0xF7, 0xFE, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xF0, 0x00,
  0x7E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7B, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x80, 0x07,
  0xE3, 0xF0, 0x07, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0x87, 0xC3, 0xFF,
  0xF3, 0xE3, 0xFF, 0xFD, 0xF3, 0xFF, 0xFE, 0xFB, 0xF8, 0x07, 0xFD, 0xF8,
  0x00, 0xFE, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xBE, 0x00,
  0x0F, 0xDF, 0x80, 0x0F, 0xEF, 0xE0, 0x0F, 0xF3, 0xFF, 0xFE, 0xF8, 0xFF,
  0xFF, 0x7C, 0x3F, 0xFF, 0x3E, 0x0F, 0xFE, 0x1F, 0x00, 0xFC, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x03, 0xE0, 0x1F, 0x0F, 0xFE, 0x0F, 0x9F, 0xFF, 0x87, 0xDF, 0xFF, 0xE3,
  0xEF, 0xCF, 0xF9, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFC, 0xF8, 0x00,
  0x0F, 0x8F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xE0,
  0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x01, 0xF8, 0x0F, 0x80,
  0x1F, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x07, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x7E,
  0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0xF8, 0x01, 0xF8, 0x0F,
  0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00,
  0x3F, 0x0F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xFC,
  0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xF0, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x70, 0x07, 0x07, 0xCF, 0xE1, 0xFE, 0x3E, 0xFF, 0x8F, 0xF9, 0xFF, 0xFE,
  0xFF, 0xEF, 0xE3, 0xF6, 0x3F, 0x7E, 0x07, 0xE0, 0xFB, 0xE0, 0x3E, 0x03,
  0xFF, 0x01, 0xF0, 0x1F, 0xF8, 0x07, 0x80, 0xFF, 0xC0, 0x3C, 0x07, 0xFE,
  0x01, 0xE0, 0x3F, 0xF0, 0x0F, 0x01, 0xFF, 0x80, 0x78, 0x0F, 0xFC, 0x03,
  0xC0, 0x7F, 0xE0, 0x1E, 0x03, 0xFF, 0x00, 0xF0, 0x1F, 0xF8, 0x07, 0x80,
  0xFF, 0xC0, 0x3C, 0x07, 0xFE, 0x01, 0xE0, 0x3F, 0xF0, 0x0F, 0x01, 0xFF,
  0x80, 0x78, 0x0F, 0xFC, 0x03, 0xC0, 0x7F, 0xE0, 0x1E, 0x03, 0xFF, 0x00,
  0xF0, 0x1F, 0xF8, 0x07, 0x80, 0xFF, 0xC0, 0x3C, 0x07, 0xFE, 0x01, 0xE0,
  0x3F, 0xF0, 0x0F, 0x01, 0xFF, 0x80, 0x78, 0x0F, 0xFC, 0x03, 0xC0, 0x7F,
  0xE0, 0x1E, 0x03, 0xFF, 0x00, 0xF0, 0x1F, 0xF8, 0x07, 0x80, 0xFF, 0xC0,
  0x3C, 0x07, 0xFE, 0x01, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x3F, 0xF8,
  0x3E, 0x7F, 0xFE, 0x1F, 0x7F, 0xFF, 0x8F, 0xBF, 0xFF, 0xE7, 0xFC, 0x03,
  0xFB, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x0F, 0xE0, 0x3F, 0x87, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0x7E, 0xFC, 0x00,
  0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB,
  0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xC3, 0xF8, 0x0F,
  0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x1F, 0xFC, 0x0F,
  0x9F, 0xFF, 0x83, 0xEF, 0xFF, 0xF0, 0xFB, 0xFF, 0xFE, 0x3F, 0xE0, 0x1F,
  0xCF, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xBE, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x3E,
  0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xCF, 0xF8, 0x07, 0xF3, 0xEF, 0xFF,
  0xF8, 0xF9, 0xFF, 0xFC, 0x3E, 0x3F, 0xFE, 0x0F, 0x87, 0xFE, 0x03, 0xE0,
  0x18, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xFF, 0x87, 0xC3, 0xFF, 0xF3, 0xE3, 0xFF, 0xFD, 0xF3,
  0xFF, 0xFE, 0xFB, 0xF8, 0x07, 0xFD, 0xF8, 0x00, 0xFE, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x03, 0xF7, 0xC0, 0x01, 0xFB, 0xF0, 0x01, 0xFC, 0xFE, 0x03, 0xFE,
  0x7F, 0xFF, 0xDF, 0x1F, 0xFF, 0xEF, 0x87, 0xFF, 0xE7, 0xC0, 0xFF, 0xC3,
  0xE0, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x3E, 0x1F, 0xFC, 0x0F, 0x8F, 0xFF, 0x83, 0xE7, 0xFF, 0xF8,
  0xFB, 0xF3, 0xFE, 0x3F, 0xE0, 0x1F, 0xCF, 0xE0, 0x01, 0xFB, 0xF8, 0x00,
  0x7E, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x1F, 0xC0, 0x0F,
  0xE7, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xE7, 0xF0, 0x03, 0xF8, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x07,
  0xEF, 0x80, 0x03, 0xE7, 0xE0, 0x03, 0xF1, 0xFC, 0x07, 0xF0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07,
  0xC0, 0x7C, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x1F, 0x3C, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xBC, 0x01,
  0xF0, 0x07, 0xDE, 0x00, 0xF8, 0x03, 0xCF, 0x00, 0x7E, 0x01, 0xE7, 0xC0,
  0x77, 0x00, 0xF3, 0xE0, 0x3B, 0x80, 0x79, 0xF0, 0x1D, 0xC0, 0x3C, 0x78,
  0x0E, 0xE0, 0x3E, 0x3C, 0x07, 0x70, 0x1E, 0x1E, 0x03, 0x9C, 0x0F, 0x0F,
  0x03, 0xCE, 0x07, 0x87, 0xC1, 0xC7, 0x03, 0xC3, 0xE0, 0xE3, 0x81, 0xE0,
  0xF0, 0x71, 0xC1, 0xF0, 0x78, 0x38, 0xE0, 0xF0, 0x3C, 0x1C, 0x78, 0x78,
  0x1E, 0x1E, 0x1C, 0x3C, 0x0F, 0x0E, 0x0E, 0x1E, 0x07, 0xC7, 0x07, 0x0F,
  0x01, 0xE3, 0x83, 0x87, 0x00, 0xF1, 0xC1, 0xC7, 0x80, 0x78, 0xE0, 0xF3,
  0xC0, 0x3C, 0xF0, 0x39, 0xE0, 0x1E, 0x70, 0x1C, 0xF0, 0x0F, 0xB8, 0x0E,
  0x78, 0x03, 0xDC, 0x07, 0x38, 0x01, 0xEE, 0x03, 0x9C, 0x00, 0xF7, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0,
  0x1F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x3E,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x3F, 0x3E, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xF3,
  0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xF0, 0x3E,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0,
  0x1F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3E, 0x1F,
  0x80, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7C, 0xFC, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x03,
  0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xF0, 0x3E,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0xFF, 0xC0, 0x07, 0xCF, 0xFF, 0x00, 0x3E,
  0xFF, 0xFC, 0x01, 0xF7, 0xC3, 0xF0, 0x0F, 0xBC, 0x0F, 0xC0, 0x7F, 0xE0,
  0x3F, 0x03, 0xFF, 0x00, 0xFC, 0x3E, 0xF8, 0x03, 0xFF, 0xF7, 0xC0, 0x0F,
  0xFF, 0x3E, 0x00, 0x3F, 0xF1, 0xF0, 0x00, 0xFF, 0x00,
};

const GFXglyph JetBrainsMono_Light62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 9, 45, 37, 14, -45 },
  { 52, 18, 18, 37, 10, -45 },
  { 93, 33, 45, 37, 2, -45 },
  { 279, 28, 63, 37, 5, -54 },
  { 500, 35, 46, 37, 1, -46 },
  { 702, 31, 47, 37, 4, -46 },
  { 885, 5, 18, 37, 16, -45 },
  { 897, 18, 59, 37, 12, -52 },
  { 1030, 18, 59, 37, 7, -52 },
  { 1163, 33, 32, 37, 2, -38 },
  { 1295, 29, 29, 37, 4, -35 },
  { 1401, 12, 19, 37, 11, -9 },
  { 1430, 20, 5, 37, 9, -23 },
  { 1443, 10, 10, 37, 14, -9 },
  { 1456, 27, 58, 37, 5, -51 },
  { 1652, 27, 47, 37, 5, -46 },
  { 1811, 27, 45, 37, 6, -45 },
  { 1963, 28, 46, 37, 5, -46 },
  { 2124, 26, 46, 37, 5, -45 },
  { 2274, 26, 45, 37, 5, -45 },
  { 2421, 26, 46, 37, 6, -45 },
  { 2571, 28, 46, 37, 5, -45 },
  { 2732, 28, 45, 37, 5, -45 },
  { 2890, 27, 47, 37, 5, -46 },
  { 3049, 28, 46, 37, 5, -46 },
  { 3210, 10, 36, 37, 14, -35 },
  { 3255, 13, 45, 37, 11, -35 },
  { 3329, 27, 33, 37, 5, -37 },
  { 3441, 27, 19, 37, 5, -30 },
  { 3506, 27, 33, 37, 5, -37 },
  { 3618, 22, 45, 37, 9, -45 },
  { 3742, 31, 57, 37, 3, -46 },
  { 3963, 31, 45, 37, 3, -45 },
  { 4138, 27, 45, 37, 6, -45 },
  { 4290, 26, 47, 37, 6, -46 },
  { 4443, 25, 45, 37, 6, -45 },
  { 4584, 25, 45, 37, 7, -45 },
  { 4725, 27, 45, 37, 6, -45 },
  { 4877, 26, 47, 37, 6, -46 },
  { 5030, 25, 45, 37, 6, -45 },
  { 5171, 23, 45, 37, 7, -45 },
  { 5301, 27, 46, 37, 3, -45 },
  { 5457, 28, 45, 37, 6, -45 },
  { 5615, 26, 45, 37, 7, -45 },
  { 5762, 27, 45, 37, 5, -45 },
  { 5914, 25, 45, 37, 6, -45 },
  { 6055, 25, 47, 37, 6, -46 },
  { 6202, 28, 45, 37, 6, -45 },
  { 6360, 27, 57, 37, 5, -46 },
  { 6553, 28, 45, 37, 6, -45 },
  { 6711, 28, 47, 37, 5, -46 },
  { 6876, 31, 45, 37, 3, -45 },
  { 7051, 25, 46, 37, 6, -45 },
  { 7195, 31, 45, 37, 3, -45 },
  { 7370, 33, 45, 37, 2, -45 },
  { 7556, 32, 45, 37, 3, -45 },
  { 7736, 33, 45, 37, 2, -45 },
  { 7922, 27, 45, 37, 5, -45 },
  { 8074, 15, 58, 37, 13, -51 },
  { 8183, 27, 58, 37, 5, -51 },
  { 8379, 15, 58, 37, 9, -51 },
  { 8488, 27, 24, 37, 5, -45 },
  { 8569, 29, 4, 37, 4, 2 },
  { 8584, 12, 9, 37, 12, -49 },
  { 8598, 27, 36, 37, 4, -35 },
  { 8720, 26, 46, 37, 6, -45 },
  { 8870, 26, 36, 37, 6, -35 },
  { 8987, 25, 46, 37, 6, -45 },
  { 9131, 26, 36, 37, 6, -35 },
  { 9248, 29, 45, 37, 4, -45 },
  { 9412, 25, 46, 37, 6, -35 },
  { 9556, 25, 45, 37, 6, -45 },
  { 9697, 29, 48, 37, 5, -48 },
  { 9871, 23, 59, 37, 5, -48 },
  { 10041, 28, 45, 37, 6, -45 },
  { 10199, 32, 45, 37, 2, -45 },
  { 10379, 29, 35, 37, 4, -35 },
  { 10506, 25, 35, 37, 6, -35 },
  { 10616, 26, 36, 37, 6, -35 },
  { 10733, 26, 46, 37, 6, -35 },
  { 10883, 25, 46, 37, 6, -35 },
  { 11027, 26, 35, 37, 7, -35 },
  { 11141, 26, 36, 37, 6, -35 },
  { 11258, 28, 44, 37, 4, -44 },
  { 11412, 25, 35, 37, 6, -34 },
  { 11522, 29, 34, 37, 4, -34 },
  { 11646, 33, 34, 37, 2, -34 },
  { 11787, 30, 34, 37, 4, -34 },
  { 11915, 29, 45, 37, 4, -34 },
  { 12079, 25, 34, 37, 6, -34 },
  { 12186, 26, 58, 37, 6, -51 },
  { 12375, 5, 58, 37, 16, -51 },
  { 12412, 26, 58, 37, 6, -51 },
  { 12601, 29, 12, 37, 4, -28 },
};

const GFXfont JetBrainsMono_Light62pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light62pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light62pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _JETBRAINSMONO_LIGHT62PT7B_H_
