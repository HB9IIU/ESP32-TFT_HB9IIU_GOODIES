#ifndef _JETBRAINSMONO_LIGHT12PT7B_H_
#define _JETBRAINSMONO_LIGHT12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFC, 0x80, 0xB6, 0xD0, 0x24, 0x48, 0x93, 0xF2, 0x85, 0x3F, 0x24,
  0x48, 0x23, 0xAB, 0x4E, 0x38, 0xA5, 0xAB, 0xC8, 0x40, 0x63, 0x2A, 0x57,
  0x41, 0x05, 0xCA, 0xA5, 0x8E, 0x72, 0x68, 0x10, 0xC6, 0xA9, 0xA6, 0xEC,
  0xF0, 0x34, 0x48, 0x88, 0x88, 0x44, 0x30, 0xC2, 0x31, 0x11, 0x11, 0x12,
  0xC0, 0x11, 0x25, 0xF0, 0x82, 0x88, 0x80, 0x21, 0x09, 0xF2, 0x10, 0x5A,
  0xF0, 0xB0, 0x08, 0x44, 0x21, 0x10, 0x88, 0x42, 0x20, 0x74, 0x63, 0x1A,
  0xC6, 0x31, 0x70, 0x27, 0x28, 0x42, 0x10, 0x84, 0xF8, 0x74, 0x62, 0x11,
  0x88, 0x88, 0xF8, 0xF8, 0xC4, 0x41, 0x84, 0x31, 0x70, 0x18, 0x88, 0x84,
  0xC7, 0xE1, 0x08, 0xFC, 0x21, 0x6C, 0x84, 0x31, 0x70, 0x11, 0x10, 0x8F,
  0xC6, 0x31, 0x70, 0xFC, 0x62, 0x21, 0x08, 0x84, 0x60, 0x74, 0x62, 0x93,
  0x66, 0x31, 0x78, 0x74, 0x63, 0x1D, 0xB4, 0x44, 0x60, 0xB0, 0x2C, 0x4C,
  0x00, 0x96, 0x80, 0x09, 0xB1, 0x83, 0x04, 0xF8, 0x01, 0xF0, 0x83, 0x06,
  0x36, 0x40, 0xE3, 0x11, 0x64, 0x40, 0xC0, 0x72, 0x28, 0x6F, 0xA6, 0x9A,
  0x6F, 0x82, 0x07, 0x00, 0x20, 0xC5, 0x14, 0x51, 0x2F, 0xA2, 0x8C, 0xF4,
  0x63, 0x1F, 0x46, 0x31, 0xF0, 0x74, 0x63, 0x08, 0x42, 0x11, 0x70, 0xF4,
  0x63, 0x18, 0xC6, 0x31, 0xF0, 0xFC, 0x21, 0x0F, 0xC2, 0x10, 0xF8, 0xFC,
  0x21, 0x0F, 0xC2, 0x10, 0x80, 0x74, 0x63, 0x08, 0x5E, 0x31, 0x70, 0x8C,
  0x63, 0x1F, 0xC6, 0x31, 0x88, 0xF9, 0x08, 0x42, 0x10, 0x84, 0xF8, 0x38,
  0x42, 0x10, 0x84, 0x31, 0xF0, 0x8E, 0x29, 0x24, 0xE2, 0x49, 0x22, 0x8C,
  0x84, 0x21, 0x08, 0x42, 0x10, 0xF8, 0x8E, 0xF7, 0xBA, 0xC6, 0x31, 0x88,
  0xCE, 0x73, 0x5A, 0xD6, 0x73, 0x88, 0x74, 0x63, 0x18, 0xC6, 0x31, 0x70,
  0xF2, 0x28, 0x62, 0xFA, 0x08, 0x20, 0x80, 0x74, 0x63, 0x18, 0xC6, 0x31,
  0x70, 0x82, 0xF4, 0x63, 0x1F, 0xCA, 0x51, 0x88, 0x74, 0x61, 0x87, 0x04,
  0x31, 0x78, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x70, 0x8E, 0x28, 0xA2, 0x51, 0x45, 0x0C, 0x20, 0x93, 0x25,
  0x4B, 0x56, 0xCD, 0x9B, 0x36, 0x64, 0x8E, 0x25, 0x14, 0x21, 0x45, 0x22,
  0x8C, 0xC2, 0x88, 0x91, 0x41, 0x82, 0x04, 0x08, 0x10, 0xF8, 0x44, 0x22,
  0x11, 0x10, 0xF8, 0xEA, 0xAA, 0xAC, 0x82, 0x10, 0x82, 0x10, 0x82, 0x10,
  0x42, 0xE4, 0x92, 0x49, 0x27, 0x80, 0x21, 0x94, 0x98, 0x80, 0xF8, 0xE0,
  0x74, 0x42, 0xF8, 0xC7, 0xE0, 0x84, 0x2D, 0x98, 0xC6, 0x31, 0xF0, 0x76,
  0x63, 0x08, 0x45, 0xC0, 0x08, 0x5B, 0x38, 0xC6, 0x31, 0x78, 0x74, 0x63,
  0xF8, 0x45, 0xC0, 0x39, 0x09, 0xF2, 0x10, 0x84, 0x20, 0x6C, 0xE3, 0x18,
  0xEC, 0xA1, 0x78, 0x84, 0x2D, 0x98, 0xC6, 0x31, 0x88, 0x30, 0x0E, 0x08,
  0x20, 0x82, 0x08, 0xFC, 0x10, 0xF1, 0x11, 0x11, 0x11, 0xE0, 0x82, 0x08,
  0xE2, 0x93, 0x89, 0x26, 0x8C, 0xF0, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x1E, 0xFD, 0x6B, 0x5A, 0xD6, 0xA0, 0xB6, 0x63, 0x18, 0xC6, 0x20, 0x76,
  0x63, 0x18, 0xC5, 0xC0, 0xB6, 0x63, 0x18, 0xC7, 0xD0, 0x80, 0x6C, 0xE3,
  0x18, 0xC5, 0xE1, 0x08, 0xB6, 0x63, 0x08, 0x42, 0x00, 0x74, 0x60, 0xE0,
  0xC5, 0xE0, 0x27, 0xC8, 0x42, 0x10, 0x87, 0x8C, 0x63, 0x18, 0xC5, 0xC0,
  0x8C, 0x62, 0xA5, 0x28, 0x80, 0x92, 0xA5, 0x53, 0x66, 0xCD, 0x9B, 0x00,
  0x89, 0x25, 0x08, 0x51, 0x48, 0xC0, 0x8C, 0x52, 0xA5, 0x18, 0x84, 0x40,
  0xF8, 0x44, 0x44, 0x23, 0xE0, 0x19, 0x08, 0x21, 0x70, 0x82, 0x21, 0x06,
  0xFF, 0xE0, 0xC1, 0x08, 0x42, 0x1C, 0x84, 0x21, 0x30, 0xEC, 0xC0,
};

const GFXglyph JetBrainsMono_Light12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 9, 7, 3, -9 },
  { 3, 3, 4, 7, 2, -9 },
  { 5, 7, 9, 7, 0, -9 },
  { 13, 5, 12, 7, 1, -10 },
  { 21, 7, 9, 7, 0, -9 },
  { 29, 6, 9, 7, 1, -9 },
  { 36, 1, 4, 7, 3, -9 },
  { 37, 4, 11, 7, 2, -10 },
  { 43, 4, 11, 7, 1, -10 },
  { 49, 7, 6, 7, 0, -7 },
  { 55, 5, 6, 7, 1, -7 },
  { 59, 2, 4, 7, 2, -2 },
  { 60, 4, 1, 7, 2, -4 },
  { 61, 2, 2, 7, 3, -2 },
  { 62, 5, 11, 7, 1, -10 },
  { 69, 5, 9, 7, 1, -9 },
  { 75, 5, 9, 7, 1, -9 },
  { 81, 5, 9, 7, 1, -9 },
  { 87, 5, 9, 7, 1, -9 },
  { 93, 5, 9, 7, 1, -9 },
  { 99, 5, 9, 7, 1, -9 },
  { 105, 5, 9, 7, 1, -9 },
  { 111, 5, 9, 7, 1, -9 },
  { 117, 5, 9, 7, 1, -9 },
  { 123, 5, 9, 7, 1, -9 },
  { 129, 2, 7, 7, 3, -7 },
  { 131, 3, 9, 7, 2, -7 },
  { 135, 5, 6, 7, 1, -7 },
  { 139, 5, 4, 7, 1, -6 },
  { 142, 5, 6, 7, 1, -7 },
  { 146, 4, 9, 7, 2, -9 },
  { 151, 6, 11, 7, 1, -9 },
  { 160, 6, 9, 7, 1, -9 },
  { 167, 5, 9, 7, 1, -9 },
  { 173, 5, 9, 7, 1, -9 },
  { 179, 5, 9, 7, 1, -9 },
  { 185, 5, 9, 7, 1, -9 },
  { 191, 5, 9, 7, 1, -9 },
  { 197, 5, 9, 7, 1, -9 },
  { 203, 5, 9, 7, 1, -9 },
  { 209, 5, 9, 7, 1, -9 },
  { 215, 5, 9, 7, 1, -9 },
  { 221, 6, 9, 7, 1, -9 },
  { 228, 5, 9, 7, 1, -9 },
  { 234, 5, 9, 7, 1, -9 },
  { 240, 5, 9, 7, 1, -9 },
  { 246, 5, 9, 7, 1, -9 },
  { 252, 6, 9, 7, 1, -9 },
  { 259, 5, 11, 7, 1, -9 },
  { 266, 5, 9, 7, 1, -9 },
  { 272, 5, 9, 7, 1, -9 },
  { 278, 6, 9, 7, 1, -9 },
  { 285, 5, 9, 7, 1, -9 },
  { 291, 6, 9, 7, 1, -9 },
  { 298, 7, 9, 7, 0, -9 },
  { 306, 6, 9, 7, 1, -9 },
  { 313, 7, 9, 7, 0, -9 },
  { 321, 5, 9, 7, 1, -9 },
  { 327, 2, 11, 7, 3, -10 },
  { 330, 5, 11, 7, 1, -10 },
  { 337, 3, 11, 7, 2, -10 },
  { 342, 5, 5, 7, 1, -9 },
  { 346, 5, 1, 7, 1, 0 },
  { 347, 3, 1, 7, 2, -9 },
  { 348, 5, 7, 7, 1, -7 },
  { 353, 5, 9, 7, 1, -9 },
  { 359, 5, 7, 7, 1, -7 },
  { 364, 5, 9, 7, 1, -9 },
  { 370, 5, 7, 7, 1, -7 },
  { 375, 5, 9, 7, 1, -9 },
  { 381, 5, 9, 7, 1, -7 },
  { 387, 5, 9, 7, 1, -9 },
  { 393, 6, 9, 7, 1, -9 },
  { 400, 4, 11, 7, 1, -9 },
  { 406, 6, 9, 7, 1, -9 },
  { 413, 7, 9, 7, 0, -9 },
  { 421, 5, 7, 7, 1, -7 },
  { 426, 5, 7, 7, 1, -7 },
  { 431, 5, 7, 7, 1, -7 },
  { 436, 5, 9, 7, 1, -7 },
  { 442, 5, 9, 7, 1, -7 },
  { 448, 5, 7, 7, 1, -7 },
  { 453, 5, 7, 7, 1, -7 },
  { 458, 5, 8, 7, 1, -8 },
  { 463, 5, 7, 7, 1, -7 },
  { 468, 5, 7, 7, 1, -7 },
  { 473, 7, 7, 7, 0, -7 },
  { 480, 6, 7, 7, 1, -7 },
  { 486, 5, 9, 7, 1, -7 },
  { 492, 5, 7, 7, 1, -7 },
  { 497, 5, 11, 7, 1, -10 },
  { 504, 1, 11, 7, 3, -10 },
  { 506, 5, 11, 7, 1, -10 },
  { 513, 5, 2, 7, 1, -5 },
};

const GFXfont JetBrainsMono_Light12pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light12pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _JETBRAINSMONO_LIGHT12PT7B_H_
