#ifndef _JETBRAINSMONO_LIGHT33PT7B_H_
#define _JETBRAINSMONO_LIGHT33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light33pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xE6, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x6F,
  0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x86, 0xE1,
  0xB8, 0x60, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x70, 0x0C, 0x18, 0x07,
  0x06, 0x01, 0x81, 0x80, 0x60, 0x61, 0xFF, 0xFF, 0x7F, 0xFF, 0xC3, 0x83,
  0x00, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x06, 0x00, 0xC1, 0x83,
  0xFF, 0xFC, 0xFF, 0xFF, 0x06, 0x06, 0x01, 0x83, 0x80, 0x60, 0xC0, 0x38,
  0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC1, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x01, 0xFE, 0x07, 0xFE, 0x1E, 0xCE, 0x31,
  0x8E, 0xE3, 0x1D, 0xC6, 0x3B, 0x8C, 0x07, 0x18, 0x07, 0x30, 0x0F, 0x60,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x0C, 0xF0, 0x18, 0xE0,
  0x31, 0xE0, 0x61, 0xB0, 0xC3, 0x61, 0x8E, 0xE3, 0x1C, 0xE6, 0x71, 0xFF,
  0xC0, 0xFF, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x7E, 0x00, 0xFF, 0xC0, 0x6C, 0x30, 0x3B, 0x0E, 0x0C, 0xC3, 0x86, 0x30,
  0xE3, 0x0C, 0x38, 0xC3, 0x0E, 0x60, 0xE7, 0x30, 0x1F, 0xDC, 0x03, 0xC6,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x63, 0xC0, 0x33, 0xF8, 0x1C, 0xC7,
  0x06, 0x60, 0xC3, 0x18, 0x31, 0xC6, 0x0C, 0x61, 0x83, 0x30, 0x60, 0xD8,
  0x1C, 0x76, 0x03, 0xFB, 0x00, 0x7C, 0x0F, 0xE0, 0x1F, 0xF8, 0x0E, 0x1E,
  0x0E, 0x07, 0x07, 0x01, 0x83, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x0F, 0x70, 0x77, 0x1C, 0x3B,
  0x87, 0x39, 0xC3, 0x9C, 0xE0, 0xFC, 0x70, 0x3C, 0x38, 0x0E, 0x1C, 0x07,
  0x0E, 0x07, 0xC7, 0x87, 0x71, 0xFF, 0x1C, 0x7F, 0x0F, 0xFF, 0xFF, 0xFF,
  0x6C, 0x00, 0x40, 0x70, 0x7C, 0x3C, 0x1E, 0x0E, 0x03, 0x81, 0xC0, 0x70,
  0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70,
  0x0F, 0x01, 0xF0, 0x3C, 0x03, 0x80, 0x38, 0x0F, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03,
  0x81, 0xC0, 0xF0, 0x78, 0x3C, 0x3E, 0x0E, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x1C, 0x30, 0xEF, 0xCC,
  0xFD, 0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0x30, 0x00, 0x3E, 0x00, 0x1C, 0xC0,
  0x07, 0x38, 0x03, 0x87, 0x01, 0xC1, 0xC0, 0x70, 0x38, 0x08, 0x04, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x3C, 0xF3, 0x9E, 0x71,
  0xC7, 0x38, 0xE3, 0x00, 0xFF, 0xFF, 0xF0, 0x7B, 0xEF, 0xFE, 0x78, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0xC7, 0x87, 0xB8,
  0x0E, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x31, 0xF1, 0xE7, 0xC7, 0x9F, 0x0C, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x39, 0xE1, 0xE3, 0xFF, 0x07, 0xF8,
  0x07, 0x80, 0x1F, 0x00, 0xF6, 0x03, 0xCC, 0x0E, 0x18, 0x18, 0x30, 0x20,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x3F,
  0xF0, 0xE0, 0xF3, 0x80, 0xE6, 0x00, 0xEC, 0x01, 0xF8, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0F,
  0xC0, 0x1F, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x0F, 0xC0, 0x1D, 0x80, 0x3B, 0x00, 0x67, 0x01, 0xC7, 0x07, 0x8F,
  0xFE, 0x07, 0xF0, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x06, 0x70, 0x37, 0x01,
  0xF0, 0x0F, 0x80, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x7F, 0xF9, 0xFF, 0xE6, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE7, 0xC3, 0xBF, 0xCF,
  0xFF, 0xBC, 0x0E, 0xE0, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xF8, 0x07, 0xE0, 0x39, 0xC1, 0xE3, 0xFF, 0x07, 0xF8,
  0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x33, 0xC0, 0xFF, 0xE1, 0xF3, 0xE7, 0x81,
  0xEE, 0x01, 0xD8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0D, 0x80, 0x1B,
  0x80, 0x77, 0x01, 0xE7, 0x87, 0x87, 0xFE, 0x07, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3E, 0x00, 0xEC, 0x01, 0xD8, 0x03, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1F, 0xE0, 0xFF, 0xC7, 0x07, 0x98,
  0x0E, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xD8, 0x06, 0x70, 0x38, 0xE1, 0xC1,
  0xFE, 0x01, 0xE0, 0x1F, 0xE0, 0xE1, 0xC7, 0x03, 0xB8, 0x07, 0xE0, 0x1F,
  0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x1D, 0xE1, 0xE7, 0xFF, 0x07, 0xF8,
  0x0F, 0xF0, 0x3F, 0xF0, 0xF0, 0xF3, 0x80, 0x77, 0x00, 0xEC, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x06, 0xC0, 0x1D, 0xC0, 0x3B, 0xC0, 0xF3, 0xEF,
  0xC3, 0xFF, 0x81, 0xEE, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x7B, 0xFF, 0xDE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC7, 0xBF, 0xF9, 0xE0, 0x3C,
  0xFD, 0xF9, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x8F,
  0x1C, 0x78, 0xE1, 0xC3, 0x8E, 0x1C, 0x30, 0x00, 0x00, 0x04, 0x00, 0x30,
  0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x00, 0xE0, 0x03,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x0C, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x03,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x3C, 0x00, 0x70, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x3C, 0x00, 0xC0, 0x02, 0x00, 0x00, 0xFE, 0x1F, 0xF0, 0x1F, 0x00, 0xF0,
  0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x07, 0x1F, 0xE3, 0xF0,
  0x78, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0xF8,
  0x1F, 0x01, 0xC0, 0x0F, 0xF8, 0x1F, 0xFC, 0x38, 0x0E, 0x70, 0x06, 0xE0,
  0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFB, 0xC1, 0xFF, 0xC3,
  0x87, 0xC3, 0x83, 0xC3, 0x03, 0xC3, 0x03, 0xC3, 0x03, 0xC3, 0x03, 0xC3,
  0x03, 0xC3, 0x03, 0xC3, 0x83, 0xC3, 0x87, 0xC1, 0xFF, 0xC0, 0xFB, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x06,
  0xE0, 0x06, 0x60, 0x0E, 0x60, 0x0E, 0x70, 0x0C, 0x70, 0x0C, 0x30, 0x1C,
  0x30, 0x1C, 0x38, 0x18, 0x38, 0x18, 0x18, 0x38, 0x18, 0x3F, 0xFC, 0x3F,
  0xFC, 0x30, 0x0C, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x0E, 0xE0, 0x06, 0xE0,
  0x07, 0xE0, 0x07, 0xFF, 0xC3, 0xFF, 0xCE, 0x0F, 0xB8, 0x0E, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1B, 0x80, 0xEF, 0xFF, 0x3F, 0xF8,
  0xFF, 0xF3, 0x80, 0xEE, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x07, 0xE0, 0x3F, 0x83, 0xEF, 0xFF, 0x3F, 0xF0, 0x1F, 0xE0, 0xFF,
  0xC7, 0x87, 0x98, 0x06, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0x70, 0x39, 0xE1, 0xE3,
  0xFF, 0x07, 0xF8, 0xFF, 0xC3, 0xFF, 0x8E, 0x0F, 0x38, 0x0E, 0xE0, 0x3B,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x0E, 0xE0, 0x3B, 0x87, 0xCF, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0xFE,
  0xFF, 0xFB, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x1F, 0xE0, 0xFF,
  0xC7, 0x87, 0x98, 0x06, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE3, 0xFF, 0x8F, 0xFE, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0x70, 0x39, 0xE1, 0xE3,
  0xFF, 0x07, 0xF8, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0F, 0x00, 0x3C, 0x01, 0xF8, 0x07, 0xE0, 0x1D, 0xE1, 0xE3,
  0xFF, 0x07, 0xF8, 0xE0, 0x0F, 0xC0, 0x3B, 0x80, 0x77, 0x01, 0xCE, 0x03,
  0x9C, 0x0E, 0x38, 0x1C, 0x70, 0x70, 0xE0, 0xE1, 0xC3, 0x83, 0xFF, 0x07,
  0xFC, 0x0F, 0xFC, 0x1C, 0x38, 0x38, 0x38, 0x70, 0x70, 0xE0, 0x71, 0xC0,
  0xE3, 0x80, 0xE7, 0x01, 0xCE, 0x01, 0xDC, 0x03, 0xB8, 0x03, 0xF0, 0x07,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0xC0, 0xFF, 0x03, 0xFC,
  0x1F, 0xD8, 0x6F, 0x61, 0xBD, 0x86, 0xF3, 0x33, 0xCC, 0xCF, 0x33, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xF6, 0x07, 0xF8, 0x1F, 0xF0, 0x7E, 0xC1,
  0xFB, 0x07, 0xEE, 0x1F, 0x98, 0x7E, 0x71, 0xF8, 0xC7, 0xE3, 0x1F, 0x8E,
  0x7E, 0x19, 0xF8, 0x67, 0xE1, 0xDF, 0x83, 0x7E, 0x0D, 0xF8, 0x3F, 0xE0,
  0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0x1F, 0xE0, 0xFF, 0xC7, 0x87, 0x98,
  0x0E, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0x70, 0x39, 0xE1, 0xE3, 0xFF, 0x07, 0xF8,
  0xFF, 0xE1, 0xFF, 0xF3, 0x81, 0xF7, 0x00, 0xEE, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x77, 0x07, 0xCF, 0xFF,
  0x1F, 0xFC, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x1F, 0xE0, 0xFF,
  0xC7, 0x87, 0xB8, 0x0E, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x39, 0xE1, 0xE3,
  0xFF, 0x07, 0xF8, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0xFF, 0xE1, 0xFF, 0xE3, 0x81, 0xE7, 0x00, 0xEE, 0x01, 0xDC,
  0x01, 0xB8, 0x03, 0xF0, 0x07, 0xE0, 0x0D, 0xC0, 0x3B, 0x80, 0xF7, 0xFF,
  0xCF, 0xFF, 0x1F, 0xF8, 0x38, 0x70, 0x70, 0x70, 0xE0, 0xE1, 0xC0, 0xE3,
  0x81, 0xC7, 0x01, 0xCE, 0x03, 0x9C, 0x03, 0xB8, 0x07, 0x70, 0x07, 0x0F,
  0xF0, 0x3F, 0xF0, 0xF0, 0xF1, 0x80, 0x77, 0x00, 0xEE, 0x01, 0xDC, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0D, 0x80, 0x1B, 0x00,
  0x77, 0x00, 0xE7, 0x87, 0x8F, 0xFE, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x06, 0x70, 0x39, 0xE1, 0xE3, 0xFF,
  0x07, 0xF8, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0x60, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x30, 0x0C, 0x30, 0x1C, 0x38, 0x1C, 0x38, 0x18, 0x18, 0x18,
  0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x30, 0x0C, 0x30, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0x60, 0x06, 0x60, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0xE1, 0xC1, 0xF8, 0x78, 0x7E, 0x1E, 0x1F, 0x87, 0x86, 0xE1,
  0xE1, 0x98, 0x78, 0x66, 0x12, 0x19, 0x84, 0x86, 0x63, 0x21, 0x98, 0xCC,
  0xE7, 0x33, 0x39, 0xCC, 0xCC, 0x73, 0x33, 0x0C, 0xCC, 0xC3, 0x23, 0x30,
  0xC8, 0x4C, 0x36, 0x13, 0x0D, 0x86, 0xC3, 0x61, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1E, 0x0F, 0x07, 0x81, 0xC1, 0xE0, 0x70, 0x38, 0x70, 0x03, 0x9C, 0x03,
  0x8E, 0x01, 0xC3, 0x81, 0xC1, 0xC0, 0xC0, 0x70, 0xE0, 0x18, 0x60, 0x0E,
  0x70, 0x03, 0x70, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x1F, 0x80, 0x0D, 0xC0, 0x0E, 0x70, 0x06, 0x38, 0x07, 0x0E, 0x03, 0x07,
  0x03, 0x81, 0xC3, 0x80, 0xE1, 0xC0, 0x39, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x01, 0xDC, 0x00, 0xE3, 0x00, 0x30, 0xE0, 0x1C, 0x18, 0x06, 0x07, 0x03,
  0x81, 0xC0, 0xC0, 0x38, 0x70, 0x0E, 0x18, 0x01, 0xCE, 0x00, 0x73, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x0E,
  0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01,
  0xC0, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x1E, 0x00,
  0x78, 0x03, 0x30, 0x0C, 0xC0, 0x73, 0x81, 0x86, 0x0E, 0x1C, 0x30, 0x31,
  0xC0, 0xE6, 0x01, 0xB8, 0x06, 0xC0, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0x60,
  0xE0, 0xE0, 0xE0, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xE0, 0x73, 0x80, 0x67,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x1F, 0xFE, 0xFF, 0xFD, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xB8, 0x1F, 0x3F, 0xEE,
  0x3F, 0x9C, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0xFE, 0x3F, 0xFC, 0xF8, 0x7B, 0xC0, 0xEE, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xF0, 0x3B, 0xE1, 0xEE, 0xFF, 0x39, 0xF8, 0x1F, 0xE0, 0xFF, 0xC7,
  0x83, 0xB8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x1F, 0x80, 0x77, 0x01, 0x9E, 0x1E,
  0x3F, 0xF0, 0x7F, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x71, 0xF9, 0xDF, 0xF7, 0x70, 0x7F, 0x80, 0xFE, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x3D, 0xE1, 0xF3, 0xFD, 0xC7, 0xE7, 0x1F, 0xE0,
  0xFF, 0xC7, 0x03, 0xB8, 0x06, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x76, 0x01,
  0xDC, 0x0E, 0x3F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFF, 0x03, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x1F, 0x9C, 0xFF, 0x77, 0x07, 0xF8,
  0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x3D, 0xC0, 0xF7, 0xFF, 0xCF, 0xF7, 0x0F, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x03, 0xE3, 0xFF, 0x0F, 0xF8,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0xFE,
  0x3F, 0xFC, 0xF0, 0x3B, 0xC0, 0xEE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0x01, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x3C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0E, 0x01, 0xE0, 0xFC, 0xFF, 0x8F, 0xE0, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x03, 0xF0, 0x0E, 0xE0, 0x39,
  0xC0, 0xE3, 0x81, 0xC7, 0x07, 0x0E, 0x1C, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F,
  0xE0, 0xE1, 0xC1, 0xC1, 0xC3, 0x83, 0xC7, 0x03, 0x8E, 0x03, 0x9C, 0x07,
  0xB8, 0x07, 0x70, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0x3C, 0xFF, 0xFE, 0xE3,
  0x86, 0xE1, 0x86, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1,
  0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1,
  0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xEF, 0xE3, 0xFF, 0xCF, 0x87,
  0xBC, 0x0E, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x70, 0x1F, 0xE0, 0xFF, 0xC7, 0x07, 0xB8, 0x0E, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x76, 0x03, 0x9E, 0x1E, 0x3F, 0xF0, 0x7F, 0x80, 0xEF,
  0xE3, 0xFF, 0xCF, 0x83, 0xBC, 0x0E, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F,
  0x03, 0xBE, 0x1E, 0xEF, 0xF3, 0x9F, 0x8E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x1F, 0x9C, 0xFF, 0x77, 0x07, 0xF8, 0x0F,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x03, 0xDE, 0x1F, 0x3F, 0xDC, 0x7E,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xCF,
  0xE6, 0xFF, 0xB4, 0x1F, 0xC0, 0x7E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x1F, 0xF1, 0xFF, 0xE7, 0x03, 0x98, 0x07,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x7E, 0x01, 0xDC, 0x0E, 0x7F, 0xF8, 0x7F,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x1F, 0xFF,
  0xFF, 0xFF, 0x83, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x67, 0x03, 0x9E,
  0x1E, 0x3F, 0xF0, 0x7F, 0x00, 0xE0, 0x07, 0x60, 0x06, 0x70, 0x0E, 0x70,
  0x0E, 0x30, 0x0C, 0x38, 0x1C, 0x38, 0x1C, 0x18, 0x18, 0x1C, 0x38, 0x1C,
  0x38, 0x0C, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x06, 0x60, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0xC1, 0xD8, 0x70, 0x66, 0x1E, 0x19,
  0x87, 0x86, 0x61, 0x61, 0x98, 0x58, 0xE7, 0x12, 0x30, 0xCC, 0x8C, 0x33,
  0x33, 0x0C, 0xCC, 0xC3, 0x23, 0x30, 0xC8, 0xDC, 0x3A, 0x16, 0x0F, 0x85,
  0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1C, 0x1E, 0x07, 0x07, 0x80, 0xF0, 0x0F,
  0x70, 0x1C, 0x38, 0x1C, 0x1C, 0x38, 0x1C, 0x70, 0x0E, 0x70, 0x07, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x0E, 0x60, 0x0E, 0x70,
  0x1C, 0x38, 0x38, 0x1C, 0x38, 0x1C, 0x70, 0x0E, 0xE0, 0x07, 0xE0, 0x07,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x38, 0x1C, 0x38, 0x1C, 0x18, 0x18,
  0x1C, 0x38, 0x1C, 0x38, 0x0E, 0x30, 0x0E, 0x70, 0x06, 0x60, 0x07, 0x60,
  0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0xFF, 0xFB,
  0xFF, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x07, 0xF0, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xFC, 0x03, 0xF0, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x03, 0xF0,
  0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x3F, 0xC0,
  0xFF, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0xFC, 0x03,
  0xE0, 0x0E, 0x00, 0x00, 0x3C, 0x06, 0xFE, 0x0D, 0xDE, 0x1F, 0x1E, 0x3E,
  0x1F, 0xFC, 0x1F, 0xB8, 0x04, 0x00,
};

const GFXglyph JetBrainsMono_Light33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 4, 24, 20, 8, -24 },
  { 13, 10, 10, 20, 5, -24 },
  { 26, 18, 24, 20, 1, -24 },
  { 80, 15, 34, 20, 2, -29 },
  { 144, 18, 24, 20, 1, -24 },
  { 198, 17, 24, 20, 2, -24 },
  { 249, 3, 10, 20, 8, -24 },
  { 253, 10, 32, 20, 6, -28 },
  { 293, 10, 32, 20, 4, -28 },
  { 333, 18, 17, 20, 1, -20 },
  { 372, 16, 16, 20, 2, -19 },
  { 404, 6, 10, 20, 6, -5 },
  { 412, 10, 2, 20, 5, -12 },
  { 415, 6, 5, 20, 7, -5 },
  { 419, 14, 31, 20, 3, -27 },
  { 474, 14, 24, 20, 3, -24 },
  { 516, 15, 24, 20, 3, -24 },
  { 561, 15, 24, 20, 2, -24 },
  { 606, 15, 24, 20, 2, -24 },
  { 651, 13, 24, 20, 3, -24 },
  { 690, 14, 24, 20, 3, -24 },
  { 732, 15, 24, 20, 2, -24 },
  { 777, 15, 24, 20, 3, -24 },
  { 822, 14, 24, 20, 3, -24 },
  { 864, 15, 24, 20, 2, -24 },
  { 909, 6, 18, 20, 7, -18 },
  { 923, 7, 23, 20, 6, -18 },
  { 944, 14, 18, 20, 3, -20 },
  { 976, 14, 10, 20, 3, -16 },
  { 994, 14, 18, 20, 3, -20 },
  { 1026, 11, 24, 20, 5, -24 },
  { 1059, 16, 30, 20, 2, -24 },
  { 1119, 16, 24, 20, 2, -24 },
  { 1167, 14, 24, 20, 3, -24 },
  { 1209, 14, 24, 20, 3, -24 },
  { 1251, 14, 24, 20, 3, -24 },
  { 1293, 14, 24, 20, 3, -24 },
  { 1335, 14, 24, 20, 3, -24 },
  { 1377, 14, 24, 20, 3, -24 },
  { 1419, 14, 24, 20, 3, -24 },
  { 1461, 12, 24, 20, 4, -24 },
  { 1497, 14, 24, 20, 2, -24 },
  { 1539, 15, 24, 20, 3, -24 },
  { 1584, 14, 24, 20, 4, -24 },
  { 1626, 14, 24, 20, 3, -24 },
  { 1668, 14, 24, 20, 3, -24 },
  { 1710, 14, 24, 20, 3, -24 },
  { 1752, 15, 24, 20, 3, -24 },
  { 1797, 14, 30, 20, 3, -24 },
  { 1850, 15, 24, 20, 3, -24 },
  { 1895, 15, 24, 20, 2, -24 },
  { 1940, 16, 24, 20, 2, -24 },
  { 1988, 14, 24, 20, 3, -24 },
  { 2030, 16, 24, 20, 2, -24 },
  { 2078, 18, 24, 20, 1, -24 },
  { 2132, 17, 24, 20, 1, -24 },
  { 2183, 18, 24, 20, 1, -24 },
  { 2237, 14, 24, 20, 3, -24 },
  { 2279, 8, 31, 20, 7, -27 },
  { 2310, 14, 31, 20, 3, -27 },
  { 2365, 8, 31, 20, 5, -27 },
  { 2396, 14, 13, 20, 3, -24 },
  { 2419, 16, 2, 20, 2, 1 },
  { 2423, 7, 5, 20, 6, -26 },
  { 2428, 15, 18, 20, 2, -18 },
  { 2462, 14, 24, 20, 3, -24 },
  { 2504, 14, 18, 20, 3, -18 },
  { 2536, 14, 24, 20, 3, -24 },
  { 2578, 14, 18, 20, 3, -18 },
  { 2610, 16, 24, 20, 2, -24 },
  { 2658, 14, 24, 20, 3, -18 },
  { 2700, 14, 24, 20, 3, -24 },
  { 2742, 15, 26, 20, 3, -26 },
  { 2791, 12, 32, 20, 3, -26 },
  { 2839, 15, 24, 20, 3, -24 },
  { 2884, 17, 24, 20, 1, -24 },
  { 2935, 16, 18, 20, 2, -18 },
  { 2971, 14, 18, 20, 3, -18 },
  { 3003, 14, 18, 20, 3, -18 },
  { 3035, 14, 24, 20, 3, -18 },
  { 3077, 14, 24, 20, 3, -18 },
  { 3119, 13, 18, 20, 4, -18 },
  { 3149, 14, 18, 20, 3, -18 },
  { 3181, 15, 23, 20, 2, -23 },
  { 3225, 14, 18, 20, 3, -18 },
  { 3257, 16, 18, 20, 2, -18 },
  { 3293, 18, 18, 20, 1, -18 },
  { 3334, 16, 18, 20, 2, -18 },
  { 3370, 16, 24, 20, 2, -18 },
  { 3418, 14, 18, 20, 3, -18 },
  { 3450, 14, 31, 20, 3, -27 },
  { 3505, 2, 31, 20, 9, -27 },
  { 3513, 14, 31, 20, 3, -27 },
  { 3568, 15, 7, 20, 2, -15 },
};

const GFXfont JetBrainsMono_Light33pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light33pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light33pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _JETBRAINSMONO_LIGHT33PT7B_H_
