#ifndef _JETBRAINSMONO_LIGHT46PT7B_H_
#define _JETBRAINSMONO_LIGHT46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light46pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xEF,
  0xFF, 0xFF, 0xE0, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0E, 0xE0, 0x77, 0x03,
  0xB8, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x38, 0x00,
  0xE0, 0x38, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x38, 0x01,
  0xC0, 0x70, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x70, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x00, 0xE0, 0x07,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x01, 0xC0, 0x07,
  0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x1C, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x1C,
  0x03, 0x80, 0x1C, 0x03, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x38,
  0x07, 0x00, 0x38, 0x07, 0x00, 0x38, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFD, 0xBF, 0x0F, 0x8C,
  0x7C, 0x78, 0x61, 0xE3, 0x83, 0x07, 0x3C, 0x18, 0x3D, 0xE0, 0xC1, 0xEF,
  0x06, 0x00, 0x38, 0x30, 0x01, 0xE1, 0x80, 0x0F, 0x0C, 0x00, 0x3E, 0x60,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xC0, 0x01, 0xBF, 0x00, 0x0C, 0x7C, 0x00, 0x61, 0xE0, 0x03, 0x07,
  0x80, 0x18, 0x3C, 0x00, 0xC1, 0xFE, 0x06, 0x0F, 0x70, 0x30, 0x7B, 0x81,
  0x83, 0xDE, 0x0C, 0x1E, 0xF8, 0x61, 0xE3, 0xE3, 0x3F, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x01,
  0xCF, 0xF0, 0x00, 0xE7, 0xFE, 0x00, 0x73, 0xC3, 0xC0, 0x1C, 0xE0, 0x70,
  0x0E, 0x38, 0x1C, 0x07, 0x0E, 0x07, 0x01, 0xC3, 0x81, 0xC0, 0xE0, 0xE0,
  0x70, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x0E, 0x03, 0x81, 0xC7, 0x00,
  0x78, 0xF1, 0xC0, 0x1F, 0xF8, 0xE0, 0x03, 0xFC, 0x70, 0x00, 0x0C, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE3, 0xF8, 0x00, 0x71, 0xFF, 0x00, 0x38, 0xFF, 0xE0, 0x0E, 0x38, 0x38,
  0x07, 0x1C, 0x0F, 0x03, 0x87, 0x01, 0xC0, 0xE1, 0xC0, 0x70, 0x70, 0x70,
  0x1C, 0x38, 0x1C, 0x07, 0x0E, 0x07, 0x01, 0xC7, 0x01, 0xC0, 0xF3, 0x80,
  0x38, 0x39, 0xE0, 0x0F, 0xFE, 0x70, 0x01, 0xFF, 0x38, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xF8, 0x7C, 0x03,
  0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0E, 0x00, 0xF0, 0x1C, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0xFB, 0xC0, 0x3F, 0xC3, 0xC0, 0xF7, 0x87, 0x81, 0xEE, 0x07, 0x87,
  0x9C, 0x07, 0x8E, 0x38, 0x07, 0xBC, 0x70, 0x0F, 0x70, 0xE0, 0x0F, 0xE1,
  0xC0, 0x0F, 0x83, 0x80, 0x1F, 0x07, 0x00, 0x3E, 0x0F, 0x00, 0x7E, 0x1E,
  0x01, 0xFE, 0x3E, 0x0F, 0xBC, 0x3F, 0xFE, 0x3C, 0x3F, 0xF8, 0x3C, 0x3F,
  0xE0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0xEE, 0x00, 0x08, 0x01,
  0xC0, 0x3E, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x01,
  0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x70, 0x00, 0x80, 0x80,
  0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x03, 0xF8,
  0x0F, 0xC0, 0x38, 0x00, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x70, 0x38, 0x0E, 0xFC, 0x38, 0x7E, 0xFF, 0x19, 0xFF,
  0x7F, 0xDB, 0xFC, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xE7, 0x80, 0x03, 0xC7, 0xC0,
  0x07, 0xC3, 0xC0, 0x07, 0x81, 0xE0, 0x0F, 0x01, 0xF0, 0x1F, 0x00, 0xF0,
  0x06, 0x00, 0x60, 0x02, 0x00, 0x40, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x1F, 0x8F, 0x87, 0xC3, 0xE3, 0xE1, 0xF0, 0xF0,
  0x78, 0x7C, 0x3C, 0x1E, 0x0E, 0x0F, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xF0, 0xFC, 0x7C, 0x03, 0xE7, 0x80, 0x1E,
  0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x40, 0xFE, 0x0F,
  0x0F, 0xE1, 0xF0, 0xFE, 0x1F, 0x0F, 0xE1, 0xF0, 0xFE, 0x06, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0E, 0xF0, 0x01, 0xE7, 0x80, 0x3E,
  0x7E, 0x07, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xF7, 0x80, 0x3F,
  0x3C, 0x03, 0xE1, 0xE0, 0x1E, 0x0F, 0x00, 0xE0, 0x78, 0x04, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0,
  0x3F, 0x0F, 0xC3, 0xC0, 0x1E, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCE, 0x00,
  0x0E, 0x70, 0x00, 0x7F, 0x80, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x7F, 0x00, 0x07, 0x70, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0xC0,
  0x1E, 0x3E, 0x03, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0xFE, 0x07, 0x3F, 0xF0, 0x77, 0xFF, 0x87, 0x70, 0xFC,
  0x7C, 0x03, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xE7, 0x80, 0x3E, 0x7C,
  0x07, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x7B, 0xFE,
  0x07, 0xBF, 0xF8, 0x3F, 0x8F, 0xE1, 0xF0, 0x0F, 0x9F, 0x00, 0x3C, 0xF0,
  0x00, 0xF7, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xDC, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80,
  0x0F, 0x1E, 0x00, 0xF8, 0xFC, 0x0F, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1E, 0xE0,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xF0, 0xFC, 0x7C, 0x03, 0xC7, 0x80, 0x1E, 0x70, 0x01, 0xE7, 0x00, 0x0E,
  0x70, 0x00, 0xE7, 0x00, 0x1E, 0x70, 0x01, 0xE7, 0x80, 0x1C, 0x3C, 0x03,
  0xC3, 0xE0, 0x78, 0x1F, 0x9F, 0x00, 0x7F, 0xE0, 0x01, 0xF8, 0x00, 0x7F,
  0xE0, 0x1F, 0x9F, 0x03, 0xE0, 0x78, 0x7C, 0x03, 0xC7, 0x80, 0x1E, 0xF0,
  0x01, 0xEF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x01, 0xE7, 0x80, 0x1E, 0x7C, 0x07, 0xC3, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0xF0, 0x3F, 0x0F, 0xC3, 0xE0, 0x1F, 0x3E, 0x00, 0x79, 0xE0, 0x01, 0xEE,
  0x00, 0x0F, 0x70, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xB8, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x1F, 0x3C,
  0x01, 0xF1, 0xF8, 0x1F, 0x87, 0xFF, 0xF8, 0x1F, 0xFB, 0xC0, 0x3F, 0xBC,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0xFF, 0xFF, 0xFF, 0xEF, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xDF, 0xFF, 0xFF, 0xFE, 0xFC, 0x0F, 0x07,
  0xE3, 0xF8, 0xFF, 0x3F, 0x8F, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x1F,
  0x87, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x07,
  0x01, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00,
  0x08, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x1F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0x80, 0xF8, 0x1E,
  0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x0F, 0xCF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3E, 0x77, 0xF0, 0x38, 0x1F, 0xF0,
  0x78, 0x0F, 0xF0, 0x70, 0x0F, 0xF0, 0x70, 0x0F, 0xF0, 0x70, 0x0F, 0xF0,
  0x70, 0x0F, 0xF0, 0x70, 0x0F, 0xF0, 0x70, 0x0F, 0xF0, 0x70, 0x0F, 0xF0,
  0x70, 0x0F, 0xF0, 0x70, 0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0x38, 0x1F, 0xF0,
  0x3E, 0x37, 0xF0, 0x1F, 0xF7, 0xF0, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x78, 0x00, 0x1D, 0xE0,
  0x00, 0x73, 0x80, 0x03, 0xCE, 0x00, 0x0E, 0x3C, 0x00, 0x38, 0xF0, 0x01,
  0xE1, 0xC0, 0x07, 0x87, 0x00, 0x1C, 0x1E, 0x00, 0x70, 0x78, 0x03, 0xC0,
  0xE0, 0x0F, 0x03, 0x80, 0x38, 0x0F, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0x70,
  0x1E, 0x01, 0xE0, 0x70, 0x07, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x1C, 0x78, 0x00,
  0x79, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xF0, 0xFF, 0xC0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF,
  0xCE, 0x00, 0xF9, 0xC0, 0x0F, 0xB8, 0x00, 0xF7, 0x00, 0x0E, 0xE0, 0x01,
  0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x01, 0xEE, 0x00, 0x3D, 0xC0, 0x0F,
  0x38, 0x03, 0xE7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0x80, 0x7E,
  0x70, 0x03, 0xEE, 0x00, 0x3D, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x0F, 0xB8, 0x0F, 0xE7, 0xFF, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xF0, 0xFC, 0x7C, 0x03,
  0xE7, 0x80, 0x1E, 0x70, 0x00, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x00, 0x0E, 0x78, 0x01,
  0xE7, 0xC0, 0x3E, 0x3E, 0x07, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x00,
  0xFD, 0xE0, 0x07, 0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3D, 0xE0, 0x0F,
  0xBC, 0x0F, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xFC,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFB, 0xFF, 0xFF, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xF0, 0xFC, 0x7C, 0x03, 0xE7, 0x80, 0x1E, 0x70, 0x00, 0xEF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7,
  0x00, 0x0E, 0x78, 0x01, 0xE7, 0xC0, 0x3E, 0x3E, 0x07, 0xC1, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xDC,
  0x00, 0x1C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3E, 0x00, 0xF8, 0xF8, 0x0F,
  0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xF0, 0x00, 0x7B,
  0xC0, 0x03, 0xEF, 0x00, 0x0F, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0,
  0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x3C,
  0x0F, 0x00, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x0F,
  0x03, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0x03,
  0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0,
  0x3C, 0x03, 0xC0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x3C,
  0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x3C, 0x00,
  0x3C, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFD,
  0xC0, 0x3F, 0xDC, 0x03, 0xFF, 0xC0, 0x77, 0xEE, 0x07, 0x7E, 0xE0, 0x77,
  0xEE, 0x0E, 0x7E, 0x70, 0xE7, 0xE7, 0x0E, 0x7E, 0x71, 0xC7, 0xE3, 0x9C,
  0x7E, 0x39, 0xC7, 0xE3, 0x98, 0xFE, 0x1F, 0x8F, 0xE1, 0xF8, 0xFE, 0x1F,
  0x0F, 0xE0, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xB8, 0x07,
  0xF7, 0x00, 0xFE, 0xF0, 0x1F, 0xCE, 0x03, 0xF9, 0xC0, 0x7F, 0x3C, 0x0F,
  0xE3, 0x81, 0xFC, 0x70, 0x3F, 0x87, 0x07, 0xF0, 0xE0, 0xFE, 0x1E, 0x1F,
  0xC1, 0xC3, 0xF8, 0x38, 0x7F, 0x07, 0x8F, 0xE0, 0x71, 0xFC, 0x0E, 0x3F,
  0x81, 0xE7, 0xF0, 0x1C, 0xFE, 0x03, 0x9F, 0xC0, 0x3B, 0xF8, 0x07, 0x7F,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE,
  0x00, 0x7C, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0x8F, 0xE7,
  0xC0, 0x3C, 0xF0, 0x03, 0xDC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xB8, 0x00, 0xF7, 0x80, 0x1E, 0xF0,
  0x07, 0x8F, 0x81, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0x80, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0x00, 0x3F,
  0x78, 0x00, 0x7B, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xDE, 0x00, 0x3E, 0xF0, 0x0F, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE1, 0xFF, 0xF8, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xF1, 0xFC, 0x7C, 0x03, 0xC7, 0x80, 0x1E, 0xF0, 0x01, 0xEF, 0x00,
  0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xEF, 0x00, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x3E, 0x3E, 0x07, 0xC3, 0xFF,
  0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x8F, 0x00, 0x3E, 0x78, 0x00, 0xFB, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0,
  0x00, 0x77, 0x80, 0x03, 0xBC, 0x00, 0x1D, 0xE0, 0x00, 0xEF, 0x00, 0x0F,
  0x78, 0x00, 0x7B, 0xC0, 0x07, 0x9E, 0x00, 0x7C, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x03,
  0xC0, 0x78, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x3C, 0x3C, 0x01,
  0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xF3, 0xC0, 0x07, 0x9E,
  0x00, 0x3E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0x3F,
  0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0x0F, 0xC3, 0xE0, 0x1F, 0x1E, 0x00, 0x78,
  0xE0, 0x01, 0xCF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7F, 0x80, 0x03, 0xDC, 0x00, 0x1E, 0xE0, 0x00, 0xF7, 0x80, 0x07,
  0xBE, 0x00, 0x78, 0xF8, 0x0F, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x07, 0xB8, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x07, 0x8F,
  0x81, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0E, 0x70, 0x00, 0x79, 0xE0,
  0x01, 0xE7, 0x80, 0x07, 0x1E, 0x00, 0x1C, 0x38, 0x00, 0xF0, 0xF0, 0x03,
  0xC3, 0xC0, 0x0E, 0x0F, 0x00, 0x38, 0x1C, 0x01, 0xE0, 0x78, 0x07, 0x81,
  0xE0, 0x1C, 0x07, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0,
  0x38, 0x01, 0xC0, 0xE0, 0x07, 0x07, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x70,
  0x00, 0xE3, 0xC0, 0x03, 0x8F, 0x00, 0x0F, 0x38, 0x00, 0x3C, 0xE0, 0x00,
  0x73, 0x80, 0x01, 0xDE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x1E, 0x03, 0xF8, 0x0F,
  0x01, 0xDC, 0x07, 0x80, 0xEE, 0x03, 0xC0, 0x77, 0x03, 0xE0, 0x7B, 0x81,
  0xF0, 0x3D, 0xC0, 0xDC, 0x1E, 0xF0, 0x6E, 0x0E, 0x78, 0x33, 0x07, 0x3C,
  0x19, 0x83, 0x8E, 0x0C, 0xC1, 0xC7, 0x0E, 0x60, 0xE3, 0x87, 0x30, 0x71,
  0xC3, 0x98, 0x78, 0xE1, 0x8E, 0x3C, 0x70, 0xC7, 0x1C, 0x3C, 0x63, 0x8E,
  0x1E, 0x30, 0xC7, 0x0F, 0x18, 0x63, 0x83, 0x9C, 0x31, 0xC1, 0xCE, 0x18,
  0xE0, 0xE7, 0x0C, 0x70, 0x73, 0x07, 0x38, 0x39, 0x83, 0xBC, 0x1C, 0xC1,
  0xDC, 0x0F, 0x60, 0x6E, 0x07, 0xB0, 0x37, 0x01, 0xF8, 0x1B, 0x80, 0xFC,
  0x0D, 0xC0, 0x7E, 0x06, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x3C, 0x00, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xC0, 0x03, 0xC3, 0xC0,
  0x03, 0xC3, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xEF, 0x00, 0x01, 0xE7, 0x80,
  0x01, 0xC7, 0x80, 0x03, 0xC3, 0xC0, 0x07, 0x83, 0xC0, 0x07, 0x81, 0xE0,
  0x0F, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0xF8, 0x1C, 0x00, 0x78,
  0x3C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1C,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x70,
  0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x07, 0x01, 0xE0, 0x07, 0x81, 0xC0,
  0x03, 0x83, 0xC0, 0x03, 0xC3, 0x80, 0x01, 0xC7, 0x80, 0x01, 0xE7, 0x80,
  0x00, 0xEF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xB8, 0x00, 0x39, 0xC0, 0x07, 0x9C,
  0x00, 0x70, 0xE0, 0x0F, 0x0E, 0x00, 0xE0, 0xF0, 0x1E, 0x07, 0x01, 0xC0,
  0x78, 0x1C, 0x03, 0x83, 0xC0, 0x38, 0x38, 0x01, 0xC7, 0x80, 0x1C, 0x70,
  0x01, 0xEF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x7C, 0x00, 0x7C, 0x00, 0x3F,
  0xF0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3E, 0x01, 0xE3, 0xC0, 0x0F, 0x38,
  0x00, 0xF4, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x1F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7E, 0x00, 0x77, 0x80, 0x07,
  0x70, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00,
  0xF7, 0x80, 0x1F, 0x7C, 0x03, 0x73, 0xFF, 0xF7, 0x1F, 0xFE, 0x70, 0xFF,
  0x87, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x1E, 0x3F,
  0xE3, 0xDF, 0xFE, 0x7B, 0xDF, 0xEF, 0xC0, 0x3D, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x07,
  0xFF, 0x81, 0xF7, 0xBF, 0xFE, 0xF3, 0xFF, 0x9E, 0x3F, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7C, 0x03, 0xC7, 0x80,
  0x1E, 0x78, 0x01, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0E,
  0x78, 0x01, 0xE7, 0x80, 0x1E, 0x3E, 0x07, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x03, 0xC0,
  0xE1, 0xFF, 0x1C, 0x7F, 0xF3, 0x9F, 0xDF, 0x77, 0xC0, 0x6E, 0xF0, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xF7, 0x80, 0x1E,
  0xF0, 0x07, 0xDF, 0x01, 0xF9, 0xFF, 0xFF, 0x1F, 0xFD, 0xE1, 0xFF, 0x3C,
  0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xCF, 0xC7, 0xC0, 0x3C,
  0xF0, 0x03, 0xDC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x1E, 0xF0, 0x03, 0xCF, 0x00, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xFF,
  0x3C, 0x7F, 0xF7, 0x9F, 0xDF, 0xF7, 0xC0, 0x7E, 0xF0, 0x07, 0xDC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x01, 0x73, 0xE0, 0x6E, 0x7F, 0xFF,
  0xC7, 0xFF, 0x78, 0x3F, 0xCF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x78, 0x1E, 0x7F, 0xE3, 0xDF, 0xFE, 0x7B, 0xCF, 0xEF, 0xC0, 0x3D,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1C, 0x00, 0x20, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x06, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x7C, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x1F,
  0xE0, 0x01, 0xEE, 0x00, 0x3C, 0xE0, 0x07, 0x8E, 0x00, 0x78, 0xE0, 0x0F,
  0x0E, 0x01, 0xE0, 0xE0, 0x3E, 0x0E, 0x03, 0xC0, 0xE0, 0x78, 0x0F, 0xFF,
  0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0E, 0x07, 0x80, 0xE0,
  0x3C, 0x0E, 0x03, 0xE0, 0xE0, 0x1E, 0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x8E,
  0x00, 0x78, 0xE0, 0x03, 0xCE, 0x00, 0x3E, 0xE0, 0x01, 0xEE, 0x00, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFC, 0x03, 0x81, 0xC7, 0x3F, 0x3F, 0xBB, 0xFD, 0xFD, 0xD1, 0xF8,
  0xFF, 0x07, 0x83, 0xF8, 0x38, 0x1F, 0xC1, 0xC0, 0xFE, 0x0E, 0x07, 0xF0,
  0x70, 0x3F, 0x83, 0x81, 0xFC, 0x1C, 0x0F, 0xE0, 0xE0, 0x7F, 0x07, 0x03,
  0xF8, 0x38, 0x1F, 0xC1, 0xC0, 0xFE, 0x0E, 0x07, 0xF0, 0x70, 0x3F, 0x83,
  0x81, 0xFC, 0x1C, 0x0F, 0xE0, 0xE0, 0x7F, 0x07, 0x03, 0xF8, 0x38, 0x1F,
  0xC1, 0xC0, 0xFE, 0x0E, 0x07, 0xF0, 0x70, 0x3F, 0x83, 0x81, 0xC0, 0x00,
  0x78, 0x1E, 0x7F, 0xE3, 0xDF, 0xFE, 0x7B, 0xDF, 0xEF, 0xC0, 0x7D, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1C, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xC0,
  0x7C, 0xF0, 0x07, 0xDE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0xF7, 0x80, 0x1E, 0xF0, 0x07, 0x8F, 0x81, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF,
  0x00, 0xFF, 0x80, 0x00, 0x78, 0x1E, 0x3F, 0xE3, 0xDF, 0xFE, 0x7B, 0xDF,
  0xEF, 0xC0, 0x3D, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0x81, 0xF7, 0xBF, 0xFC,
  0xF3, 0xFF, 0x9E, 0x3F, 0xC3, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x01, 0xFF, 0x3C, 0x7F, 0xF7, 0x9F, 0xDF, 0xF7, 0xC0, 0x7E,
  0xF0, 0x07, 0xDC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xF7,
  0x80, 0x1E, 0xF0, 0x07, 0xDF, 0x81, 0xB9, 0xFF, 0xF7, 0x1F, 0xFC, 0xE1,
  0xFF, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x78, 0x1E,
  0x7F, 0xC3, 0xDF, 0xFE, 0x7B, 0xCF, 0xEF, 0xC0, 0x3D, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7C, 0x03, 0xE7,
  0x80, 0x1E, 0x78, 0x00, 0xF7, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0xF7, 0x80, 0x1E, 0x7C, 0x03, 0xE3, 0xFF, 0xFC, 0x1F,
  0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xC0, 0x07, 0xFE, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3D, 0xC0,
  0x07, 0xBC, 0x00, 0xF7, 0xC0, 0x3C, 0x7C, 0x0F, 0x87, 0xFF, 0xE0, 0x7F,
  0xF8, 0x07, 0xFC, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xE7, 0x00, 0x07,
  0x9E, 0x00, 0x1E, 0x78, 0x00, 0x70, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F,
  0x00, 0x38, 0x1C, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x1C, 0x03, 0x80,
  0xF0, 0x0F, 0x03, 0x80, 0x3C, 0x0E, 0x00, 0x70, 0x78, 0x01, 0xE1, 0xC0,
  0x07, 0x87, 0x00, 0x0E, 0x3C, 0x00, 0x3C, 0xE0, 0x00, 0xF3, 0x80, 0x01,
  0xDE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x0F, 0xE0, 0x3C, 0x0E, 0xF0, 0x7C,
  0x0E, 0x70, 0x7C, 0x0E, 0x70, 0x6E, 0x0E, 0x70, 0x6E, 0x0E, 0x70, 0x66,
  0x1E, 0x70, 0x66, 0x1C, 0x78, 0xE6, 0x1C, 0x38, 0xE6, 0x1C, 0x38, 0xC7,
  0x1C, 0x38, 0xC7, 0x1C, 0x38, 0xC3, 0x18, 0x38, 0xC3, 0x38, 0x39, 0xC3,
  0x38, 0x1D, 0xC3, 0x38, 0x1D, 0x83, 0xB8, 0x1D, 0x83, 0xB8, 0x1D, 0x81,
  0xB0, 0x1D, 0x81, 0xF0, 0x1F, 0x81, 0xF0, 0x1F, 0x81, 0xF0, 0x0F, 0x01,
  0xF0, 0x0F, 0x01, 0xF0, 0xF8, 0x00, 0x79, 0xF0, 0x03, 0xC3, 0xC0, 0x1F,
  0x07, 0x80, 0x78, 0x1F, 0x03, 0xC0, 0x3C, 0x1F, 0x00, 0x78, 0x78, 0x00,
  0xF3, 0xC0, 0x03, 0xCE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xF7, 0x80,
  0x07, 0xCF, 0x00, 0x1E, 0x1E, 0x00, 0xF0, 0x7C, 0x07, 0xC0, 0xF0, 0x1E,
  0x01, 0xE0, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x1E, 0x00, 0x1E, 0xF0, 0x00,
  0x7C, 0xF0, 0x00, 0x3D, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1C,
  0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x1E, 0x07, 0x80, 0x78, 0x1E,
  0x01, 0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xE0, 0x07, 0x87,
  0x80, 0x1E, 0x1E, 0x00, 0x38, 0x70, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00,
  0x07, 0xB8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x39, 0xFE, 0x01, 0xDF,
  0xF8, 0x0E, 0xF3, 0xE0, 0x7F, 0x0F, 0x83, 0xF8, 0x3E, 0x3F, 0xC0, 0xFF,
  0xFE, 0x03, 0xFE, 0xF0, 0x0F, 0xE0,
};

const GFXglyph JetBrainsMono_Light46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 6, 34, 28, 11, -34 },
  { 27, 13, 14, 28, 7, -34 },
  { 50, 24, 34, 28, 2, -34 },
  { 152, 21, 46, 28, 3, -40 },
  { 273, 26, 34, 28, 1, -34 },
  { 384, 23, 34, 28, 3, -34 },
  { 482, 4, 14, 28, 12, -34 },
  { 489, 13, 45, 28, 9, -39 },
  { 563, 14, 45, 28, 5, -39 },
  { 642, 24, 24, 28, 2, -28 },
  { 714, 21, 22, 28, 3, -26 },
  { 772, 9, 14, 28, 8, -7 },
  { 788, 15, 3, 28, 6, -17 },
  { 794, 7, 7, 28, 10, -7 },
  { 801, 20, 43, 28, 4, -38 },
  { 909, 20, 34, 28, 4, -34 },
  { 994, 21, 34, 28, 4, -34 },
  { 1084, 21, 34, 28, 3, -34 },
  { 1174, 20, 34, 28, 3, -34 },
  { 1259, 19, 34, 28, 4, -34 },
  { 1340, 20, 34, 28, 4, -34 },
  { 1425, 21, 34, 28, 3, -34 },
  { 1515, 20, 34, 28, 4, -34 },
  { 1600, 20, 34, 28, 4, -34 },
  { 1685, 21, 34, 28, 3, -34 },
  { 1775, 7, 26, 28, 10, -26 },
  { 1798, 10, 33, 28, 8, -26 },
  { 1840, 20, 24, 28, 4, -27 },
  { 1900, 20, 14, 28, 4, -22 },
  { 1935, 20, 24, 28, 4, -27 },
  { 1995, 16, 34, 28, 7, -34 },
  { 2063, 24, 42, 28, 2, -34 },
  { 2189, 22, 34, 28, 3, -34 },
  { 2283, 19, 34, 28, 5, -34 },
  { 2364, 20, 34, 28, 4, -34 },
  { 2449, 19, 34, 28, 4, -34 },
  { 2530, 19, 34, 28, 5, -34 },
  { 2611, 19, 34, 28, 5, -34 },
  { 2692, 20, 34, 28, 4, -34 },
  { 2777, 18, 34, 28, 5, -34 },
  { 2854, 18, 34, 28, 5, -34 },
  { 2931, 21, 34, 28, 2, -34 },
  { 3021, 22, 34, 28, 4, -34 },
  { 3115, 19, 34, 28, 5, -34 },
  { 3196, 20, 34, 28, 4, -34 },
  { 3281, 19, 34, 28, 4, -34 },
  { 3362, 19, 34, 28, 4, -34 },
  { 3443, 21, 34, 28, 4, -34 },
  { 3533, 20, 42, 28, 4, -34 },
  { 3638, 21, 34, 28, 4, -34 },
  { 3728, 21, 34, 28, 3, -34 },
  { 3818, 22, 34, 28, 3, -34 },
  { 3912, 19, 34, 28, 4, -34 },
  { 3993, 22, 34, 28, 3, -34 },
  { 4087, 25, 34, 28, 1, -34 },
  { 4194, 24, 34, 28, 2, -34 },
  { 4296, 24, 34, 28, 2, -34 },
  { 4398, 20, 34, 28, 4, -34 },
  { 4483, 11, 43, 28, 10, -38 },
  { 4543, 20, 43, 28, 4, -38 },
  { 4651, 11, 43, 28, 7, -38 },
  { 4711, 20, 18, 28, 4, -34 },
  { 4756, 22, 3, 28, 3, 1 },
  { 4765, 9, 6, 28, 9, -36 },
  { 4772, 20, 26, 28, 3, -26 },
  { 4837, 19, 34, 28, 4, -34 },
  { 4918, 20, 26, 28, 4, -26 },
  { 4983, 19, 34, 28, 4, -34 },
  { 5064, 19, 26, 28, 4, -26 },
  { 5126, 21, 34, 28, 3, -34 },
  { 5216, 19, 34, 28, 4, -26 },
  { 5297, 19, 34, 28, 4, -34 },
  { 5378, 21, 36, 28, 4, -36 },
  { 5473, 17, 44, 28, 4, -36 },
  { 5567, 20, 34, 28, 5, -34 },
  { 5652, 23, 34, 28, 2, -34 },
  { 5750, 21, 26, 28, 3, -26 },
  { 5819, 19, 26, 28, 4, -26 },
  { 5881, 19, 26, 28, 4, -26 },
  { 5943, 19, 34, 28, 4, -26 },
  { 6024, 19, 34, 28, 4, -26 },
  { 6105, 19, 26, 28, 5, -26 },
  { 6167, 20, 26, 28, 4, -26 },
  { 6232, 21, 32, 28, 3, -32 },
  { 6316, 19, 25, 28, 4, -25 },
  { 6376, 22, 25, 28, 3, -25 },
  { 6445, 24, 25, 28, 2, -25 },
  { 6520, 22, 25, 28, 3, -25 },
  { 6589, 22, 33, 28, 3, -25 },
  { 6680, 19, 25, 28, 4, -25 },
  { 6740, 20, 43, 28, 4, -38 },
  { 6848, 4, 43, 28, 12, -38 },
  { 6870, 20, 43, 28, 4, -38 },
  { 6978, 21, 9, 28, 3, -21 },
};

const GFXfont JetBrainsMono_Light46pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light46pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light46pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _JETBRAINSMONO_LIGHT46PT7B_H_
