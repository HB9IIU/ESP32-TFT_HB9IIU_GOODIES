#ifndef _JETBRAINSMONO_LIGHT32PT7B_H_
#define _JETBRAINSMONO_LIGHT32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light32pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE3, 0x18, 0xC6, 0x00,
  0x00, 0x67, 0xFD, 0xC0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0x80, 0x03, 0x06, 0x01, 0x83, 0x00, 0xC1, 0x80, 0xC0, 0xC0,
  0x60, 0x60, 0x30, 0x61, 0xFF, 0xFE, 0xFF, 0xFF, 0x0C, 0x0C, 0x06, 0x06,
  0x03, 0x06, 0x01, 0x83, 0x00, 0xC1, 0x80, 0xE0, 0xC0, 0x60, 0x61, 0xFF,
  0xFE, 0xFF, 0xFF, 0x0C, 0x18, 0x06, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x01,
  0x83, 0x00, 0xC1, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x3C, 0x01, 0xFE, 0x0F, 0xFE, 0x1C, 0xCE, 0x71, 0x9C, 0xE3, 0x19, 0xC6,
  0x33, 0x8C, 0x07, 0x18, 0x07, 0x30, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x06, 0xF0, 0x0C, 0xE0, 0x18, 0xE0, 0x31, 0xF8, 0x63, 0xB0,
  0xC7, 0x71, 0x9C, 0xF3, 0x78, 0xFF, 0xE0, 0x7F, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x10, 0x00, 0x5F, 0x80, 0x6F, 0xF0, 0x33, 0x0C,
  0x0C, 0xC3, 0x06, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x60, 0xC3, 0x30,
  0x3F, 0xDC, 0x07, 0xE6, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x63, 0x00,
  0x33, 0xF0, 0x19, 0xCE, 0x06, 0x61, 0x83, 0x18, 0x71, 0x86, 0x1C, 0x61,
  0x87, 0x30, 0x61, 0xD8, 0x18, 0x66, 0x03, 0xFB, 0x00, 0x7C, 0x07, 0x80,
  0x1F, 0xE0, 0x3F, 0xF0, 0x30, 0x70, 0x70, 0x38, 0x70, 0x38, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x77, 0x07,
  0xE3, 0x06, 0xC3, 0x8E, 0xC1, 0xCC, 0xC0, 0xFC, 0xC0, 0xF8, 0xC0, 0x70,
  0xC0, 0x78, 0xE0, 0x7C, 0xF1, 0xFC, 0x7F, 0xCE, 0x3F, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xC0, 0xF0, 0x7C, 0x78, 0x1C, 0x0E, 0x07, 0x01, 0xC0,
  0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x78, 0x07, 0xC0, 0xF0, 0x0C, 0x80, 0x70, 0x3E, 0x07, 0x81, 0xE0, 0x70,
  0x1C, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x07, 0x87,
  0x8F, 0x87, 0x02, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x02, 0x0E, 0x09, 0xE3, 0x3F, 0xFD, 0x7F, 0x1F, 0xFC, 0x00,
  0xE0, 0x00, 0x58, 0x00, 0x6E, 0x00, 0x73, 0x00, 0x71, 0xC0, 0x70, 0x70,
  0x38, 0x3C, 0x08, 0x08, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1E, 0x38,
  0xF1, 0xC3, 0x87, 0x1C, 0x38, 0x61, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x77, 0xFF, 0xF7, 0x80, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00,
  0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x07,
  0x80, 0xFF, 0x87, 0xFF, 0x1C, 0x1E, 0xE0, 0x3B, 0x00, 0x6C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x21, 0xF1, 0xC7, 0xC7, 0x1F, 0x1C, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xB8, 0x06, 0xE0, 0x39,
  0xC1, 0xC3, 0xFF, 0x07, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xB8, 0x3C, 0xE0,
  0xE3, 0x82, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x80,
  0x3F, 0xE0, 0xFF, 0xE3, 0xC1, 0xE7, 0x01, 0xCC, 0x01, 0xB8, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFD, 0xFF, 0xF0, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x80, 0x1F,
  0xC0, 0x1F, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00,
  0x0F, 0x80, 0x36, 0x01, 0xDC, 0x07, 0x78, 0x38, 0xFF, 0xC0, 0xFE, 0x00,
  0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x0E, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xEF, 0xE7, 0xFF, 0xBC, 0x1F, 0xC0, 0x7E, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xF0, 0x07, 0xC0, 0x77, 0x07,
  0x1F, 0xF8, 0x7F, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x7F, 0xE0, 0xFF,
  0xE3, 0xC1, 0xE7, 0x01, 0xCC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1D, 0x80, 0x33, 0x80, 0xE3, 0x83, 0xC3, 0xFF, 0x03, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x3B, 0x00, 0xE0, 0x03,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E,
  0x00, 0x30, 0x01, 0xC0, 0x00, 0x07, 0x80, 0xFF, 0x87, 0xFF, 0x1C, 0x1E,
  0xE0, 0x3B, 0x80, 0x6E, 0x01, 0xB8, 0x0E, 0x60, 0x39, 0xC1, 0xC3, 0xDE,
  0x03, 0xE0, 0x1F, 0xC0, 0xE3, 0x87, 0x07, 0x38, 0x0E, 0xC0, 0x1B, 0x00,
  0x7C, 0x01, 0xF0, 0x06, 0xE0, 0x39, 0xC1, 0xE7, 0xFF, 0x07, 0xF0, 0x03,
  0x80, 0x3F, 0xE0, 0xFF, 0xE3, 0xC1, 0xE7, 0x01, 0xCC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1D, 0x80, 0x3B, 0x80, 0xE3, 0xC3, 0xC7,
  0xFB, 0x03, 0xEE, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x77, 0xFF, 0xF7, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFB, 0xC0, 0x39, 0xF7, 0xDF, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF3, 0x8E, 0x79, 0xC7, 0x38, 0xE3,
  0x8C, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x1E, 0x00, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x80, 0x07, 0x00,
  0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x08,
  0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x18, 0x00, 0x80,
  0x00, 0xFE, 0x1F, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x38, 0x1E, 0x1F, 0xC3, 0xE0, 0x70, 0x0E, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x07, 0x80, 0xF8, 0x1E, 0x00, 0x03, 0xC0, 0x1F,
  0xF8, 0x3E, 0x3C, 0x70, 0x0E, 0x60, 0x06, 0xE0, 0x06, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x27, 0xC1, 0xFB, 0xC3, 0xCB, 0xC3, 0x07, 0xC3, 0x07, 0xC3,
  0x07, 0xC3, 0x07, 0xC3, 0x07, 0xC3, 0x07, 0xC3, 0x07, 0xC3, 0x07, 0xC3,
  0x87, 0xC3, 0xFB, 0xC1, 0xF3, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x78, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x1B, 0x00, 0x36, 0x00, 0x6E, 0x01, 0xDC, 0x03, 0x98, 0x06, 0x30,
  0x0C, 0x70, 0x38, 0xE0, 0x70, 0xC0, 0xC1, 0x81, 0x83, 0x87, 0x07, 0x0F,
  0xFE, 0x1F, 0xFC, 0x7F, 0xFC, 0xE0, 0x39, 0x80, 0x33, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF0, 0x01, 0x80, 0xFF, 0xC3, 0xFF, 0xCE, 0x07, 0x38, 0x0E,
  0xE0, 0x1B, 0x80, 0x6E, 0x01, 0xB8, 0x0E, 0xE0, 0x3B, 0x83, 0xCF, 0xFC,
  0x3F, 0xF8, 0xE0, 0x7B, 0x80, 0xEE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x0E, 0xE0, 0xFB, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0x80,
  0x7F, 0x87, 0xFF, 0x1C, 0x0E, 0xE0, 0x3B, 0x80, 0x6E, 0x01, 0xF8, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x01, 0xB8, 0x06, 0xE0, 0x39, 0xC1,
  0xC3, 0xFF, 0x07, 0xF0, 0xFF, 0xC7, 0xFF, 0x38, 0x3D, 0xC0, 0x7E, 0x03,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0,
  0xEE, 0x1F, 0x7F, 0xF3, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F,
  0xFF, 0x3F, 0xFC, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xBF, 0xFE, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x7F, 0x87, 0xFF, 0x1C, 0x0E, 0xE0,
  0x3B, 0x80, 0x6E, 0x01, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xB8, 0x06, 0xE0, 0x39, 0xC1, 0xC3, 0xFF, 0x07, 0xF0, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x60,
  0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xB8,
  0x0E, 0x70, 0x78, 0xFF, 0xC1, 0xFC, 0x00, 0xE0, 0x1D, 0xC0, 0x3B, 0x80,
  0xE7, 0x01, 0x8E, 0x07, 0x1C, 0x0C, 0x38, 0x38, 0x70, 0x60, 0xE1, 0xC1,
  0xC3, 0x03, 0xFE, 0x07, 0xFC, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x70,
  0x70, 0xE0, 0x71, 0xC0, 0xE3, 0x80, 0xE7, 0x01, 0xCE, 0x01, 0xDC, 0x03,
  0xB8, 0x03, 0x80, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xE0, 0x3E, 0xC0, 0xFB, 0x06, 0xFC, 0x1B,
  0xD8, 0x6F, 0x63, 0x3D, 0x8D, 0xF3, 0x37, 0xCD, 0x9F, 0x36, 0x7C, 0x79,
  0xF1, 0xC7, 0xC7, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xC0, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xB0, 0x3D, 0x81, 0xEE, 0x0F, 0x30, 0x79, 0x83, 0xCE,
  0x1F, 0x30, 0xF9, 0x87, 0xC6, 0x3E, 0x31, 0xF1, 0xCF, 0x86, 0x7C, 0x33,
  0xE1, 0xDF, 0x06, 0xF8, 0x37, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xE0,
  0x07, 0x01, 0xFF, 0x1F, 0xFC, 0xE0, 0xEE, 0x03, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xB8, 0x38,
  0xFF, 0xC3, 0xF8, 0xFF, 0xE3, 0xFF, 0xEE, 0x03, 0xB8, 0x07, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x07, 0xBF, 0xFC,
  0xFF, 0xE3, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xFF, 0x87,
  0xFF, 0x1C, 0x1E, 0xE0, 0x3B, 0x80, 0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x1B,
  0x00, 0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x06,
  0xC0, 0x1B, 0x00, 0x6C, 0x01, 0xB8, 0x06, 0xE0, 0x39, 0xC1, 0xC3, 0xFF,
  0x07, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0xFF, 0xE3, 0xFF, 0xCE, 0x07, 0xB8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xEE, 0x0F, 0xBF, 0xFC, 0xFF, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x38, 0xE0, 0xE3, 0x81, 0xCE, 0x07, 0x38, 0x0E,
  0xE0, 0x3B, 0x80, 0x7E, 0x01, 0xC0, 0x03, 0x80, 0x3F, 0xE0, 0xFF, 0xE1,
  0xC0, 0xE7, 0x01, 0xCE, 0x01, 0x9C, 0x03, 0x38, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1F, 0x80, 0x3B, 0x00, 0x77, 0x01, 0xCF, 0x07, 0x8F,
  0xFE, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x77, 0x07, 0x1F, 0xF8, 0x7F,
  0x00, 0xE0, 0x07, 0xC0, 0x1D, 0x80, 0x3B, 0x00, 0x67, 0x00, 0xCE, 0x03,
  0x8C, 0x07, 0x18, 0x0C, 0x38, 0x18, 0x70, 0x70, 0x60, 0xE0, 0xC1, 0x81,
  0xC3, 0x03, 0x8E, 0x03, 0x1C, 0x06, 0x30, 0x0E, 0x60, 0x1D, 0xC0, 0x1B,
  0x80, 0x36, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0xC1, 0xC1, 0xF0,
  0xE0, 0xF8, 0x70, 0x7C, 0x2C, 0x3E, 0x16, 0x3B, 0x0B, 0x1D, 0x8D, 0x8C,
  0xC6, 0xC6, 0x63, 0x63, 0x31, 0x91, 0x9C, 0xC8, 0xCE, 0x44, 0x67, 0x23,
  0x31, 0xB1, 0xB8, 0xD8, 0xDC, 0x6C, 0x6C, 0x36, 0x36, 0x1B, 0x0B, 0x0D,
  0x85, 0x86, 0x82, 0xC3, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x70, 0x07,
  0x1C, 0x03, 0x0E, 0x03, 0x83, 0x81, 0x80, 0xC1, 0xC0, 0x71, 0xC0, 0x18,
  0xE0, 0x0E, 0xE0, 0x03, 0x60, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x3E, 0x00, 0x1B, 0x80, 0x1D, 0xC0, 0x0C, 0x70, 0x0E, 0x38, 0x0E, 0x0E,
  0x07, 0x07, 0x07, 0x01, 0xC3, 0x80, 0x63, 0x80, 0x3B, 0x80, 0x0E, 0xE0,
  0x03, 0xB8, 0x03, 0x8C, 0x01, 0xC7, 0x01, 0xC1, 0x80, 0xE0, 0xE0, 0xE0,
  0x30, 0x70, 0x1C, 0x30, 0x06, 0x38, 0x03, 0x98, 0x00, 0xDC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x80,
  0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0F, 0xFF, 0xFF, 0x80, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x3C, 0x03,
  0x60, 0x1B, 0x81, 0xCC, 0x0C, 0x60, 0xE1, 0x86, 0x0C, 0x70, 0x33, 0x01,
  0xB8, 0x0F, 0x80, 0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x07,
  0xC0, 0x7F, 0xC3, 0xC7, 0x8C, 0x07, 0x70, 0x1C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x1F, 0xFC, 0xFF, 0xF7, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E,
  0x01, 0xDC, 0x0B, 0x7F, 0xEC, 0x7F, 0x30, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x73, 0xE3, 0xBF, 0x9F, 0x1E, 0xF0, 0x3F, 0x01, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0x7F, 0x07, 0x7F, 0xFB, 0xBF, 0x80, 0x0F, 0x81, 0xFF,
  0x1F, 0x3C, 0xE0, 0x7E, 0x01, 0xF0, 0x0F, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x01, 0xF0, 0x0F, 0x80, 0xEE, 0x0F, 0x3F,
  0xF0, 0xFE, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x8F,
  0x8C, 0xFE, 0x6F, 0x1B, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF8, 0x0F, 0xC0, 0x77,
  0x05, 0xBF, 0xEC, 0x7E, 0x60, 0x0F, 0x81, 0xFF, 0x1E, 0x3C, 0xC0, 0x7E,
  0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80,
  0x0C, 0x00, 0x70, 0x03, 0x80, 0xEE, 0x0F, 0x3F, 0xF0, 0xFE, 0x00, 0x01,
  0xFE, 0x07, 0xFC, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x1F, 0x19, 0xFE, 0xDE, 0x37,
  0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x7E, 0x03, 0xB8, 0x3D, 0xF7, 0x67, 0xF3, 0x0F, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x70, 0x03, 0x9F, 0xF8, 0xFF, 0xC7, 0xF0, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x73, 0xE3, 0xBF, 0x9F, 0x1E, 0xF0,
  0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x60,
  0x03, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0xE0, 0x1E, 0x01, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x7F,
  0xE7, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0xFF, 0x8F, 0xF0, 0xFC, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x03, 0xF8, 0x07, 0x70,
  0x1C, 0xE0, 0x71, 0xC0, 0xE3, 0x83, 0x87, 0x0E, 0x0E, 0x1C, 0x1F, 0xF0,
  0x3F, 0xE0, 0x70, 0xE0, 0xE1, 0xC1, 0xC1, 0xC3, 0x81, 0xC7, 0x03, 0x8E,
  0x03, 0x9C, 0x03, 0xB8, 0x07, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0xFC, 0x01, 0xFE, 0xCE, 0x39, 0xBE, 0xFB, 0x8D,
  0x3F, 0x1C, 0x7E, 0x18, 0x7C, 0x30, 0xF8, 0x61, 0xF0, 0xC3, 0xE1, 0x87,
  0xC3, 0x0F, 0x86, 0x1F, 0x0C, 0x3E, 0x18, 0x7C, 0x30, 0xF8, 0x61, 0xF0,
  0xC3, 0xE1, 0x87, 0xC3, 0x0C, 0xE7, 0xC7, 0x7F, 0x3E, 0x3D, 0xE0, 0x7E,
  0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xC0, 0x0F,
  0x81, 0xFF, 0x1F, 0x7C, 0xE0, 0x7E, 0x03, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x1F, 0x80, 0xEE,
  0x0E, 0x3F, 0xF0, 0xFE, 0x00, 0xE7, 0xC7, 0x7F, 0x3E, 0x3D, 0xE0, 0x7E,
  0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFE, 0x0E, 0xFF, 0xF7, 0x7F, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x1F, 0x19, 0xFE, 0xDE,
  0x37, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xEE, 0x0B, 0x7F, 0xD8,
  0xFC, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xC7,
  0x86, 0xFF, 0x36, 0x3D, 0xC0, 0xEE, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0x8F, 0x98, 0x0E,
  0xE0, 0x1B, 0x80, 0x0E, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x0F,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x7E, 0x01, 0xBC, 0x0E, 0x7F, 0xF0, 0xFF,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1D, 0x80, 0xEE, 0x0E, 0x3F,
  0xE0, 0xFE, 0x00, 0xE0, 0x07, 0xC0, 0x1D, 0x80, 0x3B, 0x80, 0x67, 0x01,
  0xC6, 0x03, 0x8E, 0x06, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x60, 0x71, 0xC0,
  0x63, 0x80, 0xE6, 0x01, 0xDC, 0x01, 0xB0, 0x03, 0x60, 0x07, 0xC0, 0x07,
  0x00, 0xE1, 0xC1, 0xF0, 0xE0, 0xD8, 0x70, 0xEC, 0x28, 0x66, 0x16, 0x33,
  0x0B, 0x19, 0x8D, 0x8C, 0xE6, 0xC6, 0x33, 0x23, 0x19, 0x13, 0x0C, 0x8D,
  0x86, 0x46, 0xC3, 0x63, 0x61, 0xB1, 0xB0, 0x78, 0x58, 0x38, 0x38, 0x1C,
  0x1C, 0x0E, 0x0E, 0x00, 0xE0, 0x0E, 0xE0, 0x38, 0xE0, 0x71, 0xC1, 0xC1,
  0xC7, 0x01, 0xCE, 0x03, 0xB8, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0x77, 0x00, 0xC7, 0x03, 0x8E, 0x0E, 0x0E, 0x18, 0x0E, 0x70, 0x1D,
  0xC0, 0x1C, 0xE0, 0x0F, 0xC0, 0x1D, 0xC0, 0x33, 0x80, 0xE3, 0x01, 0xC7,
  0x03, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x30, 0x18, 0xE0, 0x39, 0xC0, 0x73,
  0x00, 0x6E, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x18, 0x07, 0xC0, 0x7E, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0xC3, 0xFC, 0x1F, 0x80, 0xFF, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x07, 0xC0, 0x3F,
  0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1F, 0xE0, 0x3F, 0x07, 0xF8,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x0F, 0xC0, 0x7C, 0x03, 0x00, 0x00, 0x7E,
  0x06, 0xFE, 0x0F, 0x8E, 0x3F, 0x0E, 0x7E, 0x0F, 0xDC, 0x0F, 0x00,
};

const GFXglyph JetBrainsMono_Light32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 23, 19, 7, -23 },
  { 16, 9, 9, 19, 5, -23 },
  { 27, 17, 23, 19, 1, -23 },
  { 76, 15, 32, 19, 2, -28 },
  { 136, 18, 24, 19, 1, -24 },
  { 190, 16, 24, 19, 2, -24 },
  { 238, 3, 9, 19, 8, -23 },
  { 242, 10, 31, 19, 6, -27 },
  { 281, 9, 31, 19, 4, -27 },
  { 316, 17, 17, 19, 1, -20 },
  { 353, 15, 15, 19, 2, -18 },
  { 382, 7, 10, 19, 5, -5 },
  { 391, 11, 3, 19, 4, -12 },
  { 396, 5, 5, 19, 7, -5 },
  { 400, 14, 31, 19, 3, -27 },
  { 455, 14, 24, 19, 3, -24 },
  { 497, 14, 23, 19, 3, -23 },
  { 538, 15, 24, 19, 2, -24 },
  { 583, 14, 23, 19, 2, -23 },
  { 624, 13, 23, 19, 3, -23 },
  { 662, 13, 23, 19, 3, -23 },
  { 700, 15, 23, 19, 2, -23 },
  { 744, 14, 23, 19, 3, -23 },
  { 785, 14, 24, 19, 3, -24 },
  { 827, 15, 24, 19, 2, -24 },
  { 872, 5, 18, 19, 7, -18 },
  { 884, 6, 23, 19, 6, -18 },
  { 902, 13, 17, 19, 3, -19 },
  { 930, 13, 9, 19, 3, -15 },
  { 945, 13, 17, 19, 3, -19 },
  { 973, 11, 23, 19, 5, -23 },
  { 1005, 16, 30, 19, 2, -24 },
  { 1065, 15, 23, 19, 2, -23 },
  { 1109, 14, 23, 19, 3, -23 },
  { 1150, 14, 24, 19, 3, -24 },
  { 1192, 13, 23, 19, 3, -23 },
  { 1230, 14, 23, 19, 3, -23 },
  { 1271, 14, 23, 19, 3, -23 },
  { 1312, 14, 24, 19, 3, -24 },
  { 1354, 13, 23, 19, 3, -23 },
  { 1392, 13, 23, 19, 3, -23 },
  { 1430, 14, 23, 19, 2, -23 },
  { 1471, 15, 23, 19, 3, -23 },
  { 1515, 13, 23, 19, 4, -23 },
  { 1553, 14, 23, 19, 3, -23 },
  { 1594, 13, 23, 19, 3, -23 },
  { 1632, 13, 24, 19, 3, -24 },
  { 1671, 14, 23, 19, 3, -23 },
  { 1712, 14, 30, 19, 3, -24 },
  { 1765, 14, 23, 19, 3, -23 },
  { 1806, 15, 24, 19, 2, -24 },
  { 1851, 15, 23, 19, 2, -23 },
  { 1895, 13, 23, 19, 3, -23 },
  { 1933, 15, 23, 19, 2, -23 },
  { 1977, 17, 23, 19, 1, -23 },
  { 2026, 17, 23, 19, 1, -23 },
  { 2075, 17, 23, 19, 1, -23 },
  { 2124, 13, 23, 19, 3, -23 },
  { 2162, 7, 31, 19, 7, -27 },
  { 2190, 14, 31, 19, 3, -27 },
  { 2245, 8, 31, 19, 5, -27 },
  { 2276, 13, 12, 19, 3, -23 },
  { 2296, 15, 2, 19, 2, 1 },
  { 2300, 6, 4, 19, 6, -25 },
  { 2303, 14, 18, 19, 2, -18 },
  { 2335, 13, 23, 19, 3, -23 },
  { 2373, 13, 18, 19, 3, -18 },
  { 2403, 13, 23, 19, 3, -23 },
  { 2441, 13, 18, 19, 3, -18 },
  { 2471, 15, 23, 19, 2, -23 },
  { 2515, 13, 24, 19, 3, -18 },
  { 2554, 13, 23, 19, 3, -23 },
  { 2592, 15, 25, 19, 3, -25 },
  { 2639, 12, 31, 19, 3, -25 },
  { 2686, 15, 23, 19, 3, -23 },
  { 2730, 17, 23, 19, 1, -23 },
  { 2779, 15, 18, 19, 2, -18 },
  { 2813, 13, 18, 19, 3, -18 },
  { 2843, 13, 18, 19, 3, -18 },
  { 2873, 13, 24, 19, 3, -18 },
  { 2912, 13, 24, 19, 3, -18 },
  { 2951, 13, 18, 19, 4, -18 },
  { 2981, 14, 18, 19, 3, -18 },
  { 3013, 15, 23, 19, 2, -23 },
  { 3057, 13, 18, 19, 3, -18 },
  { 3087, 15, 18, 19, 2, -18 },
  { 3121, 17, 18, 19, 1, -18 },
  { 3160, 15, 18, 19, 2, -18 },
  { 3194, 15, 24, 19, 2, -18 },
  { 3239, 13, 18, 19, 3, -18 },
  { 3269, 13, 31, 19, 3, -27 },
  { 3320, 3, 31, 19, 8, -27 },
  { 3332, 13, 31, 19, 3, -27 },
  { 3383, 15, 6, 19, 2, -14 },
};

const GFXfont JetBrainsMono_Light32pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light32pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _JETBRAINSMONO_LIGHT32PT7B_H_
