#ifndef _JETBRAINSMONO_LIGHT59PT7B_H_
#define _JETBRAINSMONO_LIGHT59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light59pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xF7, 0x80, 0xFB,
  0xC0, 0x7D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x70, 0x03, 0xC0, 0x01,
  0xE0, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0,
  0x03, 0xC0, 0x01, 0xE0, 0x07, 0x00, 0x03, 0xC0, 0x1E, 0x03, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x01,
  0xC0, 0x00, 0xF0, 0x03, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0x80, 0x1E,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x70, 0x0F,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x03,
  0xC0, 0x0F, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0,
  0x07, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x81, 0xFC, 0xF3, 0xF8, 0x3E, 0x1E, 0x1F, 0x0F, 0x83, 0xC1,
  0xF1, 0xF0, 0x78, 0x3E, 0x3C, 0x0F, 0x07, 0xC7, 0x81, 0xE0, 0x78, 0xF0,
  0x3C, 0x0F, 0x1E, 0x07, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x1E, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x1F, 0x8F, 0x00, 0x01, 0xFD,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0x7F, 0x80, 0x01, 0xE3, 0xF0, 0x00, 0x3C, 0x3F, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0xF0, 0x7E, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xC0, 0xF8, 0x00, 0x78,
  0x1F, 0xF8, 0x0F, 0x03, 0xEF, 0x01, 0xE0, 0x7D, 0xF0, 0x3C, 0x0F, 0xBE,
  0x07, 0x81, 0xF7, 0xE0, 0xF0, 0x7C, 0x7E, 0x1E, 0x1F, 0x8F, 0xE3, 0xCF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x8F, 0xFE,
  0x00, 0x07, 0x8F, 0xFF, 0x80, 0x03, 0xCF, 0x87, 0xC0, 0x03, 0xC7, 0x81,
  0xF0, 0x03, 0xC7, 0x80, 0x78, 0x01, 0xE3, 0xC0, 0x3C, 0x01, 0xE1, 0xE0,
  0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x80, 0xF0, 0x3C,
  0x03, 0xC0, 0xF0, 0x1E, 0x01, 0xE0, 0x78, 0x0F, 0x00, 0xF0, 0x78, 0x07,
  0x80, 0x78, 0x78, 0x01, 0xE0, 0x7C, 0x38, 0x00, 0xF8, 0x7C, 0x3C, 0x00,
  0x3F, 0xFE, 0x3C, 0x00, 0x0F, 0xFE, 0x3C, 0x00, 0x03, 0xFC, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x87,
  0xF8, 0x00, 0x07, 0x8F, 0xFF, 0x00, 0x07, 0x87, 0xFF, 0xC0, 0x03, 0xC7,
  0xC3, 0xE0, 0x03, 0xC3, 0xC0, 0xF8, 0x03, 0xC3, 0xC0, 0x3C, 0x01, 0xC1,
  0xE0, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xE0,
  0x3C, 0x03, 0xC0, 0xF0, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0xF0,
  0x07, 0x80, 0x78, 0x78, 0x03, 0xC0, 0x3C, 0x78, 0x00, 0xF0, 0x3E, 0x78,
  0x00, 0x7E, 0x7E, 0x3C, 0x00, 0x1F, 0xFF, 0x3C, 0x00, 0x07, 0xFF, 0x3C,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x3F,
  0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x1F, 0x7C, 0x1F,
  0x00, 0xF9, 0xE0, 0x3E, 0x03, 0xCF, 0x80, 0xFC, 0x1F, 0x3E, 0x01, 0xF0,
  0xF8, 0xF8, 0x03, 0xE3, 0xE3, 0xE0, 0x07, 0xDF, 0x0F, 0x80, 0x1F, 0x7C,
  0x3E, 0x00, 0x3F, 0xE0, 0xF8, 0x00, 0x7F, 0x83, 0xE0, 0x01, 0xFC, 0x0F,
  0x80, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7F, 0x81, 0xF0,
  0x01, 0xFF, 0x07, 0xC0, 0x0F, 0xFC, 0x1F, 0x80, 0xFC, 0xF8, 0x3F, 0xFF,
  0xE1, 0xF0, 0x7F, 0xFF, 0x07, 0xE0, 0xFF, 0xF8, 0x0F, 0x81, 0xFF, 0x80,
  0x1F, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x40, 0x00, 0xF0, 0x00, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xF0, 0x01, 0xE0,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x40,
  0x03, 0xC0, 0x04, 0xF0, 0x07, 0x80, 0x39, 0xF8, 0x0F, 0x03, 0xF3, 0xFE,
  0x1C, 0x1F, 0xFF, 0xFE, 0x38, 0xFF, 0xE7, 0xFF, 0x77, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x03, 0xE7,
  0x80, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x7C, 0x1F,
  0x80, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF0, 0xFE,
  0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0,
  0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x7F, 0x04, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x1F, 0xF7, 0xFE, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xF0, 0x00,
  0x7E, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7B, 0xE0,
  0x00, 0x1E, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x78, 0x1F, 0xF8, 0x3F, 0x07, 0xFE, 0x1F, 0xC1, 0xFF, 0x87,
  0xF0, 0x7F, 0xE1, 0xFC, 0x1F, 0xF8, 0x3E, 0x07, 0xFE, 0x07, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xBE, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F,
  0x00, 0x07, 0xC7, 0xE0, 0x03, 0xF0, 0xFE, 0x01, 0xF8, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xFE, 0xF8, 0x00, 0x3F, 0x9F, 0x00, 0x0F, 0xE3,
  0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x01, 0xF0, 0x01,
  0x80, 0x3E, 0x00, 0x20, 0x07, 0xC0, 0x08, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xBF, 0xF0, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0x07, 0xE1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0xF9, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x79, 0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0x8F, 0xC0, 0x07,
  0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x0F, 0x0F, 0x80, 0x0F, 0x1F, 0x80, 0x0F, 0x1F,
  0x00, 0x0F, 0x3F, 0x00, 0x0F, 0x7E, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x7F, 0xC0, 0x7C, 0xFF, 0xF8, 0x3E, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xF0, 0x1F, 0xC7, 0xF0, 0x03, 0xF3, 0xF0,
  0x00, 0xF9, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xF7, 0xC0, 0x01,
  0xF3, 0xF0, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC1, 0x00, 0x01, 0xF3, 0xFF, 0x00,
  0x7D, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0x1F, 0xF0, 0x7F, 0x00,
  0x7F, 0x0F, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0x3E, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x07, 0xF0, 0x0F, 0xE0, 0x7F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03,
  0xCF, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0x03, 0xF1, 0xF0,
  0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xE7, 0x80, 0x00, 0xF9,
  0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xC7, 0xC0, 0x01,
  0xF0, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x3E, 0x07, 0xE0, 0x1F, 0x00, 0xFC,
  0x1F, 0x80, 0x1F, 0xDF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xE3, 0xF8, 0x07, 0xE0, 0x3F,
  0x03, 0xF0, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3E, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xBE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x0F,
  0x9F, 0x00, 0x03, 0xE7, 0xE0, 0x01, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00,
  0x2C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x7F, 0x0F,
  0xC0, 0x07, 0xE1, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x79, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xE0, 0x0F, 0xE0, 0xFF, 0xCF, 0xFC,
  0x0F, 0xFF, 0xEF, 0x80, 0xFF, 0xFB, 0xE0, 0x07, 0xFC, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x3F, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x7F, 0x0C, 0x00, 0x07,
  0xC0, 0x7F, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x8F, 0xF8, 0x7F, 0xC1, 0xFC,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1E,
  0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF,
  0x80, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x0C, 0x0F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xFE, 0xFF, 0x00,
  0x7F, 0xFB, 0xFC, 0x03, 0xF0, 0x7F, 0xF0, 0x0F, 0x00, 0x7F, 0xC0, 0x7C,
  0x01, 0xFF, 0x01, 0xF0, 0x07, 0xFC, 0x07, 0xC0, 0x0F, 0xF0, 0x1E, 0x00,
  0x3F, 0xC0, 0x78, 0x00, 0xFF, 0x01, 0xE0, 0x03, 0xFC, 0x07, 0x80, 0x0F,
  0xF0, 0x1E, 0x00, 0x3F, 0xC0, 0x78, 0x00, 0xFF, 0x01, 0xE0, 0x03, 0xFC,
  0x07, 0x80, 0x0F, 0xF0, 0x1E, 0x00, 0x7F, 0xC0, 0x7C, 0x01, 0xFF, 0x01,
  0xF0, 0x07, 0xFC, 0x03, 0xC0, 0x1F, 0xF0, 0x0F, 0x80, 0xFF, 0xC0, 0x1F,
  0xFE, 0xFF, 0x00, 0x7F, 0xFB, 0xFC, 0x00, 0xFF, 0xCF, 0xF0, 0x00, 0x78,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x07, 0xBE, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0xF1,
  0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xF0,
  0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x78, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x01, 0xE0, 0x01, 0xE0,
  0x0F, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0x7C, 0x01, 0xE0, 0x03, 0xE0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xE0,
  0x00, 0xF8, 0x1F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0xF8, 0x7C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0x00, 0x3F, 0xC7, 0x80, 0x03,
  0xF3, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x7E, 0xF0, 0x00, 0x1F, 0x78, 0x00,
  0x0F, 0xBC, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0xFB, 0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x7E, 0x78,
  0x00, 0x7E, 0x3C, 0x01, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF1, 0xE0, 0x01, 0xFC, 0xF0, 0x00, 0x3E,
  0x78, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xEF, 0x00,
  0x03, 0xF7, 0x80, 0x03, 0xF3, 0xC0, 0x0F, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE1, 0xFC, 0x03, 0xF8, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0x7C, 0x00,
  0x0F, 0xBE, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x80,
  0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xFC, 0x7F,
  0x00, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xF0, 0x07, 0xF8, 0xF0, 0x00, 0xFC,
  0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xFC,
  0xF0, 0x07, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF1, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE1, 0xFC, 0x03, 0xF8, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0x7C, 0x00,
  0x0F, 0xBE, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x80,
  0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xFC, 0x7F,
  0x00, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7D, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xE3, 0xF8,
  0x07, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x01,
  0xF3, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xF1, 0xE0,
  0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x7C,
  0x1E, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x0F, 0x00,
  0x1F, 0x01, 0xE0, 0x07, 0xC0, 0x3C, 0x00, 0xF8, 0x07, 0x80, 0x3E, 0x00,
  0xF0, 0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x03, 0xC0, 0x3E, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0x80, 0x7C, 0x00, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F,
  0x80, 0x78, 0x01, 0xF0, 0x0F, 0x00, 0x3F, 0x01, 0xE0, 0x03, 0xE0, 0x3C,
  0x00, 0x7E, 0x07, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0xFC, 0x1E, 0x00, 0x0F,
  0x83, 0xC0, 0x01, 0xF8, 0x78, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xF1, 0xE0,
  0x00, 0x3E, 0x3C, 0x00, 0x07, 0xE7, 0x80, 0x00, 0x7C, 0xF0, 0x00, 0x0F,
  0xDE, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xEF, 0x00, 0x3F, 0xFB, 0xC0, 0x0E,
  0xFE, 0xF0, 0x07, 0xBF, 0x9E, 0x01, 0xEF, 0xF7, 0x80, 0x73, 0xFD, 0xE0,
  0x3C, 0xFF, 0x3C, 0x0F, 0x3F, 0xCF, 0x03, 0x8F, 0xF3, 0xC1, 0xE3, 0xFC,
  0x78, 0x78, 0xFF, 0x1E, 0x1C, 0x7F, 0xC7, 0x8F, 0x1F, 0xF0, 0xF3, 0xC7,
  0xFC, 0x3C, 0xE1, 0xFF, 0x0F, 0x78, 0x7F, 0xC1, 0xDE, 0x1F, 0xF0, 0x7F,
  0x07, 0xFC, 0x1F, 0xC1, 0xFF, 0x03, 0xF0, 0x7F, 0xC0, 0xF8, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xF7, 0x80,
  0x1F, 0xF7, 0x80, 0x1F, 0xF7, 0x80, 0x1F, 0xF3, 0xC0, 0x1F, 0xF3, 0xC0,
  0x1F, 0xF3, 0xC0, 0x1F, 0xF1, 0xE0, 0x1F, 0xF1, 0xE0, 0x1F, 0xF1, 0xF0,
  0x1F, 0xF0, 0xF0, 0x1F, 0xF0, 0xF0, 0x1F, 0xF0, 0x78, 0x1F, 0xF0, 0x78,
  0x1F, 0xF0, 0x78, 0x1F, 0xF0, 0x3C, 0x1F, 0xF0, 0x3C, 0x1F, 0xF0, 0x3E,
  0x1F, 0xF0, 0x1E, 0x1F, 0xF0, 0x1E, 0x1F, 0xF0, 0x1F, 0x1F, 0xF0, 0x0F,
  0x1F, 0xF0, 0x0F, 0x1F, 0xF0, 0x07, 0x9F, 0xF0, 0x07, 0x9F, 0xF0, 0x07,
  0x9F, 0xF0, 0x03, 0xDF, 0xF0, 0x03, 0xDF, 0xF0, 0x03, 0xEF, 0xF0, 0x01,
  0xEF, 0xF0, 0x01, 0xEF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x00, 0x3C,
  0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC1, 0xFC, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x7C,
  0x00, 0x1F, 0x3E, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xEF,
  0x80, 0x01, 0xF7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0xFC,
  0x7F, 0x00, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0xFF, 0x3C,
  0x00, 0x0F, 0xCF, 0x00, 0x01, 0xFB, 0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xFB, 0xC0, 0x00, 0xFC,
  0xF0, 0x01, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xE0, 0x1F, 0x87, 0xE0,
  0x03, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xBE, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xBE,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07,
  0xBE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xF8, 0x00,
  0x07, 0xBE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xF8,
  0x00, 0x07, 0xBE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E,
  0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xC3, 0xE0, 0x03, 0xF0, 0xFE, 0x01,
  0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0xF0, 0x01, 0xFE, 0x3C, 0x00, 0x1F, 0xCF, 0x00, 0x01,
  0xF3, 0xC0, 0x00, 0x7E, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0xFB, 0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x07,
  0xCF, 0x00, 0x03, 0xF3, 0xC0, 0x03, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x80, 0x3C,
  0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xC0, 0x1F, 0x00, 0xF0, 0x03, 0xE0,
  0x3C, 0x00, 0xF8, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0xC0, 0xF0, 0x00,
  0xF8, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0xC3, 0xC0, 0x01, 0xF0, 0xF0,
  0x00, 0x7E, 0x3C, 0x00, 0x0F, 0x8F, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x7C,
  0xF0, 0x00, 0x1F, 0xBC, 0x00, 0x03, 0xEF, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x7F, 0x07, 0xC0, 0x03, 0xE1, 0xF0, 0x00,
  0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x0F, 0x1E,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x3C, 0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xF1, 0xFC, 0x01,
  0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x7E,
  0x7F, 0x00, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x00, 0x38, 0x00, 0xF8, 0x00, 0x00, 0xFB, 0xC0, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x7C, 0x3E,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF0, 0x3E, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x1E,
  0x01, 0xF0, 0x01, 0xF0, 0x07, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x3C, 0x01, 0xF0, 0x01, 0xF0,
  0x0F, 0x80, 0x0F, 0x80, 0x78, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xE0, 0x3E,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x0F,
  0x1F, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x1F, 0x3C,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0x07,
  0xE0, 0x1F, 0xF0, 0x07, 0xE0, 0x1E, 0xF8, 0x07, 0xE0, 0x1E, 0xF8, 0x07,
  0xE0, 0x1E, 0xF8, 0x07, 0xE0, 0x1E, 0xF8, 0x0E, 0xE0, 0x1E, 0x78, 0x0E,
  0xE0, 0x1E, 0x78, 0x0E, 0xE0, 0x3E, 0x78, 0x0E, 0x70, 0x3E, 0x78, 0x0E,
  0x70, 0x3C, 0x78, 0x0E, 0x70, 0x3C, 0x7C, 0x0E, 0x70, 0x3C, 0x7C, 0x0E,
  0x70, 0x3C, 0x7C, 0x1C, 0x70, 0x3C, 0x3C, 0x1C, 0x70, 0x3C, 0x3C, 0x1C,
  0x70, 0x3C, 0x3C, 0x1C, 0x70, 0x7C, 0x3C, 0x1C, 0x38, 0x78, 0x3C, 0x1C,
  0x38, 0x78, 0x3C, 0x1C, 0x38, 0x78, 0x3C, 0x1C, 0x38, 0x78, 0x3E, 0x38,
  0x38, 0x78, 0x3E, 0x38, 0x38, 0x78, 0x1E, 0x38, 0x38, 0x78, 0x1E, 0x38,
  0x38, 0x78, 0x1E, 0x38, 0x1C, 0x78, 0x1E, 0x38, 0x1C, 0xF0, 0x1E, 0x38,
  0x1C, 0xF0, 0x1E, 0x78, 0x1C, 0xF0, 0x1E, 0x70, 0x1C, 0xF0, 0x1F, 0x70,
  0x1C, 0xF0, 0x0F, 0x70, 0x1C, 0xF0, 0x0F, 0x70, 0x1C, 0xF0, 0x0F, 0x70,
  0x0E, 0xF0, 0x0F, 0x70, 0x0E, 0xE0, 0x0F, 0x70, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x03,
  0xE1, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x3D,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0,
  0x1F, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x03,
  0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF0, 0x0F,
  0x80, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0x9E, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE1, 0xE0, 0x01,
  0xE0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x78, 0x0F, 0x80,
  0x7C, 0x03, 0xC0, 0x3C, 0x01, 0xF0, 0x3E, 0x00, 0x78, 0x1E, 0x00, 0x3C,
  0x1F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xE7, 0xC0, 0x00,
  0xF3, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xE0,
  0x7F, 0x07, 0xE0, 0x07, 0xE3, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xF0, 0x00, 0x7D, 0xF0,
  0x00, 0x1F, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFD, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xCF, 0xF0, 0x7D, 0xF1, 0xFF,
  0xFF, 0x7C, 0x3F, 0xFF, 0x1F, 0x07, 0xFF, 0x87, 0xC0, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x3F, 0x80, 0xF0, 0xFF, 0xE0,
  0xF3, 0xFF, 0xF0, 0xF3, 0xFF, 0xF8, 0xF7, 0x81, 0xFC, 0xF6, 0x00, 0x7E,
  0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x3E, 0xFE, 0x00, 0x7E, 0xF7, 0x00, 0xFC, 0xF7, 0xFF, 0xFC,
  0xF3, 0xFF, 0xF8, 0xF1, 0xFF, 0xF0, 0xF0, 0xFF, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x81, 0xFC, 0x1F, 0xE1, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0x1F, 0x7C, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x07,
  0xE7, 0xC0, 0x07, 0xE3, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x7F, 0x83, 0xE0, 0xFF, 0xF1,
  0xF0, 0xFF, 0xFC, 0xF8, 0xFF, 0xFF, 0x7C, 0xFF, 0x07, 0xBE, 0x7E, 0x00,
  0xFF, 0x7E, 0x00, 0x3F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xDE, 0x00, 0x03,
  0xEF, 0x80, 0x03, 0xF7, 0xC0, 0x01, 0xFB, 0xF0, 0x01, 0xFC, 0xFC, 0x01,
  0xFE, 0x3F, 0xEF, 0xDF, 0x1F, 0xFF, 0xEF, 0x83, 0xFF, 0xE7, 0xC0, 0xFF,
  0xC3, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xF8, 0x0F, 0xE1, 0xF8, 0x01, 0xF1,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0xBC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x07, 0xDF, 0x00, 0x03, 0xE7, 0xC0, 0x03, 0xE3, 0xF0, 0x03, 0xF0,
  0xFF, 0x1F, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC7,
  0xC3, 0xFF, 0xF3, 0xE3, 0xFF, 0xFD, 0xF3, 0xFC, 0x1E, 0xF9, 0xF8, 0x03,
  0xFD, 0xF8, 0x00, 0xFE, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBC, 0x00,
  0x07, 0xDE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF7, 0x80, 0x00, 0xFB,
  0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x9F, 0x80, 0x3F, 0xCF, 0xF0, 0x7B, 0xE3, 0xFF, 0xFD, 0xF0, 0xFF, 0xFC,
  0xF8, 0x1F, 0xFC, 0x7C, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x7F, 0x80, 0xF1, 0xFF, 0xE0,
  0xF3, 0xFF, 0xF0, 0xF7, 0xFF, 0xF8, 0xF7, 0x81, 0xFC, 0xF6, 0x00, 0x7E,
  0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x00, 0x06, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE3, 0xE0,
  0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x83,
  0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x3E, 0x01, 0xF8, 0x0F, 0x80, 0xFC,
  0x03, 0xE0, 0x3E, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x03, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x7C,
  0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00,
  0x1F, 0x8F, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0xBE,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x7C, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xF0, 0x3F, 0x1E, 0x7F, 0x8F, 0xF3, 0xDF, 0xF3, 0xFF, 0x7B, 0xFF,
  0x7F, 0xEF, 0x43, 0xE8, 0x3F, 0xF0, 0x3E, 0x07, 0xFE, 0x03, 0xC0, 0x7F,
  0x80, 0x78, 0x0F, 0xF0, 0x0F, 0x01, 0xFE, 0x01, 0xE0, 0x3F, 0xC0, 0x3C,
  0x07, 0xF8, 0x07, 0x80, 0xFF, 0x00, 0xF0, 0x1F, 0xE0, 0x1E, 0x03, 0xFC,
  0x03, 0xC0, 0x7F, 0x80, 0x78, 0x0F, 0xF0, 0x0F, 0x01, 0xFE, 0x01, 0xE0,
  0x3F, 0xC0, 0x3C, 0x07, 0xF8, 0x07, 0x80, 0xFF, 0x00, 0xF0, 0x1F, 0xE0,
  0x1E, 0x03, 0xFC, 0x03, 0xC0, 0x7F, 0x80, 0x78, 0x0F, 0xF0, 0x0F, 0x01,
  0xFE, 0x01, 0xE0, 0x3F, 0xC0, 0x3C, 0x07, 0xF8, 0x07, 0x80, 0xFF, 0x00,
  0xF0, 0x1F, 0xE0, 0x1E, 0x03, 0xFC, 0x03, 0xC0, 0x7F, 0x80, 0x78, 0x0F,
  0xF0, 0x0F, 0x01, 0xE0, 0x00, 0x3F, 0x80, 0xF1, 0xFF, 0xE0, 0xF3, 0xFF,
  0xF0, 0xF3, 0xFF, 0xF8, 0xF7, 0x81, 0xFC, 0xF6, 0x00, 0x7E, 0xFC, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFC, 0x1F, 0xE1, 0xF8,
  0x03, 0xF1, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xBC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x78, 0x00,
  0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xC7, 0xC0, 0x07, 0xE3, 0xF8,
  0x07, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0x80, 0xF0, 0xFF, 0xE0,
  0xF3, 0xFF, 0xF8, 0xF3, 0xFF, 0xF8, 0xF7, 0x81, 0xFC, 0xF6, 0x00, 0x7E,
  0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x3E, 0xFE, 0x00, 0x7E, 0xF7, 0x00, 0xFC, 0xF7, 0xFF, 0xFC,
  0xF3, 0xFF, 0xF8, 0xF1, 0xFF, 0xF0, 0xF0, 0xFF, 0xC0, 0xF0, 0x0C, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xC7,
  0xC3, 0xFF, 0xF3, 0xE3, 0xFF, 0xFD, 0xF3, 0xFC, 0x1E, 0xF9, 0xF8, 0x03,
  0xFD, 0xF8, 0x00, 0xFE, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBC, 0x00,
  0x07, 0xDE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x0F,
  0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xE7, 0xC0, 0x07, 0xF3, 0xF0, 0x07,
  0xF8, 0xFF, 0xBF, 0x7C, 0x7F, 0xFF, 0x3E, 0x0F, 0xFF, 0x9F, 0x03, 0xFF,
  0x0F, 0x80, 0x18, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x80, 0xF0, 0xFF, 0xE0, 0xF3, 0xFF, 0xF8, 0xF3, 0xFF, 0xFC,
  0xF7, 0x81, 0xFC, 0xF6, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0x80, 0x7F, 0x0F, 0x80, 0x07, 0xC7, 0xE0,
  0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xBE, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7F, 0x00,
  0x3F, 0x8F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0x7C, 0x00,
  0x7C, 0x7F, 0x00, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3E, 0x78, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3C, 0x7C, 0x00, 0x07,
  0xC3, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF8, 0x1E,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF0, 0x1F, 0x00, 0x1F, 0x00, 0xF0, 0x01,
  0xF0, 0x0F, 0x80, 0x1E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00,
  0x7C, 0x03, 0xC0, 0x07, 0xC0, 0x3C, 0x00, 0x3C, 0x07, 0xC0, 0x03, 0xE0,
  0x78, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1F, 0x0F, 0x00,
  0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x0F,
  0x9E, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0xF8,
  0x07, 0xC0, 0x1E, 0xF0, 0x0F, 0x80, 0x3D, 0xE0, 0x1F, 0x00, 0x7B, 0xC0,
  0x3F, 0x01, 0xE7, 0x80, 0x6E, 0x03, 0xCF, 0x01, 0xDC, 0x07, 0x9F, 0x03,
  0xB8, 0x0F, 0x1E, 0x07, 0x70, 0x1E, 0x3C, 0x0E, 0x60, 0x3C, 0x78, 0x1C,
  0xE0, 0x70, 0xF0, 0x39, 0xC1, 0xE1, 0xE0, 0xE3, 0x83, 0xC3, 0xC1, 0xC7,
  0x07, 0x83, 0xC3, 0x8E, 0x0F, 0x07, 0x87, 0x0C, 0x1E, 0x0F, 0x0E, 0x1C,
  0x38, 0x1E, 0x1C, 0x38, 0xF0, 0x3C, 0x70, 0x71, 0xE0, 0x78, 0xE0, 0xE3,
  0xC0, 0x71, 0xC1, 0xC7, 0x80, 0xF3, 0x83, 0x8F, 0x01, 0xE7, 0x03, 0x9C,
  0x03, 0xCE, 0x07, 0x38, 0x07, 0xB8, 0x0E, 0xF0, 0x0F, 0x70, 0x1D, 0xE0,
  0x1E, 0xE0, 0x3B, 0xC0, 0x1D, 0xC0, 0x77, 0x80, 0x3F, 0x80, 0x7E, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x07, 0xC0,
  0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x0F, 0x80, 0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00,
  0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x00,
  0xFC, 0x03, 0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7E,
  0x1F, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80,
  0x1F, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0,
  0x03, 0xC0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x3C,
  0xFF, 0xE0, 0x07, 0xBF, 0xFE, 0x00, 0xF7, 0xC7, 0xE0, 0x1F, 0xF0, 0x7E,
  0x03, 0xFE, 0x07, 0xE0, 0x7F, 0xC0, 0x7E, 0x1F, 0xF8, 0x07, 0xFF, 0xDF,
  0x00, 0x7F, 0xFB, 0xE0, 0x07, 0xFE, 0x7C, 0x00, 0x3F, 0x00,
};

const GFXglyph JetBrainsMono_Light59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 8, 43, 35, 14, -43 },
  { 44, 17, 18, 35, 9, -43 },
  { 83, 31, 43, 35, 2, -43 },
  { 250, 27, 59, 35, 4, -51 },
  { 450, 33, 43, 35, 1, -43 },
  { 628, 30, 45, 35, 3, -44 },
  { 797, 5, 18, 35, 15, -43 },
  { 809, 18, 57, 35, 11, -50 },
  { 938, 17, 57, 35, 7, -50 },
  { 1060, 31, 30, 35, 2, -36 },
  { 1177, 27, 27, 35, 4, -33 },
  { 1269, 12, 18, 35, 10, -9 },
  { 1296, 19, 5, 35, 8, -22 },
  { 1308, 9, 10, 35, 13, -9 },
  { 1320, 26, 55, 35, 5, -49 },
  { 1499, 26, 45, 35, 5, -44 },
  { 1646, 27, 43, 35, 5, -43 },
  { 1792, 27, 44, 35, 4, -44 },
  { 1941, 26, 44, 35, 4, -43 },
  { 2084, 24, 43, 35, 5, -43 },
  { 2213, 25, 44, 35, 5, -43 },
  { 2351, 27, 44, 35, 4, -43 },
  { 2500, 26, 43, 35, 5, -43 },
  { 2640, 26, 45, 35, 5, -44 },
  { 2787, 27, 44, 35, 4, -44 },
  { 2936, 9, 34, 35, 13, -33 },
  { 2975, 13, 42, 35, 10, -33 },
  { 3044, 25, 31, 35, 5, -35 },
  { 3141, 25, 19, 35, 5, -29 },
  { 3201, 25, 31, 35, 5, -35 },
  { 3298, 21, 43, 35, 8, -43 },
  { 3411, 30, 55, 35, 3, -44 },
  { 3618, 29, 43, 35, 3, -43 },
  { 3774, 25, 43, 35, 6, -43 },
  { 3909, 25, 45, 35, 5, -44 },
  { 4050, 24, 43, 35, 6, -43 },
  { 4179, 25, 43, 35, 6, -43 },
  { 4314, 25, 43, 35, 6, -43 },
  { 4449, 25, 45, 35, 5, -44 },
  { 4590, 24, 43, 35, 6, -43 },
  { 4719, 23, 43, 35, 6, -43 },
  { 4843, 26, 44, 35, 3, -43 },
  { 4986, 27, 43, 35, 6, -43 },
  { 5132, 24, 43, 35, 7, -43 },
  { 5261, 26, 43, 35, 5, -43 },
  { 5401, 24, 43, 35, 6, -43 },
  { 5530, 25, 45, 35, 5, -44 },
  { 5671, 26, 43, 35, 6, -43 },
  { 5811, 26, 55, 35, 5, -44 },
  { 5990, 26, 43, 35, 6, -43 },
  { 6130, 27, 45, 35, 4, -44 },
  { 6282, 29, 43, 35, 3, -43 },
  { 6438, 24, 44, 35, 6, -43 },
  { 6570, 29, 43, 35, 3, -43 },
  { 6726, 32, 43, 35, 2, -43 },
  { 6898, 30, 43, 35, 3, -43 },
  { 7060, 31, 43, 35, 2, -43 },
  { 7227, 25, 43, 35, 5, -43 },
  { 7362, 14, 55, 35, 12, -49 },
  { 7459, 26, 55, 35, 5, -49 },
  { 7638, 14, 55, 35, 9, -49 },
  { 7735, 25, 23, 35, 5, -43 },
  { 7807, 28, 4, 35, 4, 1 },
  { 7821, 12, 8, 35, 11, -46 },
  { 7833, 26, 34, 35, 4, -33 },
  { 7944, 24, 44, 35, 6, -43 },
  { 8076, 25, 34, 35, 5, -33 },
  { 8183, 25, 44, 35, 5, -43 },
  { 8321, 25, 34, 35, 5, -33 },
  { 8428, 27, 43, 35, 4, -43 },
  { 8574, 25, 44, 35, 5, -33 },
  { 8712, 24, 43, 35, 6, -43 },
  { 8841, 27, 46, 35, 5, -46 },
  { 8997, 22, 57, 35, 5, -46 },
  { 9154, 26, 43, 35, 6, -43 },
  { 9294, 30, 43, 35, 2, -43 },
  { 9456, 27, 33, 35, 4, -33 },
  { 9568, 24, 33, 35, 6, -33 },
  { 9667, 25, 34, 35, 5, -33 },
  { 9774, 24, 44, 35, 6, -33 },
  { 9906, 25, 44, 35, 5, -33 },
  { 10044, 24, 33, 35, 7, -33 },
  { 10143, 26, 34, 35, 5, -33 },
  { 10254, 27, 42, 35, 3, -42 },
  { 10396, 24, 33, 35, 6, -32 },
  { 10495, 28, 32, 35, 4, -32 },
  { 10607, 31, 32, 35, 2, -32 },
  { 10731, 29, 32, 35, 3, -32 },
  { 10847, 28, 43, 35, 4, -32 },
  { 10998, 25, 32, 35, 5, -32 },
  { 11098, 25, 55, 35, 5, -49 },
  { 11270, 5, 55, 35, 15, -49 },
  { 11305, 25, 55, 35, 5, -49 },
  { 11477, 27, 12, 35, 4, -27 },
};

const GFXfont JetBrainsMono_Light59pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light59pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light59pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _JETBRAINSMONO_LIGHT59PT7B_H_
