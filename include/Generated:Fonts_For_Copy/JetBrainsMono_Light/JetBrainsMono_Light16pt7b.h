#ifndef _JETBRAINSMONO_LIGHT16PT7B_H_
#define _JETBRAINSMONO_LIGHT16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xAA, 0x8F, 0xCE, 0x52, 0x94, 0x80, 0x32, 0x22, 0x22, 0x22,
  0xFF, 0x24, 0x44, 0x44, 0xFE, 0x44, 0x48, 0x88, 0x10, 0x20, 0xF3, 0xB5,
  0x2A, 0x14, 0x38, 0x1C, 0x24, 0x4E, 0x95, 0x2F, 0x84, 0x08, 0x70, 0xEC,
  0xE2, 0x51, 0x45, 0x41, 0x20, 0x20, 0x2F, 0x14, 0x92, 0x51, 0x38, 0x70,
  0x38, 0x6C, 0x44, 0x40, 0x60, 0x60, 0xD3, 0x9A, 0x8E, 0x84, 0x8E, 0x7B,
  0xF8, 0x1B, 0x11, 0x88, 0x42, 0x10, 0x84, 0x30, 0x86, 0x18, 0x20, 0xC3,
  0x0C, 0x21, 0x0C, 0x63, 0x18, 0xC4, 0x23, 0x72, 0x00, 0x10, 0x10, 0x10,
  0xD7, 0x3C, 0x38, 0x2C, 0x66, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10,
  0x6B, 0x48, 0xF8, 0xF0, 0x02, 0x0C, 0x10, 0x20, 0xC1, 0x06, 0x08, 0x10,
  0x60, 0x81, 0x04, 0x08, 0x30, 0x00, 0x38, 0xCF, 0x0E, 0x1C, 0x3B, 0x76,
  0xE1, 0xC3, 0x85, 0x19, 0xE0, 0x18, 0x38, 0x48, 0x88, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0xFF, 0x38, 0xCF, 0x0C, 0x10, 0x20, 0xC3, 0x04,
  0x10, 0x41, 0x07, 0xF0, 0x7E, 0x0C, 0x30, 0x41, 0x03, 0x81, 0x81, 0x03,
  0x85, 0x1B, 0xE0, 0x04, 0x18, 0x20, 0x83, 0x04, 0x50, 0xE1, 0xFE, 0x04,
  0x08, 0x10, 0x7E, 0x81, 0x02, 0x05, 0x8D, 0xD0, 0x81, 0x03, 0x85, 0x19,
  0xE0, 0x0C, 0x30, 0x41, 0x82, 0x0F, 0xB1, 0xE1, 0x83, 0x85, 0x19, 0xE0,
  0xFF, 0xFF, 0xC2, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x10, 0x30,
  0x3C, 0xCD, 0x0A, 0x14, 0x67, 0x8F, 0x23, 0xC3, 0x85, 0x1B, 0xE0, 0x38,
  0xCF, 0x0C, 0x18, 0x38, 0x5F, 0x8A, 0x0C, 0x10, 0x41, 0x80, 0xF0, 0x03,
  0xC0, 0x7C, 0x00, 0x03, 0x5A, 0x40, 0x06, 0x39, 0xC6, 0x06, 0x03, 0x03,
  0x81, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0xC0, 0x60, 0x30, 0x10, 0x63, 0x18,
  0x40, 0xF3, 0xE0, 0xC1, 0x0C, 0x27, 0x18, 0x60, 0x06, 0x18, 0x3C, 0x66,
  0x83, 0x81, 0x8D, 0x93, 0x91, 0x91, 0x91, 0x91, 0x9F, 0x80, 0xC0, 0x60,
  0x38, 0x18, 0x18, 0x38, 0x28, 0x24, 0x24, 0x64, 0x46, 0x7E, 0x42, 0xC2,
  0x83, 0xF2, 0x78, 0x61, 0x87, 0xEF, 0xE1, 0x86, 0x18, 0xFE, 0x3C, 0xCD,
  0x0E, 0x1C, 0x18, 0x30, 0x60, 0xC0, 0x85, 0x19, 0xE0, 0xF2, 0x68, 0x61,
  0x86, 0x18, 0x61, 0x86, 0x18, 0xFE, 0xFE, 0x08, 0x20, 0x83, 0xF8, 0x20,
  0x82, 0x08, 0x3F, 0xFE, 0x08, 0x20, 0x82, 0x0F, 0xE0, 0x82, 0x08, 0x20,
  0x3C, 0xCD, 0x0E, 0x1C, 0x18, 0x33, 0xE1, 0xC2, 0x85, 0x19, 0xE0, 0x86,
  0x18, 0x61, 0x87, 0xFF, 0xE1, 0x86, 0x18, 0x61, 0xFC, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x3F, 0x1E, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x03, 0x0F, 0x13, 0xE0, 0x87, 0x0A, 0x34, 0x49, 0x9E, 0x3C, 0x4C, 0x89,
  0x1A, 0x14, 0x30, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x07, 0xF0, 0xC3, 0x8E, 0x9D, 0x3A, 0xB3, 0x76, 0xE1, 0xC3, 0x87, 0x0E,
  0x10, 0x87, 0x1C, 0x71, 0xA6, 0x9A, 0x65, 0x96, 0x78, 0xE3, 0x38, 0xCD,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC2, 0x85, 0x19, 0xE0, 0xF9, 0x1A, 0x1C,
  0x38, 0x70, 0xBE, 0x40, 0x81, 0x02, 0x04, 0x00, 0x38, 0xCD, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x85, 0x19, 0xE0, 0xC0, 0xC0, 0x80, 0xF1, 0x3A,
  0x14, 0x38, 0x51, 0xBE, 0x48, 0x89, 0x12, 0x34, 0x30, 0x3C, 0xCD, 0x0A,
  0x04, 0x0E, 0x07, 0x01, 0x03, 0x85, 0x0B, 0xE0, 0xFF, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x18, 0xDE, 0x83, 0x82, 0xC2, 0x42, 0x46, 0x64, 0x64,
  0x24, 0x2C, 0x38, 0x18, 0x18, 0xCC, 0xA6, 0x53, 0x29, 0x94, 0xCA, 0xAD,
  0x54, 0xAA, 0x73, 0x19, 0x8C, 0xC6, 0x60, 0x83, 0x42, 0x64, 0x24, 0x38,
  0x18, 0x18, 0x38, 0x24, 0x46, 0x42, 0x83, 0x81, 0xC2, 0x42, 0x44, 0x24,
  0x28, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFE, 0x04, 0x18, 0x20, 0x83,
  0x04, 0x18, 0x20, 0x81, 0x07, 0xF0, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xCC, 0xF0, 0xC0, 0x81, 0x81, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x10, 0x30,
  0x20, 0x40, 0xC0, 0x80, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0,
  0x18, 0x30, 0xA1, 0x24, 0x48, 0x70, 0x80, 0xFF, 0x88, 0x80, 0x3C, 0x8D,
  0x08, 0x17, 0xF8, 0x60, 0xE3, 0x7A, 0x82, 0x08, 0x2E, 0xCE, 0x18, 0x61,
  0x86, 0x18, 0xFE, 0x3C, 0xCD, 0x0E, 0x0C, 0x18, 0x30, 0xA3, 0x3C, 0x02,
  0x04, 0x09, 0xD6, 0x68, 0x70, 0xE1, 0xC3, 0x85, 0x1B, 0xD0, 0x3C, 0x8D,
  0x0E, 0x1F, 0xF8, 0x30, 0x23, 0x3C, 0x0F, 0x18, 0x10, 0x10, 0xFF, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x3A, 0xCD, 0x0E, 0x1C, 0x38, 0x51,
  0xBD, 0x02, 0x04, 0x19, 0xE0, 0x82, 0x08, 0x2E, 0xCE, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x18, 0x08, 0x00, 0x78, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0xFF, 0x0C, 0x10, 0x1F, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x0C,
  0x2F, 0x00, 0x81, 0x02, 0x04, 0x38, 0xD1, 0x24, 0x78, 0x99, 0x12, 0x34,
  0x30, 0xF0, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x10,
  0x1F, 0xB6, 0xDA, 0x93, 0x93, 0x93, 0x93, 0x93, 0x93, 0x93, 0xBB, 0x38,
  0x61, 0x86, 0x18, 0x61, 0x84, 0x3C, 0xCD, 0x0E, 0x1C, 0x38, 0x70, 0xA3,
  0x3C, 0xBB, 0x38, 0x61, 0x86, 0x18, 0x63, 0xFA, 0x08, 0x20, 0x3A, 0xCD,
  0x0E, 0x1C, 0x38, 0x50, 0xA3, 0x7A, 0x04, 0x08, 0x10, 0xBB, 0x38, 0x61,
  0x82, 0x08, 0x20, 0x80, 0x3C, 0x8D, 0x02, 0x03, 0xC0, 0xE0, 0xA1, 0x7C,
  0x30, 0x63, 0xF9, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x20, 0x78, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x63, 0x78, 0x83, 0xC2, 0x42, 0x46, 0x64, 0x24, 0x28,
  0x38, 0x18, 0x91, 0x99, 0x99, 0x9A, 0xAA, 0xEA, 0x66, 0x66, 0x66, 0xC3,
  0x46, 0x24, 0x38, 0x18, 0x38, 0x24, 0x46, 0xC3, 0xC3, 0xC2, 0x46, 0x64,
  0x24, 0x2C, 0x38, 0x18, 0x18, 0x10, 0x30, 0x20, 0x7E, 0x0C, 0x10, 0x41,
  0x86, 0x18, 0x20, 0xFE, 0x0E, 0x10, 0x20, 0x40, 0x81, 0x06, 0x78, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x81, 0x80, 0xFF, 0xFE, 0xE0, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x0F, 0x10, 0x20, 0x40, 0x81, 0x06, 0x38, 0x00, 0xF3, 0x36,
  0x38,
};

const GFXglyph JetBrainsMono_Light16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 12, 10, 4, -12 },
  { 4, 5, 5, 10, 2, -12 },
  { 8, 8, 12, 10, 1, -12 },
  { 20, 7, 16, 10, 1, -14 },
  { 34, 9, 12, 10, 0, -12 },
  { 48, 8, 12, 10, 1, -12 },
  { 60, 1, 5, 10, 4, -12 },
  { 61, 5, 15, 10, 3, -13 },
  { 71, 5, 15, 10, 2, -13 },
  { 81, 8, 8, 10, 1, -10 },
  { 89, 8, 7, 10, 1, -9 },
  { 96, 3, 5, 10, 3, -2 },
  { 98, 5, 1, 10, 2, -6 },
  { 99, 2, 2, 10, 4, -2 },
  { 100, 7, 15, 10, 1, -13 },
  { 114, 7, 12, 10, 1, -12 },
  { 125, 8, 12, 10, 1, -12 },
  { 137, 7, 12, 10, 1, -12 },
  { 148, 7, 12, 10, 1, -12 },
  { 159, 7, 12, 10, 1, -12 },
  { 170, 7, 12, 10, 1, -12 },
  { 181, 7, 12, 10, 1, -12 },
  { 192, 8, 12, 10, 1, -12 },
  { 204, 7, 12, 10, 1, -12 },
  { 215, 7, 12, 10, 1, -12 },
  { 226, 2, 9, 10, 4, -9 },
  { 229, 3, 12, 10, 3, -9 },
  { 234, 7, 8, 10, 1, -9 },
  { 241, 7, 5, 10, 1, -8 },
  { 246, 7, 8, 10, 1, -9 },
  { 253, 6, 12, 10, 2, -12 },
  { 262, 8, 15, 10, 1, -12 },
  { 277, 8, 12, 10, 1, -12 },
  { 289, 6, 12, 10, 2, -12 },
  { 298, 7, 12, 10, 1, -12 },
  { 309, 6, 12, 10, 2, -12 },
  { 318, 6, 12, 10, 2, -12 },
  { 327, 6, 12, 10, 2, -12 },
  { 336, 7, 12, 10, 1, -12 },
  { 347, 6, 12, 10, 2, -12 },
  { 356, 6, 12, 10, 2, -12 },
  { 365, 7, 12, 10, 1, -12 },
  { 376, 7, 12, 10, 2, -12 },
  { 387, 7, 12, 10, 2, -12 },
  { 398, 7, 12, 10, 1, -12 },
  { 409, 6, 12, 10, 2, -12 },
  { 418, 7, 12, 10, 1, -12 },
  { 429, 7, 12, 10, 2, -12 },
  { 440, 7, 15, 10, 1, -12 },
  { 454, 7, 12, 10, 2, -12 },
  { 465, 7, 12, 10, 1, -12 },
  { 476, 8, 12, 10, 1, -12 },
  { 488, 6, 12, 10, 2, -12 },
  { 497, 8, 12, 10, 1, -12 },
  { 509, 9, 12, 10, 0, -12 },
  { 523, 8, 12, 10, 1, -12 },
  { 535, 8, 12, 10, 1, -12 },
  { 547, 7, 12, 10, 1, -12 },
  { 558, 4, 15, 10, 3, -13 },
  { 566, 7, 15, 10, 1, -13 },
  { 580, 4, 15, 10, 2, -13 },
  { 588, 7, 7, 10, 1, -12 },
  { 595, 8, 1, 10, 1, 0 },
  { 596, 3, 3, 10, 3, -13 },
  { 598, 7, 9, 10, 1, -9 },
  { 606, 6, 12, 10, 2, -12 },
  { 615, 7, 9, 10, 1, -9 },
  { 623, 7, 12, 10, 1, -12 },
  { 634, 7, 9, 10, 1, -9 },
  { 642, 8, 12, 10, 1, -12 },
  { 654, 7, 12, 10, 1, -9 },
  { 665, 6, 12, 10, 2, -12 },
  { 674, 8, 12, 10, 1, -12 },
  { 686, 6, 15, 10, 1, -12 },
  { 698, 7, 12, 10, 2, -12 },
  { 709, 8, 12, 10, 1, -12 },
  { 721, 8, 9, 10, 1, -9 },
  { 730, 6, 9, 10, 2, -9 },
  { 737, 7, 9, 10, 1, -9 },
  { 745, 6, 12, 10, 2, -9 },
  { 754, 7, 12, 10, 1, -9 },
  { 765, 6, 9, 10, 2, -9 },
  { 772, 7, 9, 10, 1, -9 },
  { 780, 7, 11, 10, 1, -11 },
  { 790, 6, 9, 10, 2, -9 },
  { 797, 8, 9, 10, 1, -9 },
  { 806, 8, 9, 10, 1, -9 },
  { 815, 8, 9, 10, 1, -9 },
  { 824, 8, 12, 10, 1, -9 },
  { 836, 7, 9, 10, 1, -9 },
  { 844, 7, 15, 10, 1, -13 },
  { 858, 1, 15, 10, 4, -13 },
  { 860, 7, 15, 10, 1, -13 },
  { 874, 7, 3, 10, 1, -7 },
};

const GFXfont JetBrainsMono_Light16pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light16pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _JETBRAINSMONO_LIGHT16PT7B_H_
