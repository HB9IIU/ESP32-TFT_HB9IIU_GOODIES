#ifndef _JETBRAINSMONO_LIGHT72PT7B_H_
#define _JETBRAINSMONO_LIGHT72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Light.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Light72pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xCF, 0xFB,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x00, 0xFE, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xEF,
  0x80, 0x3F, 0x7C, 0x01, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x7C, 0xF8, 0x03,
  0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xF3, 0xCF, 0xF8,
  0x0F, 0xE1, 0xE1, 0xFC, 0x0F, 0xE0, 0xF0, 0x7F, 0x07, 0xE0, 0x78, 0x1F,
  0x87, 0xE0, 0x3C, 0x07, 0xE3, 0xF0, 0x1E, 0x03, 0xF1, 0xF8, 0x0F, 0x01,
  0xF8, 0xFC, 0x07, 0x80, 0xFC, 0x7E, 0x03, 0xC0, 0x7E, 0x3F, 0x01, 0xE0,
  0x00, 0x1F, 0x80, 0xF0, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x07, 0xF0, 0x3C,
  0x00, 0x01, 0xF8, 0x1E, 0x00, 0x00, 0xFE, 0x0F, 0x00, 0x00, 0x7F, 0x87,
  0x80, 0x00, 0x1F, 0xE3, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xE7, 0xFC, 0x00, 0x00, 0xF0, 0xFF, 0x00,
  0x00, 0x78, 0x3F, 0x80, 0x00, 0x3C, 0x0F, 0xE0, 0x00, 0x1E, 0x03, 0xF0,
  0x00, 0x0F, 0x01, 0xF8, 0x00, 0x07, 0x80, 0x7E, 0x00, 0x03, 0xC0, 0x3F,
  0x00, 0x01, 0xE0, 0x1F, 0xFE, 0x00, 0xF0, 0x0F, 0xFF, 0x00, 0x78, 0x07,
  0xEF, 0x80, 0x3C, 0x03, 0xF7, 0xE0, 0x1E, 0x01, 0xFB, 0xF0, 0x0F, 0x01,
  0xF9, 0xFC, 0x07, 0x80, 0xFC, 0x7E, 0x03, 0xC0, 0xFE, 0x3F, 0xC1, 0xE0,
  0xFE, 0x0F, 0xF0, 0xF1, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0x83, 0xFF, 0x80, 0x00, 0x07, 0x87, 0xFF, 0xE0, 0x00, 0x07, 0xC7,
  0xFF, 0xF8, 0x00, 0x07, 0xC3, 0xFF, 0xFE, 0x00, 0x07, 0xC3, 0xF0, 0x1F,
  0x00, 0x03, 0xE1, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x03,
  0xE0, 0x78, 0x01, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x1E,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x00, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x1F,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x78,
  0x00, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x78, 0x01, 0xF0, 0x7C, 0x00, 0x3E,
  0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x80, 0xF8, 0x3E, 0x00, 0x07, 0xE1, 0xFC,
  0x3E, 0x00, 0x03, 0xFF, 0xFC, 0x3E, 0x00, 0x00, 0xFF, 0xFE, 0x1F, 0x00,
  0x00, 0x3F, 0xFC, 0x1F, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0xC0, 0x00,
  0x03, 0xE1, 0xFF, 0xF8, 0x00, 0x03, 0xE1, 0xFF, 0xFE, 0x00, 0x01, 0xE1,
  0xFF, 0xFF, 0x00, 0x01, 0xF0, 0xFC, 0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x03,
  0xE0, 0x01, 0xF0, 0x7C, 0x00, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x07,
  0xC0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x03,
  0xE0, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x07,
  0xC0, 0x3E, 0x1F, 0x00, 0x03, 0xF8, 0x7F, 0x0F, 0x00, 0x00, 0xFF, 0xFF,
  0x0F, 0x80, 0x00, 0x7F, 0xFF, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0x0F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x1F, 0x80,
  0x07, 0xE7, 0xE0, 0xFE, 0x00, 0x7E, 0x3F, 0x03, 0xF8, 0x03, 0xF3, 0xF0,
  0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0x1F,
  0x87, 0xE0, 0x07, 0xE0, 0xFC, 0x3F, 0x00, 0x1F, 0x8F, 0xC1, 0xF8, 0x00,
  0x7E, 0x7C, 0x0F, 0xC0, 0x03, 0xFF, 0xE0, 0x7E, 0x00, 0x0F, 0xFE, 0x03,
  0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0x80, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0x07,
  0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0x0F, 0xF8, 0x0F, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0x00, 0x0F, 0xFF,
  0x01, 0xF8, 0x00, 0xFE, 0xFC, 0x0F, 0xF0, 0x0F, 0xE7, 0xF0, 0x3F, 0xF7,
  0xFE, 0x1F, 0x81, 0xFF, 0xFF, 0xE0, 0x7E, 0x07, 0xFF, 0xFE, 0x01, 0xF8,
  0x1F, 0xFF, 0xE0, 0x0F, 0xE0, 0x3F, 0xFC, 0x00, 0x3F, 0x80, 0x3E, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x0F,
  0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x80, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x3C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x04, 0x00, 0x0F, 0x80, 0x01, 0x1E,
  0x00, 0x3E, 0x00, 0x1C, 0x7E, 0x00, 0xF8, 0x03, 0xF3, 0xFF, 0x03, 0xE0,
  0x7F, 0xEF, 0xFF, 0x07, 0x87, 0xFF, 0xBF, 0xFF, 0x1C, 0x7F, 0xFF, 0x3F,
  0xFE, 0x73, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x7E, 0x00, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0x07, 0xF9, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xF8, 0xFE, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03,
  0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x40, 0x0F, 0xFE, 0x03, 0xF0,
  0x1F, 0xFC, 0x0F, 0xE0, 0x3F, 0xF8, 0x1F, 0xE0, 0x7F, 0xF0, 0x7F, 0xC0,
  0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xC0, 0xFE, 0x03, 0xFF, 0x80, 0xFC, 0x07,
  0xFF, 0x00, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xF3,
  0xF0, 0x00, 0x1F, 0xE3, 0xF0, 0x00, 0x7F, 0xC3, 0xF0, 0x00, 0xFF, 0x03,
  0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xF0, 0x03,
  0xF0, 0x00, 0xE0, 0x03, 0xF0, 0x00, 0xC0, 0x03, 0xF0, 0x00, 0x80, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7E,
  0xF8, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x0F,
  0xF0, 0x03, 0xFC, 0x0F, 0xFE, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0xFC, 0x3F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x3F,
  0x3F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x03, 0x80, 0x01,
  0xF0, 0x7F, 0xF0, 0x03, 0xE3, 0xFF, 0xF8, 0x07, 0xCF, 0xFF, 0xF8, 0x0F,
  0xBF, 0xFF, 0xF8, 0x1F, 0x7F, 0xFF, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x7F,
  0x80, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x07, 0xE7, 0xF0,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE,
  0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xFE, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0xF8, 0x00, 0x3F,
  0xBF, 0xFF, 0x00, 0x1F, 0xBF, 0xFF, 0xE0, 0x1F, 0xBF, 0xFF, 0xF8, 0x0F,
  0xFF, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0x7C, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x0F, 0xFE,
  0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x0F, 0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0xFF, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x3F,
  0x80, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0x9F, 0xE0, 0x00, 0x7F, 0x1F, 0xE0, 0x03,
  0xFC, 0x1F, 0xFC, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x00,
  0x00, 0x7E, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x07, 0xE7, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC,
  0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F,
  0x07, 0xF8, 0x00, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF7, 0xE0, 0x0F, 0xFF, 0xF7, 0xE0, 0x01, 0xFF, 0xE7,
  0xF0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x8F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xC7, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC3, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xF1, 0xFE, 0x0E,
  0x00, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF,
  0xC7, 0xFF, 0x0F, 0xFE, 0x0F, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x81, 0xFE, 0x03,
  0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0x3F, 0x81, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xC1, 0xFF, 0x80, 0x07, 0xFF, 0x1F,
  0xF8, 0x00, 0xFF, 0xF9, 0xFF, 0x80, 0x1F, 0xFF, 0xDF, 0xF8, 0x01, 0xFE,
  0x3F, 0xFF, 0x80, 0x3F, 0x80, 0x7F, 0xF8, 0x03, 0xF0, 0x03, 0xFF, 0x80,
  0x3E, 0x00, 0x3F, 0xF8, 0x07, 0xE0, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0x1F,
  0xF8, 0x07, 0xE0, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xE0,
  0x01, 0xFF, 0x80, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xE0, 0x01, 0xFF, 0x80,
  0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xE0, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0x1F,
  0xF8, 0x07, 0xE0, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xE0,
  0x01, 0xFF, 0x80, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xE0, 0x03, 0xFF, 0x80,
  0x3E, 0x00, 0x3F, 0xF8, 0x03, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0x7F,
  0xF8, 0x01, 0xFE, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xDF, 0xF8, 0x00, 0xFF,
  0xFD, 0xFF, 0x80, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x01, 0xF1, 0xF8, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8,
  0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x1F,
  0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0x00, 0x07, 0xFC, 0x7E, 0x00,
  0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xF8,
  0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0x07, 0xFE, 0x1F,
  0x80, 0x01, 0xFE, 0x3F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x1F, 0xDF, 0x80, 0x00, 0x7F, 0x3F, 0x00, 0x01, 0xFE, 0x7E, 0x00, 0x1F,
  0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0x7F, 0x83, 0xF8, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xFC, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x03, 0xFE, 0x3F, 0x00,
  0x03, 0xF8, 0xFC, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x3F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xBF, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x3F,
  0xCF, 0xC0, 0x01, 0xFE, 0x3F, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0xFF, 0x80, 0x7F, 0x83, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFE,
  0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xFC, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xCF,
  0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x1F,
  0xFC, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xFC,
  0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x07, 0xE0,
  0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1F,
  0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xE0,
  0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07,
  0xF1, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x03, 0xF8, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFD, 0xF0, 0x00, 0xFF,
  0xFB, 0xE0, 0x03, 0xEF, 0xF7, 0xC0, 0x07, 0xDF, 0xE7, 0xC0, 0x0F, 0xBF,
  0xCF, 0x80, 0x1E, 0x7F, 0x9F, 0x00, 0x7C, 0xFF, 0x9E, 0x00, 0xF9, 0xFF,
  0x3E, 0x01, 0xE3, 0xFE, 0x7C, 0x07, 0xC7, 0xFC, 0x78, 0x0F, 0x8F, 0xF8,
  0xF8, 0x1E, 0x3F, 0xF1, 0xF0, 0x7C, 0x7F, 0xE1, 0xF0, 0xF8, 0xFF, 0xC3,
  0xE1, 0xE1, 0xFF, 0x87, 0xC7, 0xC3, 0xFF, 0x07, 0x8F, 0x87, 0xFE, 0x0F,
  0x9E, 0x0F, 0xFC, 0x0F, 0x7C, 0x1F, 0xF8, 0x1E, 0xF8, 0x3F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0x81, 0xFF, 0x80, 0xFE,
  0x03, 0xFF, 0x00, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0x00, 0x07, 0xFE,
  0xF8, 0x00, 0x3F, 0xF7, 0xE0, 0x01, 0xFF, 0x9F, 0x00, 0x0F, 0xFC, 0xF8,
  0x00, 0x7F, 0xE3, 0xE0, 0x03, 0xFF, 0x1F, 0x00, 0x1F, 0xF8, 0xF8, 0x00,
  0xFF, 0xC3, 0xE0, 0x07, 0xFE, 0x1F, 0x00, 0x3F, 0xF0, 0xF8, 0x01, 0xFF,
  0x83, 0xE0, 0x0F, 0xFC, 0x1F, 0x00, 0x7F, 0xE0, 0x7C, 0x03, 0xFF, 0x03,
  0xE0, 0x1F, 0xF8, 0x1F, 0x00, 0xFF, 0xC0, 0x7C, 0x07, 0xFE, 0x03, 0xE0,
  0x3F, 0xF0, 0x1F, 0x01, 0xFF, 0x80, 0x7C, 0x0F, 0xFC, 0x03, 0xE0, 0x7F,
  0xE0, 0x1F, 0x83, 0xFF, 0x00, 0x7C, 0x1F, 0xF8, 0x03, 0xE0, 0xFF, 0xC0,
  0x0F, 0x87, 0xFE, 0x00, 0x7C, 0x3F, 0xF0, 0x03, 0xE1, 0xFF, 0x80, 0x0F,
  0x8F, 0xFC, 0x00, 0x7C, 0x7F, 0xE0, 0x03, 0xE3, 0xFF, 0x00, 0x0F, 0x9F,
  0xF8, 0x00, 0x7C, 0xFF, 0xC0, 0x03, 0xF7, 0xFE, 0x00, 0x0F, 0xBF, 0xF0,
  0x00, 0x7D, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x83, 0xF8,
  0x00, 0xFF, 0x1F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x03, 0xFB, 0xF0, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFB, 0xF0, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xF8,
  0x1F, 0xF8, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC,
  0x00, 0x07, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFE, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFC, 0xFC,
  0x00, 0x03, 0xFC, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x3F,
  0x80, 0x01, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x1F, 0xFC, 0x7F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x40, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x0F, 0xF8, 0xFC,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xFC, 0xFC,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x01, 0xFC,
  0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03,
  0xF8, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x01,
  0xF9, 0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x03, 0xFC, 0x1F, 0xF8, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x1F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x01,
  0xF8, 0x1F, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x00, 0x7C, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x01, 0xF8, 0x7C,
  0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x7E,
  0x7C, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xF8, 0x00,
  0xFF, 0xE0, 0x07, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0xE0, 0x07, 0xEF, 0x80,
  0x1F, 0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0xC0, 0x1F, 0x3E, 0x00, 0x77, 0x80,
  0x3E, 0x7C, 0x00, 0xEF, 0x00, 0x7C, 0xF8, 0x01, 0xDE, 0x00, 0xF9, 0xF8,
  0x07, 0xBC, 0x01, 0xF3, 0xF0, 0x0F, 0x38, 0x03, 0xE3, 0xE0, 0x1E, 0x70,
  0x07, 0xC7, 0xC0, 0x3C, 0xE0, 0x1F, 0x8F, 0x80, 0x79, 0xE0, 0x3E, 0x1F,
  0x00, 0xE3, 0xC0, 0x7C, 0x3E, 0x01, 0xC7, 0x80, 0xF8, 0x7C, 0x07, 0x8F,
  0x01, 0xF0, 0xF8, 0x0F, 0x1E, 0x03, 0xE1, 0xF8, 0x1E, 0x1C, 0x07, 0xC3,
  0xF0, 0x3C, 0x38, 0x0F, 0x83, 0xE0, 0x78, 0x70, 0x1F, 0x07, 0xC0, 0xF0,
  0xE0, 0x7E, 0x0F, 0x81, 0xC1, 0xE0, 0xF8, 0x1F, 0x03, 0x83, 0xC1, 0xF0,
  0x3E, 0x0F, 0x07, 0x83, 0xE0, 0x7C, 0x1E, 0x0F, 0x07, 0xC0, 0xF8, 0x3C,
  0x1E, 0x0F, 0x81, 0xF8, 0x78, 0x1C, 0x1F, 0x01, 0xF0, 0xF0, 0x38, 0x3E,
  0x03, 0xE1, 0xC0, 0x70, 0x7C, 0x07, 0xC3, 0x80, 0xF0, 0xF0, 0x0F, 0x87,
  0x01, 0xE3, 0xE0, 0x1F, 0x1E, 0x03, 0xC7, 0xC0, 0x3E, 0x3C, 0x07, 0x8F,
  0x80, 0x7C, 0x78, 0x0F, 0x1F, 0x00, 0xF8, 0xF0, 0x0E, 0x3E, 0x01, 0xF9,
  0xE0, 0x1C, 0x7C, 0x01, 0xF3, 0x80, 0x38, 0xF8, 0x03, 0xE7, 0x00, 0x79,
  0xE0, 0x07, 0xCE, 0x00, 0xF3, 0xC0, 0x0F, 0xBC, 0x01, 0xEF, 0x80, 0x1F,
  0x78, 0x03, 0xDF, 0x00, 0x3E, 0xF0, 0x07, 0xBE, 0x00, 0x7D, 0xE0, 0x0F,
  0x7C, 0x00, 0xFB, 0xC0, 0x0E, 0xF8, 0x00, 0xF7, 0x00, 0x1D, 0xF0, 0x01,
  0xEE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x1F, 0x9F,
  0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x3E, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x3F, 0x00,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF8, 0xFC, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x03,
  0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x7C, 0x1F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0xFC, 0x00,
  0x01, 0xF9, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F,
  0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xE0,
  0x00, 0x0F, 0xBF, 0x80, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x1E,
  0xF9, 0xFF, 0x00, 0xFD, 0xF1, 0xFF, 0xFF, 0xF3, 0xE1, 0xFF, 0xFF, 0xC7,
  0xC1, 0xFF, 0xFF, 0x0F, 0x80, 0xFF, 0xF8, 0x1F, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x3F, 0xE0, 0x0F, 0xC3, 0xFF, 0xF0, 0x3F, 0x3F, 0xFF, 0xE0,
  0xFD, 0xFF, 0xFF, 0xC3, 0xF7, 0xFF, 0xFF, 0x8F, 0xFE, 0x01, 0xFE, 0x3F,
  0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x01,
  0xFB, 0xFC, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x7F, 0x3F, 0xF0, 0x03, 0xFC,
  0xFD, 0xF0, 0x7F, 0xE3, 0xF7, 0xFF, 0xFF, 0x0F, 0xCF, 0xFF, 0xF8, 0x3F,
  0x1F, 0xFF, 0xC0, 0xFC, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x0F, 0xF0,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF,
  0x80, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF0, 0x7F,
  0x80, 0x1F, 0xE0, 0x7F, 0xE3, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x01, 0xFF, 0x81, 0xF0, 0x1F, 0xFF, 0x07, 0xC1, 0xFF,
  0xFF, 0x1F, 0x0F, 0xFF, 0xFE, 0x7C, 0x7F, 0xFF, 0xF9, 0xF1, 0xFE, 0x00,
  0xF7, 0xCF, 0xE0, 0x01, 0xDF, 0x3F, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0xFD,
  0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x37, 0xCF, 0xF0,
  0x03, 0xDF, 0x1F, 0xF8, 0x3F, 0x7C, 0x3F, 0xFF, 0xF9, 0xF0, 0x7F, 0xFF,
  0xC7, 0xC0, 0xFF, 0xFE, 0x1F, 0x00, 0xFF, 0xF0, 0x7C, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x01, 0xFE,
  0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x03,
  0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x0B, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0xF8, 0x1F,
  0xFF, 0x87, 0xC3, 0xFF, 0xFE, 0x3E, 0x3F, 0xFF, 0xF9, 0xF3, 0xFF, 0xFF,
  0xCF, 0x9F, 0xE0, 0x0F, 0x7D, 0xFE, 0x00, 0x3B, 0xEF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x3B, 0xE7,
  0xF8, 0x03, 0xDF, 0x3F, 0xFF, 0xFE, 0xF8, 0xFF, 0xFF, 0xEF, 0xC3, 0xFF,
  0xFE, 0x7E, 0x07, 0xFF, 0xE3, 0xF0, 0x0F, 0xFC, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x07, 0xFC, 0x03, 0xF0,
  0xFF, 0xF8, 0x1F, 0x9F, 0xFF, 0xF0, 0xFD, 0xFF, 0xFF, 0xC7, 0xEF, 0xFF,
  0xFF, 0x3F, 0xF0, 0x07, 0xF9, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F,
  0x7F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x01, 0xFD, 0xF8, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xC0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x07,
  0xE0, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0x80, 0x7F, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x83, 0xF0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x01, 0xFC, 0x7E, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x03, 0xF8, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0xF8, 0xFE, 0x03, 0xF8, 0x7C, 0xFF, 0xC3, 0xFE, 0x3E, 0xFF,
  0xE3, 0xFF, 0x9F, 0x7F, 0xFB, 0xFF, 0xEF, 0xB0, 0xFD, 0xC7, 0xF7, 0xF0,
  0x3F, 0x80, 0xFF, 0xF0, 0x0F, 0xC0, 0x7F, 0xF8, 0x07, 0xC0, 0x1F, 0xF8,
  0x03, 0xE0, 0x0F, 0xFC, 0x01, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x03, 0xFF,
  0x00, 0x7C, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x7F,
  0xE0, 0x0F, 0x80, 0x3F, 0xF0, 0x07, 0xC0, 0x1F, 0xF8, 0x03, 0xE0, 0x0F,
  0xFC, 0x01, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7C, 0x01,
  0xFF, 0x80, 0x3E, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x7F, 0xE0, 0x0F, 0x80,
  0x3F, 0xF0, 0x07, 0xC0, 0x1F, 0xF8, 0x03, 0xE0, 0x0F, 0xFC, 0x01, 0xF0,
  0x07, 0xFE, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x3E,
  0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x3F, 0xF0, 0x07,
  0xC0, 0x1F, 0xF8, 0x03, 0xE0, 0x0F, 0xFC, 0x01, 0xF0, 0x07, 0xFE, 0x00,
  0xF8, 0x03, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0xFF, 0xC0,
  0x1F, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x3F, 0xF0, 0x07, 0xC0, 0x1F, 0xFC,
  0x0F, 0xF8, 0x07, 0xE1, 0xFF, 0xF0, 0x3F, 0x3F, 0xFF, 0xE1, 0xFB, 0xFF,
  0xFF, 0x8F, 0xDF, 0xFF, 0xFE, 0x7F, 0xF0, 0x0F, 0xF3, 0xFE, 0x00, 0x1F,
  0xDF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x0F,
  0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0xFC,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F,
  0x3F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xF0,
  0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0xF7, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x03, 0x80, 0x00, 0xFC, 0x0F, 0xFC, 0x03, 0xF0, 0xFF, 0xFC, 0x0F, 0xCF,
  0xFF, 0xF8, 0x3F, 0x7F, 0xFF, 0xF0, 0xFD, 0xFF, 0xFF, 0xE3, 0xFF, 0x80,
  0x7F, 0xCF, 0xF8, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF,
  0x80, 0x00, 0x7E, 0xFF, 0x00, 0x03, 0xFB, 0xFE, 0x00, 0x1F, 0xCF, 0xFC,
  0x00, 0xFF, 0x3F, 0x7E, 0x1F, 0xF8, 0xFD, 0xFF, 0xFF, 0xC3, 0xF3, 0xFF,
  0xFE, 0x0F, 0xC7, 0xFF, 0xF0, 0x3F, 0x07, 0xFF, 0x00, 0xFC, 0x03, 0xC0,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0xF8, 0x1F, 0xFF, 0x87, 0xC3, 0xFF, 0xFE, 0x3E, 0x3F, 0xFF, 0xF9,
  0xF3, 0xFF, 0xFF, 0xCF, 0x9F, 0xE0, 0x0F, 0x7D, 0xFC, 0x00, 0x3B, 0xEF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x7E, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x37, 0xCF, 0xE0, 0x07, 0xBE, 0x7F, 0xE0, 0xFD, 0xF1, 0xFF, 0xFF, 0xCF,
  0x87, 0xFF, 0xFC, 0x7C, 0x1F, 0xFF, 0xC3, 0xE0, 0x3F, 0xFC, 0x1F, 0x00,
  0x3F, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0xFC,
  0x0F, 0xFC, 0x03, 0xF0, 0xFF, 0xFC, 0x0F, 0xC7, 0xFF, 0xF8, 0x3F, 0x3F,
  0xFF, 0xF0, 0xFD, 0xFF, 0xFF, 0xE3, 0xF7, 0x80, 0x3F, 0xCF, 0xF8, 0x00,
  0x7F, 0x3F, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0xFD, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x2F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x3F, 0x8F, 0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xF9,
  0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00,
  0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x01,
  0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x00,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x01, 0xF8, 0x1F,
  0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0x7E,
  0x1F, 0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00,
  0x1F, 0x9F, 0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xC0, 0x0F, 0xBE, 0x00, 0xFE,
  0x00, 0x7D, 0xF0, 0x07, 0x70, 0x03, 0xCF, 0x80, 0x3B, 0xC0, 0x3E, 0x7C,
  0x03, 0xDE, 0x01, 0xF3, 0xE0, 0x1E, 0xF0, 0x0F, 0x9F, 0x00, 0xF3, 0x80,
  0x7C, 0x7C, 0x07, 0x9C, 0x03, 0xE3, 0xE0, 0x38, 0xE0, 0x1E, 0x1F, 0x01,
  0xC7, 0x81, 0xF0, 0xF8, 0x1E, 0x3C, 0x0F, 0x87, 0xC0, 0xF1, 0xE0, 0x7C,
  0x3E, 0x07, 0x8F, 0x03, 0xE0, 0xF0, 0x3C, 0x38, 0x1F, 0x07, 0xC1, 0xC1,
  0xC0, 0xF0, 0x3E, 0x0E, 0x0F, 0x07, 0x81, 0xF0, 0xF0, 0x78, 0x7C, 0x0F,
  0x87, 0x83, 0xC3, 0xE0, 0x7C, 0x3C, 0x1E, 0x1F, 0x01, 0xE1, 0xE0, 0x70,
  0xF8, 0x0F, 0x8E, 0x03, 0x87, 0x80, 0x7C, 0x70, 0x1E, 0x3C, 0x03, 0xE7,
  0x80, 0xF1, 0xE0, 0x1F, 0x3C, 0x07, 0x9F, 0x00, 0xF9, 0xE0, 0x3C, 0xF8,
  0x03, 0xCF, 0x00, 0xE7, 0x80, 0x1E, 0x70, 0x07, 0x3C, 0x00, 0xFB, 0x80,
  0x3D, 0xE0, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x01, 0xF8,
  0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00,
  0x3F, 0x1F, 0xC0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xC7,
  0xFF, 0x80, 0x03, 0xE7, 0xFF, 0xE0, 0x01, 0xF7, 0xFF, 0xF8, 0x00, 0xFB,
  0xF8, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0x80, 0x3F, 0xF8, 0x0F, 0xE0, 0x1F,
  0xF8, 0x03, 0xF8, 0x1F, 0xFC, 0x00, 0xFE, 0x1F, 0xFE, 0x00, 0x3F, 0xFF,
  0xDF, 0x00, 0x0F, 0xFF, 0xCF, 0x80, 0x03, 0xFF, 0xE7, 0xC0, 0x00, 0xFF,
  0xC3, 0xE0, 0x00, 0x0F, 0x80,
};

const GFXglyph JetBrainsMono_Light72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 10, 53, 43, 17, -53 },
  { 68, 21, 22, 43, 11, -53 },
  { 126, 38, 53, 43, 3, -53 },
  { 378, 33, 73, 43, 5, -63 },
  { 680, 41, 53, 43, 1, -53 },
  { 952, 37, 54, 43, 4, -53 },
  { 1202, 6, 22, 43, 18, -53 },
  { 1219, 21, 69, 43, 14, -60 },
  { 1401, 22, 69, 43, 8, -60 },
  { 1591, 38, 37, 43, 3, -44 },
  { 1767, 33, 34, 43, 5, -41 },
  { 1908, 15, 23, 43, 12, -11 },
  { 1952, 23, 5, 43, 10, -26 },
  { 1967, 11, 12, 43, 16, -11 },
  { 1984, 31, 68, 43, 6, -60 },
  { 2248, 31, 54, 43, 6, -53 },
  { 2458, 32, 53, 43, 7, -53 },
  { 2670, 33, 53, 43, 5, -53 },
  { 2889, 31, 54, 43, 5, -53 },
  { 3099, 30, 53, 43, 6, -53 },
  { 3298, 31, 54, 43, 6, -53 },
  { 3508, 33, 54, 43, 5, -53 },
  { 3731, 32, 53, 43, 6, -53 },
  { 3943, 31, 54, 43, 6, -53 },
  { 4153, 33, 53, 43, 5, -53 },
  { 4372, 11, 41, 43, 16, -40 },
  { 4429, 15, 52, 43, 13, -40 },
  { 4527, 31, 38, 43, 6, -43 },
  { 4675, 31, 22, 43, 6, -35 },
  { 4761, 31, 38, 43, 6, -43 },
  { 4909, 26, 53, 43, 10, -53 },
  { 5082, 36, 66, 43, 4, -53 },
  { 5379, 35, 53, 43, 4, -53 },
  { 5611, 31, 53, 43, 7, -53 },
  { 5817, 30, 54, 43, 7, -53 },
  { 6020, 30, 53, 43, 7, -53 },
  { 6219, 29, 53, 43, 8, -53 },
  { 6412, 31, 53, 43, 7, -53 },
  { 6618, 30, 54, 43, 7, -53 },
  { 6821, 29, 53, 43, 7, -53 },
  { 7014, 27, 53, 43, 8, -53 },
  { 7193, 31, 54, 43, 4, -53 },
  { 7403, 33, 53, 43, 7, -53 },
  { 7622, 30, 53, 43, 8, -53 },
  { 7821, 31, 53, 43, 6, -53 },
  { 8027, 29, 53, 43, 7, -53 },
  { 8220, 30, 54, 43, 7, -53 },
  { 8423, 32, 53, 43, 7, -53 },
  { 8635, 32, 66, 43, 6, -53 },
  { 8899, 32, 53, 43, 7, -53 },
  { 9111, 33, 54, 43, 5, -53 },
  { 9334, 35, 53, 43, 4, -53 },
  { 9566, 29, 54, 43, 7, -53 },
  { 9762, 35, 53, 43, 4, -53 },
  { 9994, 39, 53, 43, 2, -53 },
  { 10253, 37, 53, 43, 3, -53 },
  { 10499, 37, 53, 43, 3, -53 },
  { 10745, 31, 53, 43, 6, -53 },
  { 10951, 17, 68, 43, 15, -60 },
  { 11096, 31, 68, 43, 6, -60 },
  { 11360, 17, 68, 43, 11, -60 },
  { 11505, 31, 29, 43, 6, -53 },
  { 11618, 35, 5, 43, 4, 2 },
  { 11640, 15, 11, 43, 13, -57 },
  { 11661, 31, 41, 43, 5, -40 },
  { 11820, 30, 54, 43, 7, -53 },
  { 12023, 31, 41, 43, 6, -40 },
  { 12182, 30, 54, 43, 6, -53 },
  { 12385, 31, 41, 43, 6, -40 },
  { 12544, 33, 53, 43, 5, -53 },
  { 12763, 29, 53, 43, 7, -40 },
  { 12956, 29, 53, 43, 7, -53 },
  { 13149, 34, 56, 43, 6, -56 },
  { 13387, 27, 69, 43, 6, -56 },
  { 13620, 33, 53, 43, 7, -53 },
  { 13839, 36, 53, 43, 3, -53 },
  { 14078, 33, 40, 43, 5, -40 },
  { 14243, 29, 40, 43, 7, -40 },
  { 14388, 31, 41, 43, 6, -40 },
  { 14547, 30, 53, 43, 7, -40 },
  { 14746, 29, 53, 43, 7, -40 },
  { 14939, 30, 40, 43, 8, -40 },
  { 15089, 30, 41, 43, 7, -40 },
  { 15243, 33, 51, 43, 4, -51 },
  { 15454, 29, 41, 43, 7, -40 },
  { 15603, 35, 40, 43, 4, -40 },
  { 15778, 37, 40, 43, 3, -40 },
  { 15963, 35, 40, 43, 4, -40 },
  { 16138, 35, 53, 43, 4, -40 },
  { 16370, 30, 40, 43, 7, -40 },
  { 16520, 31, 68, 43, 6, -60 },
  { 16784, 5, 68, 43, 19, -60 },
  { 16827, 31, 68, 43, 6, -60 },
  { 17091, 33, 15, 43, 5, -33 },
};

const GFXfont JetBrainsMono_Light72pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Light72pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Light72pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _JETBRAINSMONO_LIGHT72PT7B_H_
