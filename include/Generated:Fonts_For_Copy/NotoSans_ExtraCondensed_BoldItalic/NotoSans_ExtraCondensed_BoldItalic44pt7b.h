#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC44PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x03, 0xE0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7E, 0x03, 0xE0, 0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0x00, 0x3C, 0x7C, 0x00, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x1E,
  0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0x78,
  0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x03,
  0xC3, 0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x8F,
  0x00, 0x1E, 0x3C, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x81, 0xE3, 0xE0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF0,
  0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xC0,
  0x07, 0x8F, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC,
  0x0F, 0xD9, 0xC0, 0xF9, 0x88, 0x0F, 0x98, 0x00, 0xF9, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x05, 0xF8, 0x00,
  0xCF, 0x84, 0x0C, 0xF8, 0x60, 0xDF, 0x87, 0x09, 0xF8, 0x7F, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x03, 0xC0,
  0x00, 0x80, 0x7F, 0x00, 0xF0, 0x0F, 0xF0, 0x1F, 0x01, 0xFF, 0x81, 0xE0,
  0x1E, 0x78, 0x3C, 0x03, 0xC7, 0x83, 0xC0, 0x3C, 0x78, 0x78, 0x07, 0x87,
  0x87, 0x80, 0x78, 0x78, 0xF0, 0x07, 0x8F, 0x8F, 0x00, 0x78, 0xF1, 0xE0,
  0x0F, 0x0F, 0x3E, 0x00, 0xF0, 0xF3, 0xC0, 0x0F, 0x1E, 0x7C, 0x7C, 0xF1,
  0xE7, 0x9F, 0xEF, 0x3E, 0xFB, 0xFE, 0x7F, 0xCF, 0x3F, 0xF7, 0xF9, 0xE7,
  0x8F, 0x7F, 0x1E, 0x78, 0xF1, 0xE3, 0xCF, 0x8F, 0x00, 0x3C, 0xF0, 0xF0,
  0x07, 0x8F, 0x1F, 0x00, 0xF8, 0xF1, 0xE0, 0x0F, 0x1F, 0x1E, 0x01, 0xF1,
  0xE1, 0xE0, 0x1E, 0x1E, 0x3E, 0x03, 0xE1, 0xE3, 0xC0, 0x3C, 0x1E, 0x3C,
  0x07, 0x81, 0xF7, 0x80, 0x78, 0x0F, 0xF8, 0x0F, 0x00, 0xFF, 0x01, 0xF0,
  0x07, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x1F, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1,
  0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x7C,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x01,
  0x0F, 0xF8, 0x7C, 0x3F, 0xF8, 0xF8, 0x7F, 0xF3, 0xF1, 0xF3, 0xF7, 0xC7,
  0xE7, 0xFF, 0x8F, 0x87, 0xFE, 0x3F, 0x0F, 0xFC, 0x7E, 0x1F, 0xF0, 0xF8,
  0x1F, 0xC1, 0xF0, 0x3F, 0x83, 0xF0, 0xFF, 0x07, 0xF7, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFD, 0xFC, 0x0F, 0xE1, 0xF8, 0x3F, 0x3E,
  0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0x00, 0x3C, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F,
  0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C,
  0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x03,
  0x1F, 0x01, 0xEF, 0x05, 0xFF, 0xBC, 0xFF, 0xFF, 0x7F, 0xFF, 0x87, 0xFF,
  0xC1, 0xFF, 0xE1, 0xFE, 0x01, 0xFF, 0x81, 0xFB, 0xC1, 0xF9, 0xF0, 0x3C,
  0xFC, 0x0C, 0x3C, 0x04, 0x18, 0x00, 0x08, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x0F, 0x8F, 0xC7, 0xE3,
  0xE3, 0xF1, 0xF0, 0xF8, 0xFC, 0x7C, 0x3E, 0x3E, 0x1F, 0x00, 0x3F, 0xF7,
  0xFF, 0x7F, 0xF7, 0xFE, 0x7F, 0xEF, 0xFE, 0x18, 0xFD, 0xFF, 0xFF, 0xFF,
  0x9E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x1F,
  0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0xC1, 0xFB, 0xF0, 0xFC, 0x7C, 0x7E, 0x1F,
  0x1F, 0x87, 0xC7, 0xC1, 0xF3, 0xF0, 0xFC, 0xF8, 0x3F, 0x3E, 0x0F, 0xDF,
  0x83, 0xF7, 0xE0, 0xFD, 0xF0, 0x3E, 0x7C, 0x1F, 0xBF, 0x07, 0xEF, 0xC1,
  0xFB, 0xF0, 0x7E, 0xFC, 0x3F, 0x3E, 0x0F, 0xCF, 0x83, 0xF3, 0xE1, 0xF8,
  0xF8, 0x7E, 0x3E, 0x1F, 0x0F, 0x8F, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F,
  0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC1,
  0xFF, 0x0F, 0xF8, 0x7F, 0xE3, 0xFF, 0x9F, 0xFE, 0xFD, 0xF1, 0xE7, 0xC3,
  0x1F, 0x08, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x81, 0xF9, 0xFC, 0x07, 0x07, 0xE0, 0x30, 0x3F, 0x01, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0xF3, 0xFC, 0x04, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x84, 0x00, 0xFC, 0x30, 0x0F, 0xE1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3B, 0xE0,
  0x07, 0xFE, 0x00, 0xF7, 0xC0, 0x0F, 0x7C, 0x01, 0xE7, 0xC0, 0x3C, 0xFC,
  0x03, 0xCF, 0xC0, 0x78, 0xF8, 0x0F, 0x0F, 0x80, 0xF0, 0xF8, 0x1E, 0x1F,
  0x83, 0xE1, 0xF0, 0x3C, 0x1F, 0x07, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xF0,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xF8, 0x08, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x80, 0x7F, 0x0C,
  0x0F, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x1F, 0xFE, 0x07, 0xF0, 0x41, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF7, 0xE0, 0x7D, 0xFE,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xC3, 0xF3, 0xF8, 0x7E,
  0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xC7, 0xE1, 0xF8,
  0xFC, 0x3F, 0x1F, 0x87, 0xC3, 0xF1, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xC0,
  0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3F, 0x0F, 0x83, 0xF0,
  0xF8, 0x3E, 0x0F, 0xC7, 0xE0, 0xFC, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xBF,
  0x03, 0xF3, 0xF0, 0x7E, 0x1F, 0x87, 0xC1, 0xF8, 0xFC, 0x0F, 0x8F, 0xC0,
  0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x0F, 0xE7, 0xF0, 0xFF,
  0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x3E, 0x00,
  0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xCF, 0xC3,
  0xF1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7C, 0x1F, 0x9F,
  0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x1F, 0xCF, 0xC3, 0xF1, 0xF8, 0xFE, 0x3F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xF7, 0xC0, 0x79, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFC,
  0x00, 0x07, 0xC0, 0xF8, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x01, 0xF0, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xC0, 0x00, 0xF0,
  0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07,
  0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00,
  0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03,
  0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x1F, 0xFE, 0x1F,
  0xFE, 0x1F, 0xFF, 0x1C, 0x3F, 0x10, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0F,
  0x0F, 0x80, 0x81, 0xE1, 0xE0, 0xFF, 0x1C, 0x78, 0x7F, 0xE3, 0x8F, 0x1F,
  0xFC, 0x73, 0xC3, 0xC7, 0x8E, 0x78, 0xF1, 0xE1, 0xCE, 0x1E, 0x3C, 0x7B,
  0xC7, 0x87, 0x8F, 0x78, 0xF0, 0xF1, 0xEF, 0x1C, 0x3C, 0x39, 0xC7, 0x87,
  0x87, 0x78, 0xF0, 0xF1, 0xEF, 0x1E, 0x3E, 0x39, 0xE3, 0xC7, 0x8F, 0x3C,
  0x78, 0xF1, 0xC7, 0x8F, 0x7F, 0x78, 0xF1, 0xFF, 0xFE, 0x1E, 0x1F, 0x9F,
  0x83, 0xC1, 0xE1, 0xE0, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x10, 0x01, 0xF0, 0x0E, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xDF, 0x00, 0x3E, 0xF8, 0x01,
  0xF7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7C, 0x7C,
  0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x87, 0xC0, 0xFC,
  0x3E, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xC0, 0x7E, 0x7E, 0x03,
  0xF3, 0xF0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x7E, 0x3F,
  0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x7E,
  0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x87, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xF8, 0x7E, 0x07, 0xC1,
  0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x03, 0xF0, 0xF8, 0x1F, 0x8F,
  0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0x9C,
  0x0F, 0xE0, 0x41, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x0C, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x87, 0xF0, 0x7E, 0x1F,
  0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3,
  0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0,
  0x7F, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF0, 0x1F, 0x8F, 0xC0, 0xFE,
  0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF8, 0x7E,
  0x1F, 0xC1, 0xF9, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xF3, 0xE0,
  0xFE, 0x01, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE1, 0xFF,
  0x3F, 0x07, 0xFC, 0xFC, 0x1F, 0xF3, 0xF0, 0xFF, 0xCF, 0xC3, 0xFE, 0x3F,
  0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7C, 0x3F, 0x03,
  0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xE0, 0xFC, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x03,
  0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0,
  0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC,
  0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x1F,
  0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7E, 0x07, 0xE0,
  0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC,
  0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F,
  0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x00,
  0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0x80, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8,
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x03, 0xE0, 0xFC, 0x03, 0xE0,
  0xFC, 0x03, 0xE1, 0xF8, 0x07, 0xE3, 0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xC7,
  0xE0, 0x07, 0xCF, 0xC0, 0x0F, 0xCF, 0xC0, 0x0F, 0xDF, 0x80, 0x0F, 0xFF,
  0x00, 0x0F, 0xBF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xBE, 0x00, 0x3F, 0x3F,
  0x00, 0x3F, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x1F,
  0x00, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x1F,
  0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x01,
  0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x03,
  0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xBC, 0x1F,
  0xFC, 0x0F, 0xBC, 0x1F, 0xFC, 0x0F, 0xBC, 0x1E, 0xF8, 0x0F, 0xBC, 0x3E,
  0xF8, 0x1F, 0xBC, 0x3D, 0xF8, 0x1F, 0x3C, 0x7D, 0xF8, 0x1F, 0x3C, 0x7D,
  0xF0, 0x1F, 0x3C, 0xF9, 0xF0, 0x1F, 0x3C, 0xF9, 0xF0, 0x3F, 0x3D, 0xF3,
  0xF0, 0x3E, 0x3D, 0xF3, 0xF0, 0x3E, 0x3F, 0xE3, 0xE0, 0x3E, 0x3F, 0xE3,
  0xE0, 0x7E, 0x3F, 0xC3, 0xE0, 0x7E, 0x3F, 0xC7, 0xE0, 0x7C, 0x3F, 0x87,
  0xE0, 0x7C, 0x3F, 0x87, 0xC0, 0x7C, 0x3F, 0x87, 0xC0, 0xFC, 0x3F, 0x0F,
  0xC0, 0xF8, 0x3F, 0x0F, 0xC0, 0xF8, 0x3E, 0x0F, 0x80, 0x03, 0xF8, 0x07,
  0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x80, 0xF8, 0x0F, 0xE0, 0x3E, 0x03, 0xFC,
  0x0F, 0x81, 0xFF, 0x03, 0xE0, 0x7F, 0xC1, 0xF8, 0x1F, 0xF0, 0x7C, 0x07,
  0xFC, 0x1F, 0x03, 0xEF, 0x07, 0xC0, 0xFB, 0xE1, 0xF0, 0x3E, 0xF8, 0xFC,
  0x0F, 0xBE, 0x3E, 0x03, 0xEF, 0x8F, 0x81, 0xFB, 0xE3, 0xE0, 0x7C, 0x7C,
  0xF8, 0x1F, 0x1F, 0x7E, 0x07, 0xC7, 0xDF, 0x01, 0xF1, 0xF7, 0xC0, 0xFC,
  0x7D, 0xF0, 0x3E, 0x1F, 0x7C, 0x0F, 0x83, 0xFE, 0x03, 0xE0, 0xFF, 0x81,
  0xF8, 0x3F, 0xE0, 0x7C, 0x0F, 0xF8, 0x1F, 0x03, 0xFE, 0x07, 0xC0, 0xFF,
  0x01, 0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x3E, 0x01, 0xFC, 0x0F, 0x80,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xCF, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0x7F,
  0x1F, 0x80, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0xC0, 0x3F, 0x7E,
  0x01, 0xFD, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xBF, 0x80, 0x7E, 0xFC, 0x01,
  0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0xFC, 0xFC, 0x03, 0xF3,
  0xF0, 0x1F, 0xCF, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0,
  0x7F, 0x0F, 0xE3, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0x87, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F,
  0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF8, 0xFF, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xCF,
  0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0x7F, 0x1F, 0x80, 0xFC, 0xFC, 0x03, 0xF3,
  0xF0, 0x0F, 0xDF, 0xC0, 0x3F, 0x7E, 0x01, 0xFD, 0xF8, 0x07, 0xEF, 0xE0,
  0x1F, 0xBF, 0x80, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x3F,
  0xBF, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x7E, 0x3F,
  0x01, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0x7F, 0x0F, 0xE3, 0xF8, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3E, 0x7F, 0x83, 0xF0, 0xFC,
  0x1F, 0x87, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0,
  0x7C, 0x1F, 0x87, 0xE0, 0xF8, 0x7F, 0x07, 0xC7, 0xF0, 0x7F, 0xFF, 0x83,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7E, 0x7C,
  0x03, 0xF3, 0xE0, 0x1F, 0x1F, 0x80, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E,
  0x3F, 0x03, 0xF0, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8,
  0x7E, 0x0F, 0xC3, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80,
  0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xC1,
  0x80, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x83,
  0x01, 0xFC, 0x1C, 0x1F, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF,
  0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81,
  0xF8, 0x3E, 0x03, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F,
  0x07, 0xE0, 0x7E, 0x1F, 0x80, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0,
  0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F,
  0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7C, 0x07, 0xE1, 0xF8, 0x1F, 0x83, 0xF0,
  0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x3E, 0x07,
  0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x3F, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0xFC, 0x03,
  0xFF, 0xC0, 0x3E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xCF, 0xC0,
  0xFC, 0xFC, 0x0F, 0x8F, 0x81, 0xF8, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0xF8,
  0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0xFC, 0x0F,
  0x8F, 0x80, 0xF9, 0xF8, 0x0F, 0x9F, 0x80, 0xF9, 0xF0, 0x0F, 0xBF, 0x00,
  0xFB, 0xE0, 0x0F, 0xBE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x3F, 0x7C, 0x07, 0xE0, 0x7E,
  0x7C, 0x07, 0xE0, 0x7C, 0x7C, 0x0F, 0xC0, 0x7C, 0x7C, 0x0F, 0xC0, 0xFC,
  0x7C, 0x0F, 0xC0, 0xF8, 0x7C, 0x1F, 0xC1, 0xF8, 0x7C, 0x1F, 0xC1, 0xF8,
  0x7C, 0x3F, 0xC1, 0xF0, 0x7C, 0x3F, 0xC3, 0xF0, 0x7C, 0x3F, 0xC3, 0xE0,
  0x7C, 0x7F, 0xC7, 0xE0, 0x7C, 0x7B, 0xC7, 0xE0, 0x7C, 0xFB, 0xC7, 0xC0,
  0xFC, 0xFB, 0xCF, 0xC0, 0xFC, 0xF3, 0xCF, 0x80, 0xFD, 0xF3, 0xCF, 0x80,
  0xFD, 0xE7, 0xDF, 0x80, 0xFF, 0xE7, 0xDF, 0x00, 0xFB, 0xE7, 0xFF, 0x00,
  0xFB, 0xC7, 0xFE, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0xC7, 0xFE, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x80,
  0x7E, 0x0F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xC0, 0x0F, 0xC7, 0xE0,
  0x03, 0xE7, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7D, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0xCF, 0x80, 0x0F,
  0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xE0, 0xFC, 0x03,
  0xF0, 0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xFF,
  0x81, 0xFB, 0xF0, 0x7E, 0x7E, 0x0F, 0xC7, 0xC3, 0xF0, 0xF8, 0x7C, 0x1F,
  0x1F, 0x83, 0xE3, 0xE0, 0x7C, 0xFC, 0x0F, 0x9F, 0x01, 0xFF, 0xE0, 0x3F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0xF8, 0x3C, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0x78, 0x03,
  0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x07, 0xC3, 0xC1, 0xF0, 0x7C, 0x3E,
  0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x1E, 0x7C, 0x03, 0xFF, 0x00, 0x7C, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xF0, 0xFE, 0x3F, 0x1F, 0x87, 0xC3, 0xF0, 0xF8,
  0x3E, 0x03, 0xF1, 0xF0, 0x7F, 0xBE, 0x0F, 0xFB, 0xE1, 0xFF, 0xFE, 0x1F,
  0xDF, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0xC7, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7,
  0xE0, 0xFC, 0x7E, 0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8,
  0xFC, 0x1F, 0x8F, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7F,
  0x0F, 0xEF, 0xF0, 0xFF, 0xFE, 0x07, 0xFB, 0xE0, 0x7F, 0xBE, 0x03, 0xE3,
  0xE0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF9,
  0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xCF, 0xC3, 0xF0,
  0xF8, 0xFC, 0x1F, 0x1F, 0x83, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81,
  0xF3, 0xF0, 0x7E, 0x7C, 0x0F, 0xCF, 0x81, 0xF9, 0xF0, 0x3E, 0x7E, 0x0F,
  0xCF, 0xC1, 0xF9, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xF3, 0xF1, 0xFF, 0xFE,
  0x3F, 0xFF, 0x87, 0xDF, 0xE0, 0xF1, 0xF8, 0x00, 0x01, 0xFE, 0x03, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFE, 0x1F, 0xEE, 0x3F, 0x82, 0x3F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x10, 0xFF, 0xF0,
  0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xCF, 0x80,
  0x7F, 0xBE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0x7F, 0x83, 0xF0,
  0xFC, 0x0F, 0xC3, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x03, 0xE0, 0xFC, 0x0F, 0x83, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8, 0x3F,
  0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x3F, 0x0F,
  0xC0, 0xFC, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xEF, 0x80,
  0x3F, 0x3E, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF1,
  0xF8, 0xF9, 0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x7E, 0x1F, 0xBE, 0x3F,
  0x9F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0x07, 0xFC, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x81, 0x87, 0xFF, 0xC3,
  0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x20, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x27, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFC,
  0x7C, 0x07, 0xFB, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xF7, 0xF8,
  0x3F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03,
  0xF1, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF,
  0xF8, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x80, 0x7E, 0x03, 0x83, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xB0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xFB, 0xF0, 0x3F,
  0xFF, 0x07, 0xDF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xF1, 0xF8, 0xFC,
  0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7C, 0x1F, 0x8F, 0x83, 0xE3, 0xF0,
  0x7C, 0x7E, 0x1F, 0x8F, 0x83, 0xF1, 0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0xC1,
  0xF1, 0xF8, 0x7E, 0x3E, 0x0F, 0xC7, 0xC1, 0xF1, 0xF8, 0x3E, 0x3F, 0x0F,
  0xC7, 0xE1, 0xF8, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0,
  0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x0D, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x8F, 0xC0, 0xF8, 0x7C, 0x07, 0xC7, 0xE0,
  0x3E, 0x7E, 0x03, 0xF7, 0xE0, 0x1F, 0x3E, 0x00, 0xFB, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x7F, 0x7C, 0x03, 0xF3, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xFC,
  0x07, 0xC3, 0xE0, 0x7E, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8,
  0x3F, 0x00, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xF8, 0x00, 0x07, 0x9F, 0x87, 0xE0, 0x7D, 0xFE, 0x7F, 0x83,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0xFE, 0xFF, 0xBF, 0x87, 0xE3,
  0xF8, 0xFC, 0x7E, 0x1F, 0x87, 0xC3, 0xF0, 0xFC, 0x3E, 0x1F, 0x07, 0xC1,
  0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xFC, 0x7E, 0x1F, 0x87, 0xC3,
  0xE0, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x8F, 0xC3,
  0xF0, 0xFC, 0x7E, 0x1F, 0x87, 0xC3, 0xE0, 0xF8, 0x3E, 0x1F, 0x07, 0xC1,
  0xF0, 0xF8, 0x3E, 0x1F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7E, 0x1F, 0x07, 0xC3,
  0xE0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xF0, 0x07, 0x8F, 0x80, 0xF7, 0xF8,
  0x3E, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0x8F, 0xC7, 0xE1, 0xF8,
  0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xE0, 0xF8, 0x7C, 0x1F, 0x1F, 0x83, 0xE3,
  0xF0, 0xFC, 0x7C, 0x1F, 0x8F, 0x83, 0xE1, 0xF0, 0x7C, 0x7E, 0x0F, 0x8F,
  0xC3, 0xF1, 0xF0, 0x7E, 0x3E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF8, 0x3E, 0x3E,
  0x0F, 0xC7, 0xC1, 0xF8, 0x00, 0x30, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xE3, 0xF0, 0xFC, 0xFC, 0x3F, 0x7E, 0x0F,
  0xDF, 0x83, 0xF7, 0xC0, 0xFD, 0xF0, 0x3F, 0xFC, 0x0F, 0xBF, 0x03, 0xEF,
  0xC0, 0xFB, 0xF0, 0x7E, 0xF8, 0x1F, 0xBE, 0x0F, 0xCF, 0x83, 0xF3, 0xF1,
  0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xE0,
  0x00, 0x00, 0xF1, 0xF0, 0x07, 0xDF, 0xE0, 0x1F, 0x7F, 0xC0, 0x7F, 0xFF,
  0x01, 0xFC, 0xFC, 0x07, 0xE1, 0xF0, 0x3F, 0x07, 0xC0, 0xFC, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xC0,
  0xFC, 0x1F, 0x03, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xFB, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x01, 0xF7, 0xF8, 0x07, 0xCF, 0xC0, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF9, 0xF0, 0x7F, 0xBE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xDF, 0xE1,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC,
  0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x1F,
  0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xEF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xF7, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x9F, 0x0F, 0xBF, 0x0F, 0xBF, 0x0F, 0xFE, 0x0F,
  0xFE, 0x0F, 0xFE, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0x03, 0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F,
  0x8E, 0x3F, 0x02, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x81, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF,
  0xE0, 0xFF, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x07,
  0xFC, 0xFF, 0xE7, 0xFF, 0x7F, 0xF8, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x87, 0xFC, 0x1F, 0xE0, 0xFF,
  0x03, 0xF8, 0x00, 0x0F, 0x83, 0xE3, 0xF0, 0x7C, 0x7C, 0x1F, 0x8F, 0x83,
  0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF0, 0x7E, 0x3E, 0x0F,
  0x87, 0xC1, 0xF1, 0xF8, 0x3E, 0x3F, 0x0F, 0xC7, 0xC1, 0xF8, 0xF8, 0x3E,
  0x1F, 0x07, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xC3, 0xF1, 0xF8,
  0x7E, 0x7F, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xEF, 0x01, 0xF9, 0xE0,
  0xF8, 0x1F, 0xFC, 0x0F, 0xBE, 0x0F, 0xDF, 0x07, 0xCF, 0x87, 0xE7, 0xC3,
  0xE3, 0xE1, 0xF1, 0xF1, 0xF8, 0xF8, 0xF8, 0x7C, 0xFC, 0x3E, 0x7C, 0x1F,
  0x3E, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0x7C, 0x1F, 0x83, 0xEF, 0x87, 0xF0, 0xFD, 0xF0, 0xFE,
  0x1F, 0x3E, 0x1F, 0xC3, 0xE7, 0xC7, 0xF8, 0xF8, 0xF8, 0xFF, 0x1F, 0x1F,
  0x3F, 0xE3, 0xE3, 0xE7, 0xFC, 0xF8, 0x7C, 0xFF, 0x9F, 0x0F, 0xBF, 0xF7,
  0xC1, 0xF7, 0xBE, 0xF8, 0x3C, 0xF7, 0x9F, 0x07, 0xBE, 0xF7, 0xC0, 0xF7,
  0x9E, 0xF8, 0x3E, 0xF3, 0xDE, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x8F, 0xF8,
  0x1F, 0xF1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF0, 0x0F, 0xE0,
  0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF0, 0x07, 0xE0, 0x7E, 0x00,
  0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0x3E, 0x3F, 0x00, 0xF8, 0xFC, 0x03,
  0xE7, 0xE0, 0x0F, 0xDF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3E,
  0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xC7, 0xC0, 0x3F, 0x1F, 0x01, 0xF8, 0x7C,
  0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8,
  0x0F, 0x83, 0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x3F, 0x00,
  0xF8, 0x7C, 0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F,
  0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB,
  0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x11, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x08, 0x7F, 0xFC, 0x1F, 0xFF,
  0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0x80, 0x27, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x7F, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xE8, 0x03, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 13, 31, 11, 0, -31 },
  { 52, 16, 11, 17, 4, -31 },
  { 74, 22, 31, 21, 0, -31 },
  { 160, 20, 36, 19, 0, -33 },
  { 250, 28, 32, 31, 2, -32 },
  { 362, 23, 32, 23, 0, -32 },
  { 454, 8, 11, 11, 4, -31 },
  { 465, 14, 39, 12, 1, -32 },
  { 534, 14, 39, 12, -3, -32 },
  { 603, 17, 19, 18, 3, -34 },
  { 644, 18, 21, 20, 2, -26 },
  { 692, 9, 12, 10, -2, -6 },
  { 706, 12, 6, 13, 0, -15 },
  { 715, 7, 7, 10, 0, -7 },
  { 722, 22, 32, 16, -2, -32 },
  { 810, 18, 32, 19, 1, -32 },
  { 882, 14, 31, 19, 4, -31 },
  { 937, 21, 32, 19, -2, -32 },
  { 1021, 21, 32, 19, -1, -32 },
  { 1105, 20, 32, 19, -1, -32 },
  { 1185, 20, 31, 19, 0, -31 },
  { 1263, 19, 32, 19, 1, -32 },
  { 1339, 20, 31, 19, 1, -31 },
  { 1417, 20, 32, 19, 0, -32 },
  { 1497, 19, 32, 19, 0, -32 },
  { 1573, 11, 24, 11, 0, -24 },
  { 1606, 13, 30, 11, -2, -24 },
  { 1655, 18, 21, 20, 2, -26 },
  { 1703, 18, 13, 20, 2, -22 },
  { 1733, 18, 21, 20, 2, -26 },
  { 1781, 16, 32, 15, 1, -32 },
  { 1845, 27, 36, 29, 1, -32 },
  { 1967, 21, 32, 21, -3, -32 },
  { 2051, 21, 31, 21, 0, -31 },
  { 2133, 20, 32, 19, 2, -32 },
  { 2213, 22, 31, 23, 0, -31 },
  { 2299, 20, 31, 18, 0, -31 },
  { 2377, 20, 31, 17, 0, -31 },
  { 2455, 22, 32, 23, 2, -32 },
  { 2543, 25, 31, 23, 0, -31 },
  { 2640, 19, 31, 14, -2, -31 },
  { 2714, 19, 40, 11, -7, -31 },
  { 2809, 24, 31, 20, 0, -31 },
  { 2902, 14, 31, 17, 0, -31 },
  { 2957, 32, 31, 31, 0, -31 },
  { 3081, 26, 31, 25, 0, -31 },
  { 3182, 22, 32, 24, 2, -32 },
  { 3270, 22, 31, 20, 0, -31 },
  { 3356, 22, 39, 24, 2, -32 },
  { 3464, 21, 31, 20, 0, -31 },
  { 3546, 21, 32, 18, -1, -32 },
  { 3630, 18, 31, 17, 3, -31 },
  { 3700, 23, 31, 23, 1, -31 },
  { 3790, 20, 31, 20, 4, -31 },
  { 3868, 32, 31, 31, 3, -31 },
  { 3992, 25, 31, 19, -3, -31 },
  { 4089, 19, 31, 19, 4, -31 },
  { 4163, 22, 31, 17, -2, -31 },
  { 4249, 18, 39, 12, -2, -32 },
  { 4337, 9, 32, 17, 4, -32 },
  { 4373, 17, 39, 12, -3, -32 },
  { 4456, 19, 18, 19, 0, -31 },
  { 4499, 15, 3, 14, -4, 4 },
  { 4505, 9, 7, 13, 6, -34 },
  { 4513, 20, 24, 20, 1, -24 },
  { 4573, 19, 33, 20, 0, -33 },
  { 4652, 16, 24, 16, 1, -24 },
  { 4700, 22, 33, 20, 1, -33 },
  { 4791, 17, 24, 19, 1, -24 },
  { 4842, 22, 45, 12, -5, -34 },
  { 4966, 22, 35, 20, -1, -24 },
  { 5063, 19, 33, 20, 0, -33 },
  { 5142, 12, 33, 10, 0, -33 },
  { 5192, 18, 44, 10, -6, -33 },
  { 5291, 21, 33, 19, 0, -33 },
  { 5378, 12, 33, 10, 0, -33 },
  { 5428, 29, 24, 30, 0, -24 },
  { 5515, 19, 24, 20, 0, -24 },
  { 5572, 18, 25, 20, 1, -25 },
  { 5629, 22, 34, 20, -3, -24 },
  { 5723, 20, 35, 20, 1, -24 },
  { 5811, 16, 24, 14, 0, -24 },
  { 5859, 16, 24, 16, 0, -24 },
  { 5907, 13, 29, 13, 1, -29 },
  { 5955, 19, 24, 20, 1, -24 },
  { 6012, 17, 24, 18, 3, -24 },
  { 6063, 27, 24, 27, 2, -24 },
  { 6144, 22, 24, 18, -2, -24 },
  { 6210, 23, 35, 18, -3, -24 },
  { 6311, 18, 24, 15, -2, -24 },
  { 6365, 18, 38, 15, 0, -31 },
  { 6451, 5, 44, 16, 5, -34 },
  { 6479, 17, 38, 15, -3, -31 },
  { 6560, 18, 7, 20, 2, -19 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic44pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC44PT7B_H_
