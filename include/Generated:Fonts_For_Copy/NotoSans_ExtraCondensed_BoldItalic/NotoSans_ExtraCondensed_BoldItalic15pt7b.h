#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC15PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x33, 0x66, 0x66, 0x0C, 0xC0, 0x6D, 0xA5, 0xB6, 0x1A, 0x1A,
  0x16, 0x7F, 0x7E, 0x2C, 0x2A, 0xFC, 0x58, 0x50, 0xD0, 0x08, 0x7C, 0xD3,
  0x87, 0x07, 0x07, 0x0E, 0xED, 0xF0, 0x81, 0x00, 0x71, 0x29, 0x35, 0x92,
  0x8B, 0xD5, 0x5F, 0x7A, 0x29, 0x35, 0x92, 0x99, 0xC0, 0x1C, 0x3E, 0x34,
  0x3C, 0x38, 0x3B, 0x7E, 0xDE, 0xCC, 0xDC, 0xF6, 0x6D, 0x60, 0x18, 0x8C,
  0x46, 0x31, 0x18, 0xC6, 0x31, 0x8C, 0x00, 0x10, 0xC6, 0x31, 0x8C, 0x62,
  0x31, 0x98, 0xCC, 0x00, 0x20, 0xCF, 0x5F, 0x73, 0x65, 0x00, 0x20, 0x82,
  0x3F, 0xFC, 0x82, 0x00, 0x76, 0x6C, 0xFF, 0xF0, 0x03, 0x06, 0x06, 0x0C,
  0x0C, 0x18, 0x10, 0x30, 0x20, 0x60, 0xC0, 0x1C, 0xF2, 0x59, 0x6D, 0xBC,
  0xF3, 0xDB, 0xE7, 0x00, 0x19, 0xDF, 0xB1, 0x18, 0xC6, 0x33, 0x18, 0x0E,
  0x3E, 0x13, 0x06, 0x06, 0x0C, 0x1C, 0x18, 0x30, 0x7C, 0xFC, 0x1C, 0x7C,
  0x98, 0x20, 0xC6, 0x07, 0x06, 0x0D, 0xF3, 0xC0, 0x06, 0x18, 0x70, 0xE2,
  0xCD, 0x92, 0x7E, 0xFC, 0x30, 0x40, 0x3E, 0x78, 0xC1, 0x07, 0x8F, 0x83,
  0x06, 0x1D, 0xF3, 0xC0, 0x0E, 0x3C, 0xC3, 0x07, 0xCF, 0xBB, 0x66, 0xCC,
  0xF1, 0xE0, 0x3E, 0xFC, 0x18, 0x60, 0xC3, 0x06, 0x18, 0x30, 0xC3, 0x80,
  0x1C, 0x7D, 0x9B, 0x23, 0xC7, 0x1E, 0x66, 0xCD, 0xB1, 0xE0, 0x1C, 0x79,
  0x93, 0x36, 0xCD, 0x9F, 0x06, 0x19, 0xF3, 0xC0, 0x76, 0x00, 0x00, 0xCC,
  0x39, 0x80, 0x00, 0x01, 0x8C, 0x66, 0x00, 0x04, 0x77, 0x30, 0xF0, 0xF0,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x83, 0x87, 0x87, 0x3B, 0x88, 0x00, 0x39,
  0xF0, 0xC2, 0x18, 0xC6, 0x18, 0x01, 0x8C, 0x00, 0x07, 0x06, 0x63, 0x08,
  0xBF, 0x4A, 0xD4, 0xA5, 0x6B, 0x5A, 0xDB, 0x30, 0x04, 0x20, 0xF0, 0x06,
  0x1C, 0x38, 0xF1, 0xE6, 0xCD, 0x9F, 0x66, 0xCF, 0x18, 0x3C, 0x7C, 0xD9,
  0x36, 0xEF, 0x1B, 0x36, 0xCD, 0xFB, 0xE0, 0x1E, 0x79, 0x87, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0xE3, 0xC0, 0x3C, 0x3E, 0x36, 0x37, 0x67, 0x66, 0x66,
  0x66, 0xCC, 0xFC, 0xF0, 0x3E, 0x78, 0xC1, 0x86, 0x4F, 0x18, 0x30, 0xC1,
  0xF3, 0xE0, 0x3E, 0x78, 0xC1, 0x86, 0x4F, 0x1E, 0x30, 0xC1, 0x83, 0x00,
  0x1E, 0x7D, 0x8F, 0x0C, 0x1B, 0xF7, 0x66, 0xCD, 0xF9, 0xE0, 0x33, 0x33,
  0x33, 0x33, 0x63, 0x7E, 0x66, 0x66, 0xC6, 0xC6, 0xCC, 0x1E, 0x78, 0x60,
  0xC1, 0x83, 0x0C, 0x18, 0x30, 0x63, 0xE0, 0x0C, 0x30, 0xC3, 0x18, 0x61,
  0x86, 0x18, 0xC3, 0x0C, 0xE3, 0x80, 0x33, 0x36, 0x36, 0x2C, 0x78, 0x78,
  0x78, 0x78, 0xCC, 0xCC, 0xCC, 0x31, 0x8C, 0x66, 0x31, 0x8C, 0xC7, 0xFE,
  0x38, 0xE7, 0x1C, 0xE7, 0x1C, 0xE7, 0xBC, 0xF7, 0x9E, 0xB2, 0xF4, 0xDD,
  0x9B, 0xB3, 0x66, 0x00, 0x31, 0x9C, 0xCE, 0x47, 0x67, 0xB3, 0x59, 0xAC,
  0x9C, 0xCE, 0x67, 0x33, 0x80, 0x1C, 0x7D, 0x9E, 0x3C, 0x78, 0xF1, 0xE6,
  0xCD, 0xF3, 0xC0, 0x3C, 0x7C, 0xD9, 0xB6, 0x6F, 0xDF, 0x30, 0xC1, 0x83,
  0x00, 0x1C, 0x7D, 0x9E, 0x3C, 0x78, 0xF1, 0xE6, 0xCD, 0xF3, 0xC1, 0x83,
  0x83, 0x00, 0x3C, 0x7C, 0xD9, 0x36, 0x6F, 0x9E, 0x3C, 0xC9, 0x9B, 0x30,
  0x1C, 0x7D, 0xD3, 0x07, 0x07, 0x06, 0x0E, 0x19, 0xF3, 0xC0, 0x7F, 0xF3,
  0x0C, 0x61, 0x86, 0x18, 0x63, 0x0C, 0x00, 0x66, 0xCD, 0x9E, 0x3C, 0xD9,
  0xB3, 0x66, 0xD9, 0xF3, 0xC0, 0xC7, 0x8F, 0x36, 0x6C, 0x9B, 0x36, 0x78,
  0xF1, 0xC3, 0x80, 0xC4, 0x79, 0x9B, 0x33, 0x66, 0x6D, 0xD9, 0xAB, 0x3D,
  0x47, 0xB8, 0xE7, 0x1C, 0xC3, 0x38, 0x00, 0x19, 0x8D, 0x86, 0x83, 0xC1,
  0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x36, 0x31, 0x80, 0xC7, 0x99, 0x33, 0xC7,
  0x0E, 0x18, 0x30, 0x60, 0xC3, 0x00, 0x1F, 0x3F, 0x06, 0x0C, 0x0C, 0x18,
  0x18, 0x30, 0x60, 0x7C, 0xFC, 0x1C, 0x71, 0x04, 0x30, 0xC3, 0x08, 0x61,
  0x86, 0x18, 0xF0, 0xC4, 0x46, 0x66, 0x66, 0x22, 0x30, 0x1C, 0xF0, 0x86,
  0x18, 0x61, 0x84, 0x30, 0xC3, 0x08, 0xE0, 0x08, 0x30, 0x71, 0xE6, 0xC8,
  0xB1, 0x80, 0xF8, 0xEC, 0x3E, 0xDD, 0xB3, 0x6C, 0xD9, 0xBF, 0x34, 0x30,
  0x60, 0xC3, 0xE7, 0x6C, 0xD9, 0xA6, 0xCD, 0xFB, 0xE0, 0x3D, 0xD6, 0x18,
  0xC3, 0x0F, 0x9E, 0x03, 0x06, 0x06, 0x3E, 0x6E, 0x64, 0x4C, 0xCC, 0xCC,
  0xFC, 0x68, 0x3D, 0xB6, 0xDE, 0xC3, 0x0C, 0x9E, 0x07, 0x0C, 0x0C, 0x1E,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0xE0, 0xC0, 0x3E,
  0xDD, 0xB3, 0x6C, 0xD9, 0xBF, 0x34, 0x19, 0x33, 0xC3, 0x00, 0x30, 0x60,
  0xC3, 0xE7, 0xEC, 0x9B, 0x36, 0xCD, 0x9B, 0x60, 0x33, 0x16, 0x66, 0x66,
  0xCC, 0xC0, 0x0C, 0x30, 0x46, 0x18, 0x61, 0x86, 0x30, 0xC3, 0x0C, 0x23,
  0x8C, 0x00, 0x30, 0x60, 0x83, 0x36, 0xCF, 0x1E, 0x3C, 0xD9, 0xB3, 0x70,
  0x33, 0x36, 0x66, 0x66, 0xCC, 0xC0, 0x7D, 0xDF, 0xB6, 0xCD, 0xB2, 0x4D,
  0xB3, 0x6C, 0x9B, 0x66, 0x3C, 0xFD, 0x93, 0x64, 0xD9, 0xB3, 0x6C, 0x3D,
  0xB6, 0x53, 0xCF, 0x3F, 0x9E, 0x3E, 0x3B, 0x33, 0x33, 0x26, 0x66, 0x7E,
  0x7C, 0x60, 0x40, 0xC0, 0xC0, 0x3E, 0xDD, 0x92, 0x6C, 0xD9, 0xBF, 0x34,
  0x18, 0x30, 0x60, 0xC0, 0x7D, 0xE6, 0x18, 0x63, 0x0C, 0x30, 0x7D, 0xA6,
  0x1C, 0x38, 0x6F, 0x3C, 0x11, 0x9E, 0xC6, 0x31, 0x88, 0xD3, 0x80, 0x66,
  0xCD, 0x93, 0x64, 0xD9, 0xBE, 0x34, 0xCF, 0x6D, 0xBC, 0xF3, 0x8E, 0x30,
  0xD9, 0xEC, 0xBE, 0xDD, 0x4A, 0xE7, 0x73, 0x31, 0x98, 0x37, 0x36, 0x1C,
  0x18, 0x38, 0x3C, 0x6C, 0xEC, 0x33, 0x36, 0x36, 0x3C, 0x3C, 0x38, 0x38,
  0x30, 0x30, 0x20, 0xE0, 0xC0, 0x3E, 0x18, 0x60, 0xC3, 0x04, 0x1E, 0x7C,
  0x0C, 0x71, 0x8C, 0x30, 0xCE, 0x38, 0x61, 0x86, 0x18, 0x70, 0xFF, 0xFF,
  0xFF, 0xFC, 0x10, 0xE1, 0x86, 0x18, 0x61, 0xC7, 0x30, 0xC3, 0x18, 0xE0,
  0x47, 0xF9, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 6, 4, 6, 1, -11 },
  { 10, 8, 11, 7, 0, -11 },
  { 21, 7, 12, 6, 0, -11 },
  { 32, 9, 11, 11, 1, -11 },
  { 45, 8, 11, 8, 0, -11 },
  { 56, 3, 4, 4, 1, -11 },
  { 58, 5, 13, 4, 0, -11 },
  { 67, 5, 13, 4, -1, -11 },
  { 76, 6, 7, 6, 1, -12 },
  { 82, 6, 7, 7, 1, -9 },
  { 88, 4, 4, 4, -1, -2 },
  { 90, 4, 2, 4, 0, -5 },
  { 91, 2, 2, 4, 0, -2 },
  { 92, 8, 11, 6, -1, -11 },
  { 103, 6, 11, 6, 0, -11 },
  { 112, 5, 11, 7, 1, -11 },
  { 119, 8, 11, 6, -1, -11 },
  { 130, 7, 11, 6, 0, -11 },
  { 140, 7, 11, 7, 0, -11 },
  { 150, 7, 11, 6, 0, -11 },
  { 160, 7, 11, 6, 0, -11 },
  { 170, 7, 11, 6, 0, -11 },
  { 180, 7, 11, 6, 0, -11 },
  { 190, 7, 11, 6, 0, -11 },
  { 200, 4, 8, 4, 0, -8 },
  { 204, 5, 10, 4, -1, -8 },
  { 211, 6, 7, 7, 1, -9 },
  { 217, 6, 5, 7, 1, -8 },
  { 221, 6, 7, 7, 1, -9 },
  { 227, 6, 11, 5, 0, -11 },
  { 236, 10, 12, 10, 0, -11 },
  { 251, 7, 11, 7, -1, -11 },
  { 261, 7, 11, 7, 0, -11 },
  { 271, 7, 11, 7, 1, -11 },
  { 281, 8, 11, 8, 0, -11 },
  { 292, 7, 11, 6, 0, -11 },
  { 302, 7, 11, 6, 0, -11 },
  { 312, 7, 11, 8, 1, -11 },
  { 322, 8, 11, 8, 0, -11 },
  { 333, 7, 11, 5, -1, -11 },
  { 343, 6, 14, 4, -2, -11 },
  { 354, 8, 11, 7, 0, -11 },
  { 365, 5, 11, 6, 0, -11 },
  { 372, 11, 11, 10, 0, -11 },
  { 388, 9, 11, 8, 0, -11 },
  { 401, 7, 11, 8, 1, -11 },
  { 411, 7, 11, 7, 0, -11 },
  { 421, 7, 14, 8, 1, -11 },
  { 434, 7, 11, 7, 0, -11 },
  { 444, 7, 11, 6, 0, -11 },
  { 454, 6, 11, 6, 1, -11 },
  { 463, 7, 11, 8, 1, -11 },
  { 473, 7, 11, 7, 1, -11 },
  { 483, 11, 11, 11, 1, -11 },
  { 499, 9, 11, 7, -1, -11 },
  { 512, 7, 11, 6, 1, -11 },
  { 522, 8, 11, 6, -1, -11 },
  { 533, 6, 13, 4, -1, -11 },
  { 543, 4, 11, 6, 1, -11 },
  { 549, 6, 13, 4, -1, -11 },
  { 559, 7, 7, 7, 0, -11 },
  { 566, 5, 1, 5, -1, 1 },
  { 567, 3, 2, 4, 2, -11 },
  { 568, 7, 8, 7, 0, -8 },
  { 575, 7, 11, 7, 0, -11 },
  { 585, 6, 8, 5, 0, -8 },
  { 591, 8, 11, 7, 0, -11 },
  { 602, 6, 8, 6, 0, -8 },
  { 608, 8, 15, 4, -2, -11 },
  { 623, 7, 12, 7, 0, -8 },
  { 634, 7, 11, 7, 0, -11 },
  { 644, 4, 11, 3, 0, -11 },
  { 650, 6, 15, 3, -2, -11 },
  { 662, 7, 11, 6, 0, -11 },
  { 672, 4, 11, 3, 0, -11 },
  { 678, 10, 8, 10, 0, -8 },
  { 688, 7, 8, 7, 0, -8 },
  { 695, 6, 8, 7, 0, -8 },
  { 701, 8, 12, 7, -1, -8 },
  { 713, 7, 12, 7, 0, -8 },
  { 724, 6, 8, 5, 0, -8 },
  { 730, 6, 8, 5, 0, -8 },
  { 736, 5, 10, 4, 0, -10 },
  { 743, 7, 8, 7, 0, -8 },
  { 750, 6, 8, 6, 1, -8 },
  { 756, 9, 8, 9, 1, -8 },
  { 765, 8, 8, 6, -1, -8 },
  { 773, 8, 12, 6, -1, -8 },
  { 785, 7, 8, 5, -1, -8 },
  { 792, 6, 13, 5, 0, -11 },
  { 802, 2, 15, 6, 2, -12 },
  { 806, 6, 13, 5, -1, -11 },
  { 816, 6, 3, 7, 1, -7 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic15pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC15PT7B_H_
