#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC32PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x7C, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x00, 0x00, 0x0C, 0x0F, 0x0F,
  0x87, 0xC3, 0xC0, 0x79, 0xEF, 0x3D, 0xE7, 0xBC, 0xE7, 0x3D, 0xE7, 0xBC,
  0xF7, 0x1C, 0x01, 0xC7, 0x01, 0xCE, 0x01, 0xCE, 0x03, 0x8E, 0x03, 0x9C,
  0x03, 0x9C, 0x1F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x07, 0x38, 0x0E, 0x38,
  0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x70, 0xFF, 0xFC, 0xFF, 0xFC, 0x38, 0xE0,
  0x39, 0xC0, 0x39, 0xC0, 0x31, 0xC0, 0x73, 0x80, 0x73, 0x80, 0xE3, 0x80,
  0x00, 0x60, 0x01, 0x80, 0x1F, 0x81, 0xFF, 0x0F, 0xFC, 0x7F, 0xE1, 0xE9,
  0x87, 0xA0, 0x1E, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x02, 0xF1, 0x0B, 0xC6, 0x2F, 0x3F, 0xFC, 0xFF,
  0xE3, 0xFF, 0x01, 0xE0, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x1F, 0x03,
  0x83, 0xF0, 0x38, 0x3F, 0x87, 0x07, 0x38, 0xF0, 0x73, 0x8E, 0x0E, 0x39,
  0xC0, 0xE3, 0x9C, 0x0E, 0x73, 0x80, 0xE7, 0x38, 0x0E, 0x77, 0x3C, 0xEE,
  0x77, 0xEF, 0xEE, 0x7E, 0xFC, 0xEE, 0x77, 0x9C, 0xE7, 0x03, 0xDC, 0x70,
  0x39, 0xCE, 0x07, 0x1C, 0xE0, 0x71, 0xCE, 0x0E, 0x18, 0xE0, 0xE1, 0x9C,
  0x1C, 0x1F, 0xC1, 0xC1, 0xF8, 0x38, 0x0F, 0x00, 0x01, 0xF0, 0x03, 0xF8,
  0x07, 0xFC, 0x07, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0F, 0x78,
  0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0xCF, 0x3F, 0xCF, 0x3F, 0xCF,
  0x79, 0xFE, 0xF1, 0xFE, 0xF1, 0xFC, 0xF0, 0xF8, 0xF0, 0xF8, 0xF9, 0xF8,
  0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0x3E, 0x7D, 0xE7, 0x9E, 0x71, 0xCF, 0x3C,
  0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1E,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E,
  0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x01,
  0xE0, 0x3C, 0x00, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70,
  0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0xF0,
  0x1E, 0x07, 0x80, 0xE0, 0x78, 0x00, 0x08, 0x01, 0xE0, 0x3C, 0x27, 0x8F,
  0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0x3F, 0x0F, 0xE3, 0xEE, 0x39, 0xE2, 0x38,
  0x04, 0x00, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0x1E, 0x3C, 0xF1, 0xE3, 0xCF, 0x1E, 0x78, 0x7F, 0xBF,
  0xDF, 0xDF, 0xE0, 0x33, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x3F, 0x83,
  0xFC, 0x3F, 0xF1, 0xE7, 0x9E, 0x3C, 0xF1, 0xEF, 0x0F, 0x78, 0x7B, 0xC7,
  0xFE, 0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0x7B, 0xC7, 0xDE, 0x3C, 0xF1, 0xE7,
  0x1F, 0x3C, 0xF1, 0xEF, 0x0F, 0xF8, 0x7F, 0x81, 0xF8, 0x00, 0x03, 0xC1,
  0xF0, 0xFC, 0x7F, 0x3F, 0x9F, 0xEF, 0x79, 0x9E, 0x47, 0x83, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0x01, 0xF8, 0x0F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0xE3,
  0xE0, 0x83, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xF8, 0x00, 0x03,
  0xF0, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x08, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x78, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC8, 0x1F, 0x39, 0xF8, 0xFF, 0xC3,
  0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0x81, 0xDE, 0x06, 0xF0, 0x3B, 0xC1, 0xCF, 0x07,
  0x3C, 0x38, 0xF1, 0xC7, 0x87, 0x1E, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xE0,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0x07, 0xFC, 0x1F,
  0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x7F, 0x83, 0xFF, 0x0F, 0xFC, 0x11, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x07, 0xC8, 0x1E, 0x3F, 0xF8, 0xFF, 0xC3, 0xFE, 0x0F,
  0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xF2, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x79, 0xC1, 0xEF, 0x87, 0xFF, 0x3F, 0xFC, 0xF8,
  0xF3, 0xE3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF1, 0xF3, 0xC7, 0x8F, 0x1E, 0x3F,
  0xF0, 0xFF, 0xC1, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0xFF,
  0xF1, 0xFF, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0xC7, 0xCF, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x9F, 0x1F, 0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xF0,
  0x1F, 0xE0, 0xF7, 0xC7, 0x8F, 0x3E, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F,
  0x3E, 0x7C, 0xFF, 0xE1, 0xFF, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xE0,
  0xFF, 0x87, 0xFF, 0x1E, 0x3C, 0xF8, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x7C,
  0xF1, 0xF3, 0xCF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFD, 0xE1, 0xEF, 0x00, 0x3C,
  0x01, 0xF0, 0x07, 0x80, 0x3E, 0x21, 0xF0, 0xFF, 0x83, 0xFC, 0x0F, 0xE0,
  0x00, 0x06, 0x1F, 0x1F, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x78, 0xF8, 0xF8, 0xF0, 0x01, 0x81, 0xF0, 0x7C, 0x1F,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x00, 0x00,
  0x08, 0x01, 0xC0, 0x3E, 0x07, 0xF0, 0xFF, 0x1F, 0xC3, 0xF8, 0x1F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0x80, 0x1C, 0x00, 0x20,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x07, 0x80, 0x3F, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0x01, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE,
  0x0F, 0xC0, 0x78, 0x03, 0x00, 0x00, 0x0F, 0x87, 0xF8, 0xFF, 0x9D, 0xF2,
  0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0x70, 0x0E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x03, 0xE3, 0xC0, 0x78, 0x0E,
  0x0E, 0x00, 0xE1, 0xC0, 0x06, 0x1C, 0x7E, 0x73, 0x8F, 0xE7, 0x31, 0xCE,
  0x77, 0x38, 0xC7, 0x73, 0x9C, 0x66, 0x71, 0xC6, 0xE7, 0x1C, 0xEE, 0x71,
  0xCE, 0xE7, 0x38, 0xCE, 0x73, 0x9C, 0xC7, 0x79, 0x8C, 0x7D, 0xF8, 0xC3,
  0xDF, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x18, 0x03,
  0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xEF, 0x03, 0xDE,
  0x07, 0xBC, 0x1E, 0x78, 0x3C, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xFF, 0x8F,
  0xFF, 0x1F, 0xFE, 0x7C, 0x3C, 0xF0, 0x7B, 0xE0, 0xF7, 0x81, 0xEF, 0x03,
  0xFE, 0x07, 0x80, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F,
  0x1F, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x1F, 0xFC, 0x1F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3C, 0x78, 0x3C, 0x3C, 0x7C, 0x3C, 0x78,
  0x7C, 0x78, 0x78, 0x78, 0xF8, 0x79, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF,
  0x80, 0x01, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xE1, 0xF0, 0x43, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x0F,
  0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0x1F, 0x0F, 0x1F, 0x1F, 0x0F, 0x1E,
  0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1F, 0x3C,
  0x1E, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x78, 0x7C, 0x78, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0xFF,
  0xC3, 0xFF, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x7F,
  0xC1, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x1F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x00,
  0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF,
  0x83, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC1,
  0xFF, 0xE1, 0xF8, 0x20, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x3F, 0x8F, 0x1F, 0xCF, 0x8F, 0xE7, 0xC7, 0xE3, 0xE0,
  0xF1, 0xF0, 0x78, 0xF8, 0x3C, 0x7C, 0x3E, 0x3E, 0x1E, 0x0F, 0xDF, 0x07,
  0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0x80, 0x07, 0x83, 0xC3, 0xE0, 0xF0, 0xF8,
  0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xF0, 0xF8, 0x78, 0x3E,
  0x1E, 0x0F, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F,
  0x07, 0x83, 0xC1, 0xE1, 0xF0, 0x78, 0x7C, 0x3E, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3C, 0x1F, 0x0F, 0x07, 0x80, 0x0F, 0xFC,
  0x3F, 0xE0, 0x7F, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x7F, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C,
  0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xE0, 0x00, 0x07, 0x87, 0xC3, 0xC3,
  0xE0, 0xF0, 0xF0, 0x3C, 0x78, 0x0F, 0x3E, 0x03, 0xCF, 0x01, 0xE7, 0x80,
  0x7B, 0xE0, 0x1E, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x79, 0xF0, 0x1E, 0x3C,
  0x07, 0x8F, 0x01, 0xE3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3E, 0x0F, 0x0F, 0x80,
  0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F,
  0x01, 0xF8, 0x7E, 0x07, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x87, 0xF0,
  0x7F, 0x0F, 0xE1, 0xFE, 0x1F, 0xC3, 0xBC, 0x3F, 0x87, 0xF0, 0x77, 0x1F,
  0xE1, 0xEE, 0x3B, 0xC3, 0xDC, 0xF7, 0x87, 0xB9, 0xCE, 0x0F, 0x7F, 0xBC,
  0x1C, 0xFE, 0x78, 0x79, 0xFC, 0xF0, 0xF3, 0xF1, 0xE1, 0xE7, 0xE7, 0x83,
  0x8F, 0x8F, 0x0F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x78, 0x78, 0x00,
  0x07, 0x81, 0xE1, 0xF8, 0x3C, 0x3F, 0x07, 0x07, 0xE1, 0xE0, 0xFC, 0x3C,
  0x1F, 0x87, 0x87, 0xF0, 0xF0, 0xFF, 0x1C, 0x1F, 0xE7, 0x83, 0xBC, 0xF0,
  0x73, 0x9E, 0x1E, 0x73, 0xC3, 0xCE, 0x70, 0x79, 0xFE, 0x0F, 0x3F, 0xC1,
  0xC7, 0xF8, 0x78, 0x7F, 0x0F, 0x0F, 0xC1, 0xE1, 0xF8, 0x38, 0x3F, 0x0F,
  0x07, 0xE1, 0xE0, 0xF8, 0x3C, 0x0F, 0x00, 0x01, 0xF8, 0x03, 0xFE, 0x07,
  0xFE, 0x0F, 0xFF, 0x1F, 0x1F, 0x1E, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x7C,
  0x0F, 0x7C, 0x0F, 0x78, 0x1F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0xF8, 0x7F, 0xF8, 0x7F,
  0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0x07, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F,
  0xFF, 0x0F, 0x1F, 0x0F, 0x0F, 0x1F, 0x0F, 0x1E, 0x1F, 0x1E, 0x1F, 0x1E,
  0x1E, 0x1E, 0x3E, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xC0, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x01, 0xF8, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0x1F,
  0x1F, 0x1E, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x7C, 0x0F, 0x7C, 0x0F, 0x78,
  0x1F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3C, 0xF8, 0x7C, 0xF8, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x07,
  0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xF1, 0xE1, 0xE3, 0xC7, 0x87,
  0x8F, 0x0F, 0x1E, 0x3E, 0x3C, 0x78, 0x7B, 0xF1, 0xFF, 0xC3, 0xFF, 0x07,
  0xFC, 0x0F, 0x78, 0x1E, 0xF0, 0x79, 0xE0, 0xF3, 0xE1, 0xE3, 0xC3, 0xC7,
  0x8F, 0x0F, 0x1E, 0x1F, 0x3C, 0x3E, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x07,
  0xFE, 0x0F, 0xFE, 0x0F, 0x84, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x40, 0xF0, 0x7F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0xFB, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x00, 0x0F, 0x0F, 0x8F, 0x87, 0x87,
  0x83, 0xC3, 0xC1, 0xE1, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x78, 0x78, 0x3C,
  0x3C, 0x1E, 0x1E, 0x1F, 0x1F, 0x0F, 0x8F, 0x87, 0x87, 0x83, 0xC3, 0xC1,
  0xE1, 0xE1, 0xF1, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3E, 0x3E, 0x1F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0xF0, 0x3F, 0xE0, 0x7B,
  0xC1, 0xF7, 0x83, 0xCF, 0x07, 0x9E, 0x1E, 0x3C, 0x3C, 0x78, 0xF0, 0xF1,
  0xE1, 0xE3, 0xC3, 0xCF, 0x07, 0x9E, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x3C, 0x1E, 0xF0, 0x78, 0x3D, 0xE1, 0xF0,
  0xF3, 0xC3, 0xE1, 0xE7, 0x87, 0xC7, 0x8F, 0x1F, 0x8F, 0x1E, 0x3F, 0x1E,
  0x38, 0xFC, 0x78, 0x71, 0xF8, 0xF0, 0xE3, 0xF1, 0xE1, 0xCF, 0xE7, 0x83,
  0x9D, 0xCF, 0x0F, 0x7B, 0xBC, 0x1E, 0xE7, 0x78, 0x3D, 0xCE, 0xF0, 0x7F,
  0x9F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1,
  0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x00, 0x07,
  0xC3, 0xC0, 0xF1, 0xF0, 0x3C, 0x78, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF7,
  0x80, 0x3D, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F,
  0x78, 0x07, 0xDE, 0x01, 0xE7, 0x80, 0xF1, 0xE0, 0x3C, 0x7C, 0x1E, 0x1F,
  0x0F, 0x83, 0xC0, 0xF0, 0x7F, 0x83, 0xFC, 0x3D, 0xE3, 0xEF, 0x1E, 0x39,
  0xF1, 0xEF, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0,
  0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F,
  0xFE, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF,
  0xE0, 0xFF, 0xE0, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x78, 0x07, 0x80, 0x70,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x00, 0xF0, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xF1, 0xE3, 0xC3,
  0x87, 0x0F, 0x1E, 0x3C, 0x78, 0xF0, 0xE1, 0xC3, 0x87, 0x8F, 0x1E, 0x3C,
  0x78, 0x70, 0xE1, 0xC3, 0xC7, 0x80, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x0F,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0xF7,
  0x03, 0x9C, 0x1E, 0x78, 0x71, 0xE3, 0xC3, 0x9E, 0x0E, 0x70, 0x3F, 0xC0,
  0xF0, 0xFF, 0xFF, 0xF8, 0xF3, 0xC7, 0x9E, 0x38, 0xF0, 0x07, 0x00, 0x7E,
  0xF1, 0xFF, 0xCF, 0xFE, 0x7C, 0xF9, 0xE1, 0xE7, 0x87, 0xBE, 0x3E, 0xF0,
  0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x7C, 0xF1, 0xE3, 0xC7, 0x8F, 0x3E, 0x3F,
  0xF8, 0xFD, 0xE1, 0xE7, 0x00, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x01, 0xE7, 0x07, 0xBE, 0x1F, 0xFC, 0x7F, 0xF1, 0xE3,
  0xCF, 0x8F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCE, 0x0F, 0x78, 0x79, 0xE1,
  0xE7, 0x87, 0x9E, 0x3C, 0xFD, 0xF3, 0xFF, 0x8F, 0xFE, 0x39, 0xE0, 0x03,
  0xC0, 0xFF, 0x1F, 0xE3, 0xFE, 0x3C, 0x27, 0x80, 0x78, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x08, 0xF9, 0x8F, 0xF8, 0x7F,
  0x83, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x81, 0xCF, 0x07, 0xDE, 0x1F, 0xFC, 0x7F, 0xF0, 0xF3, 0xE3, 0xC3,
  0xC7, 0x87, 0x9F, 0x1F, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xE1, 0xE3,
  0xC7, 0x87, 0x8F, 0x0F, 0x3E, 0x1F, 0xFC, 0x3F, 0xF8, 0x3E, 0xE0, 0x03,
  0xC0, 0xFE, 0x1F, 0xF3, 0xEF, 0x3C, 0x77, 0x87, 0x78, 0xFF, 0x3E, 0xFF,
  0xEF, 0xF8, 0xF0, 0x0F, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x4F, 0xFC, 0x7F,
  0xC3, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x03, 0xEF, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x3C, 0x7C,
  0x3C, 0x78, 0x3D, 0xF8, 0x3F, 0xF8, 0x3F, 0x78, 0x1E, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xF0, 0x81, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80,
  0x1E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xE7, 0x07, 0xBE, 0x1F, 0xFC, 0x7F, 0xF1, 0xE3, 0xCF, 0x8F, 0x3C,
  0x3C, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x8F, 0x1E,
  0x3C, 0xF8, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x78, 0x07, 0x87, 0xC3, 0xE1,
  0xE0, 0x00, 0x00, 0x04, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0xC3, 0xC1, 0xE0,
  0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x87, 0x83, 0xC1, 0xE0, 0x00,
  0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x0F, 0xE0, 0x7E, 0x03,
  0xE0, 0x1E, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x0F, 0x1F, 0x1E, 0x3C, 0x3C, 0xF0, 0x73, 0xC1,
  0xEF, 0x03, 0xDE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xE7, 0x83, 0xCF, 0x07, 0x1E, 0x1E, 0x3C, 0x3C, 0x7C, 0x78, 0x78,
  0x07, 0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0x3C, 0x1E, 0x0F, 0x07,
  0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x87,
  0x83, 0xC1, 0xE0, 0x00, 0x70, 0xE0, 0xFF, 0xDF, 0x87, 0x7F, 0xFE, 0x3F,
  0xFF, 0xF1, 0xE3, 0xC7, 0x9F, 0x1E, 0x3C, 0xF1, 0xE1, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xC3, 0xC7, 0x9E, 0x1C, 0x3C, 0xF1, 0xE1, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0xC7, 0x9E, 0x1C, 0x3C, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x00, 0x00, 0x70, 0x73, 0xE1, 0xDF, 0xC7, 0xFF, 0x1E, 0x3C,
  0xF8, 0xF3, 0xC3, 0xCF, 0x1E, 0x3C, 0x78, 0xF1, 0xE7, 0x87, 0x9E, 0x1E,
  0x78, 0xF1, 0xE3, 0xC7, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC7, 0x80, 0x03,
  0xC0, 0x7F, 0x07, 0xFC, 0x7F, 0xE7, 0xCF, 0x3C, 0x3D, 0xE1, 0xFE, 0x0F,
  0xF0, 0xF7, 0x87, 0xBC, 0x3D, 0xE1, 0xEF, 0x1F, 0x78, 0xF3, 0xCF, 0x9F,
  0xF8, 0x7F, 0x81, 0xF8, 0x00, 0x00, 0x1C, 0x07, 0xBE, 0x07, 0x7F, 0x07,
  0xFF, 0x07, 0x8F, 0x0F, 0x8F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E,
  0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x1F, 0x7C, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3D, 0xF0, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x3E,
  0xF1, 0xFF, 0xCF, 0xFE, 0x3C, 0xF9, 0xE1, 0xE7, 0x87, 0xBC, 0x1E, 0xF0,
  0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xE3, 0xC7, 0x8F, 0x3E, 0x3F,
  0xF8, 0xFD, 0xE1, 0xEF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x71, 0xEF, 0x1F, 0xE1,
  0xFE, 0x1F, 0xE3, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0xC1,
  0xFF, 0x1F, 0xF3, 0xFE, 0x3C, 0x23, 0xC0, 0x3C, 0x03, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xC8, 0x3C, 0xC7, 0xCF, 0xF8, 0xFF, 0x0F,
  0xE0, 0x0E, 0x07, 0x03, 0x83, 0xC7, 0xFB, 0xFD, 0xFE, 0x78, 0x3C, 0x1C,
  0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3F, 0x9F, 0xC7,
  0xE0, 0x3C, 0x3C, 0xF1, 0xE3, 0xC7, 0x8E, 0x1E, 0x78, 0x79, 0xE1, 0xC7,
  0x8F, 0x1E, 0x3C, 0x70, 0xF3, 0xC3, 0xCF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xCF, 0x8F, 0xFE, 0x3F, 0x70, 0x7D, 0xC0, 0xF0, 0xFF, 0x0F, 0xF1, 0xEF,
  0x1E, 0xF3, 0xCF, 0x3C, 0xF3, 0x8F, 0x78, 0xF7, 0x0F, 0xF0, 0xFF, 0x0F,
  0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x00, 0xF1, 0xF1, 0xFE,
  0x3E, 0x3F, 0xCF, 0xCF, 0x79, 0xF9, 0xEF, 0x3F, 0x39, 0xEF, 0xEF, 0x3D,
  0xF9, 0xE7, 0x7F, 0x78, 0xEE, 0xEF, 0x1D, 0xDD, 0xC3, 0xF3, 0xF8, 0x7E,
  0x7E, 0x0F, 0xCF, 0xC1, 0xF1, 0xF8, 0x3E, 0x3E, 0x07, 0x87, 0xC0, 0xF0,
  0xF0, 0x00, 0x0F, 0x8F, 0x07, 0x9E, 0x07, 0xBE, 0x07, 0xBC, 0x07, 0xF8,
  0x03, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x7C, 0xF8, 0xF8, 0x78,
  0x0F, 0x0F, 0x87, 0x87, 0x83, 0xC7, 0x81, 0xE3, 0xC0, 0xF3, 0xC0, 0x79,
  0xE0, 0x3C, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0x87, 0xFC, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80,
  0x78, 0x03, 0xC0, 0x3C, 0x03, 0xFF, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x78,
  0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x07, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x80,
  0x3E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x7C, 0x07,
  0xE0, 0x7E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x7F, 0x07, 0xC0, 0xF8, 0x0F,
  0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC,
  0x0F, 0x00, 0x3C, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 9, 23, 8, 0, -23 },
  { 27, 11, 8, 13, 3, -23 },
  { 38, 16, 23, 15, 0, -23 },
  { 84, 14, 26, 14, 0, -24 },
  { 130, 20, 23, 23, 2, -23 },
  { 188, 16, 23, 17, 0, -23 },
  { 234, 6, 8, 8, 3, -23 },
  { 240, 11, 28, 9, 0, -23 },
  { 279, 11, 28, 9, -3, -23 },
  { 318, 11, 14, 13, 3, -25 },
  { 338, 13, 15, 15, 1, -19 },
  { 363, 7, 8, 8, -2, -4 },
  { 370, 9, 4, 9, 0, -11 },
  { 375, 5, 5, 8, 0, -5 },
  { 379, 17, 23, 12, -2, -23 },
  { 428, 13, 23, 14, 1, -23 },
  { 466, 10, 23, 14, 3, -23 },
  { 495, 15, 23, 14, -1, -23 },
  { 539, 14, 23, 14, 0, -23 },
  { 580, 14, 23, 14, 0, -23 },
  { 621, 14, 23, 14, 0, -23 },
  { 662, 14, 23, 14, 1, -23 },
  { 703, 15, 23, 14, 1, -23 },
  { 747, 14, 23, 14, 0, -23 },
  { 788, 14, 23, 14, 0, -23 },
  { 829, 8, 18, 8, 0, -18 },
  { 847, 10, 22, 8, -2, -18 },
  { 875, 13, 15, 15, 1, -19 },
  { 900, 13, 10, 15, 1, -16 },
  { 917, 13, 15, 15, 1, -19 },
  { 942, 11, 23, 11, 1, -23 },
  { 974, 20, 26, 21, 1, -23 },
  { 1039, 15, 23, 15, -2, -23 },
  { 1083, 16, 23, 15, 0, -23 },
  { 1129, 15, 23, 14, 1, -23 },
  { 1173, 16, 23, 16, 0, -23 },
  { 1219, 14, 23, 13, 0, -23 },
  { 1260, 14, 23, 12, 0, -23 },
  { 1301, 17, 23, 17, 1, -23 },
  { 1350, 18, 23, 17, 0, -23 },
  { 1402, 14, 23, 10, -1, -23 },
  { 1443, 14, 30, 8, -5, -23 },
  { 1496, 18, 23, 15, 0, -23 },
  { 1548, 10, 23, 12, 0, -23 },
  { 1577, 23, 23, 22, 0, -23 },
  { 1644, 19, 23, 18, 0, -23 },
  { 1699, 16, 23, 17, 1, -23 },
  { 1745, 16, 23, 15, 0, -23 },
  { 1791, 16, 28, 17, 1, -23 },
  { 1847, 15, 23, 15, 0, -23 },
  { 1891, 16, 23, 13, -1, -23 },
  { 1937, 13, 23, 13, 2, -23 },
  { 1975, 17, 23, 17, 1, -23 },
  { 2024, 15, 23, 15, 3, -23 },
  { 2068, 23, 23, 22, 2, -23 },
  { 2135, 18, 23, 14, -2, -23 },
  { 2187, 13, 23, 14, 3, -23 },
  { 2225, 16, 23, 12, -1, -23 },
  { 2271, 12, 28, 9, -1, -23 },
  { 2313, 7, 23, 12, 3, -23 },
  { 2334, 12, 28, 9, -2, -23 },
  { 2376, 14, 14, 14, 0, -23 },
  { 2401, 11, 2, 10, -3, 3 },
  { 2404, 6, 6, 10, 5, -25 },
  { 2409, 14, 18, 15, 1, -18 },
  { 2441, 14, 24, 15, 0, -24 },
  { 2483, 12, 18, 12, 1, -18 },
  { 2510, 15, 24, 15, 1, -24 },
  { 2555, 12, 18, 14, 1, -18 },
  { 2582, 17, 32, 9, -4, -24 },
  { 2650, 16, 26, 15, -1, -18 },
  { 2702, 14, 24, 15, 0, -24 },
  { 2744, 9, 24, 7, 0, -24 },
  { 2771, 13, 32, 7, -4, -24 },
  { 2823, 15, 24, 14, 0, -24 },
  { 2868, 9, 24, 7, 0, -24 },
  { 2895, 21, 18, 21, 0, -18 },
  { 2943, 14, 18, 15, 0, -18 },
  { 2975, 13, 18, 14, 1, -18 },
  { 3005, 16, 26, 15, -2, -18 },
  { 3057, 14, 26, 15, 1, -18 },
  { 3103, 12, 18, 10, 0, -18 },
  { 3130, 12, 18, 11, 0, -18 },
  { 3157, 9, 21, 9, 1, -21 },
  { 3181, 14, 17, 14, 1, -17 },
  { 3211, 12, 17, 13, 2, -17 },
  { 3237, 19, 17, 20, 2, -17 },
  { 3278, 16, 17, 13, -2, -17 },
  { 3312, 17, 25, 13, -2, -17 },
  { 3366, 13, 17, 11, -1, -17 },
  { 3394, 13, 28, 11, 0, -23 },
  { 3440, 3, 32, 12, 4, -25 },
  { 3452, 12, 28, 11, -2, -23 },
  { 3494, 13, 5, 15, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic32pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC32PT7B_H_
