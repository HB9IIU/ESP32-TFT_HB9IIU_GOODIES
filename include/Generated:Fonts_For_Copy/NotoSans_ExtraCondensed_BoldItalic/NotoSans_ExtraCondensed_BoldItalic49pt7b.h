#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC49PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8,
  0x07, 0xC0, 0x00, 0x7F, 0x3F, 0xBF, 0x9F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE7,
  0xE3, 0xF3, 0xE1, 0xF1, 0xF1, 0xF9, 0xF8, 0xFC, 0xFC, 0x7C, 0x7C, 0x3E,
  0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x87, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x0F,
  0x8F, 0x80, 0x07, 0x87, 0x80, 0x07, 0xC3, 0xC0, 0x03, 0xE3, 0xE0, 0x01,
  0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x78, 0x78, 0x00,
  0x3C, 0x3C, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x07, 0xC7, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xE1, 0xE0,
  0x01, 0xF1, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x7C, 0x7C,
  0x43, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x07, 0x87, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xE1,
  0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x78, 0x78, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xDB,
  0xC0, 0x7E, 0xC2, 0x01, 0xF3, 0x00, 0x0F, 0xCC, 0x00, 0x3F, 0xB0, 0x00,
  0xFE, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x27, 0xE0, 0x01, 0x9F, 0x84, 0x06, 0x7E, 0x18,
  0x19, 0xF8, 0x70, 0x6F, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0xF0, 0x03, 0xE0, 0x3F, 0xC0, 0x1F, 0x01, 0xFF, 0x80, 0x78, 0x07, 0xFE,
  0x03, 0xE0, 0x3E, 0x78, 0x1F, 0x00, 0xF1, 0xF0, 0x7C, 0x07, 0xC7, 0xC3,
  0xE0, 0x1E, 0x1E, 0x0F, 0x80, 0x78, 0x78, 0x7C, 0x03, 0xE1, 0xE1, 0xE0,
  0x0F, 0x8F, 0x8F, 0x80, 0x3C, 0x3E, 0x3C, 0x00, 0xF0, 0xF9, 0xF0, 0x03,
  0xC3, 0xC7, 0x81, 0x0F, 0x1F, 0x3E, 0x3F, 0x3C, 0x7C, 0xF1, 0xFE, 0xF3,
  0xE7, 0xCF, 0xFF, 0xFF, 0xBE, 0x7F, 0xFF, 0xFC, 0xF9, 0xE3, 0xDF, 0xE7,
  0xCF, 0x8F, 0x7F, 0x1F, 0x3C, 0x3C, 0x00, 0xF9, 0xF0, 0xF0, 0x03, 0xC7,
  0xC7, 0xC0, 0x1F, 0x1E, 0x1F, 0x00, 0x78, 0x78, 0x7C, 0x03, 0xE3, 0xE1,
  0xE0, 0x0F, 0x0F, 0x87, 0x80, 0x7C, 0x3E, 0x3E, 0x03, 0xE0, 0xF8, 0xF8,
  0x0F, 0x83, 0xE3, 0xC0, 0x7C, 0x0F, 0x9F, 0x01, 0xF0, 0x3F, 0xF8, 0x0F,
  0x80, 0x7F, 0xC0, 0x3C, 0x01, 0xFF, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0x9F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xE1, 0xF0,
  0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7C,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x0F, 0xC3, 0xFF, 0x87, 0xE3, 0xFF,
  0xE7, 0xE3, 0xFB, 0xF3, 0xF1, 0xF9, 0xFB, 0xF1, 0xF8, 0xFF, 0xF8, 0xFC,
  0x3F, 0xF8, 0xFC, 0x1F, 0xFC, 0x7E, 0x0F, 0xFC, 0x3F, 0x03, 0xFE, 0x1F,
  0x81, 0xFE, 0x0F, 0xC0, 0xFF, 0x07, 0xF0, 0xFF, 0x83, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFC, 0xFE, 0x07, 0xF8, 0x7F,
  0x00, 0x3F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xFC, 0xF8,
  0xF8, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x21,
  0xF0, 0x1C, 0x7C, 0x07, 0xDF, 0x0D, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0xC1,
  0xFD, 0xF0, 0x7E, 0x7E, 0x0F, 0x8F, 0xC1, 0xC3, 0xE0, 0x20, 0xE0, 0x00,
  0x20, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x3F,
  0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x3E, 0x7F, 0xFF, 0xFF, 0xFE, 0xFE, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFF,
  0x03, 0xFF, 0xF0, 0x7F, 0x3F, 0x07, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF3, 0xF8, 0x3F, 0x3F, 0x03, 0xF3, 0xF0,
  0x3F, 0x3F, 0x03, 0xF7, 0xF0, 0x7F, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E,
  0x07, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF,
  0xC1, 0xFC, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x3F, 0x8F, 0xC3, 0xF0,
  0xFC, 0x7F, 0x0F, 0xEF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF8,
  0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF8,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x87, 0xFF, 0x1F, 0xFE, 0x7F, 0xFD, 0xFF,
  0xF3, 0xF7, 0xE3, 0x8F, 0xC2, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x3F, 0x1F, 0xC0, 0x78, 0x3F, 0x80, 0x60, 0x3F, 0x00,
  0x80, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3C, 0x3F, 0xC0, 0x20,
  0x3F, 0x80, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x08, 0x01, 0xFE, 0x1E, 0x0F, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x7B, 0xF0, 0x00, 0xF7, 0xC0, 0x03, 0xDF, 0x80, 0x0F, 0xBF, 0x00,
  0x1E, 0x7E, 0x00, 0x78, 0xFC, 0x01, 0xF3, 0xF0, 0x03, 0xC7, 0xE0, 0x0F,
  0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x78, 0x3F, 0x01, 0xF0, 0xFC, 0x07, 0xC1,
  0xF8, 0x0F, 0x03, 0xF0, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xE3, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x20, 0x07, 0xF0, 0xC0, 0x3F, 0x83, 0xC3,
  0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xC0, 0x80,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x38, 0x03, 0xF3, 0xF8, 0x0F, 0xDF, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F,
  0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0x83,
  0xF8, 0xFE, 0x07, 0xE7, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x1F, 0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC0,
  0xFC, 0x3F, 0x07, 0xF0, 0xFE, 0x1F, 0x81, 0xF8, 0xFE, 0x07, 0xE7, 0xF0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xDF, 0xC0, 0xFC, 0x3F,
  0x07, 0xF0, 0xFE, 0x1F, 0x81, 0xF8, 0xFE, 0x07, 0xE3, 0xF0, 0x1F, 0x8F,
  0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xCF, 0xE1, 0xFC, 0x3F, 0x0F, 0xC1,
  0xF8, 0x7E, 0x0F, 0xC7, 0xF0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F,
  0xC1, 0xFC, 0x7E, 0x0F, 0xE3, 0xF0, 0x7F, 0x1F, 0x87, 0xF8, 0xFC, 0x7F,
  0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F,
  0x9F, 0x80, 0x71, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x82, 0x07, 0xFC, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xE0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xC0, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0xFF, 0x0F, 0xF0,
  0xFE, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x3C, 0x01, 0xFC, 0x03, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x3E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0x80,
  0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xF8,
  0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0xC1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0x87, 0xF0, 0x80, 0xFC, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x0F, 0x00, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00,
  0x3C, 0x0F, 0x03, 0xFC, 0x78, 0x3E, 0x1F, 0xFC, 0xF8, 0x78, 0x7F, 0xF1,
  0xF1, 0xE1, 0xFB, 0xE3, 0xE3, 0xC3, 0xC3, 0xC7, 0x8F, 0x8F, 0x8F, 0x8F,
  0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x7C, 0x3C, 0x3C, 0xF0, 0xF0, 0x78, 0x79,
  0xE1, 0xE1, 0xF0, 0xF3, 0xC7, 0xC3, 0xC3, 0xC7, 0x8F, 0x07, 0x87, 0x9F,
  0x1E, 0x1F, 0x0F, 0x3C, 0x3C, 0x3E, 0x3C, 0x78, 0x78, 0x7C, 0x78, 0xF0,
  0xF1, 0xF1, 0xE1, 0xE1, 0xF7, 0xF7, 0xC3, 0xC3, 0xFF, 0xFF, 0x07, 0x83,
  0xFB, 0xFC, 0x0F, 0x07, 0xE3, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x20, 0x00, 0xFC, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xE7, 0xE0,
  0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x03,
  0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xE0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x3F, 0x01, 0xF8, 0xFE, 0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xF0, 0x0F,
  0xCF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0x7F, 0x00, 0x7E, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xF0, 0xFF, 0x03, 0xF0, 0x7F,
  0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x1F, 0x87, 0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x81, 0xF8,
  0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x03, 0xF8, 0x3F, 0x03, 0xF8,
  0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x1F, 0xE0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0xFF, 0x8E, 0x03, 0xFC, 0x04, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x10, 0x1F,
  0xF3, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xC3, 0xFC, 0x07, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F,
  0xC1, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x7F, 0x01,
  0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x7F, 0x07, 0xE0,
  0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xF8, 0x07, 0xF0, 0xFC,
  0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x03, 0xFC, 0x3F, 0x81, 0xFC, 0x1F,
  0x81, 0xFE, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF1, 0xFF, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xF1, 0xF0, 0x1F, 0xE0, 0x18, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0xFC, 0x7E,
  0x0F, 0xFE, 0x7F, 0x07, 0xFE, 0x3F, 0x83, 0xFF, 0x1F, 0xC1, 0xFF, 0x8F,
  0xE1, 0xFF, 0xC7, 0xF0, 0x0F, 0xC3, 0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xF0,
  0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0x7E,
  0x0F, 0xF0, 0x3F, 0x03, 0xFC, 0x7F, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xE0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x0F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x09, 0xFE, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x03, 0xF8, 0x07, 0xE0, 0x7E,
  0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFC,
  0x3F, 0x80, 0x1F, 0x8F, 0xE0, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0x7F, 0x00,
  0x1F, 0x9F, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xBF, 0x00, 0x07, 0xE7, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x3F,
  0x1F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xE0,
  0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x83, 0xF8, 0x03, 0xF0,
  0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x01,
  0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0x7D, 0xF0, 0x3F, 0xF8, 0x07, 0xDF, 0x07, 0xFF, 0x80, 0xFD, 0xF0,
  0x7D, 0xF8, 0x0F, 0xDF, 0x07, 0xDF, 0x80, 0xFD, 0xF0, 0xFB, 0xF0, 0x0F,
  0xDF, 0x0F, 0xBF, 0x00, 0xF9, 0xF1, 0xFB, 0xF0, 0x1F, 0x9F, 0x1F, 0x3F,
  0x01, 0xF9, 0xF3, 0xF3, 0xF0, 0x1F, 0x9F, 0x3E, 0x7E, 0x01, 0xF9, 0xF3,
  0xE7, 0xE0, 0x1F, 0x1F, 0x7C, 0x7E, 0x03, 0xF1, 0xF7, 0xC7, 0xE0, 0x3F,
  0x1F, 0xF8, 0xFC, 0x03, 0xF1, 0xFF, 0x8F, 0xC0, 0x3E, 0x1F, 0xF8, 0xFC,
  0x07, 0xE1, 0xFF, 0x0F, 0xC0, 0x7E, 0x1F, 0xF0, 0xFC, 0x07, 0xE1, 0xFE,
  0x1F, 0x80, 0x7E, 0x1F, 0xE1, 0xF8, 0x07, 0xC1, 0xFC, 0x1F, 0x80, 0xFC,
  0x1F, 0xC1, 0xF8, 0x0F, 0xC1, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x83, 0xF0,
  0x00, 0x01, 0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x7F, 0x80, 0x7E,
  0x03, 0xFC, 0x03, 0xE0, 0x3F, 0xE0, 0x3F, 0x01, 0xFF, 0x01, 0xF8, 0x0F,
  0xF8, 0x0F, 0xC0, 0x7F, 0xC0, 0x7C, 0x07, 0xFF, 0x07, 0xE0, 0x3F, 0xF8,
  0x3F, 0x01, 0xFF, 0xC1, 0xF8, 0x0F, 0xBE, 0x0F, 0xC0, 0x7D, 0xF0, 0x7C,
  0x07, 0xEF, 0xC7, 0xE0, 0x3F, 0x7E, 0x3F, 0x01, 0xFB, 0xF1, 0xF8, 0x0F,
  0xCF, 0x8F, 0xC0, 0x7C, 0x7C, 0x7C, 0x07, 0xE3, 0xE7, 0xE0, 0x3F, 0x1F,
  0xBF, 0x01, 0xF8, 0xFD, 0xF8, 0x0F, 0xC7, 0xEF, 0xC0, 0x7C, 0x1F, 0x7C,
  0x07, 0xE0, 0xFF, 0xE0, 0x3F, 0x07, 0xFF, 0x01, 0xF8, 0x3F, 0xF8, 0x0F,
  0x81, 0xFF, 0x80, 0xFC, 0x0F, 0xFC, 0x07, 0xE0, 0x3F, 0xE0, 0x3F, 0x01,
  0xFF, 0x01, 0xF8, 0x0F, 0xF8, 0x0F, 0x80, 0x7F, 0x80, 0xFC, 0x03, 0xFC,
  0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F,
  0x80, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE,
  0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFE,
  0x0F, 0xF0, 0xFF, 0xBF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x07,
  0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x7F, 0x0F,
  0xE0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xC1, 0xFE, 0x0F, 0xC3, 0xFC, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07,
  0xF8, 0xFF, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x80, 0x7F, 0x7F,
  0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE,
  0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFF,
  0xBF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7E, 0x3F, 0xC0, 0xFC,
  0x3F, 0x81, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81,
  0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x1F, 0x83, 0xF0, 0x7F,
  0x07, 0xE1, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x1F,
  0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0xFC, 0x7F, 0x03, 0xF8,
  0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x07,
  0xF0, 0xFE, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xFE, 0x06, 0x03, 0xF8, 0x04, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x82, 0x00, 0x7F, 0x07, 0x01, 0xFC, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x83, 0xF0,
  0x1F, 0xC1, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x7E,
  0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0x80, 0xFE, 0x1F, 0xC0, 0x7E, 0x0F,
  0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xC1,
  0xFC, 0x07, 0xE0, 0xFE, 0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xFC,
  0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x7F, 0x07, 0xE0, 0x3F,
  0x83, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFC, 0x07,
  0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xE1,
  0xFE, 0x07, 0xF9, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0x9F,
  0xC0, 0x7F, 0x3F, 0x80, 0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x07, 0xE0, 0xFC,
  0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE1, 0xFC, 0x0F, 0xC3,
  0xF0, 0x1F, 0x07, 0xE0, 0x3E, 0x1F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0xFC,
  0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xCF, 0xC0, 0x0F, 0x9F, 0x80,
  0x1F, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0xF8, 0x07, 0xF7, 0xE0, 0x1F, 0x80, 0x7E, 0x7E,
  0x01, 0xF8, 0x0F, 0xE7, 0xE0, 0x3F, 0x80, 0xFC, 0x7E, 0x03, 0xF8, 0x0F,
  0xC7, 0xE0, 0x3F, 0x81, 0xF8, 0x7E, 0x07, 0xF8, 0x1F, 0x87, 0xE0, 0x7F,
  0x83, 0xF8, 0x7E, 0x0F, 0xF8, 0x3F, 0x07, 0xE0, 0xFF, 0x83, 0xF0, 0x7E,
  0x0F, 0xF8, 0x7E, 0x07, 0xE1, 0xFF, 0x87, 0xE0, 0x7E, 0x1F, 0xF8, 0x7E,
  0x07, 0xE3, 0xEF, 0x8F, 0xC0, 0x7E, 0x3E, 0xF8, 0xFC, 0x07, 0xE3, 0xEF,
  0x9F, 0xC0, 0x7E, 0x7D, 0xF1, 0xF8, 0x07, 0xE7, 0xDF, 0x1F, 0x80, 0x7E,
  0x7D, 0xF3, 0xF0, 0x07, 0xEF, 0x9F, 0x3F, 0x00, 0x7E, 0xF9, 0xF7, 0xF0,
  0x07, 0xDF, 0x9F, 0x7E, 0x00, 0x7D, 0xF1, 0xF7, 0xE0, 0x07, 0xDF, 0x1F,
  0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x7F,
  0xE1, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x1F,
  0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x00,
  0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1,
  0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x7E, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xFC, 0x3F,
  0x00, 0x1F, 0x83, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x03, 0xF8, 0x07,
  0xF0, 0x1F, 0x80, 0xFE, 0x01, 0xF8, 0x00, 0xFE, 0x03, 0xFB, 0xF0, 0x1F,
  0x9F, 0x81, 0xFC, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07, 0xE1, 0xF8,
  0x7F, 0x0F, 0xC3, 0xF0, 0x7E, 0x3F, 0x81, 0xF1, 0xF8, 0x0F, 0xDF, 0x80,
  0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x00,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xBF, 0x00, 0xFD,
  0xF8, 0x07, 0xC7, 0xC0, 0x7E, 0x3E, 0x07, 0xE1, 0xF0, 0x3E, 0x0F, 0xC3,
  0xF0, 0x3E, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x9F, 0x80, 0x7E, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0x80, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xDF, 0xFF,
  0xE0, 0xFE, 0x7F, 0x1F, 0xCF, 0xE3, 0xF0, 0xF8, 0x7E, 0x1F, 0x00, 0xF8,
  0xFC, 0x0F, 0xF3, 0xF0, 0x7F, 0xEF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x7F, 0x9F, 0xE1, 0xFC, 0x7F, 0x8F, 0xE0, 0xFC, 0x3F, 0x83, 0xF0, 0xFC,
  0x0F, 0xC7, 0xF0, 0x3F, 0x1F, 0x81, 0xFC, 0x7E, 0x07, 0xE3, 0xF8, 0x1F,
  0x8F, 0xE0, 0x7E, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF0, 0x3F, 0x0F,
  0xC0, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x3F, 0xC3, 0xF8, 0xFE, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xDF, 0x81, 0xFE, 0x7E, 0x03, 0xF1, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x7E, 0x01, 0xFB, 0xFC, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0xC7, 0xE0, 0x7F, 0x1F, 0x81, 0xFC, 0x7E,
  0x07, 0xE1, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x0F,
  0xE3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x3E, 0x7F, 0x80, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xF0,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x87, 0xF8, 0xC1, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x04, 0x3F, 0x87, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0xF8, 0xFC, 0x03, 0xFE, 0xFC, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xC7, 0xF8, 0x1F, 0x87, 0xF8, 0x3F,
  0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x7E,
  0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0xFC,
  0x07, 0xE0, 0xFC, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0x7F, 0xEF, 0x80, 0x7F, 0xCF, 0x80, 0x3F, 0x8F, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F,
  0x87, 0xC7, 0xE0, 0xF9, 0xF8, 0x1F, 0x3F, 0x07, 0xE7, 0xC0, 0xFD, 0xF8,
  0x7F, 0x3F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xF8,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x04, 0x1F, 0xC7, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0xFF, 0xBF, 0x01, 0xFF, 0xBF, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xF9, 0xFE, 0x07, 0xF1, 0xFE, 0x0F,
  0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F,
  0x81, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x81, 0xF8, 0x3F,
  0x81, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x3F,
  0x07, 0xF0, 0x3F, 0x0F, 0xF0, 0x3F, 0x9F, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xEF, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0xC0, 0x3F, 0x80, 0xFD, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xF9, 0xF8, 0x0F, 0xDF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE1, 0xFE, 0x7F, 0x0F, 0xE1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0,
  0x7E, 0x3F, 0x83, 0xF1, 0xF8, 0x1F, 0x8F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC7,
  0xF0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC1, 0xF8, 0x7E, 0x0F,
  0xC7, 0xF0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x3F, 0x8F, 0xC1, 0xF8, 0x7E,
  0x0F, 0xC7, 0xF0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x3F, 0x8F, 0xC1, 0xF8,
  0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x80, 0xF8, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F,
  0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x1F,
  0xC0, 0xFC, 0x7F, 0x03, 0xF0, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0xCF, 0xE0,
  0x1F, 0xBF, 0x80, 0x3E, 0x7E, 0x00, 0xFD, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0xFE, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7,
  0xE0, 0x1F, 0x8F, 0xE0, 0x3F, 0x0F, 0xC0, 0x7C, 0x1F, 0x81, 0xF8, 0x3F,
  0x03, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x00, 0x07, 0xC7, 0xE0, 0xFC, 0x07, 0xCF, 0xF3, 0xFE, 0x07,
  0xDF, 0xF7, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xF3, 0xFE, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F,
  0xC1, 0xF8, 0x3F, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x1F,
  0x83, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x03, 0xE0, 0x7C, 0x3F,
  0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x3F,
  0x07, 0xE0, 0xFC, 0x7E, 0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E,
  0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0xFC,
  0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC,
  0x1F, 0x83, 0xF0, 0x07, 0xC7, 0xE0, 0x3E, 0x7F, 0x81, 0xF7, 0xFE, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFD, 0xFC, 0x3F, 0x87, 0xE1, 0xF8, 0x3F,
  0x0F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x07, 0xE1, 0xF8,
  0x3F, 0x0F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x07, 0xE1,
  0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x07,
  0xE1, 0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x3F,
  0x07, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xE1, 0xFE, 0xFE, 0x1F, 0x87, 0xF3, 0xF8, 0x3F, 0x3F, 0x03,
  0xF7, 0xF0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x07, 0xFF, 0xE0,
  0x7E, 0xFE, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFE, 0xFC,
  0x0F, 0xCF, 0xC1, 0xFC, 0xFC, 0x1F, 0xCF, 0xE3, 0xF8, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x18, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x7C, 0xFF, 0x00, 0x3E, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xF1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF0,
  0x7F, 0x01, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E,
  0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F,
  0xC0, 0xFE, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x81,
  0xFC, 0x1F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x9F, 0xC0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xBF, 0xF0, 0x0F, 0xDF, 0xF0, 0x07, 0xE7, 0xE0,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x7C, 0x07, 0xFB, 0xF0, 0x3F, 0xEF, 0x81, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x1F, 0xE1, 0xF8, 0x3F, 0x8F, 0xE0, 0xFC,
  0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC7, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E,
  0x07, 0xE1, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07,
  0xE3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0xC3,
  0xF8, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF,
  0x7E, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC7, 0xC1, 0xF3, 0xF0, 0x7D, 0xFC, 0x1F, 0x7E, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF,
  0x1F, 0xFF, 0x87, 0xF0, 0xC1, 0xF8, 0x10, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8,
  0x80, 0xFE, 0x38, 0x7F, 0x8F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F,
  0xFC, 0x07, 0xFE, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07,
  0xC0, 0x3F, 0xF3, 0xFF, 0xDF, 0xFE, 0x7F, 0xF9, 0xFF, 0xE9, 0xF8, 0x07,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x1F, 0xE0,
  0x0F, 0xC0, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x03, 0xF1, 0xF8,
  0x1F, 0x8F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x03, 0xF1,
  0xF8, 0x1F, 0x8F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x3F, 0x03,
  0xF1, 0xF8, 0x1F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x3F,
  0x07, 0xF1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF8, 0x7F, 0x1F, 0xC3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFE, 0xF8, 0x0F, 0xE7, 0xC0, 0xFC,
  0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC1, 0xF9, 0xF8,
  0x3F, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3E, 0x1F, 0x8F, 0xC3, 0xF1,
  0xF8, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0xFF, 0xF0, 0x7F, 0x07, 0xEF,
  0xC1, 0xFC, 0x1F, 0xBF, 0x0F, 0xF0, 0xFC, 0xFC, 0x3F, 0xC3, 0xF3, 0xF1,
  0xFF, 0x0F, 0xCF, 0xC7, 0xFC, 0x7E, 0x3F, 0x1F, 0xF1, 0xF8, 0xFC, 0xFF,
  0xC7, 0xC3, 0xF3, 0xFF, 0x3F, 0x0F, 0x8F, 0x7C, 0xFC, 0x3E, 0x7D, 0xF7,
  0xE0, 0xF9, 0xF7, 0xDF, 0x83, 0xEF, 0x9F, 0x7C, 0x0F, 0xBE, 0x7B, 0xF0,
  0x3E, 0xF1, 0xEF, 0x80, 0xFF, 0xC7, 0xBE, 0x03, 0xFF, 0x1F, 0xF8, 0x0F,
  0xF8, 0xFF, 0xC0, 0x3F, 0xE3, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFC,
  0x3F, 0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0x83, 0xFC, 0x00, 0xFE, 0x0F,
  0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x7F, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFC, 0x03, 0xF1,
  0xF8, 0x01, 0xFB, 0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xDF, 0x80, 0x0F, 0xDF,
  0x80, 0x1F, 0x9F, 0x80, 0x3F, 0x8F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x3F, 0x00,
  0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE1, 0xF8, 0x00, 0xF8, 0x7E,
  0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xE7, 0xE0, 0x00, 0xF9,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0xFB, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF0, 0x01,
  0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x01, 0xFE, 0x00, 0x0F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x17, 0xFE, 0x03,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x3F,
  0xE8, 0x00, 0x30,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 14, 35, 12, 0, -35 },
  { 63, 17, 13, 19, 5, -35 },
  { 91, 25, 35, 23, 0, -35 },
  { 201, 22, 40, 21, 0, -37 },
  { 311, 30, 35, 35, 3, -35 },
  { 443, 25, 35, 25, 0, -35 },
  { 553, 8, 13, 12, 5, -35 },
  { 566, 16, 43, 13, 1, -35 },
  { 652, 17, 44, 13, -4, -36 },
  { 746, 18, 21, 20, 4, -38 },
  { 794, 20, 23, 23, 2, -29 },
  { 852, 11, 14, 12, -3, -7 },
  { 872, 12, 6, 14, 1, -16 },
  { 881, 8, 7, 12, 0, -7 },
  { 888, 25, 35, 18, -3, -35 },
  { 998, 20, 35, 21, 1, -35 },
  { 1086, 15, 35, 21, 5, -35 },
  { 1152, 23, 35, 21, -2, -35 },
  { 1253, 23, 35, 21, -1, -35 },
  { 1354, 23, 35, 21, -1, -35 },
  { 1455, 22, 35, 21, 0, -35 },
  { 1552, 22, 36, 21, 1, -36 },
  { 1651, 23, 35, 21, 1, -35 },
  { 1752, 22, 35, 21, 0, -35 },
  { 1849, 21, 36, 21, 0, -36 },
  { 1944, 12, 27, 12, 0, -27 },
  { 1985, 15, 34, 12, -3, -27 },
  { 2049, 20, 23, 23, 2, -29 },
  { 2107, 20, 15, 23, 2, -25 },
  { 2145, 20, 23, 23, 2, -29 },
  { 2203, 18, 35, 16, 1, -35 },
  { 2282, 31, 39, 32, 1, -35 },
  { 2434, 23, 35, 23, -3, -35 },
  { 2535, 24, 35, 23, 0, -35 },
  { 2640, 23, 35, 21, 2, -35 },
  { 2741, 25, 35, 25, 0, -35 },
  { 2851, 22, 35, 20, 0, -35 },
  { 2948, 22, 35, 19, 0, -35 },
  { 3045, 25, 35, 26, 2, -35 },
  { 3155, 28, 35, 26, 0, -35 },
  { 3278, 21, 35, 16, -2, -35 },
  { 3370, 22, 45, 12, -8, -35 },
  { 3494, 27, 35, 23, 0, -35 },
  { 3613, 16, 35, 19, 0, -35 },
  { 3683, 36, 35, 34, 0, -35 },
  { 3841, 29, 35, 27, 0, -35 },
  { 3968, 24, 36, 27, 2, -36 },
  { 4076, 24, 35, 23, 0, -35 },
  { 4181, 24, 44, 27, 2, -36 },
  { 4313, 23, 35, 23, 0, -35 },
  { 4414, 23, 35, 20, -1, -35 },
  { 4515, 20, 35, 19, 3, -35 },
  { 4603, 25, 35, 25, 2, -35 },
  { 4713, 23, 35, 23, 4, -35 },
  { 4814, 36, 35, 34, 3, -35 },
  { 4972, 28, 35, 21, -3, -35 },
  { 5095, 21, 35, 21, 4, -35 },
  { 5187, 24, 35, 19, -2, -35 },
  { 5292, 20, 43, 14, -2, -35 },
  { 5400, 10, 35, 18, 5, -35 },
  { 5444, 20, 43, 14, -4, -35 },
  { 5552, 21, 21, 21, 0, -35 },
  { 5608, 17, 4, 16, -5, 4 },
  { 5617, 9, 8, 15, 7, -38 },
  { 5626, 22, 27, 23, 1, -27 },
  { 5701, 22, 37, 22, 0, -37 },
  { 5803, 18, 27, 18, 1, -27 },
  { 5864, 24, 37, 23, 1, -37 },
  { 5975, 19, 27, 21, 1, -27 },
  { 6040, 25, 49, 14, -6, -37 },
  { 6194, 24, 39, 23, -1, -27 },
  { 6311, 21, 37, 22, 0, -37 },
  { 6409, 13, 37, 11, 0, -37 },
  { 6470, 19, 49, 11, -6, -37 },
  { 6587, 23, 37, 21, 0, -37 },
  { 6694, 14, 37, 11, 0, -37 },
  { 6759, 32, 27, 33, 0, -27 },
  { 6867, 21, 27, 22, 0, -27 },
  { 6938, 20, 28, 22, 1, -27 },
  { 7008, 25, 39, 22, -3, -27 },
  { 7130, 22, 39, 23, 1, -27 },
  { 7238, 18, 27, 16, 0, -27 },
  { 7299, 18, 27, 18, 0, -27 },
  { 7360, 14, 32, 14, 2, -32 },
  { 7416, 21, 27, 22, 1, -27 },
  { 7487, 19, 27, 20, 3, -27 },
  { 7552, 30, 27, 30, 3, -27 },
  { 7654, 24, 27, 20, -2, -27 },
  { 7735, 26, 39, 20, -4, -27 },
  { 7862, 20, 27, 17, -2, -27 },
  { 7930, 19, 43, 17, 1, -35 },
  { 8033, 5, 49, 18, 6, -38 },
  { 8064, 19, 43, 17, -3, -35 },
  { 8167, 20, 8, 23, 2, -21 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic49pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC49PT7B_H_
