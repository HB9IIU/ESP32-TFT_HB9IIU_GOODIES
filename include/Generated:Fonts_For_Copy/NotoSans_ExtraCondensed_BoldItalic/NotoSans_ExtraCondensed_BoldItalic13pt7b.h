#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC13PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x66, 0x64, 0x0C, 0xC0, 0x5E, 0xB4, 0x14, 0x29, 0xF9, 0x42,
  0x9F, 0x94, 0x28, 0xB0, 0x08, 0xF7, 0x9C, 0x70, 0xE1, 0xAE, 0xF8, 0x84,
  0x00, 0x66, 0xA4, 0xA8, 0xAA, 0xD5, 0x3D, 0x2B, 0x6A, 0x4E, 0x3C, 0x58,
  0xA1, 0xC7, 0x7A, 0xB7, 0x6C, 0xFC, 0x5C, 0x39, 0x18, 0xC4, 0x63, 0x18,
  0xC6, 0x30, 0x31, 0x11, 0x13, 0x32, 0x66, 0xC0, 0x35, 0x3E, 0xED, 0x00,
  0x63, 0x19, 0xF6, 0x31, 0x80, 0x6D, 0x60, 0xF0, 0xF0, 0x06, 0x18, 0x20,
  0xC1, 0x06, 0x08, 0x30, 0xC0, 0x39, 0xB6, 0xD3, 0xCB, 0x6D, 0xBC, 0x70,
  0x37, 0xF3, 0x22, 0x66, 0x60, 0x1C, 0x4C, 0x18, 0x60, 0x83, 0x0C, 0x3C,
  0xF8, 0x7D, 0x30, 0xC6, 0x70, 0x61, 0xAE, 0xF0, 0x0C, 0x62, 0x8E, 0x5B,
  0x6F, 0x84, 0x30, 0x3C, 0x86, 0x1C, 0x78, 0x61, 0xAC, 0xF0, 0x1C, 0xC6,
  0x16, 0x7B, 0x2D, 0xB6, 0x70, 0x7C, 0x30, 0x86, 0x10, 0xC2, 0x18, 0xC0,
  0x3D, 0xB6, 0xCE, 0x73, 0x6D, 0xB6, 0xF0, 0x39, 0xB4, 0xD3, 0x79, 0xE1,
  0xAC, 0xE0, 0x6C, 0x01, 0xB0, 0x33, 0x00, 0x06, 0x64, 0xC0, 0x04, 0x77,
  0x38, 0x38, 0x30, 0xFF, 0xF0, 0x3F, 0x86, 0x1C, 0x3E, 0x40, 0x7A, 0xC6,
  0x66, 0x20, 0x08, 0xC0, 0x1F, 0x21, 0x6F, 0x55, 0x55, 0xB5, 0xBE, 0x94,
  0x40, 0x7C, 0x0C, 0x71, 0x45, 0x34, 0xF7, 0xD9, 0xC4, 0x3C, 0x96, 0x5F,
  0x79, 0x3C, 0xF6, 0xF0, 0x3E, 0x69, 0x83, 0x04, 0x18, 0x30, 0x34, 0x78,
  0x3C, 0x59, 0x9B, 0x36, 0x49, 0xB3, 0x7C, 0xF0, 0x3C, 0x86, 0x1E, 0x79,
  0x0C, 0x3C, 0xF0, 0x3C, 0x86, 0x18, 0x79, 0x0C, 0x30, 0xC0, 0x1E, 0x65,
  0x83, 0x14, 0xD9, 0xB3, 0x36, 0x7C, 0x36, 0x4D, 0x9B, 0xF7, 0xC9, 0xB3,
  0x66, 0xC8, 0x3C, 0x61, 0x04, 0x30, 0xC3, 0x08, 0xF0, 0x0C, 0x21, 0x86,
  0x18, 0x41, 0x0C, 0x30, 0xCE, 0x30, 0x36, 0x59, 0xA3, 0xC7, 0x0F, 0x36,
  0x6C, 0xD8, 0x32, 0x66, 0x64, 0xCF, 0xF0, 0x31, 0x99, 0xDC, 0xEE, 0xF5,
  0x52, 0xAB, 0x7D, 0xB6, 0xDB, 0x00, 0x33, 0x32, 0x72, 0x76, 0x5E, 0x5C,
  0xDC, 0xCC, 0xCC, 0x3E, 0x6D, 0x9B, 0x34, 0x78, 0xF3, 0x3E, 0x78, 0x3C,
  0x96, 0x5B, 0x7D, 0xCC, 0x30, 0xC0, 0x3E, 0x6D, 0x9B, 0x34, 0x78, 0xF3,
  0x3E, 0x78, 0x30, 0x60, 0x3C, 0xB6, 0xDB, 0x79, 0x4D, 0xB6, 0xD8, 0x3D,
  0x96, 0x1C, 0x30, 0x61, 0xBC, 0xF0, 0xF9, 0x18, 0xC6, 0x23, 0x18, 0xC0,
  0x36, 0x4D, 0x9B, 0x26, 0xC9, 0xB3, 0x7C, 0x78, 0xCF, 0x2D, 0xB6, 0xF3,
  0xCE, 0x38, 0xC0, 0xC9, 0xEC, 0xF6, 0x5B, 0x6E, 0xA7, 0x73, 0xB9, 0x98,
  0xCC, 0x00, 0x37, 0x16, 0x1C, 0x18, 0x18, 0x38, 0x28, 0x6C, 0xCC, 0xCF,
  0x65, 0x1C, 0x61, 0x84, 0x30, 0xC0, 0x3E, 0x08, 0x30, 0xC1, 0x06, 0x08,
  0x30, 0xF8, 0x1C, 0x43, 0x0C, 0x20, 0x86, 0x18, 0x61, 0x4E, 0x00, 0xC9,
  0x24, 0xDB, 0x60, 0x38, 0xC6, 0x21, 0x18, 0xC6, 0x21, 0x38, 0x10, 0xE2,
  0x9A, 0xCC, 0xF0, 0xD0, 0x3D, 0xB4, 0xF2, 0xDB, 0x67, 0x80, 0x30, 0x86,
  0x1E, 0x6D, 0x34, 0xF2, 0xDA, 0xC0, 0x3B, 0x51, 0x8C, 0x69, 0xC0, 0x06,
  0x08, 0x11, 0xE6, 0xC9, 0xB2, 0x64, 0xD8, 0xF0, 0x3B, 0x53, 0xEC, 0x65,
  0xC0, 0x06, 0x1C, 0x20, 0xE1, 0x83, 0x04, 0x08, 0x30, 0x60, 0xC1, 0x0E,
  0x00, 0x3D, 0xB4, 0xF2, 0xDB, 0x67, 0x84, 0xB3, 0x80, 0x30, 0x86, 0x1E,
  0x6D, 0xB4, 0xB6, 0xDB, 0x60, 0x32, 0x06, 0x66, 0x4C, 0xCC, 0x0C, 0x20,
  0x06, 0x18, 0x61, 0x0C, 0x30, 0xC2, 0x18, 0xE0, 0x30, 0x82, 0x1B, 0x79,
  0x47, 0x34, 0xD3, 0x60, 0x32, 0x66, 0x66, 0x4C, 0xCC, 0x7B, 0x6D, 0x49,
  0x49, 0xDB, 0xDB, 0xDA, 0x79, 0xB6, 0xD2, 0xDB, 0x6D, 0x80, 0x39, 0xA4,
  0xF2, 0xCB, 0x67, 0x00, 0x3E, 0x6C, 0x99, 0x36, 0x4D, 0x9E, 0x20, 0x41,
  0x80, 0x35, 0xB4, 0xF2, 0xCB, 0x67, 0x84, 0x10, 0xC0, 0x7B, 0x98, 0x8C,
  0x63, 0x00, 0x7A, 0x58, 0xE3, 0x5B, 0x80, 0x22, 0x76, 0x64, 0x4C, 0x60,
  0x6D, 0xB4, 0x92, 0xDB, 0x6F, 0x80, 0x9C, 0xAD, 0x4E, 0x63, 0x00, 0x9B,
  0xBE, 0xB6, 0xF4, 0xDC, 0xD8, 0xD8, 0x36, 0x78, 0xE0, 0xC3, 0x8F, 0x32,
  0x00, 0x26, 0x48, 0xB1, 0x43, 0x86, 0x0C, 0x10, 0x61, 0x80, 0x3C, 0x21,
  0x8C, 0x21, 0x8F, 0x80, 0x19, 0x8C, 0x66, 0x61, 0x8C, 0x43, 0x18, 0xFF,
  0xF8, 0x30, 0xC6, 0x21, 0x0C, 0xC4, 0x23, 0x30, 0x67, 0xF8, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 4, 9, 3, 0, -9 },
  { 6, 5, 3, 5, 1, -9 },
  { 8, 7, 9, 6, 0, -9 },
  { 16, 6, 11, 6, 0, -10 },
  { 25, 8, 9, 9, 1, -9 },
  { 34, 7, 9, 7, 0, -9 },
  { 42, 2, 3, 3, 1, -9 },
  { 43, 5, 11, 4, 0, -9 },
  { 50, 4, 11, 4, -1, -9 },
  { 56, 5, 5, 5, 1, -10 },
  { 60, 5, 7, 6, 1, -8 },
  { 65, 3, 4, 3, -1, -2 },
  { 67, 4, 1, 4, 0, -4 },
  { 68, 2, 2, 3, 0, -2 },
  { 69, 7, 9, 5, -1, -9 },
  { 77, 6, 9, 6, 0, -9 },
  { 84, 4, 9, 6, 1, -9 },
  { 89, 7, 9, 6, -1, -9 },
  { 97, 6, 9, 6, 0, -9 },
  { 104, 6, 9, 6, 0, -9 },
  { 111, 6, 9, 6, 0, -9 },
  { 118, 6, 9, 6, 0, -9 },
  { 125, 6, 9, 6, 0, -9 },
  { 132, 6, 9, 6, 0, -9 },
  { 139, 6, 9, 6, 0, -9 },
  { 146, 3, 7, 3, 0, -7 },
  { 149, 4, 9, 3, -1, -7 },
  { 154, 6, 6, 6, 0, -8 },
  { 159, 6, 4, 6, 0, -7 },
  { 162, 5, 6, 6, 1, -8 },
  { 166, 5, 9, 4, 0, -9 },
  { 172, 8, 10, 8, 0, -9 },
  { 182, 6, 9, 6, -1, -9 },
  { 189, 6, 9, 6, 0, -9 },
  { 196, 7, 9, 6, 0, -9 },
  { 204, 7, 9, 7, 0, -9 },
  { 212, 6, 9, 5, 0, -9 },
  { 219, 6, 9, 5, 0, -9 },
  { 226, 7, 9, 7, 0, -9 },
  { 234, 7, 9, 7, 0, -9 },
  { 242, 6, 9, 4, -1, -9 },
  { 249, 6, 12, 3, -2, -9 },
  { 258, 7, 9, 6, 0, -9 },
  { 266, 4, 9, 5, 0, -9 },
  { 271, 9, 9, 9, 0, -9 },
  { 282, 8, 9, 7, 0, -9 },
  { 291, 7, 9, 7, 0, -9 },
  { 299, 6, 9, 6, 0, -9 },
  { 306, 7, 11, 7, 0, -9 },
  { 316, 6, 9, 6, 0, -9 },
  { 323, 6, 9, 5, 0, -9 },
  { 330, 5, 9, 5, 1, -9 },
  { 336, 7, 9, 7, 0, -9 },
  { 344, 6, 9, 6, 1, -9 },
  { 351, 9, 9, 9, 1, -9 },
  { 362, 8, 9, 6, -1, -9 },
  { 371, 6, 9, 6, 1, -9 },
  { 378, 7, 9, 5, -1, -9 },
  { 386, 6, 11, 4, -1, -9 },
  { 395, 3, 9, 5, 1, -9 },
  { 399, 5, 11, 4, -1, -9 },
  { 406, 6, 5, 6, 0, -9 },
  { 410, 4, 1, 4, -1, 1 },
  { 411, 2, 2, 4, 2, -10 },
  { 412, 6, 7, 6, 0, -7 },
  { 418, 6, 10, 6, 0, -10 },
  { 426, 5, 7, 5, 0, -7 },
  { 431, 7, 10, 6, 0, -10 },
  { 440, 5, 7, 5, 0, -7 },
  { 445, 7, 13, 4, -2, -10 },
  { 457, 6, 10, 6, 0, -7 },
  { 465, 6, 10, 6, 0, -10 },
  { 473, 4, 10, 3, 0, -10 },
  { 478, 6, 13, 3, -2, -10 },
  { 488, 6, 10, 6, 0, -10 },
  { 496, 4, 10, 3, 0, -10 },
  { 501, 8, 7, 9, 0, -7 },
  { 508, 6, 7, 6, 0, -7 },
  { 514, 6, 7, 6, 0, -7 },
  { 520, 7, 10, 6, -1, -7 },
  { 529, 6, 10, 6, 0, -7 },
  { 537, 5, 7, 4, 0, -7 },
  { 542, 5, 7, 5, 0, -7 },
  { 547, 4, 9, 4, 0, -9 },
  { 552, 6, 7, 6, 0, -7 },
  { 558, 5, 7, 5, 1, -7 },
  { 563, 8, 7, 8, 1, -7 },
  { 570, 7, 7, 5, -1, -7 },
  { 577, 7, 10, 5, -1, -7 },
  { 586, 6, 7, 4, -1, -7 },
  { 592, 5, 11, 4, 0, -9 },
  { 599, 1, 13, 5, 2, -10 },
  { 601, 5, 11, 4, -1, -9 },
  { 608, 6, 3, 6, 0, -6 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic13pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC13PT7B_H_
