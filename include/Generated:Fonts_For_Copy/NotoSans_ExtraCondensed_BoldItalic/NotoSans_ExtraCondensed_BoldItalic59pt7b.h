#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC59PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xCF, 0xF3,
  0xF8, 0xFF, 0x7F, 0x8F, 0xF7, 0xF8, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE,
  0x7F, 0x0F, 0xC7, 0xE1, 0xFC, 0x7E, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F,
  0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x3F, 0x00, 0x00,
  0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xF8,
  0x3E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7C, 0x1F,
  0x00, 0x01, 0xF0, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E,
  0x0F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xF0, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0x98, 0xF0, 0x07, 0xF3, 0x04,
  0x01, 0xFC, 0x60, 0x00, 0x3F, 0x9C, 0x00, 0x07, 0xFB, 0x80, 0x00, 0xFF,
  0x60, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1B, 0xFC, 0x00, 0x07, 0x7F, 0x80, 0x00, 0xC7,
  0xF0, 0x40, 0x19, 0xFE, 0x0C, 0x03, 0x3F, 0xC1, 0xE0, 0xE7, 0xF0, 0x3F,
  0x1D, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xFE, 0x00,
  0x7C, 0x00, 0xFF, 0xF0, 0x07, 0xE0, 0x0F, 0xEF, 0xC0, 0x3E, 0x00, 0x7E,
  0x7E, 0x03, 0xF0, 0x07, 0xE3, 0xF0, 0x3F, 0x00, 0x3F, 0x1F, 0x81, 0xF8,
  0x01, 0xF0, 0xFC, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0xF8, 0x00, 0xFC, 0x3F,
  0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x87, 0xE0, 0x03,
  0xF0, 0x7C, 0x3E, 0x00, 0x1F, 0x87, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x1F,
  0x00, 0x07, 0xC1, 0xF1, 0xF8, 0x3C, 0x3E, 0x1F, 0x9F, 0x87, 0xF9, 0xF0,
  0xFC, 0xFC, 0x7F, 0xEF, 0xCF, 0xCF, 0xC7, 0xFF, 0x7E, 0xFC, 0x7C, 0x7F,
  0xFF, 0xFF, 0xE7, 0xE7, 0xE7, 0xEF, 0xFE, 0x3E, 0x3E, 0x3F, 0x7F, 0xE3,
  0xF3, 0xF0, 0xF9, 0xFE, 0x1F, 0x1F, 0x07, 0xC1, 0x81, 0xF8, 0xF8, 0x7E,
  0x00, 0x0F, 0x8F, 0xC3, 0xF0, 0x00, 0xFC, 0x7E, 0x1F, 0x80, 0x0F, 0xC3,
  0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0x07, 0xC0, 0x07, 0xE1, 0xF8, 0x3E, 0x00,
  0x3F, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x7E, 0x1F, 0x80, 0x1F, 0x03, 0xF0,
  0xF8, 0x01, 0xF8, 0x1F, 0x0F, 0xC0, 0x0F, 0x80, 0xF8, 0x7C, 0x00, 0xFC,
  0x07, 0xE7, 0xE0, 0x07, 0xC0, 0x3F, 0xFE, 0x00, 0x7E, 0x00, 0xFF, 0xF0,
  0x03, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x0F, 0xE7, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x07, 0xF0, 0x3F, 0xFC, 0x1F, 0xC1, 0xFF, 0xF8,
  0xFE, 0x0F, 0xFF, 0xE3, 0xF8, 0x7F, 0xBF, 0x9F, 0xE3, 0xFC, 0xFF, 0x7F,
  0x0F, 0xE3, 0xFF, 0xFC, 0x7F, 0x07, 0xFF, 0xE1, 0xFC, 0x1F, 0xFF, 0x8F,
  0xF0, 0x7F, 0xFC, 0x3F, 0x80, 0xFF, 0xF0, 0xFE, 0x03, 0xFF, 0x83, 0xF8,
  0x07, 0xFC, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0xC0, 0xFF, 0x0F,
  0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xBF, 0xC0, 0xFF, 0xF8, 0xFF, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x60, 0x00, 0x00, 0x3F, 0xCF, 0xE3, 0xF9, 0xFE, 0x7F, 0x9F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0x8F, 0xE3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x20, 0x7E, 0x00, 0xC1, 0xF8, 0x07, 0xC7, 0xC0,
  0x1F, 0xDF, 0x0E, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xE0, 0x03, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xF9, 0xF8, 0x0F, 0xC7, 0xF0,
  0x1F, 0x1F, 0xE0, 0x38, 0x3E, 0x00, 0x40, 0xF0, 0x00, 0x01, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xF8,
  0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F,
  0x80, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF,
  0xBF, 0xFF, 0x00, 0x1F, 0x1F, 0xDF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7E, 0x08, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFE, 0x7F, 0x03, 0xF8, 0x7F,
  0x07, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x0F, 0xE0, 0x7F, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F,
  0x3F, 0xC0, 0x7F, 0x3F, 0xC0, 0xFF, 0x3F, 0x80, 0xFF, 0x3F, 0x80, 0xFF,
  0x7F, 0x80, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x01, 0xFE,
  0x7F, 0x01, 0xFE, 0xFF, 0x01, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC,
  0xFF, 0x03, 0xFC, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF0,
  0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xC0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F,
  0xBF, 0x87, 0xE7, 0xF0, 0xF9, 0xFE, 0x0E, 0x3F, 0xC0, 0x87, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xE3, 0xFF, 0x00, 0xF8, 0x1F, 0xF0, 0x07, 0x00, 0xFF,
  0x00, 0x60, 0x0F, 0xF0, 0x04, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xE1, 0xFF, 0x00,
  0x60, 0x1F, 0xE0, 0x08, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC2, 0x00, 0x0F, 0xF0, 0x60, 0x03, 0xFE, 0x0F, 0x81, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xDF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3E, 0xFE,
  0x00, 0x0F, 0x9F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x7C, 0xFF, 0x00, 0x1F,
  0x1F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xF8, 0x7F, 0x00, 0x3E, 0x0F, 0xE0,
  0x0F, 0xC3, 0xFC, 0x01, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0x81,
  0xFC, 0x03, 0xE0, 0x7F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xCC, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x20,
  0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x20, 0x01,
  0xFE, 0x0C, 0x01, 0xFF, 0x83, 0xF1, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFE, 0x02, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE7, 0xF0, 0x07, 0xF3, 0xFE, 0x01, 0xFD, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0x3F, 0xE1, 0xFF, 0x07,
  0xF8, 0x7F, 0xC1, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFC,
  0x07, 0xF8, 0x7F, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x3F, 0xC3,
  0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F,
  0x81, 0xFC, 0x3F, 0xE0, 0x7F, 0x9F, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xF7, 0xFC, 0x0F, 0xF0, 0xFF, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x81, 0xFC, 0x1F, 0xE0, 0x7F,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x0F, 0xE3,
  0xFC, 0x03, 0xFD, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFD, 0xFF, 0x03, 0xFC, 0x3F,
  0xC1, 0xFE, 0x07, 0xF0, 0x7F, 0x81, 0xFE, 0x1F, 0xC0, 0x7F, 0x8F, 0xF0,
  0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x8F,
  0xF0, 0x1F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xF1, 0xFE, 0x07, 0xF8,
  0x3F, 0x81, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F,
  0xF0, 0x3F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x81, 0xFE,
  0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x0F, 0xF8, 0x7F, 0x83,
  0xFE, 0x1F, 0xE1, 0xFF, 0x87, 0xFC, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xBF, 0x80, 0x7F, 0xCF, 0xE0,
  0x07, 0xC7, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0xC0, 0x7F, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x07, 0xE0, 0x3F,
  0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x03, 0xF0, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x3F, 0xC0, 0x7E, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0x7E, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE0, 0xE0, 0x7F, 0x04, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x08, 0x01,
  0xF0, 0x3E, 0x03, 0xFF, 0x0F, 0x83, 0xF0, 0x7F, 0xFC, 0x7C, 0x1F, 0x07,
  0xFF, 0xC3, 0xE1, 0xF0, 0x7F, 0xFE, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0xF8,
  0xF8, 0x3E, 0x0F, 0x87, 0xC7, 0xC3, 0xF0, 0xF8, 0x3E, 0x3E, 0x1F, 0x07,
  0xC1, 0xF3, 0xE1, 0xF8, 0x3E, 0x0F, 0x1F, 0x0F, 0x83, 0xF0, 0xF8, 0xF8,
  0x7C, 0x1F, 0x07, 0xCF, 0x87, 0xE0, 0xF8, 0x3E, 0x7C, 0x3E, 0x07, 0xC1,
  0xE3, 0xE1, 0xF0, 0x7E, 0x1F, 0x1F, 0x0F, 0x83, 0xF0, 0xF8, 0xF8, 0x7C,
  0x1F, 0x07, 0x87, 0xC3, 0xE1, 0xF8, 0x7C, 0x7C, 0x1F, 0x0F, 0xC3, 0xE3,
  0xE0, 0xF8, 0xFE, 0x3E, 0x1F, 0x07, 0xEF, 0xF3, 0xE0, 0xF8, 0x3F, 0xF7,
  0xFF, 0x07, 0xC1, 0xFF, 0xBF, 0xF0, 0x3E, 0x07, 0xF8, 0xFF, 0x01, 0xF8,
  0x1F, 0x87, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x08, 0x00, 0x07, 0xF0, 0x03, 0xC0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0x7F,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01,
  0xFC, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x87,
  0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00,
  0xFE, 0x07, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xE0,
  0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF,
  0x3F, 0xC0, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0xC1, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F,
  0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC,
  0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x1F,
  0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0x80,
  0xFF, 0x81, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x0F, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFC, 0x78, 0x03, 0xFF, 0x01, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x06, 0x00, 0x7F, 0xF3, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0x87, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x3F,
  0xC0, 0x7F, 0xC0, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0,
  0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x07,
  0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0xC1, 0xFC, 0x01, 0xFE,
  0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x83,
  0xFC, 0x03, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE,
  0x01, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0x00,
  0xFF, 0x83, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x80, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xE0, 0xF8, 0x03, 0xFF, 0x00, 0x70, 0x07, 0xFC, 0x00, 0x20,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x0F, 0xFF, 0x87, 0xF8, 0x1F, 0xFF, 0x0F, 0xF0, 0x3F, 0xFC, 0x1F, 0xE0,
  0x7F, 0xF8, 0x3F, 0xC0, 0xFF, 0xF0, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0x07,
  0xFF, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03,
  0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F,
  0xC0, 0xFF, 0x80, 0x7F, 0x81, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE,
  0x03, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07,
  0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07,
  0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0,
  0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC,
  0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x01, 0x9F, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x1F,
  0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x7F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x07,
  0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x00,
  0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0x3F, 0x8F, 0xF0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x0F, 0xE7, 0xF8, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFB, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x03, 0xF8, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xF0, 0x01, 0xFC,
  0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x00,
  0xFD, 0xF8, 0x0F, 0xDF, 0xC0, 0x3F, 0xBF, 0x01, 0xFF, 0xF8, 0x07, 0xF7,
  0xE0, 0x7F, 0xFE, 0x00, 0xFE, 0xFC, 0x0F, 0xDF, 0xC0, 0x1F, 0xDF, 0x83,
  0xFB, 0xF8, 0x03, 0xFB, 0xF0, 0x7E, 0x7F, 0x00, 0xFE, 0x7E, 0x1F, 0xDF,
  0xE0, 0x1F, 0xCF, 0xC3, 0xF3, 0xF8, 0x03, 0xF9, 0xF8, 0x7E, 0x7F, 0x00,
  0x7F, 0x3F, 0x1F, 0x8F, 0xE0, 0x0F, 0xE7, 0xE3, 0xF3, 0xFC, 0x03, 0xF8,
  0xFC, 0xFE, 0x7F, 0x80, 0x7F, 0x1F, 0x9F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF7,
  0xF1, 0xFC, 0x01, 0xFC, 0x7E, 0xFC, 0x3F, 0x80, 0x3F, 0x8F, 0xFF, 0x8F,
  0xF0, 0x0F, 0xE1, 0xFF, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0xFC, 0x3F, 0x80,
  0x3F, 0x87, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0xFF, 0xE0, 0xFE, 0x01, 0xFC,
  0x1F, 0xF8, 0x3F, 0xC0, 0x3F, 0x83, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x7F,
  0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFF, 0x03,
  0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x00, 0xFE, 0x03, 0xF8, 0x1F, 0xC0,
  0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x1F,
  0xF0, 0x01, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x80, 0x7F, 0xF0, 0x07,
  0xF0, 0x0F, 0xFE, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0x80, 0x3F, 0xFC,
  0x07, 0xF0, 0x07, 0xFF, 0x80, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xC0, 0x3F,
  0xFE, 0x07, 0xF0, 0x07, 0xFF, 0xC0, 0xFE, 0x00, 0xFD, 0xFC, 0x1F, 0xC0,
  0x3F, 0xBF, 0x83, 0xF8, 0x07, 0xF7, 0xF0, 0xFE, 0x00, 0xFE, 0x7E, 0x1F,
  0xC0, 0x1F, 0xCF, 0xC3, 0xF8, 0x03, 0xF9, 0xFC, 0x7F, 0x00, 0xFE, 0x3F,
  0x8F, 0xE0, 0x1F, 0xC7, 0xF3, 0xF8, 0x03, 0xF8, 0xFE, 0x7F, 0x00, 0x7F,
  0x0F, 0xCF, 0xE0, 0x0F, 0xE1, 0xF9, 0xFC, 0x03, 0xF8, 0x3F, 0xBF, 0x80,
  0x7F, 0x07, 0xF7, 0xE0, 0x0F, 0xE0, 0xFF, 0xFC, 0x01, 0xFC, 0x1F, 0xFF,
  0x80, 0x3F, 0x01, 0xFF, 0xF0, 0x0F, 0xE0, 0x3F, 0xFE, 0x01, 0xFC, 0x07,
  0xFF, 0x80, 0x3F, 0x80, 0xFF, 0xF0, 0x07, 0xF0, 0x1F, 0xFE, 0x01, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0x80, 0x3F, 0xF0, 0x07, 0xF0, 0x07, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xF8, 0x07, 0xF0, 0x03, 0xFF,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xE7, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0,
  0x7F, 0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x7F,
  0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFF, 0x3F, 0xE0,
  0x07, 0xFC, 0xFF, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x7F, 0x9F, 0xF0, 0x01,
  0xFE, 0x7F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F,
  0x9F, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xF3, 0xFE, 0x00, 0x3F, 0xCF,
  0xF8, 0x01, 0xFF, 0x3F, 0xC0, 0x07, 0xFC, 0xFF, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0xFF, 0x8F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00,
  0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F,
  0xC0, 0x7F, 0xEF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xC1, 0xFF,
  0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07,
  0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xE0,
  0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xE7, 0xFE, 0x03, 0xFE,
  0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0xC3, 0xFE, 0x01,
  0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x7F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x3F,
  0xC7, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0x00, 0x1F, 0xF3,
  0xFC, 0x00, 0x7F, 0x9F, 0xF0, 0x01, 0xFE, 0x7F, 0xC0, 0x07, 0xF9, 0xFE,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFE, 0xFF, 0x80,
  0x0F, 0xF3, 0xFE, 0x00, 0x3F, 0xCF, 0xF8, 0x01, 0xFF, 0x3F, 0xC0, 0x07,
  0xFC, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x8F, 0xF0, 0x03, 0xFC,
  0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x0F,
  0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0xEF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFE, 0x3F, 0xF0,
  0x1F, 0xE1, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0x01, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0xFF,
  0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x03, 0xFC, 0x07, 0xF0, 0x7F, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xE7, 0xF0, 0x01, 0xFC, 0x7F,
  0x00, 0x1F, 0xC7, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x3F, 0xC3, 0xF8, 0x03,
  0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x83,
  0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xE0,
  0x7F, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xE0,
  0x0F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0x03, 0x80, 0x3F, 0xE0,
  0x08, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x04, 0x00, 0x3F,
  0xC0, 0x60, 0x07, 0xFC, 0x07, 0x80, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8,
  0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80,
  0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE,
  0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFE, 0x03,
  0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFE,
  0xFF, 0x00, 0x1F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0,
  0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0xFF,
  0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x7F,
  0x80, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x07,
  0xF0, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x3F,
  0xC0, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xE7, 0xF0, 0x00,
  0x7E, 0x7F, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xDF, 0xC0, 0x0F, 0xE0, 0x0F, 0xF7, 0xF0, 0x03, 0xF8, 0x03, 0xF9,
  0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x9F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xF8, 0x0F, 0xF1, 0xFC, 0x03, 0xFE,
  0x03, 0xF8, 0x7F, 0x01, 0xFF, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0xE0, 0x7F,
  0x87, 0xF0, 0x3F, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xFE, 0x0F, 0xF0, 0x7F,
  0x03, 0xFF, 0x83, 0xF8, 0x1F, 0xC1, 0xFF, 0xE0, 0xFE, 0x07, 0xF0, 0x7F,
  0xF0, 0x7F, 0x81, 0xFC, 0x1F, 0xFC, 0x1F, 0xC0, 0x7F, 0x0F, 0xFF, 0x07,
  0xF0, 0x1F, 0xC3, 0xFF, 0xC3, 0xFC, 0x07, 0xF1, 0xFB, 0xF0, 0xFE, 0x01,
  0xFC, 0x7E, 0xFC, 0x7F, 0x80, 0x7F, 0x1F, 0xBF, 0x1F, 0xC0, 0x1F, 0xCF,
  0xCF, 0xC7, 0xF0, 0x07, 0xF3, 0xF3, 0xF3, 0xFC, 0x01, 0xFD, 0xFC, 0xFC,
  0xFE, 0x00, 0x7E, 0x7E, 0x3F, 0x3F, 0x80, 0x1F, 0x9F, 0x8F, 0xDF, 0xC0,
  0x0F, 0xEF, 0xC3, 0xF7, 0xF0, 0x03, 0xFB, 0xF0, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0,
  0x3F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x07, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xFC, 0x3F,
  0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xDF, 0xC0, 0x3F, 0xCF, 0xE0, 0x1F, 0xC7, 0xF0, 0x1F, 0xE3, 0xF8,
  0x0F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x87, 0xF8, 0x3F,
  0xC3, 0xF8, 0x0F, 0xE3, 0xFC, 0x07, 0xF1, 0xFC, 0x03, 0xF9, 0xFC, 0x01,
  0xFC, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x04, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x08, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1,
  0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xEF, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x7F, 0x3F,
  0x80, 0x3F, 0x87, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xF0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x8F,
  0xE0, 0x0F, 0xE7, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F,
  0xC0, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xC7, 0xF9, 0xFE, 0x3F, 0x8F, 0xF1, 0xFC, 0x3F, 0x0F, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0xF1, 0xFC, 0x07, 0xFF, 0x3F, 0x01, 0xFF, 0xEF,
  0xE0, 0x3F, 0xFD, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F,
  0xC7, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE,
  0x1F, 0xE0, 0x3F, 0x83, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFE, 0x1F, 0xE0,
  0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1,
  0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03,
  0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F,
  0xE0, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xF7, 0xF0, 0x1F, 0xFC, 0xFC, 0x01, 0xFF, 0x1F, 0x80, 0x1F,
  0xC3, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x38,
  0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xBF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xF0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFC, 0x07, 0xF0, 0xFF, 0x01, 0xFC, 0x3F, 0x80, 0x7F,
  0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x0F, 0xF1, 0xFC, 0x03, 0xFC, 0x7F, 0x00,
  0xFF, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xF8, 0xFF,
  0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x3F, 0xC3, 0xF8, 0x0F, 0xF0,
  0xFE, 0x03, 0xF8, 0x7F, 0xC1, 0xFE, 0x1F, 0xF0, 0x7F, 0x87, 0xFC, 0x3F,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xEF,
  0xFE, 0x03, 0xF3, 0xFF, 0x00, 0xFC, 0x7F, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFE, 0x0C, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x06, 0x07,
  0xF8, 0x78, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xE1, 0xFE, 0x00, 0x3F, 0xCF,
  0xE0, 0x03, 0xFF, 0x7F, 0x00, 0x3F, 0xFB, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xE1, 0xFF, 0x00, 0xFE,
  0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x0F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC,
  0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0,
  0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0xFC, 0x00, 0x7F, 0xE7,
  0xE0, 0x01, 0xFE, 0x3F, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFE, 0x3F, 0x87, 0xF8, 0x3F, 0x0F, 0xE0, 0x7E, 0x3F,
  0x80, 0xFC, 0x7F, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x1F, 0xC7, 0xF0,
  0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x01, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x01, 0x83, 0xFE, 0x1F, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xF3, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x11,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xC7,
  0xF0, 0x01, 0xFF, 0x9F, 0x80, 0x0F, 0xFE, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x01,
  0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE,
  0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F,
  0xE0, 0xFF, 0x80, 0x7F, 0x87, 0xFC, 0x01, 0xFF, 0x3F, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xEF,
  0xE0, 0x01, 0xFF, 0xBF, 0x80, 0x03, 0xF9, 0xFE, 0x00, 0x01, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x08, 0x00, 0x7F, 0x80, 0x38, 0x01, 0xFE, 0x00, 0xFC,
  0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x3C, 0x00, 0xFE, 0x7F, 0x80,
  0x3F, 0xBF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0xFF, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x83,
  0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFC, 0x1F, 0xC0, 0x7F,
  0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0,
  0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF8, 0x7F,
  0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0,
  0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x0F,
  0xE0, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0x03, 0xF8, 0x1F,
  0xE0, 0x3F, 0x83, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF8, 0x07,
  0xF0, 0xFF, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x3F,
  0x80, 0x0F, 0xE7, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xEF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x03, 0xF8,
  0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0,
  0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x01, 0xC0, 0x0F, 0xC7, 0xF8, 0x3F, 0xC0, 0x3F, 0x3F, 0xF1, 0xFF,
  0x80, 0xFD, 0xFF, 0xEF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x1F, 0xF8, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0xFF, 0x03,
  0xF8, 0x1F, 0xC3, 0xFC, 0x1F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x03, 0xFC,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x87, 0xF0, 0x1F,
  0xC0, 0xFE, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x1F, 0xE1,
  0xFC, 0x0F, 0xE0, 0x7F, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x3F, 0x80, 0xFE,
  0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x7F, 0x81, 0xFC, 0x0F, 0xE1, 0xFC, 0x07, 0xF0,
  0x3F, 0x87, 0xF0, 0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x81,
  0xFC, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0x00, 0x38, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x3F, 0xF0, 0x0F, 0xDF, 0xFE,
  0x03, 0xF7, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xF0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x03, 0xF8, 0x3F,
  0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF8,
  0x7F, 0x81, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07,
  0xF0, 0x7F, 0x03, 0xFC, 0x3F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8,
  0x0F, 0xE0, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xC0, 0x7F, 0x07,
  0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xFC, 0x3F, 0xC0, 0xFE,
  0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0x1F,
  0xE0, 0xFF, 0x1F, 0xE0, 0x7F, 0x3F, 0xC0, 0x7F, 0x3F, 0xC0, 0x7F, 0x3F,
  0x80, 0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x80, 0xFF, 0x7F,
  0x00, 0xFF, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF,
  0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFC, 0xFF, 0x03, 0xFC, 0xFF,
  0x03, 0xFC, 0xFF, 0x07, 0xF8, 0x7F, 0x8F, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x03, 0xF0, 0xFE,
  0x00, 0x1F, 0x9F, 0xF8, 0x00, 0xFD, 0xFF, 0xE0, 0x07, 0xEF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0xFF, 0x00, 0xFF,
  0x07, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0,
  0x7F, 0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE,
  0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x0F,
  0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xC0,
  0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xEF, 0xFF, 0x00, 0x7F, 0x7F, 0xF0, 0x03, 0xF9, 0xFF,
  0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFE, 0x0C, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0xF1, 0xFC, 0x03, 0xFF, 0x3F, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0x87, 0xFC, 0x0F,
  0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x1F, 0xE0, 0x3F,
  0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC,
  0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8,
  0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x3F, 0xC0,
  0x7F, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x03,
  0xFE, 0x3F, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xBF, 0x80, 0x1F, 0xC7, 0xF0, 0x00,
  0x41, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x0F, 0xC7, 0xF0, 0x3F, 0x3F, 0x80, 0xFD, 0xFE, 0x03, 0xF7,
  0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0x10,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF,
  0x9F, 0x07, 0xF8, 0x0C, 0x1F, 0xE0, 0x10, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC2, 0x00, 0xFF, 0x0F, 0x07, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xFF, 0x1F, 0xFF, 0x9F,
  0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF0, 0x7F, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x0E, 0x00, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F,
  0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0x7F, 0x07, 0xF0,
  0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F,
  0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x81, 0xFE,
  0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x03,
  0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC3, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFB, 0xF0, 0x1F, 0xFE, 0xFC, 0x03, 0xFF, 0x3F, 0x00, 0x7F, 0x0F,
  0x80, 0x03, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFB, 0xF8,
  0x0F, 0xE7, 0xF0, 0x1F, 0xCF, 0xE0, 0x7F, 0x9F, 0xC0, 0xFE, 0x3F, 0x83,
  0xFC, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F,
  0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xE0, 0x3F, 0x9F, 0xC0,
  0x7E, 0x3F, 0x80, 0xFC, 0xFE, 0x01, 0xF9, 0xFC, 0x03, 0xF3, 0xF0, 0x07,
  0xEF, 0xE0, 0x0F, 0xDF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x03, 0xFC, 0x07, 0xF7, 0xF0, 0x3F, 0xC0, 0x7F, 0x7F, 0x07,
  0xFC, 0x0F, 0xE7, 0xF0, 0x7F, 0xC0, 0xFE, 0x7F, 0x07, 0xFC, 0x1F, 0xC7,
  0xE0, 0xFF, 0xC1, 0xFC, 0x7E, 0x0F, 0xFC, 0x1F, 0xC7, 0xE1, 0xFF, 0xC3,
  0xF8, 0x7E, 0x1F, 0xFC, 0x3F, 0x87, 0xE1, 0xFF, 0xC7, 0xF0, 0x7E, 0x3F,
  0xFC, 0x7F, 0x07, 0xE3, 0xFF, 0xC7, 0xF0, 0xFE, 0x3E, 0xFC, 0xFE, 0x0F,
  0xE7, 0xEF, 0xCF, 0xE0, 0xFE, 0x7E, 0xFC, 0xFC, 0x0F, 0xEF, 0xCF, 0xDF,
  0xC0, 0xFE, 0xFC, 0xFD, 0xFC, 0x0F, 0xEF, 0x8F, 0xDF, 0x80, 0xFF, 0xF8,
  0xFF, 0xF8, 0x0F, 0xFF, 0x8F, 0xBF, 0x00, 0xFF, 0xF0, 0xFB, 0xF0, 0x0F,
  0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE,
  0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xC1,
  0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x0F,
  0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x83, 0xFC,
  0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x01,
  0xFC, 0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0xFF, 0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x03,
  0xF8, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0,
  0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFE, 0x01,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0,
  0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x23, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x9F, 0xF8, 0x00, 0xDF, 0xFF, 0x00, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFE,
  0xC0, 0x0F, 0xFE, 0x40, 0x00, 0xFC, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 17, 43, 15, 0, -42 },
  { 93, 20, 15, 23, 6, -42 },
  { 131, 30, 42, 28, 0, -42 },
  { 289, 27, 48, 25, 0, -45 },
  { 451, 37, 44, 42, 3, -43 },
  { 655, 30, 44, 30, 0, -43 },
  { 820, 10, 15, 14, 6, -42 },
  { 839, 20, 51, 16, 1, -42 },
  { 967, 20, 52, 16, -5, -43 },
  { 1097, 22, 24, 24, 5, -45 },
  { 1163, 24, 28, 27, 2, -35 },
  { 1247, 13, 16, 14, -3, -8 },
  { 1273, 15, 7, 17, 1, -19 },
  { 1287, 9, 10, 14, 0, -9 },
  { 1299, 30, 43, 22, -3, -43 },
  { 1461, 24, 44, 25, 1, -43 },
  { 1593, 19, 42, 26, 6, -42 },
  { 1693, 28, 43, 25, -2, -43 },
  { 1844, 27, 44, 25, -1, -43 },
  { 1993, 27, 42, 26, -1, -42 },
  { 2135, 26, 43, 25, 0, -42 },
  { 2275, 26, 44, 25, 1, -43 },
  { 2418, 28, 42, 25, 1, -42 },
  { 2565, 26, 44, 25, 0, -43 },
  { 2708, 26, 44, 25, 0, -43 },
  { 2851, 14, 34, 14, 0, -33 },
  { 2911, 17, 41, 14, -3, -33 },
  { 2999, 24, 28, 27, 2, -35 },
  { 3083, 24, 18, 27, 2, -30 },
  { 3137, 25, 28, 27, 2, -35 },
  { 3225, 21, 44, 20, 1, -43 },
  { 3341, 37, 48, 38, 1, -43 },
  { 3563, 28, 42, 28, -4, -42 },
  { 3710, 29, 42, 28, 0, -42 },
  { 3863, 28, 44, 26, 2, -43 },
  { 4017, 30, 42, 30, 0, -42 },
  { 4175, 26, 42, 23, 0, -42 },
  { 4312, 26, 42, 23, 0, -42 },
  { 4449, 31, 44, 31, 2, -43 },
  { 4620, 33, 42, 31, 0, -42 },
  { 4794, 26, 42, 19, -3, -42 },
  { 4931, 26, 55, 15, -9, -42 },
  { 5110, 33, 42, 27, 0, -42 },
  { 5284, 19, 42, 23, 0, -42 },
  { 5384, 43, 42, 41, 0, -42 },
  { 5610, 35, 42, 33, 0, -42 },
  { 5794, 30, 44, 32, 2, -43 },
  { 5959, 29, 42, 27, 0, -42 },
  { 6112, 30, 53, 32, 2, -43 },
  { 6311, 28, 42, 27, 0, -42 },
  { 6458, 28, 44, 24, -1, -43 },
  { 6612, 24, 42, 23, 4, -42 },
  { 6738, 31, 43, 30, 2, -42 },
  { 6905, 28, 42, 27, 5, -42 },
  { 7052, 42, 42, 41, 4, -42 },
  { 7273, 33, 42, 26, -3, -42 },
  { 7447, 25, 42, 25, 5, -42 },
  { 7579, 29, 42, 23, -2, -42 },
  { 7732, 23, 51, 17, -2, -42 },
  { 7879, 12, 43, 22, 6, -43 },
  { 7944, 23, 51, 17, -4, -42 },
  { 8091, 26, 25, 26, 0, -42 },
  { 8173, 20, 4, 19, -6, 5 },
  { 8183, 10, 9, 18, 9, -45 },
  { 8195, 27, 34, 27, 1, -33 },
  { 8310, 26, 46, 27, 0, -45 },
  { 8460, 22, 34, 22, 1, -33 },
  { 8554, 29, 46, 27, 1, -45 },
  { 8721, 23, 34, 25, 1, -33 },
  { 8819, 30, 59, 16, -7, -45 },
  { 9041, 30, 47, 27, -2, -33 },
  { 9218, 26, 45, 27, 0, -45 },
  { 9365, 16, 45, 14, 0, -45 },
  { 9455, 24, 59, 14, -8, -45 },
  { 9632, 28, 45, 25, 0, -45 },
  { 9790, 17, 45, 13, 0, -45 },
  { 9886, 38, 33, 40, 0, -33 },
  { 10043, 26, 33, 27, 0, -33 },
  { 10151, 24, 34, 26, 1, -33 },
  { 10253, 29, 47, 27, -3, -33 },
  { 10424, 27, 47, 27, 1, -33 },
  { 10583, 22, 33, 19, 0, -33 },
  { 10674, 22, 34, 21, 0, -33 },
  { 10768, 17, 40, 17, 2, -39 },
  { 10853, 26, 33, 27, 1, -32 },
  { 10961, 23, 32, 24, 4, -32 },
  { 11053, 36, 32, 36, 3, -32 },
  { 11197, 29, 32, 24, -3, -32 },
  { 11313, 31, 46, 24, -4, -32 },
  { 11492, 24, 32, 20, -2, -32 },
  { 11588, 23, 51, 20, 1, -42 },
  { 11735, 7, 58, 22, 7, -45 },
  { 11786, 22, 51, 20, -3, -42 },
  { 11927, 25, 10, 27, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic59pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC59PT7B_H_
