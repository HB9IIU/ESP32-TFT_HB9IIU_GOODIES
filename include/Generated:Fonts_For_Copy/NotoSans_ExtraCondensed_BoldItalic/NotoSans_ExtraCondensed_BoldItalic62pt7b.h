#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC62PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF0, 0x01, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFE, 0x3F, 0x87, 0xF1, 0xFE, 0x1F, 0xC7,
  0xF0, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xE0,
  0xFE, 0x1F, 0x83, 0xF0, 0xFE, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1, 0xFC,
  0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC,
  0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x3F,
  0x00, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xFC, 0x3F, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x03, 0xE0, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFC, 0xC7, 0x80, 0x3F, 0x8C, 0x10, 0x03, 0xF9, 0xC0, 0x00, 0x3F,
  0x9C, 0x00, 0x03, 0xF9, 0xC0, 0x00, 0x3F, 0x98, 0x00, 0x03, 0xFD, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0E, 0xFF, 0x00, 0x00, 0xCF, 0xF0, 0x00, 0x0C,
  0xFF, 0x04, 0x00, 0xCF, 0xF0, 0x60, 0x1C, 0xFF, 0x07, 0x01, 0xCF, 0xF0,
  0x7C, 0x19, 0xFE, 0x07, 0xFD, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x1F, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x00, 0xFC,
  0x00, 0xFF, 0xF8, 0x03, 0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xE0, 0x07, 0xE3,
  0xF0, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0xFC,
  0x00, 0x7E, 0x1F, 0x81, 0xF8, 0x00, 0xF8, 0x3F, 0x07, 0xE0, 0x03, 0xF0,
  0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xF0, 0x7E,
  0x00, 0x1F, 0x07, 0xE1, 0xF8, 0x00, 0x3E, 0x0F, 0xC3, 0xE0, 0x00, 0xFC,
  0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0x3E, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x7E,
  0x0F, 0xC7, 0xE1, 0xF9, 0xF8, 0x7F, 0xCF, 0xC7, 0xE3, 0xF1, 0xFF, 0xDF,
  0x8F, 0xCF, 0xC7, 0xFF, 0xBF, 0xBF, 0x1F, 0x9F, 0xFF, 0xBF, 0xFE, 0x7E,
  0x3F, 0x3F, 0x7F, 0xF8, 0xFC, 0xFC, 0x7E, 0x7F, 0xE3, 0xF1, 0xF0, 0xFC,
  0xFF, 0x87, 0xC7, 0xE1, 0xF8, 0x7C, 0x1F, 0x8F, 0xC3, 0xF0, 0x00, 0x7E,
  0x1F, 0x07, 0xE0, 0x00, 0xFC, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x1F,
  0x80, 0x07, 0xE1, 0xF8, 0x3E, 0x00, 0x1F, 0x83, 0xE0, 0xFC, 0x00, 0x3F,
  0x07, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x07,
  0xC0, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x3F, 0x00, 0x3F,
  0x01, 0xF8, 0xFC, 0x00, 0x7C, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0x03, 0xFF,
  0xE0, 0x07, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0x00, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0xFF, 0x03, 0xFF,
  0xE0, 0xFE, 0x07, 0xFF, 0xF1, 0xFE, 0x0F, 0xFF, 0xF1, 0xFE, 0x1F, 0xEF,
  0xF1, 0xFC, 0x3F, 0xCF, 0xFB, 0xFC, 0x3F, 0xC7, 0xFB, 0xF8, 0x7F, 0x87,
  0xFF, 0xF8, 0x7F, 0x83, 0xFF, 0xF0, 0x7F, 0x03, 0xFF, 0xF0, 0xFF, 0x03,
  0xFF, 0xE0, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x87,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xBF, 0xE0, 0x1F, 0xFF, 0x1F, 0xF0, 0x0F, 0xFC,
  0x1F, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xE7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xF8, 0x7F, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F, 0xE1,
  0xFC, 0x3F, 0x87, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x04, 0x0F, 0xE0, 0x0E, 0x1F, 0x80, 0x3E,
  0x3F, 0x00, 0x7F, 0x7E, 0x1C, 0xFF, 0xFD, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFE, 0xFE,
  0x07, 0xF8, 0xFE, 0x07, 0xF1, 0xFE, 0x07, 0xC3, 0xFC, 0x07, 0x03, 0xE0,
  0x06, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF,
  0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x07,
  0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0x8F, 0xE7, 0xFD,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFB, 0xFC, 0x7E, 0x06, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFD, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC,
  0x0F, 0xF0, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7,
  0xF8, 0x0F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F,
  0x8F, 0xF0, 0x1F, 0xE7, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0x80,
  0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF1, 0xFC, 0x03, 0xFC, 0xFF,
  0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC, 0x0F, 0xF0,
  0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC7, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F,
  0xFF, 0xCF, 0xFB, 0xF8, 0x7F, 0x3F, 0x87, 0xE7, 0xF8, 0x3C, 0x7F, 0x81,
  0x87, 0xF8, 0x10, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xE3, 0xFF, 0x00, 0xFC, 0x0F, 0xF8, 0x03, 0xC0, 0x3F,
  0xC0, 0x1C, 0x01, 0xFE, 0x00, 0x40, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xC7,
  0xFF, 0x00, 0x70, 0x1F, 0xF8, 0x01, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x08, 0x00, 0x3F, 0xE0, 0x70, 0x03,
  0xFF, 0x03, 0xFD, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7D,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFB, 0xFC, 0x00, 0x1F, 0x3F, 0x80,
  0x03, 0xF3, 0xF8, 0x00, 0x3E, 0x7F, 0x80, 0x07, 0xC7, 0xF8, 0x00, 0xFC,
  0x7F, 0x00, 0x0F, 0x87, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x0F, 0xF0,
  0x03, 0xE0, 0xFF, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0xF8,
  0x1F, 0xE0, 0x1F, 0x81, 0xFE, 0x03, 0xF0, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x30, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x08, 0x00, 0x7F, 0xC0, 0xE0,
  0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xA0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFE, 0x04, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xEF,
  0xFC, 0x01, 0xFD, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x07, 0xFC,
  0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF,
  0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF,
  0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x03, 0xFE, 0x07, 0xF0, 0x3F,
  0xC0, 0x7F, 0x87, 0xFC, 0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x3F,
  0xE1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x03, 0xF8, 0x0F,
  0xF0, 0x3F, 0x80, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x03,
  0xF8, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xEF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xF3, 0xFE, 0x03, 0xFE, 0x1F, 0xE0,
  0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF,
  0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF,
  0x83, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x1F, 0xF9, 0xFE, 0x03, 0xFC, 0x3F, 0xE0, 0xFF, 0x03,
  0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F,
  0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x81, 0xFF, 0x1F, 0xE0, 0x3F,
  0xE3, 0xFC, 0x07, 0xF8, 0x7F, 0x81, 0xFF, 0x0F, 0xF0, 0x3F, 0xE1, 0xFE,
  0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x87, 0xFE, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFD, 0xFE, 0x03, 0xFF,
  0x7F, 0x80, 0x1F, 0xCF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x3E,
  0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x1F, 0x80,
  0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x03, 0xC1, 0xFE, 0x06, 0x01, 0xFE, 0x08, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0xFF, 0x03, 0xE0,
  0x7C, 0x07, 0xFF, 0x87, 0xC1, 0xF8, 0x1F, 0xFF, 0x0F, 0x83, 0xE0, 0x7F,
  0xFE, 0x1F, 0x0F, 0xC1, 0xFF, 0xFC, 0x3E, 0x1F, 0x07, 0xE1, 0xF0, 0x7C,
  0x7E, 0x1F, 0x83, 0xE0, 0xF8, 0xF8, 0x3E, 0x0F, 0xC3, 0xF1, 0xF0, 0xFC,
  0x1F, 0x87, 0xC7, 0xE1, 0xF8, 0x3E, 0x0F, 0x8F, 0x83, 0xE0, 0x7C, 0x1F,
  0x1F, 0x0F, 0xC1, 0xF8, 0x3E, 0x3E, 0x1F, 0x83, 0xF0, 0x7C, 0xFC, 0x3E,
  0x07, 0xC1, 0xF1, 0xF0, 0x7C, 0x0F, 0x83, 0xE3, 0xE1, 0xF8, 0x3F, 0x07,
  0xC7, 0xC3, 0xF0, 0x7E, 0x1F, 0x0F, 0x87, 0xE0, 0xF8, 0x3E, 0x1F, 0x0F,
  0xC3, 0xF0, 0x78, 0x7E, 0x1F, 0x87, 0xE1, 0xF0, 0xFC, 0x3F, 0x1F, 0xC7,
  0xC1, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xF0, 0x7F, 0xEF, 0xFE, 0x07, 0xE0,
  0xFF, 0x9F, 0xF8, 0x0F, 0xC0, 0xFE, 0x1F, 0xE0, 0x0F, 0x80, 0xF8, 0x1F,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x06, 0x00, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80,
  0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87,
  0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFE, 0x0F, 0xE0,
  0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8,
  0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF1, 0xFF,
  0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0xFF, 0x80, 0x1F, 0xE7, 0xF8, 0x00,
  0xFF, 0x3F, 0xC0, 0x07, 0xFB, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0xFF, 0xC0, 0x3F, 0x81, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0,
  0xFF, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x81, 0xFC, 0x03, 0xFC,
  0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03,
  0xFC, 0x07, 0xFC, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x81, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0xFC, 0x03, 0xFF, 0x80, 0xC0, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x80, 0x3F, 0xF0, 0x38, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0x87, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x03,
  0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xE0,
  0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x07,
  0xFC, 0x1F, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F,
  0xC1, 0xFE, 0x00, 0xFF, 0x83, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xFC,
  0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0xC0,
  0xFF, 0x03, 0xFF, 0x01, 0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF1, 0xFC, 0x01, 0xFF, 0x80, 0x38, 0x03,
  0xFF, 0x00, 0x08, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xF8, 0x7F,
  0xC0, 0xFF, 0xF8, 0x7F, 0xC0, 0xFF, 0xF8, 0x7F, 0xC0, 0xFF, 0xF8, 0x7F,
  0x81, 0xFF, 0xF0, 0x7F, 0x81, 0xFF, 0xF0, 0xFF, 0x81, 0xFF, 0xF0, 0xFF,
  0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF,
  0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x7F,
  0xC0, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x02, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x03,
  0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xFC, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFC, 0x7F, 0xC0,
  0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF7, 0xFC,
  0x00, 0x03, 0xF9, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00,
  0x7F, 0xCF, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8,
  0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x3F, 0x7F, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFB, 0xF0, 0x1F,
  0xBF, 0xC0, 0x3F, 0xDF, 0x81, 0xFD, 0xFC, 0x01, 0xFE, 0xFC, 0x0F, 0xEF,
  0xE0, 0x0F, 0xE7, 0xE0, 0xFE, 0xFF, 0x00, 0x7F, 0x3F, 0x07, 0xF7, 0xF8,
  0x03, 0xF9, 0xF8, 0x3F, 0x3F, 0xC0, 0x3F, 0xCF, 0xC3, 0xF9, 0xFC, 0x01,
  0xFE, 0x7E, 0x1F, 0x9F, 0xE0, 0x0F, 0xE3, 0xF1, 0xFC, 0xFF, 0x00, 0x7F,
  0x1F, 0x8F, 0xC7, 0xF8, 0x03, 0xF8, 0xFC, 0xFE, 0x3F, 0x80, 0x3F, 0xC7,
  0xE7, 0xF1, 0xFC, 0x01, 0xFC, 0x3F, 0x7F, 0x1F, 0xE0, 0x0F, 0xE1, 0xFB,
  0xF8, 0xFF, 0x00, 0x7F, 0x0F, 0xFF, 0x87, 0xF8, 0x03, 0xF8, 0x7F, 0xFC,
  0x3F, 0x80, 0x3F, 0xC3, 0xFF, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0xFE, 0x1F,
  0xE0, 0x0F, 0xE0, 0xFF, 0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xFF, 0x07, 0xF8,
  0x07, 0xF8, 0x3F, 0xF0, 0x3F, 0x80, 0x3F, 0xC1, 0xFF, 0x81, 0xFC, 0x01,
  0xFC, 0x0F, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0x7F,
  0x03, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x01, 0xFC,
  0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xFC, 0x01, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xFC, 0x07,
  0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0x80, 0x1F, 0xFF, 0x01, 0xFC, 0x01, 0xFD,
  0xF8, 0x1F, 0xE0, 0x0F, 0xEF, 0xE0, 0xFF, 0x00, 0x7F, 0x7F, 0x07, 0xF0,
  0x03, 0xFB, 0xF8, 0x3F, 0x80, 0x3F, 0xDF, 0xC1, 0xFC, 0x01, 0xFC, 0xFE,
  0x1F, 0xE0, 0x0F, 0xE3, 0xF0, 0xFF, 0x00, 0x7F, 0x1F, 0xC7, 0xF0, 0x03,
  0xF8, 0xFE, 0x3F, 0x80, 0x3F, 0xC7, 0xF1, 0xFC, 0x01, 0xFE, 0x3F, 0x9F,
  0xE0, 0x0F, 0xE1, 0xFC, 0xFF, 0x00, 0x7F, 0x07, 0xE7, 0xF0, 0x03, 0xF8,
  0x3F, 0xBF, 0x80, 0x3F, 0xC1, 0xFD, 0xFC, 0x01, 0xFC, 0x0F, 0xEF, 0xE0,
  0x0F, 0xE0, 0x7F, 0xFE, 0x00, 0x7F, 0x03, 0xFF, 0xF0, 0x03, 0xF8, 0x0F,
  0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xFC, 0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x0F,
  0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0xF0, 0x07, 0xF8, 0x07, 0xFF,
  0x80, 0x3F, 0xC0, 0x1F, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0x80,
  0x3F, 0x80, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07,
  0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0x1F,
  0xE1, 0xFF, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0xFF,
  0x1F, 0xE0, 0x01, 0xFE, 0x7F, 0xC0, 0x03, 0xFC, 0xFF, 0x80, 0x0F, 0xF9,
  0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xDF,
  0xF0, 0x00, 0xFF, 0xBF, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x07, 0xFC, 0xFF,
  0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xCF, 0xF8,
  0x00, 0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xFC, 0x7F, 0xC0,
  0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0x83, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC,
  0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03,
  0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xC0, 0xFF, 0xC0, 0x7F, 0x83, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0xFF,
  0x80, 0x1F, 0xE1, 0xFF, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x7F, 0x8F, 0xF8,
  0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x7F, 0xC0, 0x03, 0xFC, 0xFF, 0x80,
  0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x7F, 0xDF, 0xF0, 0x00, 0xFF, 0xBF, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x07,
  0xFC, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x3F,
  0xCF, 0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xFC,
  0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x0F,
  0xF8, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03,
  0xFC, 0xFF, 0xE0, 0x1F, 0xC1, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0,
  0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F,
  0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x03,
  0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x0F, 0xF1,
  0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC,
  0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x03, 0xFC, 0x07,
  0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x0F, 0xF0,
  0x1F, 0xE0, 0x7F, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F,
  0xE1, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0x81, 0xE0, 0x0F, 0xF8, 0x02, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0xC0, 0x03, 0xFC, 0x07, 0x00, 0x3F, 0xE0, 0x3F, 0x07, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFC,
  0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC,
  0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF8,
  0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xF8,
  0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0,
  0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0,
  0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0x80,
  0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x80,
  0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xFE,
  0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0x8F, 0xE0,
  0x07, 0xF8, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x01, 0xFF,
  0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE,
  0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F,
  0x80, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x1F, 0xE0, 0x0F,
  0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE3, 0xFC, 0x00, 0xFE, 0x3F,
  0x80, 0x0F, 0xE7, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xE7, 0xF0, 0x00,
  0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x07, 0xF9, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF0, 0x03,
  0xFC, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF1, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x0F,
  0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0xC0, 0x3F, 0x83, 0xFC,
  0x07, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xF0, 0x1F, 0xE0, 0xFF, 0x03,
  0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF,
  0xE0, 0x7F, 0x01, 0xFE, 0x0F, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0xF8,
  0x3F, 0xC0, 0x7F, 0x07, 0xEF, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x7E, 0x1F,
  0xE0, 0x1F, 0xC3, 0xFB, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xBF, 0x8F, 0xF0,
  0x07, 0xF0, 0xFD, 0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xEF, 0xE3, 0xF8, 0x01,
  0xFC, 0x7E, 0x7F, 0x3F, 0xC0, 0x0F, 0xE7, 0xF3, 0xF9, 0xFE, 0x00, 0x7F,
  0x3F, 0x9F, 0xDF, 0xE0, 0x03, 0xF9, 0xF8, 0xFC, 0xFF, 0x00, 0x1F, 0xDF,
  0xC7, 0xE7, 0xF0, 0x00, 0xFE, 0xFC, 0x3F, 0x7F, 0x80, 0x07, 0xF7, 0xE1,
  0xFB, 0xFC, 0x00, 0x3F, 0xFF, 0x0F, 0xDF, 0xC0, 0x01, 0xFF, 0xF0, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x01, 0xFE, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xE3, 0xF8,
  0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF,
  0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC1, 0xFC, 0x0F, 0xF0,
  0x7F, 0x07, 0xF8, 0x1F, 0xC1, 0xFE, 0x07, 0xF0, 0xFF, 0x01, 0xFE, 0x3F,
  0x80, 0x7F, 0x9F, 0xE0, 0x1F, 0xE7, 0xF0, 0x07, 0xFB, 0xFC, 0x00, 0xFE,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xE7, 0xF0, 0x01,
  0xFC, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F,
  0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xC1, 0xFC,
  0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0x7E,
  0x7F, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFC, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x8F, 0xF1, 0xFF, 0x1F, 0xE3,
  0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x0F,
  0xFC, 0x7F, 0x01, 0xFF, 0xEF, 0xF0, 0x3F, 0xFE, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFE, 0xFF, 0xE0, 0xFF, 0x87, 0xFE, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC3, 0xFE, 0x03,
  0xFC, 0x3F, 0xC0, 0x7F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0x87,
  0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF0, 0x7F, 0x80,
  0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0,
  0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0,
  0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xBF, 0x80, 0x3F,
  0xF3, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x01,
  0xFE, 0x7F, 0xC0, 0x1F, 0xEF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xF9, 0xFF, 0x03, 0xFE, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF8,
  0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF,
  0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE,
  0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x3F,
  0xC1, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F,
  0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xF1, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xF7, 0xFF, 0xC0, 0x7F, 0x7F, 0xF8, 0x07,
  0xE3, 0xFF, 0x00, 0x7E, 0x1F, 0xE0, 0x08, 0x00, 0x60, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0x78, 0x0F, 0xF8, 0x08, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x40, 0xFF, 0x80, 0xC0, 0x7F, 0xC7, 0xC0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF1,
  0xFE, 0x00, 0x3F, 0xF3, 0xFC, 0x00, 0xFF, 0xF7, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xE7, 0xFF,
  0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00,
  0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0x7F, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8,
  0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0,
  0xFF, 0x80, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xDF,
  0x80, 0x07, 0xFF, 0x3F, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xE1, 0xFC, 0x1F,
  0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x8F, 0xF0, 0x1F, 0x87, 0xF0, 0x1F, 0xC7,
  0xF8, 0x0F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFC, 0x1F, 0xF1, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x04, 0x0F, 0xF0, 0x0E, 0x07, 0xFF, 0x7F, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xE6, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x21, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xF1, 0xFC,
  0x00, 0xFF, 0xF7, 0xF8, 0x01, 0xFF, 0xEF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x01,
  0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0xC3, 0xFF,
  0x00, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xBF, 0x80, 0x07, 0xFE, 0xFF, 0x00,
  0x07, 0xF9, 0xFE, 0x00, 0x01, 0x83, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0xC0, 0x07, 0xFC, 0x01, 0xF0, 0x1F, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xE3, 0xF8, 0x01, 0xFE, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFD,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F,
  0xC0, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFC, 0x0F,
  0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03,
  0xFC, 0x1F, 0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0,
  0x7F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x02, 0x1F, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x1F,
  0xE0, 0x1F, 0xC1, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00,
  0x7F, 0x8F, 0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0xFE,
  0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFB, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xF8, 0x7F,
  0x80, 0x1F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00,
  0x7F, 0x03, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0xFF, 0x01, 0xFE,
  0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0xFF, 0x03, 0xF8, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x00,
  0x01, 0xF8, 0xFF, 0x03, 0xFC, 0x03, 0xF9, 0xFF, 0x87, 0xFE, 0x03, 0xFB,
  0xFF, 0xCF, 0xFE, 0x03, 0xF7, 0xFF, 0xDF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x7F, 0xF9, 0xFF, 0x07,
  0xFC, 0x3F, 0xF0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F,
  0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x1F, 0xE0, 0x3F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x7F, 0x81,
  0xFE, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0xFF,
  0x03, 0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8,
  0x1F, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x3E, 0x1F, 0xF0, 0x0F, 0xCF, 0xFF,
  0x01, 0xF9, 0xFF, 0xE0, 0x3F, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xFC,
  0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x1F, 0xE0,
  0x7F, 0x83, 0xF8, 0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0x83,
  0xFC, 0x07, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07,
  0xF8, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF8, 0x3F,
  0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0x7F,
  0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8,
  0x0F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xF8,
  0x7F, 0x8F, 0xF8, 0x3F, 0xC7, 0xF8, 0x0F, 0xE3, 0xFC, 0x07, 0xF3, 0xFC,
  0x03, 0xF9, 0xFE, 0x01, 0xFC, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0x7F,
  0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x07, 0xF7, 0xF8, 0x07, 0xFB, 0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xFE,
  0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x3F, 0xC0, 0xFF, 0x8F, 0xF0, 0xFF,
  0x87, 0xFD, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7F, 0x1F, 0xF0, 0x00, 0xFE,
  0x7F, 0xF0, 0x01, 0xFD, 0xFF, 0xE0, 0x03, 0xF7, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F,
  0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F,
  0xF1, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFB, 0xFF, 0x80, 0x0F, 0xF7, 0xFE, 0x00, 0x1F, 0xC7,
  0xF8, 0x00, 0x7F, 0x83, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC7, 0xF0, 0x07, 0xFE, 0x7F, 0x00, 0xFF, 0xE7, 0xF0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFC, 0xFF,
  0xE0, 0xFF, 0x87, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x1F,
  0xE0, 0x3F, 0xC1, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0x83, 0xFC, 0x07,
  0xF8, 0x3F, 0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x87,
  0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0xFF, 0x00,
  0xFF, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0,
  0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xFC,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xBF, 0x80, 0x3F, 0xF3, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x07,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x7E, 0x07, 0xF3, 0xFC, 0x0F, 0xE7,
  0xF0, 0x1F, 0xDF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0x08, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83,
  0xFE, 0x1E, 0x07, 0xF8, 0x0C, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0x00, 0x3F, 0xC3, 0x00, 0xFF, 0x87,
  0xC7, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x0F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF9,
  0xFF, 0xFE, 0x7F, 0xFF, 0x83, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF0, 0x01, 0x80, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xF0,
  0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xFC, 0x07, 0xF0, 0x7F, 0x81,
  0xFE, 0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x0F,
  0xF0, 0x1F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0x80, 0xFF, 0x07, 0xF0, 0x1F,
  0xC1, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF0, 0x1F, 0xE0, 0xFE,
  0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0xFF, 0x03, 0xFC,
  0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0,
  0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0xC7, 0xFE, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x7E, 0x03, 0xFF, 0xDF, 0xC0, 0x3F, 0xF3,
  0xF8, 0x03, 0xFC, 0x7E, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x03, 0xFC,
  0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF0,
  0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xC0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x80,
  0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x01, 0xFF, 0x01, 0xFD, 0xFC, 0x07, 0xFC, 0x0F,
  0xF7, 0xF0, 0x3F, 0xF0, 0x3F, 0x9F, 0xC0, 0xFF, 0xC0, 0xFE, 0x7F, 0x03,
  0xFF, 0x07, 0xF9, 0xFC, 0x1F, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0xE0, 0xFF,
  0x1F, 0xC3, 0xFF, 0x83, 0xF8, 0x7F, 0x0F, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F,
  0xF8, 0x7F, 0x87, 0xF1, 0xFF, 0xE1, 0xFC, 0x1F, 0xC7, 0xFF, 0x87, 0xF0,
  0x7F, 0x1F, 0xFE, 0x3F, 0x81, 0xFC, 0xFD, 0xF8, 0xFE, 0x07, 0xF3, 0xF7,
  0xE7, 0xF8, 0x1F, 0xDF, 0x9F, 0x9F, 0xC0, 0x7F, 0x7E, 0x7E, 0x7F, 0x01,
  0xF9, 0xF9, 0xFB, 0xF8, 0x07, 0xEF, 0xC7, 0xEF, 0xE0, 0x1F, 0xBF, 0x1F,
  0xBF, 0x00, 0x7E, 0xFC, 0x7F, 0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x0F,
  0xFF, 0x87, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F,
  0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x3F,
  0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x03,
  0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F,
  0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC7, 0xF8,
  0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x1F,
  0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F,
  0x00, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xF0, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F,
  0xC1, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03,
  0xF8, 0xFF, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x01, 0xFB, 0xF8, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x02, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x4F, 0xFE, 0x00,
  0x17, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x20,
  0x00, 0x7F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 18, 45, 16, 0, -44 },
  { 103, 22, 16, 24, 6, -44 },
  { 147, 31, 44, 30, 0, -44 },
  { 318, 28, 51, 26, 0, -47 },
  { 497, 39, 46, 44, 3, -45 },
  { 722, 32, 46, 32, 0, -45 },
  { 906, 11, 16, 15, 6, -44 },
  { 928, 21, 54, 17, 1, -44 },
  { 1070, 21, 55, 17, -5, -45 },
  { 1215, 23, 26, 25, 5, -48 },
  { 1290, 25, 30, 29, 3, -37 },
  { 1384, 13, 16, 15, -3, -8 },
  { 1410, 16, 7, 18, 1, -20 },
  { 1424, 10, 10, 15, 0, -9 },
  { 1437, 31, 45, 23, -3, -45 },
  { 1612, 26, 46, 26, 1, -45 },
  { 1762, 20, 44, 27, 6, -44 },
  { 1872, 29, 45, 26, -2, -45 },
  { 2036, 29, 46, 26, -1, -45 },
  { 2203, 28, 44, 27, -1, -44 },
  { 2357, 28, 45, 26, 0, -44 },
  { 2515, 28, 46, 26, 1, -45 },
  { 2676, 28, 44, 26, 2, -44 },
  { 2830, 28, 46, 26, 0, -45 },
  { 2991, 27, 46, 26, 0, -45 },
  { 3147, 15, 35, 15, 0, -34 },
  { 3213, 18, 42, 15, -3, -34 },
  { 3308, 26, 30, 29, 2, -37 },
  { 3406, 26, 18, 29, 2, -31 },
  { 3465, 25, 30, 29, 3, -37 },
  { 3559, 23, 46, 21, 1, -45 },
  { 3692, 39, 50, 40, 1, -45 },
  { 3936, 29, 44, 29, -4, -44 },
  { 4096, 30, 44, 29, 0, -44 },
  { 4261, 29, 46, 27, 2, -45 },
  { 4428, 31, 44, 32, 0, -44 },
  { 4599, 28, 44, 25, 0, -44 },
  { 4753, 28, 44, 24, 0, -44 },
  { 4907, 32, 46, 33, 2, -45 },
  { 5091, 35, 44, 33, 0, -44 },
  { 5284, 27, 44, 20, -3, -44 },
  { 5433, 28, 57, 15, -10, -44 },
  { 5633, 34, 44, 29, 0, -44 },
  { 5820, 20, 44, 24, 0, -44 },
  { 5930, 45, 44, 43, 0, -44 },
  { 6178, 37, 44, 35, 0, -44 },
  { 6382, 31, 46, 34, 2, -45 },
  { 6561, 31, 44, 29, 0, -44 },
  { 6732, 31, 56, 34, 2, -45 },
  { 6949, 29, 44, 29, 0, -44 },
  { 7109, 29, 46, 25, -1, -45 },
  { 7276, 25, 44, 25, 4, -44 },
  { 7414, 32, 45, 32, 2, -44 },
  { 7594, 28, 44, 29, 6, -44 },
  { 7748, 45, 44, 43, 4, -44 },
  { 7996, 36, 44, 27, -4, -44 },
  { 8194, 26, 44, 26, 6, -44 },
  { 8337, 30, 44, 24, -2, -44 },
  { 8502, 24, 54, 18, -2, -44 },
  { 8664, 13, 45, 23, 6, -45 },
  { 8738, 25, 54, 18, -5, -44 },
  { 8907, 27, 26, 27, 0, -44 },
  { 8995, 21, 4, 20, -6, 5 },
  { 9006, 11, 9, 18, 9, -47 },
  { 9019, 28, 35, 29, 1, -34 },
  { 9142, 28, 48, 28, -1, -47 },
  { 9310, 24, 35, 23, 1, -34 },
  { 9415, 31, 48, 29, 1, -47 },
  { 9601, 25, 35, 26, 1, -34 },
  { 9711, 31, 62, 17, -7, -47 },
  { 9952, 31, 49, 29, -2, -34 },
  { 10142, 28, 47, 28, -1, -47 },
  { 10307, 18, 47, 14, -1, -47 },
  { 10413, 25, 62, 14, -8, -47 },
  { 10607, 29, 47, 26, 0, -47 },
  { 10778, 18, 47, 14, -1, -47 },
  { 10884, 40, 34, 42, 0, -34 },
  { 11054, 27, 34, 28, 0, -34 },
  { 11169, 25, 36, 28, 1, -35 },
  { 11282, 31, 49, 28, -4, -34 },
  { 11472, 28, 49, 29, 1, -34 },
  { 11644, 23, 34, 20, 0, -34 },
  { 11742, 23, 35, 22, 0, -34 },
  { 11843, 18, 42, 18, 2, -41 },
  { 11938, 27, 35, 28, 1, -34 },
  { 12057, 24, 34, 25, 4, -34 },
  { 12159, 38, 34, 38, 3, -34 },
  { 12321, 31, 34, 25, -3, -34 },
  { 12453, 33, 49, 25, -5, -34 },
  { 12656, 25, 34, 21, -2, -34 },
  { 12763, 24, 54, 21, 1, -44 },
  { 12925, 6, 62, 23, 8, -48 },
  { 12972, 24, 54, 21, -4, -44 },
  { 13134, 26, 10, 29, 2, -27 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic62pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC62PT7B_H_
