#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC71PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x9F, 0xF0, 0xFF,
  0x8F, 0xF8, 0x7F, 0xC7, 0xFC, 0x3F, 0xE3, 0xFE, 0x1F, 0xE1, 0xFE, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0x87, 0xFC, 0x7F, 0x83, 0xFC, 0x3F, 0xC1,
  0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF0, 0x7F, 0x83, 0xF8,
  0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F,
  0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x38, 0xF8, 0x01, 0xFE, 0x38, 0x30,
  0x01, 0xFE, 0x38, 0x10, 0x01, 0xFE, 0x30, 0x00, 0x03, 0xFE, 0x70, 0x00,
  0x03, 0xFE, 0x70, 0x00, 0x03, 0xFF, 0x70, 0x00, 0x03, 0xFF, 0x70, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xBF, 0xF0, 0x00, 0x03, 0x3F, 0xF0,
  0x00, 0x07, 0x1F, 0xF0, 0x20, 0x07, 0x1F, 0xF0, 0x20, 0x07, 0x1F, 0xE0,
  0x30, 0x07, 0x3F, 0xE0, 0x7C, 0x06, 0x3F, 0xE0, 0x7F, 0x0E, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xFF,
  0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xC7, 0xF0,
  0x07, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0x87, 0xF0, 0x0F,
  0xC0, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x1F, 0x80,
  0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x3F, 0x00, 0x07,
  0xE0, 0x7F, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xE0,
  0x7E, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE,
  0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x3F,
  0x00, 0x00, 0xFC, 0x1F, 0xC7, 0xF0, 0x3F, 0x0F, 0xC1, 0xFC, 0x7E, 0x0F,
  0xFC, 0xFC, 0x3F, 0x8F, 0xE1, 0xFF, 0xCF, 0xC3, 0xF8, 0xFC, 0x3F, 0xFE,
  0xFC, 0x7F, 0x1F, 0xC7, 0xFF, 0xEF, 0xFF, 0xF3, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0x8F, 0xE7, 0xF7, 0xFF, 0xC7, 0xF1, 0xFC, 0x7F, 0x7F, 0xF8,
  0x7F, 0x1F, 0x83, 0xF3, 0xFF, 0x0F, 0xE3, 0xF8, 0x3F, 0x1F, 0xE0, 0xFE,
  0x3F, 0x03, 0xF0, 0x00, 0x1F, 0xC3, 0xF0, 0x7F, 0x00, 0x01, 0xF8, 0x7F,
  0x07, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x7F, 0x00, 0x03, 0xF0, 0x7E, 0x07,
  0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0xFE, 0x07, 0xE0,
  0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x01,
  0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x03, 0xF8,
  0x0F, 0xC1, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x0F,
  0xC3, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xFF,
  0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x80, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0xC1, 0xFE, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x7F,
  0xCF, 0xF0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFE, 0x07, 0xFF, 0xFE, 0x3F, 0xE0, 0xFF, 0xBF, 0xE3,
  0xFE, 0x1F, 0xF3, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xF7, 0xFC, 0x3F, 0xE1,
  0xFF, 0x7F, 0x87, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xC0, 0xFF, 0xFF, 0x07,
  0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xF8, 0x07, 0xFF,
  0xE0, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0x80,
  0x3F, 0xF8, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xF8, 0x0F,
  0xFC, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE7, 0xFE, 0x01, 0xFF, 0xFC, 0x3F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x80,
  0x0F, 0x00, 0x00, 0x00, 0x1F, 0xF3, 0xFF, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3,
  0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87,
  0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x02, 0x03, 0xFC, 0x00, 0xE0,
  0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0xEF, 0xE0, 0x67, 0xFF, 0xF9, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07,
  0xFE, 0x7F, 0x81, 0xFF, 0x9F, 0xE0, 0x3F, 0xC7, 0xFC, 0x07, 0xE0, 0xFF,
  0x80, 0xF0, 0x3F, 0x80, 0x1C, 0x07, 0xC0, 0x02, 0x01, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE,
  0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xDF, 0xFF,
  0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFE, 0x07, 0x83, 0xF8, 0xFF, 0xBF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xF1, 0xFC, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x1F,
  0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC,
  0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x1F,
  0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE3, 0xFF, 0x00, 0xFF, 0x8F, 0xF8,
  0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF8, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x01,
  0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xF1, 0xFF, 0x00, 0xFF,
  0xC7, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1,
  0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF,
  0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x7F,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x1F, 0xFB, 0xFE, 0x3F, 0xE7, 0xFC, 0x3F, 0x8F, 0xF0, 0x3E, 0x3F, 0xE0,
  0x78, 0x7F, 0xC0, 0x60, 0xFF, 0x80, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xC1, 0xFF, 0xC0, 0x07, 0xE0, 0x3F, 0xF0, 0x01, 0xF0, 0x0F,
  0xFC, 0x00, 0x70, 0x03, 0xFF, 0x00, 0x08, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0x03, 0xFF, 0x80, 0x0C, 0x01, 0xFF, 0xC0, 0x04, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x80, 0x00, 0x7F, 0xE0, 0x40, 0x00, 0x7F, 0xF0, 0x3C, 0x00, 0xFF, 0xF0,
  0x1F, 0xE3, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFB, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xF7, 0xF8, 0x00, 0x03, 0xF7, 0xF8, 0x00, 0x07, 0xEF, 0xF8, 0x00, 0x0F,
  0xCF, 0xF8, 0x00, 0x0F, 0xCF, 0xF8, 0x00, 0x1F, 0x8F, 0xF0, 0x00, 0x3F,
  0x8F, 0xF0, 0x00, 0x3F, 0x1F, 0xF0, 0x00, 0x7E, 0x1F, 0xF0, 0x00, 0xFE,
  0x1F, 0xE0, 0x00, 0xFC, 0x1F, 0xE0, 0x01, 0xF8, 0x3F, 0xE0, 0x03, 0xF8,
  0x3F, 0xE0, 0x03, 0xF0, 0x3F, 0xE0, 0x07, 0xE0, 0x3F, 0xC0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x0F, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x7F, 0xC0, 0x3F, 0x80,
  0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xE0, 0x01, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x80, 0x01, 0xFF, 0xC0, 0xC0, 0x03,
  0xFF, 0x80, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC3, 0xF0, 0x00, 0xFF, 0x9F, 0xF8, 0x01,
  0xFF, 0x7F, 0xF0, 0x07, 0xFD, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xE1, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x1F, 0xF8,
  0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0x80,
  0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03,
  0xFE, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x07, 0xFE,
  0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x03,
  0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x0F, 0xFC, 0x01,
  0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0xC0, 0x1F,
  0xF8, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F,
  0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF,
  0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF,
  0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0xC0, 0x7F, 0xC0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0x87, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00,
  0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x0F,
  0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF,
  0xC1, 0xFF, 0x01, 0xFF, 0x83, 0xFE, 0x07, 0xFF, 0x07, 0xFC, 0x0F, 0xFE,
  0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xF7, 0xFC, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0xFE, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x07, 0xC3, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFC, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x18, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xC7, 0xFF, 0x07, 0x80, 0xFF, 0x83,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x3F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xFF, 0x83,
  0xF0, 0x7F, 0x01, 0xFF, 0xFC, 0x3F, 0x07, 0xE0, 0x3F, 0xFF, 0x83, 0xF0,
  0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0x0F, 0xC0, 0xFF, 0x3F, 0x83, 0xF1, 0xFC,
  0x1F, 0xC1, 0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF1, 0xF8, 0x3F,
  0x03, 0xF0, 0x3E, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x07,
  0xF0, 0x7E, 0x3F, 0x07, 0xE0, 0x7F, 0x07, 0xE7, 0xE0, 0xFE, 0x07, 0xE0,
  0x7E, 0x7E, 0x0F, 0xC0, 0x7E, 0x07, 0xE7, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC,
  0x7E, 0x0F, 0xC0, 0xFE, 0x0F, 0xC7, 0xE1, 0xFC, 0x0F, 0xC0, 0xFC, 0xFC,
  0x1F, 0x80, 0xFC, 0x0F, 0x8F, 0xC1, 0xF8, 0x1F, 0xC1, 0xF8, 0xFC, 0x1F,
  0x81, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0x1F, 0x81, 0xF0, 0xFC, 0x1F, 0x83,
  0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x87, 0xF8,
  0x7E, 0x0F, 0xC1, 0xFF, 0xFF, 0xDF, 0xC0, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xC0, 0xFF, 0xE7, 0xFF, 0x00, 0xFC, 0x0F, 0xFC, 0x7F, 0xF0, 0x0F,
  0xC0, 0x7F, 0x83, 0xFC, 0x00, 0xFC, 0x01, 0xE0, 0x1F, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0x00,
  0x00, 0x1F, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F,
  0xDF, 0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFF, 0x1F, 0xE0, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00,
  0x3F, 0xC3, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0,
  0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xF8, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC7, 0xFE, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0x80,
  0x07, 0xFD, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xC1,
  0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC,
  0x03, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xF8,
  0x3F, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC,
  0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x3F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFE, 0x03, 0xFE, 0x07,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x3C, 0x00, 0x3F, 0xF8, 0x03, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x40, 0x07, 0xFF,
  0x80, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFC,
  0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF0,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x3F,
  0xF0, 0x3F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x07, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x07, 0xFE, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x1F,
  0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xF8, 0x03, 0xFE, 0x07,
  0xFF, 0x80, 0x3F, 0xE7, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x20, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0x80,
  0x1F, 0xFE, 0x00, 0x38, 0x03, 0xFF, 0xC0, 0x01, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x3F, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0xF8, 0x7F, 0xE0, 0x3F, 0xFF, 0x0F,
  0xFC, 0x07, 0xFF, 0xF0, 0xFF, 0xC0, 0x7F, 0xFF, 0x0F, 0xFC, 0x07, 0xFF,
  0xF0, 0xFF, 0xC0, 0x7F, 0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xC0,
  0xFF, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFE, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xF8, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x63, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0xFF,
  0x83, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x3F,
  0xC3, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x0F,
  0xF3, 0xFE, 0x00, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xBF, 0xE0, 0x00, 0x07, 0xFE, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xC0,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xF0,
  0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xEF, 0xF0, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xDF, 0xF0,
  0x03, 0xFE, 0xFE, 0x03, 0xFD, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x3F, 0xBF,
  0xE0, 0x03, 0xFC, 0xFE, 0x07, 0xFB, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x7F,
  0xBF, 0xE0, 0x07, 0xFC, 0xFE, 0x0F, 0xF3, 0xFE, 0x00, 0x7F, 0xCF, 0xE0,
  0xFF, 0x3F, 0xC0, 0x07, 0xF8, 0xFE, 0x0F, 0xE7, 0xFC, 0x00, 0x7F, 0x8F,
  0xE1, 0xFE, 0x7F, 0xC0, 0x07, 0xF8, 0xFE, 0x1F, 0xC7, 0xFC, 0x00, 0xFF,
  0x8F, 0xE3, 0xFC, 0x7F, 0x80, 0x0F, 0xF8, 0xFE, 0x3F, 0x87, 0xF8, 0x00,
  0xFF, 0x0F, 0xE7, 0xF8, 0xFF, 0x80, 0x0F, 0xF0, 0xFE, 0x7F, 0x0F, 0xF8,
  0x00, 0xFF, 0x0F, 0xEF, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFE, 0xFF, 0x0F,
  0xF0, 0x01, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0xFE,
  0x1F, 0xF0, 0x01, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF,
  0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xC0,
  0xFF, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0xFF, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0xFF, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xFE, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xF8, 0x0F, 0xFC, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xF8, 0x0F, 0xF8,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0xF8, 0x07,
  0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0x80,
  0x0F, 0xFF, 0xE0, 0x1F, 0xE0, 0x07, 0xFF, 0xF8, 0x0F, 0xF8, 0x01, 0xFE,
  0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0xFF, 0x00, 0x1F, 0xEF, 0xF0,
  0x3F, 0xC0, 0x07, 0xFB, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0xFF, 0x07, 0xFC,
  0x00, 0xFF, 0x3F, 0xC1, 0xFF, 0x00, 0x3F, 0xC7, 0xF0, 0x7F, 0x80, 0x0F,
  0xF1, 0xFE, 0x1F, 0xE0, 0x07, 0xFC, 0x7F, 0x87, 0xF8, 0x01, 0xFF, 0x1F,
  0xE3, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0xFF, 0x80, 0x1F, 0xE1, 0xFE, 0x3F,
  0xC0, 0x07, 0xF8, 0x3F, 0x8F, 0xF0, 0x03, 0xFE, 0x0F, 0xF3, 0xFC, 0x00,
  0xFF, 0x83, 0xFD, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x7F, 0xC0, 0x0F, 0xF0,
  0x3F, 0xDF, 0xE0, 0x03, 0xFC, 0x0F, 0xF7, 0xF8, 0x01, 0xFF, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0x80, 0x1F, 0xE0, 0x1F, 0xFF, 0xC0,
  0x07, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xF0, 0x03,
  0xFF, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFF, 0xE0, 0x07,
  0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x1F,
  0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x3F,
  0xF3, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xF3, 0xFF, 0x00,
  0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x07, 0xFE, 0x7F,
  0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0xC7, 0xFE, 0x00,
  0x0F, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF8, 0xFF,
  0xC0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF,
  0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xC7, 0xFF, 0xE0,
  0x0F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xE0,
  0x0F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xE0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x1F, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03,
  0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF8,
  0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xF3,
  0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x07,
  0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0xC7,
  0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x1F,
  0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x03, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xC0, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xC3, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x03,
  0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x07, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xE0,
  0xFF, 0xE0, 0x0F, 0xF8, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xE0,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x07, 0xFC, 0x3F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE,
  0x07, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFD, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0x00, 0x1F, 0xFC, 0x00, 0xC0,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x01, 0x00,
  0x01, 0xFF, 0x80, 0x60, 0x00, 0xFF, 0xC0, 0x1E, 0x00, 0x7F, 0xF0, 0x07,
  0xF0, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF8,
  0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xE0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFC, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xDF, 0xF0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x3F,
  0xF3, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x0F,
  0xFC, 0x3F, 0xC0, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xFE, 0x0F, 0xF0, 0x03,
  0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x07, 0xF8,
  0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xF8, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0xFF,
  0x07, 0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x1F,
  0xE1, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x03,
  0xFC, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0x3F, 0xE0, 0x00,
  0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x01, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xC1, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xFC, 0x01, 0xFE, 0x07,
  0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xF8,
  0x1F, 0xE0, 0x1F, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xC0, 0x7F, 0x80, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0x03,
  0xFE, 0x01, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0xFC,
  0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x07, 0xF7,
  0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0xFE, 0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x3F,
  0xDF, 0xC3, 0xFE, 0x00, 0x7F, 0x87, 0xF3, 0xF8, 0x7F, 0x80, 0x0F, 0xF1,
  0xFE, 0x7F, 0x1F, 0xF0, 0x01, 0xFE, 0x3F, 0x8F, 0xE3, 0xFE, 0x00, 0x3F,
  0xC7, 0xF1, 0xFC, 0xFF, 0x80, 0x07, 0xF9, 0xFE, 0x3F, 0x9F, 0xF0, 0x01,
  0xFF, 0x3F, 0x87, 0xF3, 0xFC, 0x00, 0x3F, 0xEF, 0xF0, 0xFE, 0xFF, 0x80,
  0x07, 0xFD, 0xFC, 0x1F, 0xDF, 0xF0, 0x00, 0xFF, 0xBF, 0x87, 0xFB, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x03, 0xFD, 0xFC, 0x1F, 0xDF,
  0xF0, 0x00, 0x7F, 0xBF, 0x83, 0xFB, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x81,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x03, 0xFC,
  0xFF, 0x80, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x03, 0xFD, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0x7F, 0xDF,
  0xF0, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00,
  0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0xFF, 0xC7, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFE, 0x1F,
  0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x03, 0xFE,
  0x1F, 0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF3,
  0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x7F, 0xBF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x0F, 0xE0,
  0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80,
  0x3F, 0xC0, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x07,
  0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0xFF,
  0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x1F, 0xDF, 0xE0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE3,
  0xFF, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0x07,
  0xF8, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0xF8, 0xFF,
  0x00, 0x7F, 0xF8, 0xFF, 0x00, 0xFF, 0xFD, 0xFF, 0x01, 0xFF, 0xFD, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xBF, 0xFE,
  0x07, 0xFE, 0x1F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC,
  0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8,
  0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF0,
  0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xE0,
  0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x7F, 0x80,
  0x3F, 0xFE, 0x7F, 0x80, 0x3F, 0xFE, 0x7F, 0x80, 0x1F, 0xFC, 0x7F, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x87, 0xF0,
  0x00, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xBF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xE7, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x81, 0xFF,
  0x03, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF,
  0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF,
  0x07, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFF,
  0x07, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE,
  0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xFC,
  0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF0,
  0x3F, 0xFC, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xBF, 0xFF, 0x80, 0x7F, 0xBF, 0xFF, 0x00,
  0x7F, 0x1F, 0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFC, 0x78, 0x07, 0xFF, 0x03, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x20, 0x1F, 0xF8, 0x0C, 0x03, 0xFF, 0x8F, 0x80,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x8F,
  0xF8, 0x00, 0x3F, 0xF9, 0xFF, 0x00, 0x0F, 0xFF, 0xBF, 0xE0, 0x03, 0xFF,
  0xF7, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xCF, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xE0,
  0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x3F, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x3F, 0xC0, 0x01, 0xFF, 0xC7, 0xF0, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xBF, 0xF0, 0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x0F, 0xF0,
  0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x1F, 0xF0,
  0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE, 0x0F, 0xFC,
  0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x02, 0x07, 0xFC, 0x00, 0xE0, 0x7F, 0xF0, 0x7E, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x87, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0xFF, 0xE3, 0xFC, 0x00, 0x3F, 0xFE, 0x7F, 0x80, 0x0F, 0xFF,
  0xDF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xBF, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xC0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xFE, 0x00,
  0xFF, 0xE7, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFD,
  0xFF, 0x00, 0x07, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x03,
  0x81, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x30, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x1F,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xBF,
  0xFC, 0x00, 0xFF, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC3,
  0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x01,
  0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xF8, 0x07,
  0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F,
  0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0x7F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x02, 0x1F, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x81, 0xFF, 0x80, 0x0F, 0xF0, 0x3F,
  0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0,
  0xFF, 0xC0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x0F,
  0xF9, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xCF, 0xF8, 0x00,
  0x07, 0xFB, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xF8, 0x00,
  0x1F, 0xF9, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x7F, 0xF0, 0x7F, 0xF0,
  0x03, 0xF9, 0xFF, 0xF1, 0xFF, 0xF0, 0x07, 0xF7, 0xFF, 0xF7, 0xFF, 0xE0,
  0x0F, 0xEF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF3, 0xFF, 0xF3, 0xFF, 0x01,
  0xFF, 0x83, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x07,
  0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x81, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x3F,
  0xE0, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x7F, 0xE0, 0x07, 0xF1,
  0xFF, 0xE0, 0x0F, 0xE7, 0xFF, 0xE0, 0x1F, 0xDF, 0xFF, 0xC0, 0x3F, 0xBF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x87,
  0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F,
  0xF0, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFF,
  0x03, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0x83,
  0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F,
  0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF,
  0x00, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x1F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00,
  0xFF, 0x81, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07,
  0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x7F, 0xC3, 0xFF,
  0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF1, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x07,
  0xFC, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xF9,
  0xFF, 0x00, 0x7F, 0xDF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xF7, 0xFC,
  0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x03,
  0xFE, 0x7F, 0xC0, 0x1F, 0xF3, 0xFC, 0x01, 0xFF, 0xBF, 0xE0, 0x0F, 0xF9,
  0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x07, 0xFE, 0x3F, 0xC0, 0x3F, 0xE1, 0xFF,
  0x03, 0xFF, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF7, 0xFF, 0x83, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0xF0,
  0x00, 0x7F, 0x1F, 0xFE, 0x00, 0x0F, 0xE7, 0xFF, 0xE0, 0x01, 0xFD, 0xFF,
  0xFC, 0x00, 0x3F, 0xBF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xE3, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xFE, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xF0, 0x07, 0xFE,
  0x07, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xFC, 0x7F, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFD, 0xFF, 0xF8, 0x00, 0xFF, 0xBF, 0xFE, 0x00, 0x1F, 0xF3, 0xFF,
  0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x81, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x1F, 0xF8, 0xFF, 0x00, 0x7F, 0xFC, 0xFF, 0x00, 0xFF, 0xFE, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0x3F, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0x0F, 0xFC,
  0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC,
  0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8,
  0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0,
  0x7F, 0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0xC0, 0x1F, 0xE0,
  0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xC0,
  0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xE3, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0xFF, 0x80,
  0x1F, 0xFC, 0xFF, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x03, 0x81, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03,
  0xFC, 0xFF, 0x80, 0x7F, 0xBF, 0xE0, 0x0F, 0xF7, 0xFC, 0x01, 0xFD, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFE, 0x10, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0xF8, 0x0F, 0xFC, 0x03, 0x01, 0xFF,
  0x00, 0x40, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC1, 0x00, 0x1F, 0xF8, 0x30, 0x07, 0xFF,
  0x07, 0xE3, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC8, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x40, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xF0,
  0x00, 0x03, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x0F,
  0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0x00, 0xFF,
  0x03, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8,
  0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0x81,
  0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x1F,
  0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF,
  0x00, 0xFF, 0x81, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF8,
  0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80,
  0x7F, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF,
  0xC0, 0x7F, 0xC3, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFB, 0xF8, 0x07, 0xFF, 0xF7, 0xF0, 0x07, 0xFF, 0xCF, 0xE0,
  0x07, 0xFF, 0x1F, 0xC0, 0x07, 0xFC, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xEF, 0xF8,
  0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0x7F,
  0x8F, 0xF8, 0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0x83, 0xFE, 0x07, 0xF8, 0x3F,
  0xC0, 0x7F, 0x87, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x8F, 0xF8, 0x07,
  0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x9F,
  0xE0, 0x07, 0xFB, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x07, 0xFB, 0xFC, 0x00,
  0x7F, 0x7F, 0x80, 0x07, 0xF7, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x1F, 0xEF, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0x7F, 0xC0, 0x7F,
  0xE0, 0x3F, 0xEF, 0xF8, 0x1F, 0xFC, 0x07, 0xFD, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0x3F, 0xE0, 0x7F, 0xF0, 0x3F, 0xE7, 0xFC, 0x1F, 0xFE, 0x07, 0xF8,
  0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0x1F, 0xF0, 0xFF, 0xF8, 0x3F, 0xE3, 0xFC,
  0x1F, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFF, 0xE1, 0xFF, 0x0F, 0xF0, 0xFF,
  0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xFF, 0x87, 0xF8, 0x3F, 0xC7, 0xF7, 0xF1,
  0xFF, 0x07, 0xF8, 0xFE, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xDF, 0xC7, 0xF8,
  0x1F, 0xE7, 0xF3, 0xF9, 0xFE, 0x03, 0xFC, 0xFE, 0x7F, 0x3F, 0xC0, 0x7F,
  0x9F, 0xCF, 0xEF, 0xF8, 0x0F, 0xF7, 0xF1, 0xFD, 0xFE, 0x01, 0xFE, 0xFE,
  0x3F, 0xBF, 0xC0, 0x3F, 0xDF, 0x87, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0xFD,
  0xFE, 0x00, 0xFF, 0xFE, 0x1F, 0xBF, 0xC0, 0x1F, 0xFF, 0x87, 0xF7, 0xF0,
  0x03, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0x83, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x3F, 0xFC,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x3F,
  0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x87,
  0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x3F,
  0xC7, 0xFC, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x7F,
  0xC0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x01, 0xFF,
  0x1F, 0xE0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x03,
  0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x3F,
  0xE0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x80,
  0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x09, 0xFF, 0xE0, 0x00, 0x5F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xA0, 0x00, 0x7F, 0xF1, 0x00, 0x00, 0x3C, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 21, 52, 18, 0, -51 },
  { 138, 25, 19, 28, 7, -51 },
  { 198, 36, 51, 34, 0, -51 },
  { 428, 32, 58, 30, 0, -54 },
  { 660, 44, 52, 50, 4, -51 },
  { 946, 36, 52, 37, 0, -51 },
  { 1180, 12, 19, 17, 7, -51 },
  { 1209, 24, 62, 19, 1, -51 },
  { 1395, 24, 63, 19, -6, -52 },
  { 1584, 26, 30, 29, 6, -55 },
  { 1682, 29, 34, 33, 3, -42 },
  { 1806, 16, 19, 17, -4, -9 },
  { 1844, 18, 8, 20, 1, -23 },
  { 1862, 11, 12, 17, 0, -11 },
  { 1879, 37, 52, 26, -4, -51 },
  { 2120, 30, 52, 30, 1, -51 },
  { 2315, 23, 51, 31, 7, -51 },
  { 2462, 34, 51, 30, -3, -51 },
  { 2679, 33, 52, 30, -1, -51 },
  { 2894, 32, 51, 31, -1, -51 },
  { 3098, 32, 52, 30, 0, -51 },
  { 3306, 31, 52, 30, 2, -51 },
  { 3508, 33, 51, 30, 2, -51 },
  { 3719, 32, 52, 30, 0, -51 },
  { 3927, 31, 52, 30, 0, -51 },
  { 4129, 17, 40, 17, 0, -39 },
  { 4214, 21, 49, 17, -4, -39 },
  { 4343, 29, 33, 33, 3, -42 },
  { 4463, 29, 22, 33, 3, -36 },
  { 4543, 29, 33, 33, 3, -42 },
  { 4663, 25, 52, 24, 2, -51 },
  { 4826, 44, 57, 46, 2, -51 },
  { 5140, 33, 51, 33, -4, -51 },
  { 5351, 34, 51, 34, 0, -51 },
  { 5568, 34, 52, 31, 2, -51 },
  { 5789, 36, 51, 36, 0, -51 },
  { 6019, 32, 51, 28, 0, -51 },
  { 6223, 32, 51, 27, 0, -51 },
  { 6427, 36, 52, 37, 3, -51 },
  { 6661, 40, 51, 38, 0, -51 },
  { 6916, 31, 51, 23, -3, -51 },
  { 7114, 31, 66, 18, -11, -51 },
  { 7370, 39, 51, 33, 0, -51 },
  { 7619, 23, 51, 27, 0, -51 },
  { 7766, 52, 51, 49, 0, -51 },
  { 8098, 42, 51, 40, 0, -51 },
  { 8366, 36, 52, 39, 2, -51 },
  { 8600, 35, 51, 33, 0, -51 },
  { 8824, 36, 63, 39, 2, -51 },
  { 9108, 34, 51, 33, 0, -51 },
  { 9325, 34, 52, 29, -1, -51 },
  { 9546, 29, 51, 28, 5, -51 },
  { 9731, 37, 52, 37, 2, -51 },
  { 9972, 33, 51, 33, 6, -51 },
  { 10183, 51, 51, 50, 5, -51 },
  { 10509, 40, 51, 31, -4, -51 },
  { 10764, 31, 51, 30, 6, -51 },
  { 10962, 35, 51, 28, -3, -51 },
  { 11186, 28, 62, 20, -3, -51 },
  { 11403, 15, 52, 27, 7, -51 },
  { 11501, 28, 62, 20, -5, -51 },
  { 11718, 31, 31, 31, 0, -51 },
  { 11839, 24, 5, 23, -7, 6 },
  { 11854, 13, 11, 21, 10, -54 },
  { 11872, 32, 40, 33, 1, -39 },
  { 12032, 32, 55, 33, -1, -54 },
  { 12252, 27, 40, 26, 1, -39 },
  { 12387, 35, 55, 33, 1, -54 },
  { 12628, 28, 40, 30, 1, -39 },
  { 12768, 36, 71, 20, -8, -54 },
  { 13088, 35, 56, 33, -2, -39 },
  { 13333, 32, 54, 33, -1, -54 },
  { 13549, 21, 54, 16, -1, -54 },
  { 13691, 29, 71, 16, -9, -54 },
  { 13949, 35, 54, 30, -1, -54 },
  { 14186, 21, 54, 16, -1, -54 },
  { 14328, 47, 39, 48, -1, -39 },
  { 14558, 31, 39, 33, 0, -39 },
  { 14710, 29, 41, 32, 1, -40 },
  { 14859, 35, 56, 33, -4, -39 },
  { 15104, 32, 56, 33, 1, -39 },
  { 15328, 27, 39, 23, -1, -39 },
  { 15460, 27, 40, 25, 0, -39 },
  { 15595, 21, 48, 21, 2, -47 },
  { 15721, 31, 40, 32, 2, -39 },
  { 15876, 28, 39, 28, 4, -39 },
  { 16013, 43, 39, 44, 4, -39 },
  { 16223, 35, 39, 29, -3, -39 },
  { 16394, 37, 56, 29, -5, -39 },
  { 16653, 29, 39, 24, -3, -39 },
  { 16795, 28, 62, 24, 1, -51 },
  { 17012, 8, 71, 26, 9, -55 },
  { 17083, 27, 62, 24, -4, -51 },
  { 17293, 29, 12, 33, 3, -31 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic71pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC71PT7B_H_
