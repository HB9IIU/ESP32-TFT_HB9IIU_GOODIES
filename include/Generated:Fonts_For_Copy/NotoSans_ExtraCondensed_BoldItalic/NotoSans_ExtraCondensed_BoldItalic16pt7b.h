#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC16PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x66, 0x31, 0x80, 0x06, 0x30, 0xDE, 0xE5, 0x60, 0x1B,
  0x1A, 0x12, 0x7F, 0x34, 0x24, 0xFE, 0xFE, 0x48, 0x58, 0xD0, 0x08, 0x3C,
  0xF9, 0x57, 0x07, 0x07, 0x0E, 0x9D, 0xBB, 0xE1, 0x02, 0x00, 0x20, 0x9C,
  0x4D, 0x33, 0x48, 0x96, 0x2F, 0x6E, 0xBD, 0x6B, 0x16, 0xCD, 0xA2, 0x79,
  0x8C, 0x08, 0x1E, 0x36, 0x36, 0x3C, 0x38, 0x7B, 0x7B, 0xCE, 0xCE, 0xFE,
  0x76, 0xFE, 0x1C, 0xC3, 0x18, 0x61, 0x84, 0x30, 0xC3, 0x0C, 0x30, 0x41,
  0x80, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x19, 0x8C, 0x46, 0x63, 0x00, 0x19,
  0x4F, 0xCC, 0x79, 0x20, 0x30, 0xCF, 0xFF, 0x30, 0xC3, 0x00, 0x76, 0x6C,
  0xFF, 0xF8, 0x03, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x20,
  0x60, 0xC0, 0x08, 0x3C, 0xDB, 0x36, 0x6C, 0xD9, 0xE6, 0xCD, 0x9B, 0xE3,
  0x80, 0x3B, 0xBD, 0x63, 0x31, 0x8C, 0x63, 0x30, 0x04, 0x1F, 0x33, 0x03,
  0x03, 0x06, 0x0C, 0x1C, 0x38, 0x30, 0x7E, 0xFC, 0x08, 0x7C, 0x98, 0x30,
  0x67, 0x8E, 0x06, 0x0C, 0x1B, 0xE7, 0x80, 0x0E, 0x1C, 0x50, 0xE2, 0xCD,
  0x93, 0x7F, 0xFC, 0x30, 0x60, 0x3E, 0x60, 0xC1, 0x07, 0xCF, 0x83, 0x06,
  0x0D, 0xF3, 0xC0, 0x06, 0x3C, 0xE1, 0x86, 0x0F, 0x9B, 0x76, 0xCD, 0x99,
  0xF3, 0xC0, 0x3F, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60,
  0xE0, 0x08, 0x7C, 0xDB, 0x33, 0x67, 0x8E, 0x36, 0xCD, 0x9B, 0xF3, 0xC0,
  0x08, 0x7C, 0xDB, 0x36, 0x6D, 0xDF, 0xBE, 0x0C, 0x33, 0xE7, 0x80, 0x37,
  0x20, 0x00, 0x0C, 0xC0, 0x19, 0xC4, 0x00, 0x00, 0x0E, 0x63, 0x30, 0x04,
  0x33, 0xFC, 0xC1, 0xE1, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x83, 0x0F, 0x0F,
  0x1D, 0xEE, 0x20, 0x19, 0xF4, 0xC3, 0x18, 0x63, 0x18, 0x00, 0x06, 0x30,
  0x02, 0x03, 0xE1, 0x0C, 0x89, 0x6F, 0x52, 0xD5, 0xA5, 0x4B, 0xD6, 0xB7,
  0xEC, 0x01, 0x88, 0x3E, 0x00, 0x0E, 0x0E, 0x0A, 0x1A, 0x1A, 0x32, 0x3E,
  0x7E, 0x67, 0x67, 0xC7, 0x3E, 0x37, 0x33, 0x36, 0x7E, 0x7C, 0x66, 0x66,
  0xCE, 0xFC, 0xF8, 0x0C, 0x7D, 0xD3, 0x0E, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0xE3, 0xC0, 0x3E, 0x37, 0x33, 0x33, 0x63, 0x63, 0x67, 0x66, 0xEE, 0xFC,
  0xF8, 0x3E, 0x60, 0xC1, 0x87, 0xCF, 0x98, 0x30, 0xE1, 0xF3, 0xE0, 0x3E,
  0x60, 0xC1, 0x86, 0x0F, 0x98, 0x30, 0xE1, 0x83, 0x00, 0x0C, 0x3F, 0x72,
  0x60, 0xE0, 0xC0, 0xCE, 0xD6, 0xCC, 0xCC, 0xFC, 0x7C, 0x39, 0x98, 0xCC,
  0xC6, 0x67, 0xF3, 0xF9, 0x9C, 0xCC, 0xE6, 0x63, 0x33, 0x80, 0x3E, 0x18,
  0x60, 0xC1, 0x83, 0x06, 0x18, 0x30, 0x63, 0xE0, 0x0E, 0x18, 0x30, 0x61,
  0x83, 0x06, 0x0C, 0x18, 0x60, 0xC1, 0x8F, 0x1C, 0x00, 0x33, 0x9B, 0x8D,
  0x87, 0x87, 0xC3, 0xC1, 0xB0, 0xD8, 0xCC, 0x66, 0x33, 0x00, 0x31, 0x8C,
  0x66, 0x31, 0x8C, 0xE7, 0xFE, 0x38, 0xF3, 0x8E, 0x38, 0xE3, 0x9E, 0x69,
  0x66, 0xBC, 0x6A, 0xC6, 0xEC, 0xCE, 0xCC, 0xCC, 0xCD, 0x80, 0x39, 0x9C,
  0xCE, 0x65, 0x36, 0x93, 0x79, 0xBC, 0xDE, 0xCF, 0x63, 0x31, 0x80, 0x0C,
  0x3E, 0x76, 0x67, 0xC7, 0xC7, 0xC6, 0xC6, 0xCE, 0xCC, 0xFC, 0x78, 0x3E,
  0x37, 0x33, 0x33, 0x67, 0x7E, 0x7C, 0x60, 0xE0, 0xC0, 0xC0, 0x0C, 0x3E,
  0x76, 0x67, 0xC7, 0xC7, 0xC6, 0xC6, 0xCE, 0xCC, 0xFC, 0x78, 0x38, 0x18,
  0x18, 0x3E, 0x37, 0x37, 0x36, 0x66, 0x7C, 0x78, 0x6C, 0xCC, 0xCC, 0xCC,
  0x0C, 0x7C, 0xDB, 0x87, 0x07, 0x0E, 0x0E, 0x0D, 0x1B, 0xE7, 0x80, 0xFE,
  0x60, 0xC1, 0x83, 0x0C, 0x18, 0x30, 0x61, 0xC3, 0x00, 0x63, 0x66, 0x66,
  0xE6, 0xC6, 0xCE, 0xCC, 0xCC, 0xCC, 0xF8, 0xF8, 0xC7, 0xC6, 0xCE, 0xCC,
  0xCC, 0x58, 0x58, 0x50, 0x70, 0x70, 0x60, 0xC6, 0x7C, 0xE6, 0xCE, 0xCC,
  0xEC, 0xDE, 0xCD, 0x78, 0xF7, 0x8F, 0x78, 0xE7, 0x0E, 0x70, 0xE6, 0x00,
  0x19, 0x8D, 0x87, 0x83, 0xC0, 0xC0, 0xE0, 0x70, 0x78, 0x36, 0x33, 0x31,
  0x80, 0xE6, 0xD9, 0xB3, 0xC7, 0x8E, 0x18, 0x30, 0x60, 0xC3, 0x80, 0x1F,
  0x23, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x60, 0x7C, 0xFC, 0x1E, 0x30,
  0x60, 0x83, 0x06, 0x0C, 0x18, 0x60, 0xC1, 0x83, 0x07, 0x1E, 0x00, 0x9B,
  0x6D, 0xB6, 0x4D, 0xB0, 0x1C, 0xB0, 0xC6, 0x18, 0x61, 0x84, 0x30, 0xC3,
  0x0C, 0xE3, 0x80, 0x0C, 0x38, 0xF1, 0xA6, 0x58, 0xC0, 0xFC, 0xEC, 0x1B,
  0x3E, 0x66, 0x66, 0x66, 0xCC, 0xCC, 0xFC, 0x6C, 0x30, 0x60, 0xC1, 0xE7,
  0xEC, 0xD9, 0xB3, 0x67, 0xDB, 0xF7, 0xC0, 0x1C, 0xF6, 0x18, 0x63, 0x0C,
  0x3E, 0x78, 0x03, 0x03, 0x03, 0x1E, 0x3E, 0x66, 0x66, 0x66, 0xCC, 0xCC,
  0xFC, 0x7C, 0x1C, 0x7D, 0x9B, 0x67, 0x98, 0x30, 0x34, 0x78, 0x07, 0x0F,
  0x0C, 0x0E, 0x1E, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30,
  0xE0, 0xE0, 0x1B, 0x3E, 0x66, 0x66, 0x66, 0xCC, 0xCC, 0xFC, 0x6C, 0x1C,
  0x98, 0xF8, 0xF0, 0x30, 0x60, 0xC1, 0xE7, 0xEC, 0xD9, 0xB3, 0x6D, 0x9B,
  0x36, 0x60, 0x33, 0x03, 0x76, 0x66, 0x6C, 0xCC, 0x0C, 0x30, 0x03, 0x1C,
  0x61, 0x86, 0x18, 0xC3, 0x0C, 0x30, 0xCE, 0x30, 0x30, 0x30, 0x30, 0x37,
  0x66, 0x6C, 0x78, 0x78, 0x78, 0xD8, 0xCC, 0xCC, 0x39, 0x8C, 0x67, 0x31,
  0x8C, 0x66, 0x31, 0x80, 0x2C, 0xDF, 0xF6, 0x6D, 0x9B, 0x6C, 0xDB, 0x3C,
  0xCF, 0x36, 0xDD, 0x80, 0x2C, 0x7D, 0x9B, 0x36, 0x6D, 0xB3, 0x66, 0xCC,
  0x1C, 0x7D, 0x9B, 0x3E, 0x79, 0xF3, 0x3E, 0x78, 0x16, 0x3F, 0x33, 0x33,
  0x33, 0x33, 0x76, 0x7E, 0x7C, 0x60, 0x60, 0xC0, 0xC0, 0x1A, 0x7D, 0x9B,
  0x36, 0x78, 0xB3, 0x7E, 0x6C, 0x18, 0x60, 0xC1, 0x80, 0x2D, 0xF7, 0x18,
  0x61, 0x8C, 0x30, 0xC0, 0x39, 0xF6, 0x18, 0x70, 0xE1, 0xBE, 0xF0, 0x26,
  0x7F, 0xCC, 0xCC, 0xCE, 0xE0, 0x36, 0xCD, 0x9B, 0x36, 0x4D, 0xB3, 0x7E,
  0x7C, 0xCF, 0x3D, 0xB6, 0xF3, 0xCE, 0x38, 0xE0, 0xCC, 0xF7, 0x6D, 0xDB,
  0xF4, 0xFF, 0x3B, 0xCE, 0xE3, 0xB8, 0xCC, 0x00, 0x33, 0x36, 0x1E, 0x1C,
  0x18, 0x3C, 0x3C, 0x6C, 0xEC, 0x33, 0x33, 0x36, 0x36, 0x3C, 0x3C, 0x38,
  0x38, 0x38, 0x30, 0x30, 0xE0, 0xC0, 0x3E, 0x7C, 0x30, 0xC1, 0x86, 0x1C,
  0x3E, 0xF8, 0x1E, 0x30, 0x61, 0xC3, 0x0E, 0x30, 0x30, 0x60, 0xC1, 0x83,
  0x07, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0xF1, 0x86, 0x18, 0x60,
  0xC7, 0x30, 0xC3, 0x1C, 0xE2, 0x00, 0xE7, 0xF8, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 11, 4, 0, -11 },
  { 8, 5, 4, 6, 2, -11 },
  { 11, 8, 11, 8, 0, -11 },
  { 22, 7, 13, 7, 0, -12 },
  { 34, 10, 12, 11, 1, -12 },
  { 49, 8, 12, 8, 0, -12 },
  { 61, 2, 4, 4, 2, -11 },
  { 62, 6, 14, 4, 0, -11 },
  { 73, 5, 15, 4, -1, -12 },
  { 83, 6, 6, 7, 1, -12 },
  { 88, 6, 7, 7, 1, -9 },
  { 94, 4, 4, 4, -1, -2 },
  { 96, 4, 2, 5, 0, -5 },
  { 97, 3, 2, 4, 0, -2 },
  { 98, 8, 12, 6, -1, -12 },
  { 110, 7, 12, 7, 0, -12 },
  { 121, 5, 11, 7, 2, -11 },
  { 128, 8, 12, 7, -1, -12 },
  { 140, 7, 12, 7, 0, -12 },
  { 151, 7, 11, 7, 0, -11 },
  { 161, 7, 11, 7, 0, -11 },
  { 171, 7, 12, 7, 0, -12 },
  { 182, 8, 11, 7, 0, -11 },
  { 193, 7, 12, 7, 0, -12 },
  { 204, 7, 12, 7, 0, -12 },
  { 215, 4, 9, 4, 0, -9 },
  { 220, 5, 11, 4, -1, -9 },
  { 227, 6, 8, 7, 1, -10 },
  { 233, 6, 5, 7, 1, -8 },
  { 237, 6, 8, 7, 1, -10 },
  { 243, 6, 12, 5, 0, -12 },
  { 252, 10, 13, 10, 0, -12 },
  { 269, 8, 11, 8, -1, -11 },
  { 280, 8, 11, 8, 0, -11 },
  { 291, 7, 12, 7, 1, -12 },
  { 302, 8, 11, 8, 0, -11 },
  { 313, 7, 11, 6, 0, -11 },
  { 323, 7, 11, 6, 0, -11 },
  { 333, 8, 12, 8, 1, -12 },
  { 345, 9, 11, 9, 0, -11 },
  { 358, 7, 11, 5, -1, -11 },
  { 368, 7, 14, 4, -2, -11 },
  { 381, 9, 11, 7, 0, -11 },
  { 394, 5, 11, 6, 0, -11 },
  { 401, 12, 11, 11, 0, -11 },
  { 418, 9, 11, 9, 0, -11 },
  { 431, 8, 12, 9, 1, -12 },
  { 443, 8, 11, 7, 0, -11 },
  { 454, 8, 15, 9, 1, -12 },
  { 469, 8, 11, 7, 0, -11 },
  { 480, 7, 12, 7, 0, -12 },
  { 491, 7, 11, 6, 1, -11 },
  { 501, 8, 11, 8, 1, -11 },
  { 512, 8, 11, 7, 1, -11 },
  { 523, 12, 11, 11, 1, -11 },
  { 540, 9, 11, 7, -1, -11 },
  { 553, 7, 11, 7, 1, -11 },
  { 563, 8, 11, 6, -1, -11 },
  { 574, 7, 14, 5, -1, -11 },
  { 587, 3, 12, 6, 2, -12 },
  { 592, 6, 14, 5, -1, -11 },
  { 603, 7, 6, 7, 0, -11 },
  { 609, 6, 1, 5, -2, 1 },
  { 610, 3, 2, 5, 2, -12 },
  { 611, 8, 9, 7, 0, -9 },
  { 620, 7, 12, 7, 0, -12 },
  { 631, 6, 9, 6, 0, -9 },
  { 638, 8, 12, 7, 0, -12 },
  { 650, 7, 9, 7, 0, -9 },
  { 658, 8, 16, 4, -2, -12 },
  { 674, 8, 13, 7, 0, -9 },
  { 687, 7, 12, 7, 0, -12 },
  { 698, 4, 12, 4, 0, -12 },
  { 704, 6, 16, 4, -2, -12 },
  { 716, 8, 12, 7, 0, -12 },
  { 728, 5, 12, 4, 0, -12 },
  { 736, 10, 9, 11, 0, -9 },
  { 748, 7, 9, 7, 0, -9 },
  { 756, 7, 9, 7, 0, -9 },
  { 764, 8, 13, 7, -1, -9 },
  { 777, 7, 13, 7, 0, -9 },
  { 789, 6, 9, 5, 0, -9 },
  { 796, 6, 9, 6, 0, -9 },
  { 803, 4, 11, 5, 1, -11 },
  { 809, 7, 9, 7, 0, -9 },
  { 817, 6, 9, 6, 1, -9 },
  { 824, 10, 9, 10, 1, -9 },
  { 836, 8, 9, 6, -1, -9 },
  { 845, 8, 13, 6, -1, -9 },
  { 858, 7, 9, 5, -1, -9 },
  { 866, 7, 14, 5, 0, -11 },
  { 879, 2, 16, 6, 2, -12 },
  { 883, 6, 14, 5, -1, -11 },
  { 894, 6, 3, 7, 1, -7 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic16pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC16PT7B_H_
