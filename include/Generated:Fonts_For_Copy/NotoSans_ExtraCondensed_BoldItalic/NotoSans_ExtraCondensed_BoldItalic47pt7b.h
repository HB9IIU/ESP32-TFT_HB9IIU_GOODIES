#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC47PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0,
  0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF0,
  0x00, 0x3F, 0x1F, 0x9F, 0x8F, 0xCF, 0xCF, 0xC7, 0xE7, 0xE3, 0xE3, 0xF1,
  0xF1, 0xF9, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x3E, 0x1F, 0x1F,
  0x0F, 0x0F, 0x8F, 0x87, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3E, 0x00,
  0x3E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x7C, 0x00,
  0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF0, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x01,
  0xE3, 0xE0, 0x03, 0xE3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x07,
  0xC7, 0x80, 0x07, 0x87, 0x80, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x0F, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E,
  0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C,
  0x7C, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0xF8, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F,
  0xEF, 0x01, 0xF3, 0x18, 0x1F, 0x98, 0x00, 0xFC, 0x80, 0x07, 0xEC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00,
  0x0D, 0xF8, 0x00, 0x6F, 0xC0, 0x03, 0x7E, 0x10, 0x13, 0xF0, 0xE1, 0x9F,
  0x87, 0xCD, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFC, 0x00, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x1F, 0xE0,
  0x1F, 0x00, 0xFF, 0x80, 0x78, 0x03, 0xFF, 0x03, 0xE0, 0x1F, 0x7C, 0x0F,
  0x00, 0xF8, 0xF0, 0x7C, 0x03, 0xC3, 0xC1, 0xE0, 0x0F, 0x1F, 0x0F, 0x80,
  0x7C, 0x7C, 0x3C, 0x01, 0xE1, 0xF1, 0xE0, 0x07, 0x87, 0x8F, 0x80, 0x1E,
  0x1E, 0x3C, 0x00, 0x78, 0x79, 0xF0, 0x03, 0xE3, 0xE7, 0x83, 0x0F, 0x8F,
  0x3E, 0x3F, 0x3E, 0x7C, 0xF1, 0xFE, 0x79, 0xE7, 0xCF, 0xF9, 0xFF, 0x9E,
  0x7D, 0xF7, 0xFC, 0xF9, 0xE7, 0xCF, 0xE3, 0xCF, 0x0F, 0x1F, 0x1F, 0x3C,
  0x7C, 0x00, 0xF9, 0xF1, 0xF0, 0x03, 0xC7, 0x87, 0xC0, 0x1F, 0x1E, 0x1E,
  0x00, 0x78, 0x78, 0x78, 0x03, 0xE1, 0xE1, 0xE0, 0x0F, 0x0F, 0x8F, 0x80,
  0x7C, 0x3E, 0x3C, 0x01, 0xE0, 0xF8, 0xF0, 0x0F, 0x83, 0xE7, 0xC0, 0x3C,
  0x07, 0xFE, 0x01, 0xF0, 0x1F, 0xF0, 0x07, 0x80, 0x7F, 0x80, 0x3C, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xF0, 0x01, 0xFB, 0xF0, 0x01, 0xF1, 0xF0, 0x03, 0xF1, 0xF0, 0x03,
  0xF1, 0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xE3, 0xF0, 0x03, 0xF3, 0xE0, 0x03,
  0xF7, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0x0F, 0xFE, 0x3E, 0x1F,
  0xFE, 0x7E, 0x3F, 0x7F, 0x7E, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7C,
  0x3F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC, 0x1F, 0xF0, 0xFC, 0x0F, 0xE0, 0xFC,
  0x0F, 0xE0, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFB, 0xF8, 0x1F, 0xE3, 0xFC, 0x7F, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7C, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0xF8, 0xF0, 0x00, 0x3E, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x06, 0x1F, 0x03, 0xCF,
  0x07, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xC1, 0xFF, 0xE1,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFB, 0xF0, 0xFC, 0xF8, 0x3C, 0x7E,
  0x0C, 0x3E, 0x02, 0x0C, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3E,
  0x07, 0xC1, 0xF0, 0x7E, 0x00, 0x7F, 0xF7, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF,
  0xEF, 0xFE, 0x3C, 0xFD, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F,
  0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xF9,
  0xF8, 0x7E, 0x1F, 0x1F, 0x83, 0xE3, 0xF0, 0x7C, 0x7E, 0x1F, 0x9F, 0x83,
  0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07,
  0xEF, 0xC1, 0xF9, 0xF8, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x3F,
  0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF1, 0xFC,
  0x7E, 0x3F, 0x0F, 0xCF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F,
  0xE0, 0x7F, 0xC1, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0x7F, 0xF9, 0xFB, 0xF3,
  0xE7, 0xC3, 0x9F, 0x82, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0x3F, 0x80, 0x78, 0x3F, 0x80, 0xE0, 0x7F, 0x00, 0x80, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x07, 0xDF, 0xF0, 0x18, 0x1F, 0xC0, 0x40, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x20, 0x07, 0xF0, 0xE0, 0x3F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1D, 0xF0, 0x00, 0xFF,
  0xC0, 0x07, 0xBF, 0x00, 0x1E, 0xF8, 0x00, 0xF3, 0xE0, 0x07, 0x9F, 0x80,
  0x1E, 0x7E, 0x00, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1E, 0x3F, 0x00, 0xF0,
  0xFC, 0x07, 0xC3, 0xF0, 0x1E, 0x0F, 0xC0, 0xF0, 0x3E, 0x07, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE1, 0x00, 0x7F, 0x0E, 0x0F, 0xF0, 0x7F,
  0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0xFE, 0x08, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF1, 0xE0, 0x1F,
  0xBF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFE, 0xFE,
  0x1F, 0xC3, 0xF0, 0xFC, 0x1F, 0x8F, 0xE0, 0xFC, 0x7F, 0x07, 0xE3, 0xF0,
  0x3F, 0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1,
  0xF8, 0x7E, 0x0F, 0xE7, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xF1, 0xFC, 0x1F, 0x07, 0xE1,
  0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x87,
  0xE0, 0x7E, 0x7E, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03,
  0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xF9, 0xF8,
  0x3F, 0x8F, 0xE1, 0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0,
  0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xE1, 0xF8, 0x7F, 0xBF, 0xC1,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xF0,
  0x7F, 0x7F, 0x0F, 0xE3, 0xF0, 0xFC, 0x3F, 0x1F, 0xC3, 0xF1, 0xF8, 0x3F,
  0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x7F, 0x3F, 0x87,
  0xF3, 0xF8, 0x7F, 0x1F, 0x8F, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x0F, 0xF7, 0xC0, 0x7C, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x80, 0xFE, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0x03, 0xC0, 0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0x80,
  0x00, 0x38, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F,
  0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F,
  0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00,
  0x0F, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x07, 0xFF,
  0xC3, 0xFF, 0xE1, 0xFF, 0xF8, 0xF1, 0xFC, 0x20, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xC0,
  0x3E, 0x00, 0xFC, 0x00, 0xF8, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0x78, 0x7C, 0x1F, 0xC3, 0xC3, 0xC1, 0xFF, 0x9E, 0x3E,
  0x1F, 0xF8, 0xF1, 0xE1, 0xF3, 0xC7, 0x9F, 0x1F, 0x1E, 0x3C, 0xF0, 0xF0,
  0xF1, 0xE7, 0x8F, 0x0F, 0x0F, 0x78, 0x78, 0x78, 0x7B, 0xC7, 0xC3, 0xC3,
  0xDE, 0x3C, 0x3E, 0x3C, 0xF1, 0xE1, 0xE1, 0xE7, 0x0F, 0x0F, 0x0F, 0x78,
  0x78, 0x78, 0x73, 0xC7, 0xC7, 0xC7, 0x9E, 0x3E, 0x3E, 0x38, 0xF0, 0xF3,
  0xF3, 0xC7, 0x87, 0xFF, 0xFC, 0x3C, 0x3F, 0x9F, 0xC1, 0xE0, 0xF8, 0xFC,
  0x0F, 0x03, 0x81, 0x80, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x20, 0x01, 0xF8, 0x07, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xDF, 0x00,
  0x1F, 0x7C, 0x00, 0xFD, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x7E,
  0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3F, 0x1F, 0x00, 0xF8, 0xFC,
  0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0x03,
  0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x80, 0xFC, 0xFC, 0x03, 0xF3,
  0xF0, 0x0F, 0xDF, 0xC0, 0x3F, 0x7E, 0x00, 0xFF, 0xF8, 0x03, 0xF0, 0x01,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7E, 0x7F, 0xC0, 0xFC, 0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xE0,
  0x7E, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0xC1, 0xF8, 0x7F, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFC, 0x3F, 0x81, 0xF8, 0x3F, 0x07,
  0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E,
  0x07, 0xE1, 0xF8, 0x1F, 0xC3, 0xF0, 0x7F, 0x07, 0xE1, 0xFE, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0x02, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x80, 0xFF, 0x0E, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xF1, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xF0, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7F, 0x0F,
  0xE0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F,
  0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0xFE, 0x1F, 0x80, 0xFE, 0x1F,
  0x80, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x01, 0xF8, 0x3F,
  0x03, 0xF8, 0x3F, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x7E, 0x1F, 0xE0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07,
  0xF8, 0x0C, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x0F, 0xFC, 0xFE, 0x0F, 0xF8, 0xFE, 0x1F, 0xF8, 0xFE,
  0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFC,
  0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFE,
  0x07, 0xE0, 0xFE, 0x07, 0xE0, 0xFF, 0x07, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x01,
  0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F,
  0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFC,
  0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x01,
  0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F,
  0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x1F,
  0xC0, 0x7E, 0x07, 0xE0, 0x1F, 0x03, 0xF8, 0x0F, 0xC1, 0xFC, 0x03, 0xF0,
  0x7E, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0x87, 0xE0, 0x07,
  0xE3, 0xF8, 0x01, 0xF9, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xBF, 0x80,
  0x0F, 0xDF, 0xC0, 0x03, 0xF7, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xEF, 0xE0, 0x03, 0xF1, 0xF8, 0x00,
  0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xE1, 0xFC,
  0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0,
  0xFC, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F,
  0xF0, 0x1F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x83, 0xEF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0x3E, 0xF8, 0x7D, 0xF8,
  0x0F, 0xBE, 0x1F, 0x7E, 0x07, 0xEF, 0x8F, 0x9F, 0x81, 0xFB, 0xE3, 0xE7,
  0xC0, 0x7E, 0xF9, 0xFB, 0xF0, 0x1F, 0x3E, 0x7C, 0xFC, 0x07, 0xCF, 0x9F,
  0x3F, 0x03, 0xF1, 0xEF, 0x8F, 0xC0, 0xFC, 0x7F, 0xE3, 0xE0, 0x3E, 0x1F,
  0xF1, 0xF8, 0x0F, 0x87, 0xFC, 0x7E, 0x07, 0xE1, 0xFE, 0x1F, 0x81, 0xF8,
  0x7F, 0x87, 0xC0, 0x7E, 0x1F, 0xC3, 0xF0, 0x1F, 0x07, 0xF0, 0xFC, 0x07,
  0xC1, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xE0,
  0x3F, 0x07, 0xC1, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x3F,
  0x01, 0xFC, 0x03, 0xE0, 0x3F, 0xC0, 0x3E, 0x03, 0xFC, 0x07, 0xE0, 0x3F,
  0xE0, 0x7E, 0x03, 0xFE, 0x07, 0xE0, 0x7F, 0xE0, 0x7C, 0x07, 0xFE, 0x07,
  0xC0, 0x7F, 0xE0, 0xFC, 0x07, 0xFE, 0x0F, 0xC0, 0x7F, 0xF0, 0xFC, 0x0F,
  0xDF, 0x0F, 0x80, 0xFD, 0xF0, 0xF8, 0x0F, 0x9F, 0x1F, 0x80, 0xF9, 0xF1,
  0xF8, 0x0F, 0x9F, 0x1F, 0x01, 0xF9, 0xF9, 0xF0, 0x1F, 0x8F, 0x9F, 0x01,
  0xF8, 0xFB, 0xF0, 0x1F, 0x0F, 0xBF, 0x01, 0xF0, 0xFB, 0xE0, 0x3F, 0x0F,
  0xBE, 0x03, 0xF0, 0xFF, 0xE0, 0x3E, 0x07, 0xFE, 0x03, 0xE0, 0x7F, 0xE0,
  0x7E, 0x07, 0xFC, 0x07, 0xE0, 0x7F, 0xC0, 0x7E, 0x07, 0xFC, 0x07, 0xC0,
  0x7F, 0xC0, 0x7C, 0x03, 0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xF8,
  0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFC, 0x3F,
  0x87, 0xF0, 0x7F, 0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0xFE, 0x01, 0xF9,
  0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0xC0, 0x3F, 0xBF,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xF7, 0xF0,
  0x0F, 0xEF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F, 0xBF, 0x00, 0x7E, 0x7E, 0x01,
  0xFC, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0xC7, 0xF0, 0x7F,
  0x0F, 0xF3, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F,
  0x81, 0xF8, 0x3F, 0x03, 0xF0, 0xFE, 0x07, 0xE1, 0xF8, 0x1F, 0xC3, 0xF0,
  0x3F, 0x07, 0xE0, 0xFE, 0x0F, 0xCF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC3, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x1F, 0xC0, 0x7E, 0x3F, 0x00,
  0xFC, 0xFE, 0x01, 0xF9, 0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xE0, 0x0F,
  0xDF, 0xC0, 0x3F, 0xBF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xF7, 0xF0, 0x0F, 0xEF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F, 0xBF,
  0x00, 0x7E, 0x7E, 0x01, 0xFC, 0xFC, 0x03, 0xF9, 0xF8, 0x0F, 0xE3, 0xF0,
  0x1F, 0xC7, 0xF0, 0x7F, 0x0F, 0xF3, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F,
  0xDF, 0xF0, 0x3F, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC1, 0xFC, 0x3F, 0x07, 0xE0,
  0xFC, 0x3F, 0x83, 0xF1, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7C, 0xFC, 0x03, 0xF3, 0xF0,
  0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x07, 0xE1, 0xF8, 0x1F,
  0x87, 0xE0, 0x7E, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x03,
  0xF0, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF,
  0x01, 0xFE, 0x0C, 0x03, 0xF8, 0x08, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0x00, 0x7F,
  0x03, 0x00, 0xFE, 0x07, 0xCF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x80,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x7F,
  0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E,
  0x0F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC,
  0x1F, 0x80, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xF8, 0x3F, 0x01, 0xF8,
  0x3F, 0x01, 0xF8, 0x3F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7E, 0x03, 0xF0,
  0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0xFE, 0x07, 0xF0,
  0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0xFE, 0xFC,
  0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x0F,
  0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0x80, 0xFC, 0x7E, 0x03, 0xF1,
  0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFD, 0xF8, 0x01, 0xF7, 0xE0,
  0x07, 0xDF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x01,
  0xF0, 0x0F, 0xDF, 0x80, 0x7C, 0x03, 0xF7, 0xE0, 0x3F, 0x01, 0xF9, 0xF8,
  0x0F, 0xC0, 0x7E, 0x7E, 0x07, 0xF0, 0x3F, 0x1F, 0x81, 0xFC, 0x0F, 0xC7,
  0xE0, 0x7F, 0x03, 0xF1, 0xF8, 0x3F, 0xC1, 0xF8, 0x7E, 0x0F, 0xF0, 0x7E,
  0x1F, 0x87, 0xFC, 0x1F, 0x07, 0xE1, 0xFF, 0x0F, 0xC1, 0xF8, 0x7F, 0xC3,
  0xF0, 0x7C, 0x3F, 0xF1, 0xF8, 0x1F, 0x0F, 0xFC, 0x7E, 0x07, 0xC3, 0xDF,
  0x1F, 0x01, 0xF1, 0xF7, 0xCF, 0xC0, 0x7C, 0x7D, 0xF3, 0xF0, 0x1F, 0x3E,
  0x78, 0xF8, 0x07, 0xCF, 0x9E, 0x7E, 0x01, 0xF3, 0xC7, 0x9F, 0x80, 0x7D,
  0xF1, 0xEF, 0xC0, 0x1F, 0x7C, 0x7B, 0xF0, 0x07, 0xFE, 0x1E, 0xF8, 0x01,
  0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0,
  0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x0F,
  0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0x80, 0x03,
  0xF3, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x3F,
  0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x7E,
  0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xE7, 0xE0, 0xFE, 0x7E, 0x0F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x03, 0xEF, 0xC0,
  0x3E, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0xC7, 0xE3, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xE3, 0xF1, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xF1, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF8, 0xFC, 0x3E, 0x1F, 0x0F,
  0x87, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0x7C,
  0x03, 0xE7, 0xC0, 0x7E, 0x7C, 0x07, 0xC7, 0xC0, 0xF8, 0x3E, 0x1F, 0x83,
  0xE1, 0xF0, 0x3E, 0x3F, 0x03, 0xE3, 0xE0, 0x1F, 0x7C, 0x01, 0xFF, 0xC0,
  0x1F, 0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x7F,
  0x1F, 0x8F, 0xC3, 0xF0, 0xF8, 0x7C, 0x1F, 0x01, 0xF8, 0xF8, 0x1F, 0xEF,
  0xC1, 0xFF, 0x7E, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xE7, 0xF8, 0xFE,
  0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07, 0xE3, 0xF8, 0x3F, 0x1F, 0x81, 0xF8,
  0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x7F, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81,
  0xF8, 0xFC, 0x1F, 0xC7, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x7F, 0x0F,
  0xC7, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFB, 0xE0, 0x7F, 0x9F,
  0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF9, 0xF0, 0x0F, 0xDF, 0xC0,
  0x7D, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFC, 0x7F, 0x0F, 0xC1,
  0xF8, 0x7E, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F,
  0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F,
  0x8F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xE1, 0xFC,
  0x7F, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xDF, 0xF8, 0x3E, 0xFF, 0x81,
  0xF3, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0x07, 0xF0, 0xC1, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x20,
  0xFE, 0x18, 0x3F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0xEF,
  0xC0, 0x7F, 0xDF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xE7, 0xF8,
  0x1F, 0x87, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x07,
  0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x7E, 0x03, 0xE0, 0xFC,
  0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0xC1,
  0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0x7C, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFF, 0x0F, 0xEF, 0xC7, 0xE1, 0xF1,
  0xF0, 0x7C, 0xFC, 0x1F, 0x3E, 0x07, 0xDF, 0x83, 0xF7, 0xE3, 0xF9, 0xFF,
  0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x0F, 0xFE, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x02, 0x3F, 0x83, 0x87,
  0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xF8, 0x80, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x3E, 0x01, 0xFE, 0xFC, 0x07, 0xFD, 0xF8, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0xFE, 0x7F, 0x81, 0xF8, 0x7F, 0x07, 0xE0, 0xFE,
  0x0F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1,
  0xF8, 0x1F, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F,
  0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x7F, 0x03, 0xF1,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xEF,
  0xC0, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x20, 0x0F, 0xC0, 0x60, 0x3F, 0x80, 0xFF, 0xFF, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE7, 0xC0, 0x7E, 0xFE, 0x07, 0xDF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x1F, 0xC3, 0xF1,
  0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x3F, 0x07, 0xE3, 0xF0, 0x7E,
  0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0x7E, 0x0F,
  0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1,
  0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0x00, 0x70, 0x0F, 0xC0, 0x7E, 0x07,
  0xF0, 0x3F, 0x81, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F, 0x07, 0xC1, 0xF8, 0x3F, 0x0F, 0xC0,
  0xFC, 0x7E, 0x03, 0xF3, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x7E, 0x01, 0xFB,
  0xF0, 0x07, 0xFF, 0x80, 0x1F, 0x7E, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xF7, 0xE0, 0x1F,
  0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xC3, 0xF0, 0x1F, 0x0F,
  0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xE0,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x00, 0x07,
  0xC7, 0xC1, 0xF0, 0x0F, 0xBF, 0xC7, 0xF0, 0x1E, 0xFF, 0xDF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFC, 0x7F, 0x9F, 0xC3, 0xF0,
  0xFE, 0x1F, 0x07, 0xE1, 0xF8, 0x3E, 0x1F, 0x83, 0xF0, 0xFC, 0x3F, 0x07,
  0xE1, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0xF8, 0x3F, 0x07, 0xE1, 0xF0, 0x7E,
  0x0F, 0x87, 0xE0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7E, 0x1F, 0x83, 0xE0,
  0xFC, 0x3E, 0x0F, 0xC1, 0xF0, 0xFC, 0x1F, 0x83, 0xE1, 0xF8, 0x3F, 0x0F,
  0xC3, 0xF0, 0x7C, 0x1F, 0x87, 0xE1, 0xF8, 0x3F, 0x0F, 0x83, 0xF0, 0x7C,
  0x3F, 0x07, 0xE0, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0xFC, 0x1F, 0x07, 0xE1,
  0xF0, 0x7E, 0x0F, 0xC0, 0x07, 0xC7, 0xC0, 0x78, 0xFE, 0x07, 0x9F, 0xF0,
  0xFB, 0xFF, 0x0F, 0xFF, 0xF0, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x03,
  0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xC3, 0xE0,
  0x7C, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xC0, 0xF8, 0xFC,
  0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x9F, 0xCF,
  0xE1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0xBF,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC,
  0x0F, 0xDF, 0x83, 0xFB, 0xF0, 0x7E, 0x7E, 0x1F, 0xCF, 0xC3, 0xF1, 0xFF,
  0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0xF9, 0xFC, 0x00, 0xFB, 0xFE, 0x01,
  0xF7, 0xFE, 0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x7F, 0x01, 0xF8, 0x3F, 0x01,
  0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xE0, 0x7E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xE1, 0xFC, 0x0F,
  0xE1, 0xF8, 0x0F, 0xE3, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xBF, 0xC0, 0x1F, 0x9F, 0x80, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0xF8, 0x1F, 0xE7, 0xC1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xE7, 0xF8, 0x7E, 0x1F, 0xC7,
  0xE0, 0xFC, 0x3F, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F,
  0xC7, 0xE0, 0x7C, 0x7E, 0x03, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC,
  0x0F, 0xC7, 0xE0, 0x7C, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF8,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xBF, 0x01, 0xF9,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC7, 0x83, 0xE7, 0xC1,
  0xF7, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xC4, 0x1F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x1F, 0xFF, 0x07, 0xE0, 0xC1, 0xF8, 0x10, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE2, 0x03, 0xF0,
  0xC1, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F,
  0xF0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F,
  0xF1, 0xFF, 0xCF, 0xFF, 0x3F, 0xFD, 0xFF, 0xE0, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xC1, 0xF8,
  0x7C, 0x0F, 0x83, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1,
  0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F,
  0xC1, 0xF0, 0x7C, 0x0F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F,
  0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8,
  0x7F, 0x0F, 0xC7, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFB, 0xE0,
  0x7F, 0x9E, 0x01, 0xF8, 0xF0, 0x00, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x81,
  0xFB, 0xE0, 0x7E, 0xF8, 0x1F, 0x3E, 0x0F, 0xCF, 0x83, 0xE3, 0xE1, 0xF8,
  0xF8, 0x7E, 0x3E, 0x1F, 0x0F, 0x8F, 0xC3, 0xE3, 0xE0, 0xF9, 0xF8, 0x3E,
  0x7C, 0x0F, 0xBF, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0xFB, 0xE0, 0xFE, 0x0F,
  0xDF, 0x07, 0xF0, 0x7C, 0xF8, 0x3F, 0x87, 0xE7, 0xC3, 0xFC, 0x3F, 0x3E,
  0x1F, 0xE1, 0xF1, 0xF1, 0xFF, 0x1F, 0x8F, 0x8F, 0xF8, 0xF8, 0x7C, 0x7F,
  0xC7, 0xC3, 0xE7, 0xFE, 0x7E, 0x1F, 0x3F, 0xF3, 0xE0, 0xF9, 0xEF, 0xBF,
  0x07, 0xDF, 0x7D, 0xF0, 0x3E, 0xF3, 0xEF, 0x81, 0xFF, 0x9F, 0xFC, 0x0F,
  0xFC, 0xF7, 0xC0, 0x7F, 0xC7, 0xBE, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF1,
  0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0x83, 0xFC,
  0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x07, 0xE1, 0xF8, 0x0F, 0xC3,
  0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x80, 0x7E, 0x7E, 0x00, 0x7D, 0xF8,
  0x00, 0xFB, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0x7C, 0x00, 0x7E,
  0xF8, 0x01, 0xF9, 0xF8, 0x03, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x0F,
  0xC0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0xFC,
  0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F,
  0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00,
  0xFC, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xBF, 0x00,
  0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0,
  0xFF, 0xFE, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x40, 0x07, 0xF0, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFE, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 14, 34, 12, 0, -34 },
  { 61, 17, 13, 19, 4, -34 },
  { 89, 24, 34, 22, 0, -34 },
  { 191, 21, 39, 20, 0, -36 },
  { 294, 30, 34, 33, 2, -34 },
  { 422, 24, 34, 24, 0, -34 },
  { 524, 8, 13, 11, 5, -34 },
  { 537, 15, 41, 13, 1, -34 },
  { 614, 16, 41, 13, -4, -34 },
  { 696, 17, 19, 19, 4, -36 },
  { 737, 19, 23, 22, 2, -28 },
  { 792, 11, 12, 11, -3, -6 },
  { 809, 12, 6, 14, 1, -16 },
  { 818, 7, 7, 11, 0, -7 },
  { 825, 25, 34, 17, -3, -34 },
  { 932, 19, 34, 20, 1, -34 },
  { 1013, 15, 34, 20, 5, -34 },
  { 1077, 23, 34, 20, -2, -34 },
  { 1175, 22, 34, 20, -1, -34 },
  { 1269, 22, 34, 20, -1, -34 },
  { 1363, 21, 34, 20, 0, -34 },
  { 1453, 21, 34, 20, 1, -34 },
  { 1543, 22, 34, 20, 1, -34 },
  { 1637, 21, 34, 20, 0, -34 },
  { 1727, 20, 34, 20, 0, -34 },
  { 1812, 11, 26, 11, 0, -26 },
  { 1848, 14, 32, 11, -3, -26 },
  { 1904, 19, 22, 22, 2, -28 },
  { 1957, 19, 15, 22, 2, -24 },
  { 1993, 19, 22, 22, 2, -28 },
  { 2046, 17, 34, 16, 1, -34 },
  { 2119, 29, 38, 30, 1, -34 },
  { 2257, 22, 34, 22, -3, -34 },
  { 2351, 23, 34, 22, 0, -34 },
  { 2449, 22, 34, 21, 2, -34 },
  { 2543, 24, 34, 24, 0, -34 },
  { 2645, 21, 34, 19, 0, -34 },
  { 2735, 21, 34, 18, 0, -34 },
  { 2825, 24, 34, 25, 2, -34 },
  { 2927, 27, 34, 25, 0, -34 },
  { 3042, 20, 34, 15, -2, -34 },
  { 3127, 20, 44, 12, -7, -34 },
  { 3237, 26, 34, 22, 0, -34 },
  { 3348, 15, 34, 18, 0, -34 },
  { 3412, 34, 34, 33, 0, -34 },
  { 3557, 28, 34, 26, 0, -34 },
  { 3676, 23, 34, 26, 2, -34 },
  { 3774, 23, 34, 22, 0, -34 },
  { 3872, 23, 42, 26, 2, -34 },
  { 3993, 22, 34, 22, 0, -34 },
  { 4087, 23, 34, 19, -1, -34 },
  { 4185, 19, 34, 19, 3, -34 },
  { 4266, 24, 34, 24, 2, -34 },
  { 4368, 22, 34, 22, 4, -34 },
  { 4462, 34, 34, 33, 3, -34 },
  { 4607, 27, 34, 21, -3, -34 },
  { 4722, 20, 34, 20, 4, -34 },
  { 4807, 23, 34, 18, -2, -34 },
  { 4905, 19, 41, 13, -2, -34 },
  { 5003, 9, 34, 18, 5, -34 },
  { 5042, 18, 41, 13, -3, -34 },
  { 5135, 20, 21, 20, 0, -34 },
  { 5188, 15, 3, 15, -4, 4 },
  { 5194, 9, 8, 14, 7, -36 },
  { 5203, 21, 26, 22, 1, -26 },
  { 5272, 21, 36, 22, 0, -36 },
  { 5367, 18, 26, 17, 1, -26 },
  { 5426, 23, 36, 22, 1, -36 },
  { 5530, 18, 26, 20, 1, -26 },
  { 5589, 23, 47, 13, -5, -36 },
  { 5725, 23, 37, 22, -1, -26 },
  { 5832, 20, 36, 22, 0, -36 },
  { 5922, 13, 36, 11, 0, -36 },
  { 5981, 19, 47, 11, -6, -36 },
  { 6093, 22, 36, 20, 0, -36 },
  { 6192, 13, 36, 11, 0, -36 },
  { 6251, 31, 26, 32, 0, -26 },
  { 6352, 20, 26, 22, 0, -26 },
  { 6417, 19, 27, 21, 1, -26 },
  { 6482, 24, 37, 22, -3, -26 },
  { 6593, 21, 37, 22, 1, -26 },
  { 6691, 17, 26, 15, 0, -26 },
  { 6747, 18, 26, 17, 0, -26 },
  { 6806, 14, 31, 14, 1, -31 },
  { 6861, 21, 26, 21, 1, -26 },
  { 6930, 18, 26, 19, 3, -26 },
  { 6989, 29, 26, 29, 2, -26 },
  { 7084, 23, 26, 19, -2, -26 },
  { 7159, 25, 37, 19, -4, -26 },
  { 7275, 19, 26, 16, -2, -26 },
  { 7337, 18, 41, 16, 1, -34 },
  { 7430, 5, 47, 18, 6, -36 },
  { 7460, 18, 41, 16, -3, -34 },
  { 7553, 19, 7, 22, 2, -20 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic47pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC47PT7B_H_
