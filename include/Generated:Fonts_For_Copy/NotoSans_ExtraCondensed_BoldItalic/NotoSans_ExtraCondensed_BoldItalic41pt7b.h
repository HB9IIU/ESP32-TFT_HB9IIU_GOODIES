#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC41PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0,
  0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x7D, 0xF1,
  0xF7, 0xCF, 0x9F, 0x3E, 0x78, 0xF9, 0xE3, 0xEF, 0x8F, 0x3E, 0x3C, 0xF0,
  0xF3, 0xC7, 0xC0, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x38, 0x01,
  0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xE0, 0x03, 0x8F, 0x00, 0x3C, 0x78,
  0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x07, 0x8E, 0x00, 0x38,
  0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xE1, 0xC0, 0x0F, 0x1E, 0x03,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x0F, 0x1C,
  0x00, 0x71, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x70, 0x01, 0xC7, 0x80, 0x1E,
  0x3C, 0x00, 0xF1, 0xC0, 0x07, 0x1E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x3F, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF,
  0xF0, 0x7F, 0xFC, 0x0F, 0xB3, 0x01, 0xF6, 0x00, 0x3E, 0xC0, 0x07, 0xD0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0D, 0xF0, 0x01, 0x3E,
  0x10, 0x27, 0xC3, 0x0D, 0xF8, 0x79, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0,
  0x7F, 0xFC, 0x03, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x02, 0x03, 0xF8, 0x0F, 0x01, 0xFE, 0x03,
  0xC0, 0x7F, 0xC1, 0xE0, 0x3C, 0xF0, 0x78, 0x0F, 0x3C, 0x3C, 0x07, 0x8F,
  0x0F, 0x01, 0xE3, 0xC7, 0x80, 0x78, 0xF1, 0xE0, 0x1C, 0x38, 0xF0, 0x0F,
  0x1E, 0x38, 0x03, 0xC7, 0x9E, 0x00, 0xF1, 0xEF, 0x1F, 0x3C, 0xF3, 0xCF,
  0xEF, 0x3D, 0xE7, 0xFB, 0xFE, 0x79, 0xFF, 0x7F, 0xBC, 0xF3, 0xDF, 0x8F,
  0x38, 0xF1, 0xC7, 0x9E, 0x3C, 0x01, 0xE7, 0x8F, 0x00, 0xF1, 0xC3, 0x80,
  0x3C, 0xF1, 0xE0, 0x1E, 0x3C, 0x78, 0x07, 0x0F, 0x1E, 0x03, 0xC3, 0xC7,
  0x01, 0xE0, 0xF3, 0xC0, 0x78, 0x3D, 0xF0, 0x3C, 0x0F, 0xF8, 0x0F, 0x01,
  0xFC, 0x07, 0x80, 0x3E, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x80, 0x3E, 0x7C, 0x01, 0xE3, 0xE0, 0x1F, 0x1F, 0x00,
  0xF8, 0xF0, 0x07, 0xC7, 0x80, 0x3E, 0x7C, 0x01, 0xF7, 0xC0, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x1F, 0x1F,
  0xF9, 0xF1, 0xFF, 0xCF, 0x8F, 0xBF, 0x7C, 0xF8, 0xFF, 0xC7, 0xC7, 0xFE,
  0x7C, 0x3F, 0xE3, 0xE0, 0xFE, 0x1F, 0x07, 0xF0, 0xF8, 0x3F, 0x07, 0xE3,
  0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFE, 0xFC, 0x1F, 0xE3, 0xF0,
  0x7E, 0xFD, 0xF3, 0xE7, 0xCF, 0x1E, 0x7C, 0xF9, 0xE0, 0x00, 0xF8, 0x0F,
  0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x23, 0xE0, 0x7B, 0xC2, 0x7F, 0xDE, 0xFF, 0xFE, 0x7F,
  0xFE, 0x07, 0xFF, 0x0F, 0xE0, 0x1F, 0xE0, 0x3E, 0xF0, 0x7E, 0xF8, 0x3C,
  0xF8, 0x18, 0x7C, 0x08, 0x60, 0x00, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x1F, 0x8F, 0x87,
  0xC7, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x00, 0x7F, 0xEF,
  0xFD, 0xFF, 0xBF, 0xFF, 0xFC, 0x3D, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x38, 0x00, 0xFF, 0x00, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x7E, 0xFC, 0x7E, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F,
  0x9F, 0x07, 0xCF, 0x87, 0xE7, 0xC3, 0xF7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0,
  0x7C, 0xF8, 0x3E, 0xFC, 0x3F, 0x7C, 0x1F, 0xBE, 0x0F, 0x9F, 0x07, 0xCF,
  0x87, 0xE7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7F, 0xF8,
  0x3F, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x0F,
  0xC0, 0xFE, 0x1F, 0xE1, 0xFF, 0x1F, 0xF9, 0xFF, 0xDF, 0xFC, 0x7B, 0xE3,
  0x9F, 0x08, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x3E, 0x3F,
  0x01, 0x83, 0xF0, 0x10, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0,
  0x00, 0x1E, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE,
  0x07, 0x0F, 0xC0, 0x41, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x07, 0xFC, 0x00, 0xFE, 0x00,
  0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x80, 0x3F, 0x1E,
  0x3F, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xBE, 0x00, 0xFF, 0x80, 0x1D, 0xF0,
  0x07, 0xBE, 0x01, 0xE7, 0xC0, 0x39, 0xF0, 0x0F, 0x3E, 0x03, 0xC7, 0xC0,
  0x70, 0xF8, 0x1E, 0x1F, 0x07, 0x87, 0xC0, 0xE0, 0xF8, 0x3F, 0xFF, 0xE7,
  0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0xF0,
  0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x21, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xE2, 0x03, 0xF8, 0xF3, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC0,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x81, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xF9, 0xE0, 0x3E, 0xFC, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFF, 0xF8, 0x7E, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xF8,
  0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x87, 0xE3, 0xE1, 0xF8, 0xF8, 0xFC, 0x3F,
  0x7F, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xF0, 0x00, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x7F,
  0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xF0, 0xF8, 0xF8, 0x3F, 0x7E, 0x07,
  0xFF, 0x01, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF,
  0x87, 0xE3, 0xE1, 0xF0, 0xFC, 0xFC, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3,
  0xE0, 0x7C, 0xF8, 0x3E, 0x3F, 0x1F, 0x8F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F,
  0xF8, 0x07, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F,
  0xFE, 0x0F, 0xFF, 0x83, 0xF3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3F, 0x1F, 0x0F,
  0xC7, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3E, 0x0F, 0x8F, 0x87, 0xE3,
  0xF3, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0xFD, 0xF0, 0x1C,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC,
  0x20, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x00,
  0x03, 0x01, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x07, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0x80, 0x00, 0xE0, 0x1F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x1F,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0,
  0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFF, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFE,
  0x01, 0xFC, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x20, 0x00, 0x00, 0x01, 0xC0,
  0x1F, 0xF0, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0x0F, 0xC4, 0x0F, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0x00, 0xF0, 0x1E,
  0x00, 0x38, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x0F, 0x07, 0xC3, 0x8F,
  0x0F, 0xF9, 0xC7, 0x0F, 0xF8, 0xE7, 0x8F, 0x1C, 0x73, 0x87, 0x1E, 0x39,
  0xC7, 0x8F, 0x1D, 0xE3, 0x87, 0x0E, 0xE3, 0xC3, 0x8F, 0x71, 0xE3, 0xC7,
  0xF8, 0xE1, 0xE3, 0xBC, 0x70, 0xE1, 0xDE, 0x78, 0xF1, 0xEE, 0x3C, 0x78,
  0xE7, 0x1E, 0x7C, 0xF3, 0x87, 0xFF, 0xF1, 0xC3, 0xF7, 0xF0, 0xE0, 0xF1,
  0xF0, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xF0, 0x1C, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x3D, 0xF0, 0x03, 0xDF, 0x00,
  0x7D, 0xF0, 0x07, 0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0x9F, 0x01, 0xF1, 0xF0,
  0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0x83,
  0xF1, 0xF0, 0x3F, 0x3F, 0x03, 0xF3, 0xE0, 0x3F, 0x3E, 0x03, 0xF7, 0xE0,
  0x3F, 0xFC, 0x03, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0x07, 0xC3, 0xF0, 0x7C, 0x3F, 0x07, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0x83, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xE0, 0xF8, 0xFC, 0x1F, 0xFF,
  0x81, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0x1F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0xC3, 0xE0, 0xFC, 0x3E, 0x0F, 0x87, 0xE0, 0xF8, 0x7C,
  0x1F, 0x87, 0xC1, 0xF8, 0x7C, 0x7F, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F,
  0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0x1C, 0x0F, 0xE0, 0x40, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x04, 0x07, 0xFB, 0xC0, 0x7F, 0xFC,
  0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x1F,
  0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xE1, 0xF8,
  0x1F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0,
  0x7E, 0x1F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xF8, 0x7C, 0x0F, 0xC3,
  0xE0, 0x7E, 0x1F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC1, 0xF8, 0x7C, 0x0F,
  0xC3, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0xC7, 0xF0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F,
  0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F,
  0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xFE,
  0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF8, 0x1F, 0xE1, 0xC0, 0xFE, 0x01, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE1, 0xFF, 0x1F, 0x87, 0xF8, 0x7E, 0x1F, 0xE1,
  0xF0, 0xFF, 0x87, 0xC0, 0x7E, 0x3F, 0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xF0,
  0x1F, 0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xFE, 0x7E,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0x03, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xE0,
  0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F,
  0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0x03,
  0xF0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7E,
  0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0xC0,
  0xF8, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x8F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x7E, 0x07,
  0xC1, 0xF0, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x80, 0x7C, 0x3E, 0x00, 0xF8,
  0xFC, 0x01, 0xF3, 0xF0, 0x07, 0xE7, 0xC0, 0x0F, 0x9F, 0x80, 0x1F, 0x7E,
  0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7E, 0xF8, 0x00,
  0xF9, 0xF0, 0x01, 0xF3, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F,
  0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x7E, 0x03, 0xF0,
  0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7F,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x03, 0xFC,
  0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x07,
  0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0x83,
  0xDF, 0x03, 0xDE, 0x1F, 0xF8, 0x1F, 0x78, 0x7B, 0xE0, 0x7D, 0xE1, 0xEF,
  0x81, 0xF7, 0x8F, 0x3E, 0x07, 0xDE, 0x3D, 0xF0, 0x1E, 0x79, 0xF7, 0xC0,
  0xF9, 0xE7, 0x9F, 0x03, 0xE7, 0xBE, 0x7C, 0x0F, 0x9F, 0xF1, 0xF0, 0x3E,
  0x7F, 0xCF, 0x81, 0xF1, 0xFE, 0x3E, 0x07, 0xC7, 0xF8, 0xF8, 0x1F, 0x1F,
  0xC3, 0xE0, 0x7C, 0x7F, 0x0F, 0x81, 0xF1, 0xFC, 0x7C, 0x0F, 0x87, 0xE1,
  0xF0, 0x3E, 0x1F, 0x87, 0xC0, 0xF8, 0x7C, 0x1F, 0x00, 0x03, 0xF0, 0x1F,
  0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x1F, 0x07, 0xF8, 0x1F, 0x07, 0xF8, 0x3E,
  0x07, 0xF8, 0x3E, 0x07, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3C,
  0x0F, 0xFC, 0x7C, 0x0F, 0xFC, 0x7C, 0x0F, 0x7C, 0x7C, 0x1F, 0x3C, 0x7C,
  0x1F, 0x3C, 0x78, 0x1F, 0x3C, 0xF8, 0x1F, 0x3E, 0xF8, 0x1E, 0x3E, 0xF8,
  0x3E, 0x3E, 0xF8, 0x3E, 0x1E, 0xF0, 0x3E, 0x1F, 0xF0, 0x3E, 0x1F, 0xF0,
  0x7C, 0x1F, 0xF0, 0x7C, 0x1F, 0xF0, 0x7C, 0x1F, 0xE0, 0x7C, 0x0F, 0xE0,
  0x78, 0x0F, 0xE0, 0xF8, 0x0F, 0xE0, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0,
  0x00, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x03, 0xF1, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x1F, 0x81, 0xF8,
  0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xE0, 0x1F, 0xBF, 0x00,
  0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3E, 0x7E, 0x03, 0xF3, 0xE0, 0x1F, 0x9F,
  0x00, 0xFD, 0xF8, 0x07, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x3F,
  0x0F, 0x81, 0xF8, 0x7E, 0x1F, 0x83, 0xFB, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xC7, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0xFC, 0x1F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0xF8,
  0x3F, 0x1F, 0x87, 0xE1, 0xF8, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xE0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xF1, 0xFC,
  0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0xF8, 0x0F, 0xCF, 0xC0,
  0x7E, 0x7E, 0x03, 0xF3, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF,
  0xC0, 0x3E, 0x7E, 0x03, 0xF3, 0xE0, 0x1F, 0x9F, 0x00, 0xFD, 0xF8, 0x07,
  0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x3F, 0x0F, 0x81, 0xF8, 0x7E,
  0x1F, 0x83, 0xFB, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x7C, 0x7E, 0x0F, 0x87,
  0xC1, 0xF0, 0xF8, 0x7E, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F,
  0x87, 0xC3, 0xE1, 0xF8, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xF0,
  0x1F, 0xFC, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xE0,
  0xFC, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xE3,
  0xF0, 0xFC, 0x7C, 0x0F, 0x8F, 0x81, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xFE,
  0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xBC, 0x07, 0xE0,
  0x40, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x04, 0x03, 0xF0, 0x60, 0x7E, 0x07, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0xFC, 0x1F,
  0x03, 0xE0, 0xFC, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF8, 0x3E, 0x07,
  0xC1, 0xF8, 0x1F, 0x07, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0xC1,
  0xF0, 0x3E, 0x0F, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x83, 0xE0,
  0x7E, 0x0F, 0x81, 0xF0, 0x7E, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xFC,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x0F, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xF8, 0x07, 0xFF, 0x01, 0xFB, 0xE0, 0x3E, 0x7C,
  0x07, 0xCF, 0x81, 0xF9, 0xF0, 0x3E, 0x3E, 0x0F, 0xC7, 0xC1, 0xF0, 0xF8,
  0x3E, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0x81, 0xF1,
  0xF0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0x00, 0x3F, 0xE0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x0F, 0x80, 0xFB, 0xE0, 0x7C, 0x0F, 0xDF, 0x03, 0xE0, 0x7C,
  0xF8, 0x3F, 0x03, 0xE7, 0x81, 0xF8, 0x3E, 0x7C, 0x1F, 0xC1, 0xF3, 0xE0,
  0xFE, 0x1F, 0x9F, 0x07, 0xF0, 0xF8, 0xF8, 0x7F, 0x87, 0xC7, 0xC3, 0xFC,
  0x7C, 0x3E, 0x1F, 0xE3, 0xE1, 0xF1, 0xEF, 0x1F, 0x0F, 0x8F, 0x79, 0xF0,
  0x7C, 0xFF, 0xCF, 0x83, 0xE7, 0xBE, 0xFC, 0x1F, 0x3D, 0xF7, 0xC0, 0xFB,
  0xCF, 0xBE, 0x07, 0xDE, 0x7B, 0xE0, 0x3F, 0xF3, 0xDF, 0x01, 0xFF, 0x1E,
  0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xC7, 0xFC, 0x03, 0xFC, 0x3F, 0xC0,
  0x1F, 0xE1, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x3F,
  0x83, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x7E, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x8F, 0xC0, 0x1F,
  0x1F, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7D, 0xF0, 0x01,
  0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7C,
  0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x00, 0xF8,
  0x1F, 0xFC, 0x0F, 0xBE, 0x0F, 0xDF, 0x07, 0xCF, 0x87, 0xC7, 0xC3, 0xE1,
  0xF3, 0xE0, 0xF9, 0xF0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0xF8,
  0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x83, 0xC1, 0xE0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xC1, 0xE0, 0xF0,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x7C, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x7F,
  0xC0, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x0F, 0x78, 0x07, 0xDF, 0x01, 0xE7, 0xC0, 0xF8, 0xF0, 0x7C, 0x3C,
  0x1E, 0x0F, 0x8F, 0x83, 0xE7, 0xC0, 0x79, 0xF0, 0x1E, 0xF8, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x7C, 0x7E, 0x3E, 0x1E, 0x1F, 0x01, 0xC0,
  0x01, 0xFD, 0xF0, 0xFF, 0x7C, 0x7F, 0xFF, 0x1F, 0xFF, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x07, 0xCF, 0xC1, 0xF3, 0xF0,
  0x7C, 0xFC, 0x1F, 0x3E, 0x0F, 0xCF, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x7E,
  0x3E, 0x1F, 0x8F, 0xCF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xDF, 0x03,
  0xE7, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xCE, 0x03, 0xEF,
  0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xC7, 0xE1, 0xF1, 0xF8, 0x7C,
  0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x3F, 0x3E,
  0x0F, 0x8F, 0x83, 0xE7, 0xE0, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3D, 0xFE, 0x0F, 0x3F, 0x00,
  0x00, 0xF0, 0x07, 0xFC, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0xC7, 0xE1, 0x0F,
  0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x23, 0xF1, 0x87,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x01, 0xC7, 0xC0, 0x7F, 0x7C, 0x0F, 0xF7, 0xC0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xF1, 0xF8, 0x3E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7C, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F,
  0x0F, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87,
  0xE0, 0xFC, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFB, 0xC0, 0x3E,
  0x7C, 0x00, 0x00, 0xF0, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0x9F,
  0x3F, 0x1F, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C, 0x3E, 0x7C, 0x7E, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x18, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xF9, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x1F, 0xDF, 0x03, 0xFD, 0xF0, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFC, 0x7E, 0x0F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0x7C, 0x3F, 0x07, 0xC3, 0xE0, 0xFC, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x83, 0xE1, 0xF8, 0x3F, 0x3F, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFD, 0xF0, 0x0F, 0xBF, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x08, 0x0F, 0xC0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xCE, 0x03, 0xEF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFF, 0x0F, 0xFF, 0xC7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3F, 0x1F,
  0x0F, 0x87, 0xC3, 0xE3, 0xF0, 0xF8, 0xF8, 0x3E, 0x3E, 0x1F, 0x8F, 0x87,
  0xC7, 0xE1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x0F, 0xC7, 0xC3, 0xE3,
  0xF0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x87, 0xE0, 0x01, 0xE0, 0x7C,
  0x0F, 0x83, 0xF0, 0x7C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x3E,
  0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x1F,
  0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x0F,
  0x81, 0xF0, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0xFC, 0x3E, 0x1F, 0x07, 0xC7, 0xC0, 0xF9, 0xF8, 0x3E, 0x7E, 0x07,
  0xCF, 0x80, 0xFB, 0xE0, 0x1F, 0xFC, 0x03, 0xDF, 0x00, 0xFF, 0xC0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xF7, 0xE0, 0x7C,
  0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xE1, 0xF0,
  0x7C, 0x3E, 0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x81,
  0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F,
  0x80, 0xF8, 0x00, 0x00, 0x0E, 0x07, 0x01, 0xE7, 0xF3, 0xF8, 0x3D, 0xFE,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0x1F, 0xCF, 0xC7,
  0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0xF8, 0x3E, 0x1F, 0x1F, 0x0F, 0x83, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xE0, 0xF8, 0x7C, 0x7C, 0x3E, 0x0F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7C, 0x1F, 0x0F, 0x8F, 0x83,
  0xC1, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x80, 0x00, 0x0E, 0x03,
  0xCF, 0xE0, 0xF7, 0xF8, 0x3D, 0xFF, 0x0F, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8,
  0x7C, 0x7C, 0x3F, 0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E,
  0x3E, 0x0F, 0x8F, 0x87, 0xC3, 0xE1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F,
  0x07, 0xC7, 0xC3, 0xE3, 0xF0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x87,
  0xE0, 0x00, 0xF0, 0x03, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F,
  0x1F, 0x3E, 0x1F, 0x7E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0xFC, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x7E, 0xF8,
  0x7E, 0xFC, 0xFC, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x00,
  0x03, 0x80, 0x3C, 0xFE, 0x03, 0xDF, 0xE0, 0x3D, 0xFF, 0x03, 0xFF, 0xF0,
  0x7E, 0x1F, 0x07, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x0F, 0x81, 0xF0, 0xF8, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF8, 0xFC, 0x1F, 0x9F, 0x83, 0xFF,
  0xF8, 0x3F, 0xFF, 0x03, 0xEF, 0xE0, 0x3E, 0xFC, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0,
  0x01, 0xFC, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xC7, 0xE3,
  0xE1, 0xF8, 0xF8, 0x7E, 0x7C, 0x1F, 0x9F, 0x07, 0xC7, 0xC1, 0xF3, 0xF0,
  0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E,
  0x3E, 0x1F, 0x8F, 0xCF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xDF, 0x03,
  0xEF, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0x00, 0x8E, 0x1E, 0x7C, 0x3D, 0xF8, 0x7B, 0xE0, 0xFF, 0xC3, 0xFF,
  0x87, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x0F,
  0xFC, 0x3F, 0xF8, 0xFF, 0xF1, 0xFB, 0xC7, 0xE0, 0x8F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFC, 0x01, 0xF9, 0x03, 0xF3, 0x8F, 0xC7, 0xFF, 0x8F, 0xFE,
  0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F,
  0x81, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF1, 0xF0, 0x1F, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78,
  0x0F, 0x80, 0xF8, 0x0F, 0xF8, 0xFF, 0x87, 0xF8, 0x3F, 0x80, 0x1F, 0x07,
  0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x3E, 0x0F, 0x8F, 0x87, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x3F, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0x78, 0x1F, 0x9E, 0x00,
  0xF8, 0x1F, 0xBC, 0x0F, 0x9E, 0x0F, 0x8F, 0x07, 0xC7, 0x87, 0xC3, 0xC3,
  0xE1, 0xE1, 0xE0, 0xF1, 0xF0, 0x78, 0xF8, 0x3C, 0xF8, 0x1E, 0x7C, 0x0F,
  0x7C, 0x07, 0xBE, 0x03, 0xDE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x78,
  0x3F, 0x0F, 0xBC, 0x3F, 0x87, 0xDE, 0x1F, 0xC7, 0xCF, 0x0F, 0xE3, 0xE7,
  0x8F, 0xE1, 0xE7, 0xC7, 0xF1, 0xF3, 0xE7, 0xF8, 0xF9, 0xF3, 0xFC, 0xF8,
  0xF9, 0xFE, 0x7C, 0x7D, 0xEF, 0x3C, 0x3E, 0xF7, 0xBE, 0x1F, 0x7B, 0xDF,
  0x0F, 0xF9, 0xEF, 0x07, 0xFC, 0xFF, 0x83, 0xFC, 0x7F, 0x81, 0xFE, 0x3F,
  0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3,
  0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x7C,
  0x3E, 0x03, 0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFB, 0xC0,
  0x1F, 0xBE, 0x01, 0xF3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x7C, 0x3F,
  0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0xFC, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x00,
  0xF8, 0x7C, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF9,
  0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0x0F,
  0xFF, 0x07, 0xFF, 0x87, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x03, 0xF8, 0x1F, 0xE0,
  0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFC, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0xFF, 0xC0, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFA, 0x00, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 12, 29, 10, 0, -29 },
  { 45, 14, 10, 16, 4, -29 },
  { 63, 21, 29, 20, 0, -29 },
  { 140, 19, 33, 17, 0, -31 },
  { 219, 26, 30, 29, 2, -30 },
  { 317, 21, 30, 21, 0, -30 },
  { 396, 7, 10, 10, 4, -29 },
  { 405, 13, 35, 11, 1, -29 },
  { 462, 14, 36, 11, -3, -30 },
  { 525, 16, 17, 17, 3, -31 },
  { 559, 16, 19, 19, 2, -24 },
  { 597, 9, 11, 10, -2, -5 },
  { 610, 11, 5, 12, 0, -14 },
  { 617, 6, 6, 10, 0, -6 },
  { 622, 21, 30, 15, -2, -30 },
  { 701, 17, 30, 17, 1, -30 },
  { 765, 13, 29, 18, 4, -29 },
  { 813, 20, 30, 17, -2, -30 },
  { 888, 19, 30, 17, -1, -30 },
  { 960, 19, 29, 18, -1, -29 },
  { 1029, 18, 29, 17, 0, -29 },
  { 1095, 18, 30, 17, 1, -30 },
  { 1163, 19, 29, 17, 1, -29 },
  { 1232, 18, 30, 17, 0, -30 },
  { 1300, 18, 30, 17, 0, -30 },
  { 1368, 10, 23, 10, 0, -23 },
  { 1397, 12, 29, 10, -2, -23 },
  { 1441, 16, 19, 19, 2, -24 },
  { 1479, 16, 13, 19, 2, -21 },
  { 1505, 17, 19, 19, 2, -24 },
  { 1546, 15, 30, 14, 1, -30 },
  { 1603, 25, 33, 27, 1, -30 },
  { 1707, 20, 29, 19, -3, -29 },
  { 1780, 20, 29, 19, 0, -29 },
  { 1853, 20, 30, 18, 1, -30 },
  { 1928, 21, 29, 21, 0, -29 },
  { 2005, 18, 29, 16, 0, -29 },
  { 2071, 18, 29, 16, 0, -29 },
  { 2137, 22, 30, 22, 1, -30 },
  { 2220, 23, 29, 22, 0, -29 },
  { 2304, 18, 29, 13, -2, -29 },
  { 2370, 18, 38, 10, -6, -29 },
  { 2456, 23, 29, 19, 0, -29 },
  { 2540, 13, 29, 16, 0, -29 },
  { 2588, 30, 29, 29, 0, -29 },
  { 2697, 24, 29, 23, 0, -29 },
  { 2784, 21, 30, 22, 1, -30 },
  { 2863, 20, 29, 19, 0, -29 },
  { 2936, 21, 37, 22, 1, -30 },
  { 3034, 19, 29, 19, 0, -29 },
  { 3103, 20, 30, 17, -1, -30 },
  { 3178, 16, 29, 16, 3, -29 },
  { 3236, 22, 29, 21, 1, -29 },
  { 3316, 19, 29, 19, 4, -29 },
  { 3385, 29, 29, 29, 3, -29 },
  { 3491, 23, 29, 18, -2, -29 },
  { 3575, 17, 29, 17, 4, -29 },
  { 3637, 21, 29, 16, -2, -29 },
  { 3714, 17, 36, 12, -2, -29 },
  { 3791, 9, 30, 15, 4, -30 },
  { 3825, 16, 36, 12, -3, -29 },
  { 3897, 18, 17, 18, 0, -29 },
  { 3936, 14, 2, 13, -4, 4 },
  { 3940, 8, 6, 12, 6, -31 },
  { 3946, 18, 23, 19, 1, -23 },
  { 3998, 18, 31, 19, 0, -31 },
  { 4068, 15, 23, 15, 1, -23 },
  { 4112, 20, 31, 19, 1, -31 },
  { 4190, 16, 23, 17, 1, -23 },
  { 4236, 21, 41, 11, -5, -31 },
  { 4344, 20, 33, 19, -1, -23 },
  { 4427, 18, 31, 19, 0, -31 },
  { 4497, 11, 31, 9, 0, -31 },
  { 4540, 16, 41, 9, -5, -31 },
  { 4622, 19, 31, 17, 0, -31 },
  { 4696, 12, 31, 9, 0, -31 },
  { 4743, 27, 23, 28, 0, -23 },
  { 4821, 18, 23, 19, 0, -23 },
  { 4873, 16, 23, 18, 1, -23 },
  { 4919, 20, 33, 19, -2, -23 },
  { 5002, 18, 33, 19, 1, -23 },
  { 5077, 15, 23, 13, 0, -23 },
  { 5121, 15, 23, 15, 0, -23 },
  { 5165, 12, 27, 12, 1, -27 },
  { 5206, 18, 22, 19, 1, -22 },
  { 5256, 17, 22, 16, 2, -22 },
  { 5303, 25, 22, 25, 2, -22 },
  { 5372, 20, 22, 17, -2, -22 },
  { 5427, 22, 32, 16, -3, -22 },
  { 5515, 17, 22, 14, -2, -22 },
  { 5562, 17, 35, 14, 0, -29 },
  { 5637, 5, 40, 15, 5, -31 },
  { 5662, 15, 35, 14, -2, -29 },
  { 5728, 17, 7, 19, 2, -18 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic41pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC41PT7B_H_
