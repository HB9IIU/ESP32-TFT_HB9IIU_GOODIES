#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC38PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x1F, 0x07, 0xE0, 0xFC, 0x1F,
  0x03, 0xE0, 0x00, 0x7C, 0xFB, 0xE7, 0x9E, 0x3C, 0xF3, 0xEF, 0x9F, 0x78,
  0xF3, 0xC7, 0x9E, 0x3C, 0xF1, 0xE7, 0x1E, 0x00, 0x00, 0x71, 0xE0, 0x1E,
  0x38, 0x03, 0xCF, 0x00, 0x71, 0xE0, 0x0E, 0x38, 0x03, 0xCF, 0x00, 0x71,
  0xE0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x83, 0xC7,
  0x00, 0x71, 0xE0, 0x0E, 0x38, 0x03, 0xC7, 0x00, 0x79, 0xE0, 0x7F, 0xFF,
  0x9F, 0xFF, 0xE3, 0xFF, 0xFC, 0x0E, 0x3C, 0x01, 0xC7, 0x00, 0x79, 0xE0,
  0x0E, 0x3C, 0x01, 0xC7, 0x00, 0x78, 0xE0, 0x0E, 0x3C, 0x03, 0xC7, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x1F, 0xC0, 0x3F, 0xF8,
  0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xDE, 0x0F, 0x22, 0x0F, 0xB0, 0x07, 0xD8,
  0x03, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x37, 0xC0, 0x1B, 0xE2, 0x09, 0xF1,
  0xC5, 0xF1, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x1F, 0xF8, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xC0,
  0x78, 0x1F, 0xC0, 0xF0, 0x3F, 0xE0, 0xF0, 0x39, 0xE1, 0xE0, 0x79, 0xE1,
  0xC0, 0x79, 0xE3, 0xC0, 0x71, 0xE3, 0x80, 0xF1, 0xE7, 0x80, 0xF1, 0xC7,
  0x00, 0xF1, 0xCF, 0x00, 0xE3, 0xCE, 0x18, 0xE3, 0x9E, 0x7E, 0xE7, 0xBC,
  0xFE, 0xFF, 0x3D, 0xFF, 0xFF, 0x79, 0xCF, 0x7E, 0x73, 0xCF, 0x10, 0xF3,
  0x8F, 0x00, 0xE3, 0x8F, 0x01, 0xE7, 0x8E, 0x01, 0xC7, 0x8E, 0x03, 0xC7,
  0x1E, 0x03, 0x87, 0x1E, 0x07, 0x87, 0x1C, 0x07, 0x07, 0x3C, 0x0F, 0x07,
  0xF8, 0x1E, 0x07, 0xF0, 0x1E, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xE0,
  0x0F, 0xFC, 0x01, 0xE7, 0x80, 0x7C, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0,
  0x3C, 0xF8, 0x07, 0x9E, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xE3, 0xC7, 0xFC, 0xF9, 0xFF, 0x9E, 0x7C, 0xFF, 0xCF,
  0x9F, 0xFB, 0xE3, 0xFE, 0x7C, 0x3F, 0x8F, 0x87, 0xF1, 0xF0, 0x7C, 0x3E,
  0x3F, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFE, 0x3E, 0x00,
  0x7D, 0xF7, 0xDE, 0xFB, 0xEF, 0x3C, 0xF3, 0xC0, 0x01, 0xF0, 0x1E, 0x03,
  0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E,
  0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8,
  0x07, 0x80, 0x78, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x18,
  0xF0, 0x7B, 0x87, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0x0F, 0xFC, 0x7F, 0x03,
  0xFE, 0x1F, 0x78, 0x7D, 0xF0, 0xE3, 0xC1, 0x0C, 0x00, 0x20, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1F, 0x1F,
  0x1F, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0x78, 0xF0, 0x7F, 0xDF, 0xF7, 0xFD,
  0xFF, 0xFF, 0xC0, 0x39, 0xFF, 0xFF, 0xFB, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x20, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE1, 0xF3,
  0xC7, 0xC7, 0x8F, 0x0F, 0x3E, 0x1E, 0x7C, 0x3D, 0xF0, 0x7B, 0xE1, 0xF7,
  0xC3, 0xEF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x7D, 0xF0, 0xFB, 0xE1,
  0xF7, 0x87, 0xCF, 0x0F, 0x9E, 0x1F, 0x3C, 0x7C, 0x7D, 0xF8, 0xFF, 0xE1,
  0xFF, 0x81, 0xFE, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0x07, 0xE0, 0xFE,
  0x1F, 0xE7, 0xFE, 0xFF, 0xCF, 0xBC, 0x77, 0xC6, 0x7C, 0x07, 0xC0, 0x78,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x00, 0x00,
  0x10, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x81, 0xE3,
  0xF0, 0x70, 0xFC, 0x08, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0x00, 0x08, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0xC0, 0xC3, 0xF0, 0x20, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x1F, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x88, 0x07, 0xE3, 0x83, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE,
  0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xBC, 0x01,
  0xFF, 0x00, 0x77, 0xC0, 0x39, 0xF0, 0x1E, 0x78, 0x07, 0x1E, 0x03, 0xCF,
  0x81, 0xE3, 0xE0, 0x70, 0xF8, 0x3C, 0x3C, 0x1F, 0xFF, 0xE7, 0xFF, 0xF1,
  0xFF, 0xFC, 0x7F, 0xFF, 0x20, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF,
  0xC0, 0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE0,
  0x21, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC4, 0x07, 0xE3, 0x07, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F,
  0xF0, 0x3F, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x98, 0x07, 0xBF, 0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF1,
  0xF8, 0xF8, 0xFC, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x87,
  0xC7, 0xC7, 0xE3, 0xE3, 0xE1, 0xF3, 0xF0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F,
  0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x10, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xFD,
  0xF8, 0x7C, 0x7C, 0x3C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x8F, 0x83,
  0xEF, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0xF0,
  0x3F, 0xFC, 0x3F, 0x3E, 0x1F, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC1,
  0xF3, 0xE0, 0xF1, 0xF0, 0xF8, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x03,
  0xF8, 0x00, 0x00, 0x10, 0x01, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0x0F, 0xFF,
  0x0F, 0x9F, 0x1F, 0x0F, 0x1F, 0x0F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F,
  0x3E, 0x1F, 0x3E, 0x3F, 0x3E, 0x3F, 0x3F, 0xFF, 0x3F, 0xFE, 0x1F, 0xFE,
  0x0F, 0xBE, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8,
  0x03, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x07, 0x07,
  0xC7, 0xE3, 0xF1, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x7C, 0x7E, 0x3F, 0x1F, 0x0F, 0x80, 0x01, 0xC0,
  0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x7C,
  0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x1E, 0x00, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFE, 0x0F, 0xF0,
  0x7F, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0x80, 0x03,
  0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0xFE, 0x00, 0xFC, 0x07, 0xF8, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0,
  0x7C, 0x00, 0xE0, 0x01, 0x00, 0x00, 0x00, 0x80, 0x7F, 0x8F, 0xFE, 0x7F,
  0xF3, 0xFF, 0x88, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x0F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x1F, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0xE0, 0x01, 0xC3, 0x80, 0x03,
  0x8F, 0x0F, 0xE7, 0x1C, 0x3F, 0xCE, 0x78, 0xFF, 0x9C, 0xE3, 0xCF, 0x3B,
  0xCF, 0x1C, 0x77, 0x1C, 0x38, 0xEE, 0x38, 0xF1, 0xDC, 0xF1, 0xE3, 0xF9,
  0xE3, 0x8E, 0xE3, 0x87, 0x1D, 0xC7, 0x1E, 0x3B, 0x8E, 0x3C, 0xE7, 0x1E,
  0xFB, 0xCE, 0x3F, 0xFF, 0x1C, 0x3E, 0xFC, 0x38, 0x30, 0x60, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x18, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03,
  0xDE, 0x01, 0xF7, 0x80, 0x7D, 0xE0, 0x1E, 0x78, 0x0F, 0x9E, 0x03, 0xC7,
  0x81, 0xF1, 0xE0, 0x7C, 0x78, 0x1E, 0x1E, 0x0F, 0xFF, 0x83, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x3E, 0x07, 0x8F, 0x81, 0xE3, 0xE0, 0x79, 0xF0,
  0x1E, 0x7C, 0x07, 0xBE, 0x01, 0xEF, 0x80, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xC3, 0xE1, 0xF1, 0xF8, 0x7F, 0xFC, 0x1F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x0F, 0xC7, 0xC7, 0xE1,
  0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFC, 0x00, 0x00, 0x08, 0x00,
  0x3F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xF8, 0x40, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x60, 0x7F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xC0,
  0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7D, 0xFE,
  0x1F, 0x8F, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C,
  0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x0F, 0xC7, 0xC1, 0xF9,
  0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC1, 0xF8, 0xF8, 0x3E, 0x3F, 0x0F, 0xC7,
  0xC1, 0xF0, 0xF8, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F,
  0xFE, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xE0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F,
  0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0xFF, 0xE0, 0xFE, 0x0C, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC3, 0xFC,
  0x7C, 0x3F, 0xC7, 0xC3, 0xFC, 0x7C, 0x7F, 0x8F, 0xC0, 0xF8, 0xFC, 0x0F,
  0x8F, 0xC0, 0xF8, 0xFC, 0x0F, 0x8F, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1,
  0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x07,
  0xE0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x1F,
  0x07, 0xE0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C,
  0x1F, 0x07, 0xC0, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x83,
  0xF0, 0xFC, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x01,
  0x3F, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x00, 0x00, 0x03,
  0xC1, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x8F, 0xC0, 0x78, 0x7C,
  0x07, 0xC7, 0xC0, 0x3E, 0x7E, 0x01, 0xF3, 0xE0, 0x0F, 0xBE, 0x00, 0x7B,
  0xF0, 0x07, 0xDF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xF3, 0xC0, 0x0F, 0x1F,
  0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F,
  0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x80, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF0,
  0x0F, 0xE0, 0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0xF7, 0x81, 0xFF, 0x0F, 0x78, 0x1E, 0xF1, 0xEF,
  0x81, 0xEF, 0x1E, 0xF8, 0x1E, 0xF3, 0xEF, 0x83, 0xEF, 0x3C, 0xF0, 0x3E,
  0xF3, 0xDF, 0x03, 0xC7, 0xF9, 0xF0, 0x3C, 0x7F, 0x9F, 0x07, 0xC7, 0xF1,
  0xE0, 0x7C, 0x7F, 0x1E, 0x07, 0xC7, 0xE3, 0xE0, 0x78, 0x7E, 0x3E, 0x07,
  0x87, 0xE3, 0xE0, 0xF8, 0x7C, 0x3C, 0x0F, 0x87, 0xC3, 0xC0, 0xF8, 0x78,
  0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x0F, 0xC0, 0x78, 0x1F, 0x81, 0xF0, 0x3F,
  0x83, 0xE0, 0x7F, 0x07, 0xC1, 0xFE, 0x0F, 0x03, 0xFC, 0x1E, 0x07, 0xF8,
  0x7C, 0x0F, 0xF8, 0xF8, 0x1F, 0xF1, 0xF0, 0x7D, 0xE3, 0xC0, 0xFB, 0xC7,
  0x81, 0xE7, 0x9F, 0x03, 0xCF, 0x3E, 0x07, 0x9F, 0x78, 0x1F, 0x3E, 0xF0,
  0x3E, 0x3D, 0xE0, 0x78, 0x7F, 0xC0, 0xF0, 0xFF, 0x83, 0xE1, 0xFE, 0x07,
  0xC3, 0xFC, 0x0F, 0x83, 0xF8, 0x1E, 0x07, 0xF0, 0x3C, 0x0F, 0xE0, 0xF8,
  0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xC0, 0x7E, 0x00, 0x00, 0x08, 0x00, 0x1F,
  0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0x8F, 0xC3, 0xE0,
  0xF8, 0xFC, 0x1F, 0x1F, 0x03, 0xE7, 0xE0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01,
  0xF7, 0xE0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x3F, 0xFC, 0x07,
  0xDF, 0x80, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xCF, 0xC0, 0xF9, 0xF8, 0x3F,
  0x1F, 0x0F, 0xC3, 0xF3, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0,
  0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7C, 0x7E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83,
  0xE1, 0xF0, 0xFC, 0x7C, 0x1F, 0x0F, 0x87, 0xE1, 0xF1, 0xF8, 0x3F, 0xFF,
  0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x1F,
  0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0x8F, 0xC3, 0xE0,
  0xF8, 0xFC, 0x1F, 0x1F, 0x03, 0xE7, 0xE0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01,
  0xF7, 0xE0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x3F, 0xFC, 0x07,
  0xDF, 0x80, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0xF9, 0xF8, 0x3F,
  0x1F, 0x0F, 0xC3, 0xF3, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0,
  0x07, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x1F, 0xFF, 0x07, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xC3, 0xF1, 0xF0, 0xF8, 0x7C, 0x7E, 0x1F, 0xFF, 0x07, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xC7, 0x81,
  0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xE1, 0xF8, 0xF8,
  0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE0, 0x00, 0x08, 0x00, 0x3F, 0xE0, 0x1F,
  0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x81, 0xF8, 0xE0, 0xFC, 0x08, 0x3F, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x86, 0x07, 0xE1, 0xE7, 0xF0,
  0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xE0, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xF0,
  0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7C,
  0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F,
  0xC1, 0xF0, 0xF8, 0x3F, 0x0F, 0xC3, 0xE0, 0xFC, 0x7E, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xF8, 0x07, 0xFE, 0x03,
  0xEF, 0x80, 0xFB, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xC7, 0x83, 0xE1,
  0xE0, 0xF8, 0x78, 0x7C, 0x1E, 0x1F, 0x07, 0x87, 0x81, 0xE3, 0xE0, 0x78,
  0xF8, 0x1E, 0x7C, 0x07, 0x9F, 0x01, 0xE7, 0x80, 0x7B, 0xE0, 0x1E, 0xF0,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x03,
  0xFF, 0x03, 0xE0, 0xFB, 0xE0, 0x7C, 0x1F, 0x7C, 0x1F, 0x83, 0xCF, 0x83,
  0xF0, 0xF9, 0xF0, 0xFC, 0x1F, 0x3E, 0x1F, 0x83, 0xC7, 0xC3, 0xF0, 0xF8,
  0xF8, 0xFE, 0x1F, 0x1F, 0x1F, 0xC7, 0xC3, 0xE7, 0xF8, 0xF8, 0x7C, 0xFF,
  0x1E, 0x0F, 0x9F, 0xE7, 0xC1, 0xF7, 0xBC, 0xF8, 0x3C, 0xF7, 0xBE, 0x07,
  0xBC, 0xF7, 0xC0, 0xF7, 0x9E, 0xF0, 0x1E, 0xF3, 0xFE, 0x03, 0xFC, 0x7F,
  0xC0, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F,
  0x87, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0,
  0x03, 0xE0, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8,
  0x7C, 0x03, 0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0,
  0x0F, 0x9F, 0x00, 0x78, 0x78, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0x03, 0xE0,
  0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0xBC, 0x0F, 0x9F, 0x0F, 0x8F, 0x87,
  0xC7, 0xC7, 0xC3, 0xE3, 0xC1, 0xF3, 0xE0, 0xF9, 0xE0, 0x7D, 0xF0, 0x1E,
  0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xF0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF,
  0x80, 0xF0, 0xF0, 0xF0, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0x78, 0x07,
  0x9E, 0x07, 0x8F, 0x07, 0xC7, 0x83, 0xC3, 0xC3, 0xC1, 0xF3, 0xE0, 0x79,
  0xE0, 0x3D, 0xF0, 0x1F, 0x7F, 0xFB, 0xFF, 0xFF, 0xFE, 0xF9, 0xF1, 0xF3,
  0xE3, 0xC3, 0xC0, 0x03, 0xC7, 0x87, 0xF7, 0xC7, 0xFB, 0xC3, 0xFF, 0xE3,
  0xF3, 0xF1, 0xF1, 0xF9, 0xF0, 0xFC, 0xF8, 0x7C, 0x7C, 0x3E, 0x7C, 0x1F,
  0x3E, 0x0F, 0x9F, 0x07, 0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF1,
  0xF8, 0xF9, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xDF, 0x07, 0xCF, 0x80,
  0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xBE, 0x07, 0xFF, 0x83, 0xFF, 0xC3,
  0xFF, 0xF1, 0xF9, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3C, 0x1F, 0x3E, 0x0F,
  0x9F, 0x07, 0xCF, 0x07, 0xC7, 0x83, 0xE3, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0,
  0xF8, 0xF8, 0x7C, 0x7E, 0x7C, 0x7F, 0xFE, 0x3F, 0xFE, 0x1E, 0xFE, 0x0F,
  0x3E, 0x00, 0x03, 0xF8, 0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x3F, 0x10, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x43, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x3F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xCF,
  0x81, 0xFD, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xF3, 0xF0, 0x7C, 0x7E,
  0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8,
  0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0,
  0xF8, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xBC, 0x03, 0xE7, 0x00,
  0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xF3, 0xE3, 0xE7, 0x87, 0xDF,
  0x0F, 0x3E, 0x1E, 0x79, 0xFD, 0xFF, 0xF3, 0xFF, 0xC7, 0xFE, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x11, 0xF9, 0xE1, 0xFF, 0xC3,
  0xFF, 0x83, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x07, 0xE4, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF1, 0xE0, 0x7F, 0x7C, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFC, 0xFC, 0x1F,
  0x1F, 0x87, 0xC3, 0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0x87, 0xC1, 0xF0, 0xF8,
  0x3E, 0x1F, 0x07, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF1,
  0xF8, 0x3E, 0x7E, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFB,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x80, 0xFC, 0x18, 0x3F,
  0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xBE, 0x07, 0xBF, 0x83, 0xFF, 0xC3, 0xFF,
  0xE1, 0xF9, 0xF8, 0xF8, 0x7C, 0x7C, 0x3C, 0x3C, 0x3E, 0x3E, 0x1F, 0x1F,
  0x0F, 0x8F, 0x87, 0xC7, 0x83, 0xC3, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8,
  0xF8, 0x7C, 0x78, 0x3C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x87,
  0x80, 0x01, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xC0, 0x00, 0x00, 0x0F,
  0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x81, 0x3E, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x87, 0xC3, 0xC3,
  0xE0, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x3E, 0x07, 0xDF, 0x01, 0xEF, 0x80,
  0x7B, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x1F, 0xBC, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0x78, 0xF8, 0x3E, 0x3E,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x78, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80,
  0x0F, 0x3E, 0x1E, 0x07, 0xBF, 0xBF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF1, 0xF9, 0xF8, 0xF8, 0xF8, 0xFC, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3E,
  0x1E, 0x3E, 0x1F, 0x1F, 0x1F, 0x0F, 0x0F, 0x8F, 0x87, 0x87, 0xC7, 0x87,
  0xC3, 0xC3, 0xC3, 0xE1, 0xE3, 0xE1, 0xE1, 0xF1, 0xF0, 0xF0, 0xF8, 0xF8,
  0xF8, 0x7C, 0x78, 0x7C, 0x3C, 0x7C, 0x3E, 0x1E, 0x3E, 0x1E, 0x1F, 0x1F,
  0x0F, 0x0F, 0x8F, 0x0F, 0x87, 0xC0, 0x0F, 0x3E, 0x07, 0xBF, 0x83, 0xFF,
  0xC3, 0xFF, 0xE1, 0xF9, 0xF8, 0xF8, 0x78, 0x7C, 0x3C, 0x3C, 0x3E, 0x3E,
  0x1F, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0x83, 0xC3, 0xC3, 0xE3, 0xE1, 0xF1,
  0xF0, 0xF8, 0xF8, 0x7C, 0x78, 0x3C, 0x3C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F,
  0x8F, 0x87, 0x80, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF3, 0xF3,
  0xE7, 0xC7, 0xDF, 0x0F, 0xBE, 0x1F, 0x78, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x0F, 0xBE, 0x1F, 0x7C, 0x7E, 0xF8, 0xF9, 0xFF,
  0xE1, 0xFF, 0xC3, 0xFF, 0x01, 0xF8, 0x00, 0x03, 0xCF, 0x80, 0x7B, 0xF8,
  0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x7E, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8,
  0x3C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xE0,
  0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x1F, 0x07,
  0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xEF, 0x80, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC7, 0x83, 0xF7, 0xC3,
  0xFF, 0xC3, 0xFF, 0xE3, 0xF3, 0xF1, 0xF1, 0xF9, 0xF0, 0xF8, 0xF8, 0x7C,
  0x7C, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0x8F, 0x83, 0xC7, 0xC3,
  0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F,
  0xFF, 0x07, 0xEF, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x3C, 0x3D, 0xF0, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00,
  0x07, 0xF0, 0x3F, 0xF1, 0xFF, 0xC7, 0xFE, 0x3E, 0x18, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0x1F, 0x00, 0x7C, 0x83, 0xF3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF0, 0xFF,
  0x80, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xFE, 0x7F, 0xDF, 0xFB, 0xFF,
  0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x00,
  0x1F, 0x0F, 0x1E, 0x0F, 0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1E,
  0x3C, 0x1E, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x7C,
  0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x78, 0xF8, 0xF8, 0xF9, 0xF8, 0xFF, 0xF8,
  0xFF, 0x78, 0xFF, 0xF0, 0x7E, 0xF0, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xF7,
  0xC3, 0xEF, 0x87, 0x9F, 0x1F, 0x3E, 0x3C, 0x7C, 0xF8, 0x79, 0xE0, 0xF3,
  0xC1, 0xEF, 0x83, 0xDE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80,
  0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x7C,
  0x1F, 0xF0, 0xF8, 0x7F, 0xE3, 0xF0, 0xF7, 0xC7, 0xE3, 0xEF, 0x8F, 0xC7,
  0xDF, 0x3F, 0x8F, 0x3E, 0x7F, 0x3E, 0x7D, 0xFE, 0x78, 0xFB, 0xFC, 0xF1,
  0xF7, 0x7B, 0xE3, 0xDE, 0xF7, 0x87, 0xBD, 0xEF, 0x0F, 0x73, 0xFC, 0x1F,
  0xE7, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xF8,
  0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0x83, 0xE0, 0x00, 0x07,
  0xC3, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE7, 0xC0, 0x3C, 0xF0, 0x07,
  0xBE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7B,
  0xE0, 0x1F, 0x7C, 0x07, 0xCF, 0x80, 0xF8, 0xF0, 0x3E, 0x1F, 0x0F, 0x83,
  0xE0, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0xC1, 0xE0, 0x3C, 0x3E, 0x03,
  0xC3, 0xC0, 0x3C, 0x7C, 0x03, 0xC7, 0xC0, 0x3C, 0xF8, 0x03, 0xCF, 0x80,
  0x3C, 0xF0, 0x03, 0xDF, 0x00, 0x3D, 0xE0, 0x03, 0xDE, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE1,
  0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0xFE, 0x01, 0xFE, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0,
  0x7F, 0x80, 0x7F, 0x00, 0x78, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x0F,
  0xC0, 0x3F, 0x01, 0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0xC0,
  0x3F, 0x00, 0x3C, 0x07, 0xF0, 0x3F, 0xC1, 0xF8, 0x07, 0xC0, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x03,
  0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xF0, 0x00, 0x00, 0x01, 0x7F, 0x81, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x80, 0x18,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 11, 27, 10, 0, -27 },
  { 39, 13, 10, 15, 4, -27 },
  { 56, 19, 27, 18, 0, -27 },
  { 121, 17, 31, 16, 0, -29 },
  { 187, 24, 28, 27, 2, -28 },
  { 271, 19, 27, 20, 0, -27 },
  { 336, 6, 10, 9, 4, -27 },
  { 344, 12, 33, 10, 1, -27 },
  { 394, 13, 34, 10, -3, -28 },
  { 450, 14, 16, 16, 3, -29 },
  { 478, 15, 19, 18, 2, -23 },
  { 514, 8, 10, 9, -2, -5 },
  { 524, 10, 5, 11, 0, -13 },
  { 531, 6, 6, 9, 0, -6 },
  { 536, 19, 27, 14, -2, -27 },
  { 601, 15, 28, 16, 1, -28 },
  { 654, 12, 27, 16, 4, -27 },
  { 695, 18, 28, 16, -1, -28 },
  { 758, 18, 28, 16, -1, -28 },
  { 821, 18, 27, 16, -1, -27 },
  { 882, 17, 27, 16, 0, -27 },
  { 940, 17, 28, 16, 1, -28 },
  { 1000, 17, 27, 16, 1, -27 },
  { 1058, 17, 28, 16, 0, -28 },
  { 1118, 16, 28, 16, 0, -28 },
  { 1174, 9, 21, 9, 0, -21 },
  { 1198, 11, 26, 9, -2, -21 },
  { 1234, 16, 18, 18, 1, -23 },
  { 1270, 16, 11, 18, 1, -19 },
  { 1292, 15, 18, 18, 2, -23 },
  { 1326, 13, 28, 13, 1, -28 },
  { 1372, 23, 30, 25, 1, -27 },
  { 1459, 18, 27, 18, -2, -27 },
  { 1520, 18, 27, 18, 0, -27 },
  { 1581, 18, 28, 17, 1, -28 },
  { 1644, 19, 27, 20, 0, -27 },
  { 1709, 17, 27, 15, 0, -27 },
  { 1767, 17, 27, 15, 0, -27 },
  { 1825, 20, 28, 20, 1, -28 },
  { 1895, 21, 27, 20, 0, -27 },
  { 1966, 17, 27, 12, -2, -27 },
  { 2024, 17, 35, 9, -6, -27 },
  { 2099, 21, 27, 18, 0, -27 },
  { 2170, 12, 27, 15, 0, -27 },
  { 2211, 28, 27, 26, 0, -27 },
  { 2306, 23, 27, 21, 0, -27 },
  { 2384, 19, 28, 21, 1, -28 },
  { 2451, 19, 27, 17, 0, -27 },
  { 2516, 19, 34, 21, 1, -28 },
  { 2597, 18, 27, 18, 0, -27 },
  { 2658, 18, 28, 16, -1, -28 },
  { 2721, 15, 27, 15, 3, -27 },
  { 2772, 20, 27, 20, 1, -27 },
  { 2840, 18, 27, 18, 3, -27 },
  { 2901, 27, 27, 27, 3, -27 },
  { 2993, 21, 27, 17, -2, -27 },
  { 3064, 17, 27, 16, 3, -27 },
  { 3122, 19, 27, 15, -2, -27 },
  { 3187, 16, 33, 11, -2, -27 },
  { 3253, 8, 27, 14, 4, -27 },
  { 3280, 15, 33, 11, -3, -27 },
  { 3342, 17, 16, 16, 0, -27 },
  { 3376, 13, 3, 12, -4, 3 },
  { 3381, 7, 6, 11, 6, -29 },
  { 3387, 17, 21, 18, 1, -21 },
  { 3432, 17, 29, 17, 0, -29 },
  { 3494, 14, 21, 14, 1, -21 },
  { 3531, 19, 29, 18, 1, -29 },
  { 3600, 15, 21, 16, 1, -21 },
  { 3640, 19, 38, 11, -4, -29 },
  { 3731, 19, 30, 18, -1, -21 },
  { 3803, 17, 29, 17, 0, -29 },
  { 3865, 10, 29, 9, 0, -29 },
  { 3902, 15, 38, 9, -5, -29 },
  { 3974, 18, 29, 16, 0, -29 },
  { 4040, 11, 29, 9, 0, -29 },
  { 4080, 25, 21, 26, 0, -21 },
  { 4146, 17, 21, 17, 0, -21 },
  { 4191, 15, 21, 17, 1, -21 },
  { 4231, 19, 30, 17, -2, -21 },
  { 4303, 17, 30, 17, 1, -21 },
  { 4367, 14, 21, 12, 0, -21 },
  { 4404, 14, 21, 14, 0, -21 },
  { 4441, 11, 25, 11, 1, -25 },
  { 4476, 16, 21, 17, 1, -21 },
  { 4518, 15, 21, 15, 2, -21 },
  { 4558, 23, 21, 23, 2, -21 },
  { 4619, 19, 21, 15, -2, -21 },
  { 4669, 20, 30, 15, -3, -21 },
  { 4744, 15, 21, 13, -1, -21 },
  { 4784, 16, 33, 13, 0, -27 },
  { 4850, 4, 38, 14, 5, -29 },
  { 4869, 14, 33, 13, -2, -27 },
  { 4927, 16, 7, 18, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic38pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC38PT7B_H_
