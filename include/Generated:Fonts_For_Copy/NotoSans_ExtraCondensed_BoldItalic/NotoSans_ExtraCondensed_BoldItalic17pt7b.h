#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC17PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x63, 0x31, 0x8C, 0x02, 0x39, 0x80, 0xDF, 0x6D, 0xA6,
  0x0D, 0x0D, 0x86, 0xCF, 0xF7, 0xF1, 0xB0, 0x91, 0xFE, 0xFE, 0x34, 0x16,
  0x1B, 0x00, 0x04, 0x0E, 0x3F, 0x3A, 0x38, 0x38, 0x3C, 0x1C, 0x1E, 0x9E,
  0xFC, 0xFC, 0x20, 0x20, 0x71, 0x8B, 0x23, 0x6C, 0x6D, 0x09, 0x61, 0x6B,
  0xBB, 0xD8, 0x5A, 0x1A, 0x46, 0x58, 0xCB, 0x31, 0xC0, 0x1E, 0x0B, 0x0D,
  0x86, 0xC3, 0xC1, 0xC5, 0xEC, 0xDE, 0xCE, 0x67, 0x3F, 0x8E, 0xE0, 0xFB,
  0x60, 0x0C, 0x63, 0x0C, 0x61, 0x86, 0x18, 0xC3, 0x0C, 0x30, 0xC1, 0x06,
  0x00, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x19, 0x8C, 0x66, 0x63, 0x00, 0x18,
  0xB3, 0xF9, 0xF3, 0x8D, 0x8A, 0x00, 0x30, 0x60, 0xC7, 0xFF, 0xE6, 0x0C,
  0x18, 0x76, 0x6C, 0x7F, 0x80, 0x5F, 0x00, 0x03, 0x81, 0x81, 0x80, 0xC0,
  0xC0, 0x60, 0x60, 0x30, 0x30, 0x38, 0x18, 0x18, 0x00, 0x1E, 0x7C, 0xDB,
  0x36, 0x6C, 0xD9, 0xF7, 0xCD, 0x9B, 0xE3, 0x80, 0x1B, 0xFF, 0xE3, 0x18,
  0xCC, 0x63, 0x19, 0xC0, 0x1F, 0x3F, 0x13, 0x03, 0x03, 0x06, 0x0C, 0x1C,
  0x38, 0x70, 0x7E, 0xFE, 0x3E, 0x3F, 0x07, 0x06, 0x0E, 0x38, 0x3C, 0x0C,
  0x0C, 0x8C, 0xFC, 0xF8, 0x07, 0x0E, 0x0E, 0x16, 0x3E, 0x2C, 0x6C, 0xCC,
  0xFE, 0xFE, 0x18, 0x18, 0x1F, 0x3E, 0x30, 0x30, 0x78, 0x7C, 0x4E, 0x0E,
  0x0C, 0x8C, 0xFC, 0xF8, 0x0F, 0x1F, 0x30, 0x30, 0x6C, 0x7E, 0x66, 0xE6,
  0xEE, 0xEC, 0x7C, 0x78, 0x3F, 0x3F, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18,
  0x30, 0x30, 0x60, 0xE0, 0x1E, 0x37, 0x37, 0x36, 0x3E, 0x3C, 0x7C, 0xEC,
  0xCE, 0xCC, 0xFC, 0x78, 0x1E, 0x7D, 0xDB, 0x36, 0x6D, 0xDF, 0x9F, 0x0C,
  0x3B, 0xE7, 0x80, 0x37, 0x00, 0x00, 0x4E, 0xC0, 0x19, 0xC0, 0x00, 0x00,
  0x0E, 0x63, 0x30, 0x06, 0x3D, 0xE7, 0x0E, 0x07, 0x83, 0x81, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x81, 0xC1, 0xE0, 0xF1, 0xEF, 0x38, 0x40, 0x7C,
  0xF0, 0xC3, 0x18, 0xE3, 0x18, 0x00, 0x06, 0x38, 0x0F, 0xC3, 0x08, 0xC1,
  0x93, 0xD6, 0xD2, 0x92, 0xD6, 0xDA, 0xDA, 0xDA, 0xDB, 0xF1, 0x00, 0x30,
  0x83, 0xE0, 0x07, 0x0F, 0x0F, 0x0B, 0x1B, 0x1B, 0x33, 0x3F, 0x7F, 0x63,
  0x63, 0xC3, 0x3E, 0x3F, 0x33, 0x33, 0x37, 0x7C, 0x7E, 0x66, 0x66, 0xE6,
  0xFC, 0xF8, 0x1F, 0x3E, 0x70, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xF8, 0x78, 0x3E, 0x1F, 0x8C, 0xE6, 0x73, 0x3B, 0x99, 0x8C, 0xC6, 0x67,
  0x77, 0x3F, 0x1F, 0x00, 0x3F, 0x3E, 0x30, 0x30, 0x30, 0x7C, 0x7C, 0x60,
  0x60, 0xE0, 0xF8, 0xF8, 0x3F, 0x3E, 0x30, 0x30, 0x30, 0x7C, 0x7C, 0x60,
  0x60, 0xE0, 0xE0, 0xC0, 0x1F, 0x3F, 0x70, 0x60, 0xE0, 0xCF, 0xCE, 0xC6,
  0xC6, 0xCE, 0xFC, 0x7C, 0x39, 0xCC, 0x63, 0x18, 0xC6, 0x33, 0x9F, 0xC7,
  0xF1, 0x8C, 0x67, 0x39, 0xCE, 0x63, 0x18, 0x1F, 0x0C, 0x0C, 0x1C, 0x18,
  0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0xF8, 0x07, 0x06, 0x06, 0x06, 0x06,
  0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0xB8, 0x70, 0xE0, 0x39,
  0x99, 0x8D, 0xC6, 0xC3, 0xC3, 0xE1, 0xF0, 0xD8, 0x6C, 0x76, 0x33, 0x99,
  0xC0, 0x38, 0xC3, 0x0C, 0x31, 0xC6, 0x18, 0x63, 0x8F, 0xFE, 0x38, 0x73,
  0x87, 0x38, 0xF3, 0x8F, 0x39, 0xE6, 0xDE, 0x6F, 0x66, 0xF6, 0x6E, 0xEC,
  0xEC, 0xCC, 0xCC, 0xCC, 0x38, 0xCE, 0x33, 0x8C, 0xF6, 0x3D, 0x9B, 0x66,
  0xD9, 0xB4, 0x67, 0x31, 0xCC, 0x73, 0x1C, 0x1E, 0x3F, 0x63, 0x63, 0xE3,
  0xC3, 0xC7, 0xC7, 0xC6, 0xCE, 0xFC, 0x78, 0x3F, 0x3F, 0x33, 0x33, 0x33,
  0x77, 0x7E, 0x78, 0x60, 0xE0, 0xC0, 0xC0, 0x1E, 0x3F, 0x63, 0x63, 0xE3,
  0xC3, 0xC7, 0xC7, 0xC6, 0xCE, 0xFC, 0x78, 0x18, 0x18, 0x1C, 0x3E, 0x3F,
  0x33, 0x33, 0x37, 0x7E, 0x7C, 0x6C, 0x6C, 0xEC, 0xCE, 0xCE, 0x1F, 0x3E,
  0x70, 0x70, 0x30, 0x38, 0x1C, 0x0C, 0x0C, 0x8C, 0xFC, 0xF8, 0x7F, 0xFC,
  0xC1, 0x83, 0x06, 0x1C, 0x30, 0x60, 0xC1, 0x87, 0x00, 0x73, 0x63, 0x63,
  0x67, 0xE6, 0xE6, 0xC6, 0xCE, 0xCE, 0xCC, 0xFC, 0xF8, 0xC7, 0x9F, 0x36,
  0x6D, 0x9B, 0x3C, 0x78, 0xF1, 0xC3, 0x86, 0x00, 0x66, 0x3E, 0x63, 0xC6,
  0x6C, 0xE6, 0xCE, 0xED, 0xEC, 0xDE, 0xCD, 0x78, 0xF7, 0x8F, 0x78, 0xE7,
  0x0E, 0x70, 0x19, 0xC6, 0x61, 0xB0, 0x7C, 0x0E, 0x03, 0x01, 0xC0, 0x78,
  0x36, 0x0D, 0x86, 0x63, 0x98, 0xCF, 0x9B, 0x66, 0xCF, 0x1E, 0x38, 0x70,
  0xC1, 0x83, 0x06, 0x00, 0x1F, 0x8F, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x60,
  0x70, 0x30, 0x30, 0x1F, 0x9F, 0x80, 0x1E, 0x3C, 0x60, 0xC3, 0x06, 0x0C,
  0x18, 0x30, 0xC1, 0x83, 0x06, 0x0E, 0x3C, 0x00, 0xDB, 0x6D, 0x93, 0x6D,
  0xB0, 0x1E, 0x38, 0x30, 0x60, 0xC3, 0x06, 0x0C, 0x18, 0x60, 0xC1, 0x83,
  0x1E, 0x38, 0x00, 0x0C, 0x38, 0x71, 0xB2, 0x6C, 0xF1, 0x80, 0x7F, 0xF0,
  0xE6, 0x30, 0x3B, 0x77, 0x66, 0x66, 0xE6, 0xE6, 0xEE, 0xFC, 0x7C, 0x18,
  0x30, 0x30, 0x30, 0x3E, 0x76, 0x67, 0x66, 0x66, 0x66, 0xEE, 0xFC, 0xF8,
  0x3E, 0x69, 0x83, 0x0E, 0x1C, 0x38, 0x3C, 0x78, 0x01, 0x81, 0x80, 0xC0,
  0x63, 0xF1, 0xB9, 0x98, 0xCC, 0x66, 0x73, 0x33, 0x9F, 0x87, 0xC0, 0x3E,
  0x6D, 0x9B, 0x7F, 0x98, 0x30, 0x3E, 0x7C, 0x07, 0x83, 0x83, 0x81, 0xA1,
  0xE0, 0xF0, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x80, 0xC1,
  0xE0, 0xE0, 0x00, 0x3F, 0x37, 0x66, 0x66, 0xE6, 0xE6, 0xEE, 0xFC, 0x7C,
  0x0C, 0x1C, 0xF8, 0xF0, 0x18, 0x60, 0xC1, 0x83, 0xEE, 0xDD, 0xB3, 0x66,
  0xCF, 0xBE, 0x6C, 0xC0, 0x19, 0xC4, 0x03, 0x39, 0x8C, 0x63, 0x39, 0x8C,
  0x00, 0x06, 0x1C, 0x10, 0x00, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0xE1, 0x83,
  0x06, 0x0C, 0x70, 0xE0, 0x18, 0x30, 0x30, 0x30, 0x37, 0x76, 0x6C, 0x78,
  0x78, 0x7C, 0xCC, 0xCC, 0xCC, 0x19, 0x8C, 0x63, 0x39, 0x8C, 0x63, 0x39,
  0x8C, 0x00, 0x3F, 0xEE, 0xED, 0x99, 0xB3, 0x36, 0x6E, 0xDD, 0xB3, 0x36,
  0x66, 0xCC, 0xC0, 0x2E, 0xED, 0x9B, 0x36, 0x6C, 0xFB, 0x66, 0xCC, 0x3E,
  0xED, 0x9B, 0x3E, 0x78, 0xF3, 0xBE, 0x78, 0x17, 0x1D, 0x8C, 0xE6, 0x63,
  0x31, 0x99, 0xDC, 0xFC, 0x7C, 0x30, 0x18, 0x18, 0x0C, 0x00, 0x3F, 0x37,
  0x66, 0x66, 0x66, 0xE6, 0xEE, 0xFC, 0x7C, 0x0C, 0x0C, 0x18, 0x18, 0x3D,
  0xF7, 0x18, 0x61, 0x8E, 0x30, 0xC0, 0x3D, 0x96, 0x1C, 0x38, 0x61, 0xBE,
  0xF0, 0x23, 0x7C, 0xCC, 0x63, 0x18, 0xC7, 0x38, 0x33, 0x66, 0x66, 0x66,
  0x66, 0x6E, 0xEC, 0xFC, 0x7C, 0xCF, 0x9B, 0x66, 0xCD, 0x9E, 0x3C, 0x70,
  0xE0, 0xCC, 0xF7, 0x3D, 0xDB, 0x56, 0xFF, 0x3B, 0xCE, 0xF3, 0xB8, 0xCE,
  0x00, 0x3B, 0x8F, 0x87, 0x83, 0x81, 0xC1, 0xE0, 0xF0, 0xD8, 0xEE, 0x00,
  0x33, 0x99, 0x8D, 0x86, 0xC3, 0x61, 0xE0, 0xF0, 0x70, 0x38, 0x18, 0x0C,
  0x1C, 0x0E, 0x00, 0x3E, 0x0C, 0x30, 0xC1, 0x86, 0x1C, 0x3E, 0xFC, 0x0E,
  0x3C, 0x60, 0xC1, 0x86, 0x1C, 0x70, 0x70, 0xE1, 0x83, 0x06, 0x0E, 0x0C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x38, 0x30, 0xE1, 0x83, 0x07,
  0x86, 0x38, 0x60, 0xC1, 0x87, 0x1C, 0x30, 0x00, 0xF7, 0x7C,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 12, 4, 0, -12 },
  { 9, 6, 4, 7, 2, -12 },
  { 12, 9, 12, 8, 0, -12 },
  { 26, 8, 14, 7, 0, -13 },
  { 40, 11, 12, 12, 1, -12 },
  { 57, 9, 12, 9, 0, -12 },
  { 71, 3, 4, 4, 2, -12 },
  { 73, 6, 15, 5, 0, -12 },
  { 85, 5, 15, 5, -1, -12 },
  { 95, 7, 7, 7, 1, -13 },
  { 102, 7, 8, 8, 1, -10 },
  { 109, 4, 4, 4, -1, -2 },
  { 111, 5, 2, 5, 0, -6 },
  { 113, 3, 3, 4, 0, -3 },
  { 115, 9, 12, 6, -1, -12 },
  { 129, 7, 12, 7, 0, -12 },
  { 140, 5, 12, 7, 2, -12 },
  { 148, 8, 12, 7, -1, -12 },
  { 160, 8, 12, 7, 0, -12 },
  { 172, 8, 12, 7, 0, -12 },
  { 184, 8, 12, 7, 0, -12 },
  { 196, 8, 12, 7, 0, -12 },
  { 208, 8, 12, 7, 0, -12 },
  { 220, 8, 12, 7, 0, -12 },
  { 232, 7, 12, 7, 0, -12 },
  { 243, 4, 9, 4, 0, -9 },
  { 248, 5, 11, 4, -1, -9 },
  { 255, 7, 8, 8, 1, -10 },
  { 262, 7, 6, 8, 1, -9 },
  { 268, 7, 8, 8, 1, -10 },
  { 275, 6, 12, 6, 0, -12 },
  { 284, 11, 13, 11, 0, -12 },
  { 302, 8, 12, 8, -1, -12 },
  { 314, 8, 12, 8, 0, -12 },
  { 326, 8, 12, 7, 1, -12 },
  { 338, 9, 12, 9, 0, -12 },
  { 352, 8, 12, 7, 0, -12 },
  { 364, 8, 12, 7, 0, -12 },
  { 376, 8, 12, 9, 1, -12 },
  { 388, 10, 12, 9, 0, -12 },
  { 403, 8, 12, 5, -1, -12 },
  { 415, 8, 16, 4, -3, -12 },
  { 431, 9, 12, 8, 0, -12 },
  { 445, 6, 12, 7, 0, -12 },
  { 454, 12, 12, 12, 0, -12 },
  { 472, 10, 12, 10, 0, -12 },
  { 487, 8, 12, 9, 1, -12 },
  { 499, 8, 12, 8, 0, -12 },
  { 511, 8, 15, 9, 1, -12 },
  { 526, 8, 12, 8, 0, -12 },
  { 538, 8, 12, 7, 0, -12 },
  { 550, 7, 12, 7, 1, -12 },
  { 561, 8, 12, 9, 1, -12 },
  { 573, 7, 12, 8, 2, -12 },
  { 584, 12, 12, 12, 1, -12 },
  { 602, 10, 12, 7, -1, -12 },
  { 617, 7, 12, 7, 2, -12 },
  { 628, 9, 12, 7, -1, -12 },
  { 642, 7, 15, 5, -1, -12 },
  { 656, 3, 12, 6, 2, -12 },
  { 661, 7, 15, 5, -1, -12 },
  { 675, 7, 7, 7, 0, -12 },
  { 682, 6, 2, 6, -2, 1 },
  { 684, 4, 3, 5, 2, -13 },
  { 686, 8, 9, 8, 0, -9 },
  { 695, 8, 13, 8, 0, -13 },
  { 708, 7, 9, 6, 0, -9 },
  { 716, 9, 13, 8, 0, -13 },
  { 731, 7, 9, 7, 0, -9 },
  { 739, 9, 17, 5, -2, -13 },
  { 759, 8, 13, 8, 0, -9 },
  { 772, 7, 13, 8, 0, -13 },
  { 784, 5, 13, 4, 0, -13 },
  { 793, 7, 17, 4, -2, -13 },
  { 808, 8, 13, 7, 0, -13 },
  { 821, 5, 13, 4, 0, -13 },
  { 830, 11, 9, 11, 0, -9 },
  { 843, 7, 9, 8, 0, -9 },
  { 851, 7, 9, 8, 0, -9 },
  { 859, 9, 13, 8, -1, -9 },
  { 874, 8, 13, 8, 0, -9 },
  { 887, 6, 9, 5, 0, -9 },
  { 894, 6, 9, 6, 0, -9 },
  { 901, 5, 11, 5, 1, -11 },
  { 908, 8, 9, 8, 0, -9 },
  { 917, 7, 9, 7, 1, -9 },
  { 925, 10, 9, 10, 1, -9 },
  { 937, 9, 9, 7, -1, -9 },
  { 948, 9, 13, 7, -1, -9 },
  { 963, 7, 9, 6, -1, -9 },
  { 971, 7, 15, 6, 0, -12 },
  { 985, 2, 17, 6, 2, -13 },
  { 990, 7, 15, 6, -1, -12 },
  { 1004, 7, 2, 8, 1, -7 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic17pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC17PT7B_H_
