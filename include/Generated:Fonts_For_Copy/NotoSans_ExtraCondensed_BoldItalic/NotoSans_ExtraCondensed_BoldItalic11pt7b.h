#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC11PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xA4, 0x36, 0xFF, 0xA0, 0x38, 0xA7, 0xCC, 0x53, 0xE6, 0x28,
  0x13, 0xD8, 0xC3, 0x1B, 0xCC, 0x40, 0x4E, 0xAB, 0x37, 0xEC, 0xD5, 0x77,
  0x30, 0xA7, 0x0C, 0x7E, 0xE9, 0x3E, 0xF8, 0x32, 0x44, 0x4C, 0x88, 0xCC,
  0x33, 0x13, 0x32, 0x26, 0x4C, 0xAF, 0x6A, 0x21, 0x09, 0xF2, 0x10, 0x6B,
  0x00, 0xFC, 0xF0, 0x0C, 0x21, 0x84, 0x30, 0x86, 0x30, 0x33, 0xD6, 0xBD,
  0x6B, 0xDC, 0x36, 0xA2, 0x64, 0x44, 0x32, 0xC6, 0x23, 0x33, 0x1E, 0x3A,
  0xC6, 0xE7, 0x0A, 0xDC, 0x18, 0xCC, 0xA5, 0x7C, 0xC4, 0x3B, 0x10, 0xE1,
  0x0A, 0xDC, 0x19, 0x10, 0xED, 0x6B, 0x4C, 0x78, 0x44, 0x22, 0x11, 0x18,
  0x3A, 0xD6, 0xE7, 0x6A, 0x5C, 0x33, 0xD6, 0xB7, 0x08, 0xDC, 0x68, 0x0D,
  0x80, 0x32, 0x00, 0x06, 0x4C, 0x08, 0xD9, 0xC1, 0x84, 0xFF, 0xC1, 0xF0,
  0x87, 0x0E, 0x7E, 0x40, 0x75, 0x12, 0x44, 0x4C, 0x1C, 0x45, 0x7B, 0x5A,
  0xB5, 0xAF, 0x20, 0x78, 0x18, 0xC6, 0x72, 0xBD, 0x39, 0x3B, 0x5A, 0xF5,
  0xEF, 0x5E, 0x3C, 0xA6, 0x10, 0xC3, 0x0D, 0x1C, 0x39, 0xE6, 0xD3, 0x4B,
  0x6D, 0x38, 0x3B, 0x18, 0xE7, 0x63, 0x5C, 0x3B, 0x18, 0x87, 0x63, 0x18,
  0x1C, 0xD6, 0x11, 0xDB, 0x2D, 0x9E, 0x25, 0xB6, 0xDF, 0x7B, 0x2D, 0xB6,
  0x72, 0x26, 0x64, 0x4E, 0x08, 0xC6, 0x21, 0x08, 0xC6, 0x27, 0x00, 0x2D,
  0xA7, 0x1C, 0x71, 0x4D, 0x24, 0x26, 0x64, 0x4C, 0xDE, 0x23, 0x77, 0x77,
  0x76, 0x7A, 0x7A, 0xD6, 0x94, 0x26, 0xC9, 0xD2, 0xA5, 0xCB, 0x36, 0x4C,
  0x38, 0xB6, 0xD3, 0xCF, 0x2D, 0x9C, 0x3B, 0x5A, 0x97, 0xE3, 0x18, 0x38,
  0xB6, 0xD3, 0xCF, 0x2D, 0x9C, 0x30, 0x40, 0x3B, 0x5A, 0xB7, 0x3B, 0x52,
  0x3B, 0x50, 0xC3, 0x1A, 0xDC, 0xF6, 0x44, 0x4C, 0xC8, 0x25, 0xB6, 0xD2,
  0x4B, 0x6D, 0x9C, 0x9C, 0xA5, 0x6A, 0x73, 0x18, 0x93, 0x92, 0xB6, 0xB4,
  0xB4, 0xDC, 0xD8, 0xD8, 0x36, 0x78, 0x60, 0xC3, 0x07, 0x1E, 0x64, 0x9E,
  0xB9, 0xC4, 0x23, 0x10, 0x78, 0xC4, 0x46, 0x23, 0x1E, 0x36, 0x44, 0x4C,
  0xC8, 0x8C, 0xBD, 0x55, 0x38, 0x84, 0x23, 0x10, 0x84, 0x27, 0x00, 0x11,
  0x9C, 0xA8, 0x80, 0xF0, 0xC0, 0x7A, 0xF7, 0xAD, 0x78, 0x23, 0x1E, 0xB5,
  0xEF, 0x5E, 0x34, 0xCC, 0xD6, 0x0C, 0x27, 0x96, 0xDB, 0x4D, 0x3C, 0x32,
  0xFD, 0x8C, 0x38, 0x19, 0x8E, 0xC2, 0x11, 0x8C, 0x46, 0x20, 0x7A, 0xF7,
  0xAD, 0x78, 0xDC, 0xC0, 0x23, 0x1E, 0xB5, 0xEB, 0x56, 0x61, 0xA5, 0xB4,
  0x30, 0x32, 0x26, 0x64, 0x4C, 0x80, 0x23, 0x16, 0xA6, 0x7B, 0xD2, 0x2D,
  0x25, 0xB4, 0x7E, 0xB5, 0x4E, 0xBD, 0x76, 0x80, 0x7A, 0xD7, 0xAD, 0x48,
  0x72, 0xF7, 0xBD, 0x38, 0x3C, 0xB2, 0xDB, 0x69, 0xE4, 0x10, 0xC0, 0x7A,
  0xF7, 0xAD, 0x78, 0xC6, 0x20, 0x56, 0x4C, 0xC8, 0x74, 0x62, 0xAE, 0x27,
  0x44, 0x4C, 0xE0, 0x6A, 0xD7, 0xAD, 0x78, 0xBA, 0xAC, 0xC8, 0xB6, 0xFD,
  0xB6, 0xFA, 0xC0, 0x2C, 0xA3, 0x0C, 0x73, 0x60, 0x2C, 0xA2, 0x8C, 0x30,
  0xC2, 0x38, 0xC0, 0x73, 0x64, 0xCE, 0x19, 0x88, 0x4C, 0x61, 0x08, 0x43,
  0x00, 0xFF, 0xFF, 0xFC, 0x30, 0x84, 0x61, 0x98, 0x8C, 0x66, 0x00, 0x6D,
  0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 8, 3, 0, -8 },
  { 4, 4, 3, 4, 1, -8 },
  { 6, 6, 8, 5, 0, -8 },
  { 12, 5, 9, 5, 0, -8 },
  { 18, 6, 8, 8, 1, -8 },
  { 24, 6, 8, 6, 0, -8 },
  { 30, 2, 3, 3, 1, -8 },
  { 31, 4, 10, 3, 0, -8 },
  { 36, 4, 10, 3, -1, -8 },
  { 41, 4, 4, 5, 1, -8 },
  { 43, 5, 6, 5, 0, -7 },
  { 47, 3, 3, 3, -1, -1 },
  { 49, 3, 2, 3, 0, -4 },
  { 50, 2, 2, 3, 0, -2 },
  { 51, 6, 8, 4, -1, -8 },
  { 57, 5, 8, 5, 0, -8 },
  { 62, 4, 8, 5, 1, -8 },
  { 66, 5, 8, 5, 0, -8 },
  { 71, 5, 8, 5, 0, -8 },
  { 76, 5, 8, 5, 0, -8 },
  { 81, 5, 8, 5, 0, -8 },
  { 86, 5, 8, 5, 0, -8 },
  { 91, 5, 8, 5, 0, -8 },
  { 96, 5, 8, 5, 0, -8 },
  { 101, 5, 8, 5, 0, -8 },
  { 106, 3, 6, 3, 0, -6 },
  { 109, 4, 8, 3, -1, -6 },
  { 113, 5, 6, 5, 0, -7 },
  { 117, 5, 4, 5, 0, -6 },
  { 120, 5, 6, 5, 0, -7 },
  { 124, 4, 8, 4, 0, -8 },
  { 128, 7, 9, 7, 0, -8 },
  { 136, 5, 8, 5, -1, -8 },
  { 141, 5, 8, 5, 0, -8 },
  { 146, 6, 8, 5, 0, -8 },
  { 152, 6, 8, 6, 0, -8 },
  { 158, 5, 8, 4, 0, -8 },
  { 163, 5, 8, 4, 0, -8 },
  { 168, 6, 8, 6, 0, -8 },
  { 174, 6, 8, 6, 0, -8 },
  { 180, 4, 8, 3, 0, -8 },
  { 184, 5, 10, 3, -2, -8 },
  { 191, 6, 8, 5, 0, -8 },
  { 197, 4, 8, 4, 0, -8 },
  { 201, 8, 8, 8, 0, -8 },
  { 209, 7, 8, 6, 0, -8 },
  { 216, 6, 8, 6, 0, -8 },
  { 222, 5, 8, 5, 0, -8 },
  { 227, 6, 10, 6, 0, -8 },
  { 235, 5, 8, 5, 0, -8 },
  { 240, 5, 8, 5, 0, -8 },
  { 245, 4, 8, 4, 1, -8 },
  { 249, 6, 8, 6, 0, -8 },
  { 255, 5, 8, 5, 1, -8 },
  { 260, 8, 8, 8, 1, -8 },
  { 268, 7, 8, 5, -1, -8 },
  { 275, 5, 8, 5, 1, -8 },
  { 280, 5, 8, 4, 0, -8 },
  { 285, 4, 10, 3, 0, -8 },
  { 290, 2, 8, 4, 1, -8 },
  { 292, 5, 10, 3, -1, -8 },
  { 299, 5, 5, 5, 0, -8 },
  { 303, 4, 1, 4, -1, 1 },
  { 304, 2, 1, 3, 2, -8 },
  { 305, 5, 6, 5, 0, -6 },
  { 309, 5, 8, 5, 0, -8 },
  { 314, 4, 6, 4, 0, -6 },
  { 317, 6, 8, 5, 0, -8 },
  { 323, 5, 6, 5, 0, -6 },
  { 327, 5, 11, 3, -1, -8 },
  { 334, 5, 9, 5, 0, -6 },
  { 340, 5, 8, 5, 0, -8 },
  { 345, 3, 8, 3, 0, -8 },
  { 348, 4, 11, 3, -1, -8 },
  { 354, 5, 8, 5, 0, -8 },
  { 359, 3, 8, 3, 0, -8 },
  { 362, 7, 6, 7, 0, -6 },
  { 368, 5, 6, 5, 0, -6 },
  { 372, 5, 6, 5, 0, -6 },
  { 376, 6, 9, 5, -1, -6 },
  { 383, 5, 9, 5, 0, -6 },
  { 389, 4, 6, 4, 0, -6 },
  { 392, 4, 6, 4, 0, -6 },
  { 395, 4, 7, 3, 0, -7 },
  { 399, 5, 6, 5, 0, -6 },
  { 403, 4, 6, 4, 1, -6 },
  { 406, 6, 6, 7, 1, -6 },
  { 411, 6, 6, 4, -1, -6 },
  { 416, 6, 9, 4, -1, -6 },
  { 423, 4, 6, 4, 0, -6 },
  { 426, 5, 10, 4, 0, -8 },
  { 433, 2, 11, 4, 1, -8 },
  { 436, 5, 10, 4, -1, -8 },
  { 443, 5, 2, 5, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic11pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC11PT7B_H_
