#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC52PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0xC0, 0x3F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xC0, 0x02, 0x00,
  0x00, 0x3F, 0x9F, 0xCF, 0xC7, 0xF3, 0xF1, 0xF9, 0xFC, 0x7E, 0x7E, 0x1F,
  0x9F, 0x87, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3F, 0x1F, 0x0F, 0xCF,
  0xC3, 0xE3, 0xF0, 0xF8, 0xF8, 0x7E, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x03,
  0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x1F, 0x00,
  0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3C, 0x3E,
  0x00, 0x1F, 0x0F, 0x80, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x07, 0xC3, 0xE0, 0x01,
  0xF0, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0x80,
  0x03, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x00, 0xF8, 0x78, 0x00, 0x3C,
  0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xC0, 0x01, 0xE1, 0xF0, 0x00,
  0xF8, 0x7C, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0xC3, 0xE0,
  0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xF6, 0x38, 0x07, 0xE6, 0x08, 0x07,
  0xE6, 0x00, 0x07, 0xE6, 0x00, 0x07, 0xEE, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x37, 0xF0, 0x00, 0x37, 0xF0, 0x00, 0x33, 0xF0, 0x00, 0x33, 0xF0, 0x40,
  0x73, 0xF0, 0x70, 0x67, 0xF0, 0x7C, 0x6F, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x01,
  0xF0, 0x07, 0xF8, 0x01, 0xF0, 0x0F, 0xFC, 0x03, 0xE0, 0x1F, 0xFC, 0x07,
  0xC0, 0x3E, 0x3C, 0x07, 0xC0, 0x3E, 0x3E, 0x0F, 0x80, 0x3C, 0x3E, 0x0F,
  0x80, 0x7C, 0x3E, 0x1F, 0x00, 0x7C, 0x3C, 0x1F, 0x00, 0x78, 0x7C, 0x3E,
  0x00, 0xF8, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x7C,
  0x00, 0xF8, 0x78, 0xF8, 0x00, 0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0xF9, 0xF1,
  0xFC, 0xF1, 0xF3, 0xE3, 0xFE, 0xF9, 0xF3, 0xE7, 0xFF, 0xFF, 0xE7, 0xC7,
  0xFF, 0xFF, 0xE7, 0xCF, 0x9F, 0x7F, 0xCF, 0x8F, 0x1F, 0x3F, 0x8F, 0x9F,
  0x1F, 0x1C, 0x1F, 0x1E, 0x1F, 0x00, 0x1F, 0x3E, 0x1F, 0x00, 0x3E, 0x3E,
  0x1F, 0x00, 0x3E, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x1F, 0x00, 0xF8, 0x3C,
  0x3E, 0x00, 0xF8, 0x7C, 0x3E, 0x01, 0xF0, 0x7C, 0x3E, 0x01, 0xF0, 0x7C,
  0x7C, 0x03, 0xE0, 0x7C, 0x7C, 0x03, 0xE0, 0x7C, 0xF8, 0x07, 0xC0, 0x3F,
  0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0x80, 0x1F, 0xE0, 0x1F, 0x80, 0x1F,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x1F,
  0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x1F, 0x80, 0x07,
  0xE3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF7, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x83, 0xFF, 0x87, 0xE0, 0xFF, 0xF0, 0xFC,
  0x3F, 0xFF, 0x3F, 0x87, 0xEF, 0xE7, 0xE1, 0xFC, 0xFD, 0xFC, 0x7F, 0x1F,
  0xFF, 0x0F, 0xC3, 0xFF, 0xE1, 0xF8, 0x3F, 0xF8, 0x7F, 0x07, 0xFF, 0x0F,
  0xE0, 0xFF, 0xC1, 0xF8, 0x0F, 0xF8, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x7F,
  0xC0, 0xFF, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xCF, 0xE0, 0x3F, 0xE1, 0xFE, 0x00, 0x40, 0x00,
  0x00, 0x3F, 0x9F, 0xCF, 0xC7, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3E,
  0x3F, 0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x20, 0xF8, 0x03, 0x8F, 0x80, 0x7C, 0xF8, 0x27,
  0xFF, 0xBE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x3F, 0xFE,
  0x07, 0xF8, 0x10, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFB, 0xE0, 0x7F, 0x3F,
  0x03, 0xF3, 0xF0, 0x1E, 0x1F, 0x80, 0xC1, 0xE0, 0x04, 0x1C, 0x00, 0x01,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x0F, 0xE0,
  0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x07,
  0xE0, 0x7E, 0x0F, 0xC0, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0x7F, 0xF8, 0x1E, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x10, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFC,
  0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xEF, 0xE0, 0xFE,
  0x3F, 0x07, 0xE1, 0xF8, 0x7F, 0x0F, 0xC3, 0xF0, 0x7E, 0x3F, 0x83, 0xF1,
  0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0xFE, 0x07, 0xE7, 0xF0, 0x3F, 0x3F, 0x03,
  0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xE7, 0xE0, 0x3F, 0x3F,
  0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xE7, 0xF0, 0x7F,
  0x3F, 0x83, 0xF9, 0xF8, 0x1F, 0x8F, 0xC1, 0xFC, 0x7E, 0x0F, 0xC3, 0xF0,
  0xFE, 0x1F, 0xCF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFF, 0x3F, 0xBF, 0x0F, 0x9F,
  0x83, 0x8F, 0xC0, 0x8F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x07, 0xF3, 0xFE, 0x03, 0xE0, 0xFF, 0x00, 0xE0, 0x3F, 0x80, 0x60,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00,
  0xF9, 0xFF, 0x00, 0xC0, 0x7F, 0x00, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x80,
  0x0F, 0xF0, 0xC0, 0x1F, 0xE0, 0xFE, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1E, 0xFC, 0x00, 0x1E, 0xFC, 0x00,
  0x3D, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0x79, 0xF8, 0x00, 0xF1, 0xF8, 0x01,
  0xF3, 0xF8, 0x01, 0xE3, 0xF0, 0x03, 0xE3, 0xF0, 0x07, 0xC3, 0xF0, 0x07,
  0x83, 0xF0, 0x0F, 0x87, 0xF0, 0x1F, 0x07, 0xE0, 0x1E, 0x07, 0xE0, 0x3E,
  0x07, 0xE0, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x39, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x10, 0x03, 0xFC, 0x30, 0x0F, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x7F, 0xC1, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE3, 0xE0, 0x0F, 0xDF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xF8, 0x7F, 0x0F, 0xF0, 0xFE, 0x1F, 0xC1,
  0xFC, 0x3F, 0x83, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F,
  0xC7, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0,
  0x7F, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFC, 0x3F, 0x83,
  0xF8, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF8, 0x3F,
  0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0xFE, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xF3, 0xF8, 0x1F, 0xC7, 0xF0,
  0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE3, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0x8F,
  0xE0, 0x3F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF0, 0xFF,
  0x0F, 0xE1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x81, 0xFE, 0xFF, 0x03, 0xF8, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1,
  0xFC, 0x3F, 0x03, 0xF8, 0xFE, 0x07, 0xE1, 0xFC, 0x0F, 0xC3, 0xF8, 0x3F,
  0x87, 0xF0, 0x7F, 0x0F, 0xC0, 0xFE, 0x1F, 0x83, 0xFC, 0x3F, 0x87, 0xF8,
  0x7F, 0x1F, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x03, 0xF9, 0xF8, 0x03, 0xE7, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0xE1, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x07, 0xF0,
  0x7E, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x7F, 0x07,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7C, 0x01, 0x00, 0x00, 0x1C,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x0F,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xE0,
  0x1F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xC3, 0xF8,
  0x60, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x01, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xF8,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xF3, 0xFC,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x07, 0xC0, 0x7C, 0x0F,
  0x07, 0x81, 0xFF, 0x8F, 0x0F, 0x83, 0xFF, 0x8F, 0x0F, 0x07, 0xFF, 0x8F,
  0x1F, 0x0F, 0x8F, 0x8F, 0x1E, 0x1F, 0x0F, 0x0F, 0x3E, 0x1E, 0x1F, 0x0F,
  0x3E, 0x3E, 0x1F, 0x0F, 0x3C, 0x3C, 0x1F, 0x0F, 0x7C, 0x7C, 0x1E, 0x1F,
  0x7C, 0x7C, 0x3E, 0x1F, 0x78, 0x7C, 0x3E, 0x1E, 0x78, 0x78, 0x3E, 0x1E,
  0x78, 0x78, 0x3C, 0x3E, 0xF8, 0xF8, 0x7C, 0x3C, 0xF8, 0xF8, 0x7C, 0x3C,
  0xF8, 0xF8, 0xFC, 0x78, 0xF8, 0xF8, 0xFC, 0xF8, 0xF8, 0x7F, 0xFF, 0xF0,
  0xF8, 0x7F, 0xBF, 0xE0, 0xF8, 0x7F, 0x1F, 0xC0, 0xF8, 0x1E, 0x0F, 0x80,
  0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x08, 0x00, 0x3F, 0x80, 0x38, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xBF, 0x00, 0x1F,
  0xBF, 0x00, 0x1F, 0xBF, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x7E,
  0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0x01, 0xFC, 0x3F, 0x01, 0xF8, 0x3F, 0x03, 0xF8, 0x3F, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0x80,
  0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xC7, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x81,
  0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x3F, 0x03, 0xF8, 0x1F, 0x87, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x7F,
  0x80, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x3F, 0x80,
  0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xE0, 0x3F, 0x83, 0xF0,
  0x1F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0x7C,
  0x07, 0xFC, 0x08, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x01, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0x87, 0xFC, 0x0F,
  0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x01, 0xFC,
  0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01,
  0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE,
  0x03, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1,
  0xFC, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F,
  0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC1,
  0xFE, 0x07, 0xF1, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x04, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xEF, 0xE0, 0x3F,
  0xE0, 0x18, 0x07, 0xF8, 0x01, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0xFF, 0xE1,
  0xFC, 0x1F, 0xFC, 0x7F, 0x83, 0xFF, 0x8F, 0xF0, 0x7F, 0xF1, 0xFC, 0x1F,
  0xFC, 0x3F, 0x83, 0xFF, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F,
  0xC0, 0x1F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F,
  0xC1, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0x7E, 0x07, 0xFC, 0x1F, 0xC0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01,
  0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x87, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x03,
  0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0x83, 0xFC, 0x00, 0xFC, 0x1F, 0xC0,
  0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x1F,
  0x8F, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x7F,
  0x00, 0x03, 0xF7, 0xF8, 0x00, 0x1F, 0xBF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xBF,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3F,
  0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7E, 0x07,
  0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF0,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xDF, 0x80, 0x7F, 0xF8, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0xFB, 0xF8, 0x0F, 0xDF, 0x87, 0xEF, 0xC0, 0x3F, 0x7E, 0x1F,
  0x3F, 0x00, 0xFD, 0xF8, 0xFC, 0xFC, 0x03, 0xF3, 0xE3, 0xF7, 0xF0, 0x1F,
  0xCF, 0x8F, 0x9F, 0x80, 0x7E, 0x3E, 0x7E, 0x7E, 0x01, 0xF8, 0xF9, 0xF1,
  0xF8, 0x07, 0xE3, 0xEF, 0xCF, 0xE0, 0x1F, 0x8F, 0xBE, 0x3F, 0x80, 0xFC,
  0x3F, 0xF8, 0xFC, 0x03, 0xF0, 0xFF, 0xC3, 0xF0, 0x0F, 0xC3, 0xFF, 0x0F,
  0xC0, 0x3F, 0x0F, 0xFC, 0x7F, 0x01, 0xFC, 0x3F, 0xE1, 0xFC, 0x07, 0xE0,
  0xFF, 0x87, 0xE0, 0x1F, 0x83, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xF0, 0x7E,
  0x01, 0xF8, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x3F, 0x03,
  0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x7E,
  0x03, 0xFC, 0x01, 0xFC, 0x07, 0xFC, 0x03, 0xF0, 0x0F, 0xF8, 0x07, 0xE0,
  0x1F, 0xF0, 0x0F, 0xC0, 0x3F, 0xE0, 0x3F, 0x80, 0xFF, 0xC0, 0x7E, 0x01,
  0xFF, 0x80, 0xFC, 0x03, 0xFF, 0x81, 0xF8, 0x07, 0xFF, 0x03, 0xF0, 0x1F,
  0xFE, 0x0F, 0xE0, 0x3F, 0xFC, 0x1F, 0x80, 0x7F, 0xF8, 0x3F, 0x00, 0xFD,
  0xF0, 0x7E, 0x01, 0xFB, 0xF0, 0xFC, 0x07, 0xE7, 0xE3, 0xF8, 0x0F, 0xCF,
  0xC7, 0xE0, 0x1F, 0x9F, 0x8F, 0xC0, 0x3F, 0x1F, 0x1F, 0x80, 0x7E, 0x3E,
  0x3F, 0x01, 0xFC, 0x7E, 0xFE, 0x03, 0xF0, 0xFD, 0xF8, 0x07, 0xE1, 0xFB,
  0xF0, 0x0F, 0xC3, 0xF7, 0xE0, 0x1F, 0x83, 0xEF, 0xC0, 0x7E, 0x07, 0xFF,
  0x00, 0xFC, 0x0F, 0xFE, 0x01, 0xF8, 0x1F, 0xFC, 0x03, 0xF0, 0x3F, 0xF8,
  0x0F, 0xE0, 0x7F, 0xF0, 0x1F, 0x80, 0x7F, 0xC0, 0x3F, 0x00, 0xFF, 0x80,
  0x7E, 0x01, 0xFF, 0x00, 0xFC, 0x03, 0xFE, 0x03, 0xF8, 0x07, 0xFC, 0x07,
  0xE0, 0x0F, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xEF, 0xF8, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0,
  0x3F, 0xC3, 0xF8, 0x07, 0xF1, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x3F,
  0xC0, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFD, 0xFE, 0x00, 0x7F,
  0x7F, 0x80, 0x3F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF0, 0x03, 0xFB, 0xFC, 0x00,
  0xFE, 0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x1F, 0xEF, 0xE0, 0x07, 0xFB, 0xF8,
  0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xCF, 0xE0, 0x0F, 0xE3,
  0xF8, 0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x3F, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F,
  0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xF0,
  0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7E, 0x03, 0xF8, 0x3F, 0x81, 0xFE, 0x0F, 0xE0, 0xFF, 0x03, 0xF8,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xEF, 0xF8, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xF8, 0x07,
  0xF1, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x3F, 0xC0, 0x1F, 0xCF, 0xE0,
  0x07, 0xF3, 0xF8, 0x01, 0xFD, 0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x3F, 0xDF,
  0xC0, 0x0F, 0xF7, 0xF0, 0x03, 0xFB, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x3F,
  0xBF, 0xC0, 0x1F, 0xEF, 0xE0, 0x07, 0xFB, 0xF8, 0x01, 0xFC, 0xFE, 0x00,
  0x7F, 0x3F, 0x80, 0x3F, 0xCF, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF8, 0xFE,
  0x01, 0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xE0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xCF, 0xF8, 0x0F, 0xE1, 0xFC, 0x07,
  0xF0, 0xFF, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0,
  0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x83, 0xFC,
  0x1F, 0xC1, 0xFC, 0x0F, 0xE3, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7E, 0x7F,
  0x00, 0x3F, 0x3F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xE3,
  0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC,
  0x1F, 0x80, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x3F,
  0x81, 0xFC, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xF8, 0x38, 0x03, 0xF8,
  0x04, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x02, 0x00, 0x3F, 0x81, 0x80, 0x3F, 0x80, 0xF0, 0x3F,
  0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03,
  0xF8, 0x0F, 0xE0, 0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F,
  0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F,
  0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE,
  0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0,
  0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x1F, 0xC0,
  0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01,
  0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F,
  0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xFC, 0xFC, 0x01,
  0xFC, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x07,
  0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F,
  0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFE,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFD, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0xFC, 0x03, 0xFB, 0xF0, 0x0F, 0xC0, 0x1F, 0x9F, 0x80,
  0x7E, 0x01, 0xFC, 0xFC, 0x03, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x80, 0x7E,
  0x7F, 0x01, 0xFC, 0x07, 0xF3, 0xF8, 0x1F, 0xE0, 0x3F, 0x1F, 0xC0, 0xFF,
  0x03, 0xF8, 0xFE, 0x07, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0xC0, 0xFC, 0x3F,
  0x83, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0xF0, 0x7E, 0x0F, 0xE1, 0xFF, 0x87,
  0xF0, 0x7E, 0x0F, 0xFC, 0x3F, 0x83, 0xF0, 0xFF, 0xE1, 0xF8, 0x1F, 0x87,
  0xDF, 0x1F, 0xC0, 0xFC, 0x7E, 0xF8, 0xFC, 0x07, 0xE3, 0xE7, 0xC7, 0xE0,
  0x3F, 0x1F, 0x3E, 0x7F, 0x01, 0xF9, 0xF9, 0xF3, 0xF0, 0x0F, 0xCF, 0x9F,
  0xBF, 0x80, 0x7E, 0xFC, 0xFD, 0xF8, 0x03, 0xF7, 0xE7, 0xEF, 0xC0, 0x1F,
  0xBE, 0x3F, 0xFE, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xBF,
  0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFC,
  0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xFE, 0x00,
  0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xF8, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x0F,
  0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0x0F, 0xE0,
  0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x3F, 0x3F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0xFC,
  0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFE, 0x1F,
  0x80, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x07, 0xF0,
  0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE,
  0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE1, 0xFC, 0x1F, 0x87, 0xF0, 0x7E, 0x3F,
  0x81, 0xF8, 0xFC, 0x07, 0xE7, 0xF0, 0x1F, 0x9F, 0x80, 0x7E, 0xFE, 0x01,
  0xFB, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0x81, 0xF0, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xF7,
  0xE0, 0x07, 0xEF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x1F, 0x00, 0xFC, 0x3F,
  0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0xF8, 0x3E, 0x01, 0xF0,
  0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xDF, 0x80, 0x0F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0xFE, 0x7F, 0x3F, 0xCF, 0xE3,
  0xF1, 0xF8, 0x7E, 0x1F, 0x00, 0x78, 0x00, 0x03, 0xFC, 0xFC, 0x0F, 0xFD,
  0xF8, 0x3F, 0xFB, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xF8, 0xFF,
  0x0F, 0xE1, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xE3,
  0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFC, 0x7F,
  0x01, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0,
  0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x9F,
  0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xBF, 0x01, 0xFE, 0x7E,
  0x01, 0xF8, 0xF8, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x8F, 0x00, 0x7F, 0x7F, 0x80, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F,
  0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFC, 0x0F, 0xE1, 0xF8, 0x1F, 0xC7, 0xF0,
  0x3F, 0x8F, 0xC0, 0x7F, 0x1F, 0x80, 0xFE, 0x3F, 0x01, 0xF8, 0xFE, 0x07,
  0xF1, 0xFC, 0x0F, 0xE3, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0x0F, 0xC0, 0xFE,
  0x3F, 0x81, 0xFC, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xE1, 0xFE, 0x3F, 0x83,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3E, 0x7F, 0xC0, 0x7C,
  0x7F, 0x00, 0x00, 0x10, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xE0, 0x81, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x06, 0x0F, 0xF9, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x01, 0xE1, 0xF8, 0x01,
  0xFE, 0x7E, 0x00, 0xFF, 0xDF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x03,
  0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E,
  0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x87, 0xF8, 0x0F, 0xF3,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03,
  0xFE, 0xFC, 0x00, 0x7E, 0x3E, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFE,
  0x3F, 0x0F, 0xC1, 0xF1, 0xF8, 0x1F, 0x3F, 0x81, 0xF3, 0xF0, 0x3F, 0x3F,
  0x03, 0xF7, 0xF0, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F,
  0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x30, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x88,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x09, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xCF, 0xC0, 0x3F, 0xF7, 0xE0,
  0x3F, 0xFB, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xE3, 0xFC,
  0x0F, 0xE1, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x3F,
  0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03,
  0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0,
  0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0xC0, 0xFE,
  0x1F, 0xE0, 0x7F, 0x9F, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x03, 0xFE, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x08, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x20, 0x07, 0xF0, 0x1E, 0x0F, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x8F, 0x00, 0x7F, 0x7F,
  0x80, 0xFD, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x1F, 0xE3, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xC1,
  0xF8, 0x1F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0x81, 0xFC, 0x3F,
  0x03, 0xF0, 0xFE, 0x07, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xE0,
  0x7E, 0x0F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F,
  0xE1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0xE0, 0x7E, 0x1F, 0xC1, 0xFC,
  0x3F, 0x03, 0xF8, 0x7E, 0x07, 0xE0, 0x00, 0x10, 0x03, 0xF0, 0x0F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x03, 0x7F, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x10, 0x7F,
  0x07, 0xF0, 0x3F, 0x83, 0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0xC3, 0xF8, 0x07,
  0xE3, 0xF8, 0x07, 0xF1, 0xF8, 0x03, 0xF1, 0xFC, 0x01, 0xF9, 0xFC, 0x00,
  0xFD, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0x3F,
  0x00, 0x7E, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0xC1,
  0xF8, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xF8,
  0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x01, 0xE0, 0x1E, 0x01, 0xF9, 0xFE,
  0x3F, 0xC0, 0x7E, 0xFF, 0x9F, 0xF8, 0x1F, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x1F, 0xF1, 0xFC, 0x3F,
  0x83, 0xF8, 0x7F, 0x0F, 0xE0, 0xFC, 0x1F, 0xC3, 0xF0, 0x7F, 0x07, 0xE0,
  0xFC, 0x1F, 0xC1, 0xF8, 0x7F, 0x07, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x3F,
  0x87, 0xE0, 0x7E, 0x0F, 0xE1, 0xF8, 0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xE0,
  0xFC, 0x3F, 0x83, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F,
  0x07, 0xF0, 0xFC, 0x1F, 0xC1, 0xF8, 0x7F, 0x07, 0xE0, 0x7E, 0x1F, 0xC1,
  0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x0F, 0xE1, 0xF8, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xE0, 0xFC, 0x3F, 0x83, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x0F, 0xC3,
  0xF0, 0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0xC1, 0xF8, 0x00, 0x00, 0x21, 0xE0,
  0x07, 0x8F, 0xF0, 0x1F, 0x3F, 0xF0, 0x3E, 0xFF, 0xE0, 0x7D, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC3, 0xFC, 0x7F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFC, 0x1F,
  0x81, 0xF8, 0x3F, 0x03, 0xF0, 0xFE, 0x07, 0xE1, 0xFC, 0x1F, 0xC3, 0xF0,
  0x3F, 0x87, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07,
  0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x0F, 0xE0, 0xFE,
  0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE1, 0xFC, 0x0F, 0xC3,
  0xF8, 0x3F, 0x87, 0xE0, 0x7F, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF8, 0x7F, 0x8F, 0xE3, 0xF8, 0x7F, 0x3F, 0x81, 0xF9, 0xFC, 0x0F, 0xCF,
  0xC0, 0x7E, 0xFE, 0x03, 0xF7, 0xF0, 0x3F, 0xBF, 0x01, 0xFD, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xF7, 0xF0, 0x1F, 0xBF, 0x81, 0xFD, 0xFC,
  0x0F, 0xEF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x7F, 0x1F, 0xE7, 0xF8,
  0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF,
  0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0x3F, 0xC0, 0x0F,
  0xDF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFB, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7E, 0x07,
  0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0xC0, 0xFC,
  0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x3F, 0xC7, 0xF0, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFB, 0xFF, 0x00, 0x7E, 0x7F, 0x80, 0x1F,
  0x9F, 0xC0, 0x07, 0xE0, 0x80, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x7C,
  0x0F, 0xFD, 0xF8, 0x3F, 0xFB, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x83,
  0xF8, 0xFF, 0x0F, 0xE1, 0xFE, 0x1F, 0x81, 0xFC, 0x7F, 0x03, 0xF0, 0xFC,
  0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0x80,
  0xFC, 0x3F, 0x01, 0xF8, 0xFE, 0x03, 0xF1, 0xFC, 0x07, 0xE3, 0xF8, 0x1F,
  0xC7, 0xF0, 0x3F, 0x0F, 0xE0, 0x7E, 0x1F, 0xC1, 0xFC, 0x3F, 0x87, 0xF8,
  0x7F, 0x9F, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xBF, 0x01,
  0xFE, 0xFE, 0x03, 0xF9, 0xF8, 0x00, 0x83, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0xFC, 0xFC, 0x1F, 0xBF, 0x83,
  0xF7, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xE2, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF,
  0xFC, 0x3F, 0xFF, 0x87, 0xF0, 0x20, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x20, 0x1F, 0xC7, 0x8F, 0xF8, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x04, 0x00,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8,
  0x07, 0xFF, 0xBF, 0xFE, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF0, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC2, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0x20, 0x00, 0x0F, 0xE0, 0xFE, 0x1F, 0x81,
  0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC3, 0xF8, 0x3F,
  0x87, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x7F, 0x07, 0xF0,
  0xFE, 0x0F, 0xE1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x1F,
  0xC1, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8,
  0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x8F,
  0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xDF, 0x01, 0xFF, 0x3E,
  0x01, 0xFC, 0x7C, 0x00, 0x40, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x3F,
  0xBF, 0x01, 0xF9, 0xF8, 0x1F, 0xCF, 0xC0, 0xFC, 0x7E, 0x0F, 0xE3, 0xF0,
  0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x3F, 0x87, 0xE1, 0xF8, 0x3F, 0x1F, 0xC1,
  0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x3E, 0x7E, 0x01, 0xF3, 0xF0, 0x0F, 0xBF,
  0x00, 0x7D, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xE0,
  0x7F, 0xFC, 0x0F, 0xE0, 0x7E, 0xFC, 0x1F, 0xE0, 0xFC, 0xFC, 0x1F, 0xE0,
  0xFC, 0xFC, 0x3F, 0xE1, 0xFC, 0xFC, 0x3F, 0xE1, 0xF8, 0xFC, 0x3F, 0xE1,
  0xF8, 0xFC, 0x7F, 0xE3, 0xF0, 0xFC, 0x7F, 0xE3, 0xF0, 0xFC, 0x7F, 0xE3,
  0xF0, 0xFC, 0xFB, 0xE7, 0xE0, 0xFC, 0xFB, 0xE7, 0xE0, 0xFD, 0xF3, 0xEF,
  0xC0, 0xFD, 0xF3, 0xEF, 0xC0, 0xFD, 0xF3, 0xEF, 0xC0, 0xFF, 0xE3, 0xFF,
  0x80, 0xFF, 0xE3, 0xFF, 0x80, 0xFB, 0xE3, 0xDF, 0x00, 0xFF, 0xC7, 0xFF,
  0x00, 0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x87, 0xFE,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x07, 0xFC,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03,
  0xF1, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xDF, 0xC0,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xF7, 0xE0, 0x01, 0xF9, 0xF8,
  0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0x87, 0xF0, 0x0F, 0xE0,
  0xFC, 0x07, 0xF0, 0x3F, 0x03, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC,
  0x1F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xC3, 0xF0,
  0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFD, 0xF8,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x47, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8,
  0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0xE0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x04, 0xFF, 0x00,
  0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xA0, 0x0F, 0xFC, 0x80, 0x07, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 15, 38, 13, 0, -37 },
  { 73, 18, 13, 21, 5, -37 },
  { 103, 26, 37, 25, 0, -37 },
  { 224, 24, 43, 22, 0, -40 },
  { 353, 32, 38, 37, 3, -38 },
  { 505, 27, 39, 27, 0, -38 },
  { 637, 9, 13, 13, 5, -37 },
  { 652, 17, 45, 14, 1, -37 },
  { 748, 17, 46, 14, -4, -38 },
  { 846, 20, 22, 21, 4, -40 },
  { 901, 21, 25, 24, 2, -31 },
  { 967, 12, 14, 12, -3, -7 },
  { 988, 13, 6, 15, 1, -17 },
  { 998, 8, 9, 12, 0, -8 },
  { 1007, 27, 37, 19, -3, -37 },
  { 1132, 21, 39, 22, 1, -38 },
  { 1235, 17, 37, 23, 5, -37 },
  { 1314, 25, 38, 22, -2, -38 },
  { 1433, 24, 39, 22, -1, -38 },
  { 1550, 24, 37, 23, -1, -37 },
  { 1661, 23, 38, 22, 0, -37 },
  { 1771, 23, 39, 22, 1, -38 },
  { 1884, 24, 37, 22, 1, -37 },
  { 1995, 23, 39, 22, 0, -38 },
  { 2108, 23, 39, 22, 0, -38 },
  { 2221, 12, 30, 13, 0, -29 },
  { 2266, 16, 36, 13, -3, -29 },
  { 2338, 21, 25, 24, 2, -31 },
  { 2404, 21, 16, 24, 2, -26 },
  { 2446, 22, 25, 24, 2, -31 },
  { 2515, 19, 39, 17, 1, -38 },
  { 2608, 32, 42, 34, 1, -38 },
  { 2776, 24, 37, 24, -3, -37 },
  { 2887, 25, 37, 25, 0, -37 },
  { 3003, 24, 39, 23, 2, -38 },
  { 3120, 26, 37, 27, 0, -37 },
  { 3241, 23, 37, 21, 0, -37 },
  { 3348, 23, 37, 20, 0, -37 },
  { 3455, 27, 39, 27, 2, -38 },
  { 3587, 29, 37, 28, 0, -37 },
  { 3722, 22, 37, 16, -2, -37 },
  { 3824, 23, 48, 13, -8, -37 },
  { 3962, 29, 37, 24, 0, -37 },
  { 4097, 17, 37, 20, 0, -37 },
  { 4176, 38, 37, 36, 0, -37 },
  { 4352, 31, 37, 29, 0, -37 },
  { 4496, 26, 39, 28, 2, -38 },
  { 4623, 26, 37, 24, 0, -37 },
  { 4744, 26, 47, 28, 2, -38 },
  { 4897, 25, 37, 24, 0, -37 },
  { 5013, 25, 39, 21, -1, -38 },
  { 5135, 21, 37, 21, 4, -37 },
  { 5233, 27, 38, 27, 2, -37 },
  { 5362, 24, 37, 24, 5, -37 },
  { 5473, 37, 37, 36, 4, -37 },
  { 5645, 30, 37, 23, -3, -37 },
  { 5784, 22, 37, 22, 5, -37 },
  { 5886, 26, 37, 20, -2, -37 },
  { 6007, 21, 45, 15, -2, -37 },
  { 6126, 11, 37, 20, 5, -37 },
  { 6177, 21, 45, 15, -4, -37 },
  { 6296, 23, 22, 23, 0, -37 },
  { 6360, 18, 3, 17, -5, 5 },
  { 6367, 9, 8, 16, 8, -40 },
  { 6376, 23, 30, 24, 1, -29 },
  { 6463, 23, 41, 24, 0, -40 },
  { 6581, 20, 30, 19, 1, -29 },
  { 6656, 26, 41, 24, 1, -40 },
  { 6790, 20, 30, 22, 1, -29 },
  { 6865, 26, 52, 14, -6, -40 },
  { 7034, 25, 41, 24, -1, -29 },
  { 7163, 23, 40, 24, 0, -40 },
  { 7278, 14, 40, 12, 0, -40 },
  { 7348, 21, 52, 12, -7, -40 },
  { 7485, 25, 40, 22, 0, -40 },
  { 7610, 15, 40, 12, 0, -40 },
  { 7685, 34, 29, 35, 0, -29 },
  { 7809, 23, 29, 24, 0, -29 },
  { 7893, 21, 30, 23, 1, -29 },
  { 7972, 26, 41, 24, -3, -29 },
  { 8106, 23, 41, 24, 1, -29 },
  { 8224, 19, 29, 17, 0, -29 },
  { 8293, 19, 30, 19, 0, -29 },
  { 8365, 15, 35, 15, 2, -34 },
  { 8431, 23, 29, 24, 1, -28 },
  { 8515, 21, 28, 21, 3, -28 },
  { 8589, 32, 28, 32, 3, -28 },
  { 8701, 26, 28, 21, -3, -28 },
  { 8792, 28, 40, 21, -4, -28 },
  { 8932, 21, 28, 18, -2, -28 },
  { 9006, 20, 45, 18, 1, -37 },
  { 9119, 6, 52, 19, 6, -40 },
  { 9158, 20, 45, 18, -3, -37 },
  { 9271, 22, 9, 24, 2, -23 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic52pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC52PT7B_H_
