#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC63PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xE3, 0xFC,
  0xFF, 0x0F, 0xF3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0x87, 0xF8, 0xFE,
  0x1F, 0xE7, 0xF8, 0x7F, 0x1F, 0xE1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xF8, 0x7E, 0x0F, 0xE3, 0xF8, 0x3F, 0x0F,
  0xE0, 0xFC, 0x3F, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x01, 0xF0, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xC1, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFE, 0xEF, 0xC0, 0x3F, 0xCE, 0x38, 0x03, 0xF8, 0xC0, 0x80, 0x3F, 0x8C,
  0x00, 0x03, 0xF9, 0xC0, 0x00, 0x3F, 0x9C, 0x00, 0x03, 0xFD, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xEF, 0xF8, 0x00, 0x0E, 0xFF,
  0x80, 0x00, 0xC7, 0xF8, 0x40, 0x0C, 0x7F, 0x06, 0x01, 0xCF, 0xF0, 0x78,
  0x1C, 0xFF, 0x07, 0xC1, 0xDF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xC0, 0x03, 0xFF,
  0x80, 0x0F, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0x80, 0x0F, 0xFF, 0xC0, 0x1F,
  0x80, 0x0F, 0xCF, 0xC0, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x3F, 0x00, 0x1F,
  0x8F, 0xC0, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0xFC, 0x00, 0x3E, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC1, 0xF8, 0x00,
  0x7E, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x0F,
  0x87, 0xE0, 0x00, 0x7C, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x1F, 0x8F, 0xC0,
  0x00, 0xFC, 0x1F, 0x8F, 0xC0, 0xE0, 0xFC, 0x3F, 0x1F, 0x87, 0xF8, 0xFC,
  0x3F, 0x3F, 0x8F, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0xFE, 0xFC, 0x7E, 0x7E,
  0x3F, 0xFE, 0x7F, 0xFC, 0x7E, 0x3F, 0xFE, 0x7F, 0xFC, 0xFC, 0x7E, 0x3F,
  0x7F, 0xF8, 0xFC, 0xFC, 0x3F, 0x3F, 0xF1, 0xF8, 0xFC, 0x3F, 0x1F, 0xE1,
  0xF8, 0xF8, 0x3F, 0x06, 0x03, 0xF1, 0xF8, 0x3F, 0x00, 0x03, 0xF1, 0xF8,
  0x3E, 0x00, 0x07, 0xE1, 0xF8, 0x3E, 0x00, 0x07, 0xE3, 0xF0, 0x7E, 0x00,
  0x0F, 0xC3, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x7E, 0x00, 0x1F, 0x83,
  0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x03, 0xE0, 0xFC,
  0x00, 0x7E, 0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x03, 0xE1, 0xF8, 0x00, 0xFC,
  0x03, 0xE1, 0xF8, 0x00, 0xFC, 0x03, 0xF3, 0xF0, 0x01, 0xF8, 0x03, 0xFF,
  0xF0, 0x01, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0x07, 0xFF, 0xF0, 0xFE, 0x0F, 0xFF,
  0xF1, 0xFE, 0x1F, 0xEF, 0xF9, 0xFC, 0x3F, 0xC7, 0xFB, 0xFC, 0x3F, 0xC7,
  0xFB, 0xFC, 0x7F, 0x87, 0xFF, 0xF8, 0x7F, 0x83, 0xFF, 0xF0, 0x7F, 0x03,
  0xFF, 0xF0, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0x01,
  0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xCF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xDF, 0xF0, 0x1F, 0xFF,
  0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xE7,
  0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x3F, 0x87, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x06, 0x0F, 0xE0, 0x0F, 0x1F, 0xC0, 0x3F, 0xBF, 0x03, 0x7F,
  0xFE, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFE, 0x7F, 0x03, 0xF8, 0xFF,
  0x03, 0xF1, 0xFF, 0x03, 0xC1, 0xFC, 0x03, 0x03, 0xE0, 0x02, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1,
  0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01,
  0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x06,
  0x07, 0xE3, 0xFD, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFE, 0xFF, 0x1F, 0x81,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC1,
  0xFC, 0x1F, 0xE0, 0x7F, 0x07, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF,
  0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF1,
  0xFE, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x1F,
  0xE3, 0xFC, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xE0,
  0x3F, 0xE7, 0xF8, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x3F,
  0xC0, 0x7F, 0xCF, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x03, 0xFE,
  0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x1F, 0xF0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC3, 0xFE, 0x0F, 0xF1, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xBF, 0xC7, 0xF3, 0xF8, 0x3C, 0x7F, 0x83,
  0x87, 0xF8, 0x10, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFE, 0x0F,
  0xF8, 0x01, 0xF0, 0x1F, 0xF0, 0x07, 0x80, 0x7F, 0xC0, 0x08, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x78, 0x1F, 0xF8, 0x01, 0x00, 0x7F, 0xC0, 0x10, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x40, 0x01,
  0xFF, 0x83, 0x80, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7D, 0xFC, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x7E, 0xFF, 0x00, 0x03, 0xE7, 0xF8, 0x00, 0x3F, 0x3F,
  0x80, 0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x1F, 0xE0, 0x01, 0xF8, 0xFF, 0x00,
  0x1F, 0x87, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xC3, 0xFC, 0x00, 0x7C,
  0x1F, 0xE0, 0x07, 0xE0, 0xFF, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xE0, 0x3F,
  0x80, 0x3F, 0x03, 0xFC, 0x03, 0xF0, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x02, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x08, 0x00, 0x3F,
  0xE0, 0xC0, 0x07, 0xFC, 0x0F, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7A, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0x9E, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0xFF, 0x3F, 0xE0, 0x1F, 0xEF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xE1, 0xFE,
  0x1F, 0xF8, 0x3F, 0xC3, 0xFE, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x0F, 0xF0,
  0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0,
  0xFF, 0x01, 0xFE, 0x1F, 0xC0, 0x7F, 0xC3, 0xF8, 0x0F, 0xF0, 0x7F, 0x01,
  0xFE, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xFE, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xE1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0xFF,
  0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x3F,
  0xE7, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0x3F,
  0xE0, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07,
  0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x00,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFF, 0x81, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03,
  0xFE, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F,
  0xF0, 0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F,
  0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE3, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0xFF,
  0x8F, 0xF0, 0x1F, 0xF1, 0xFF, 0x07, 0xFE, 0x3F, 0xE0, 0xFF, 0x87, 0xFC,
  0x3F, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xBF, 0xC0, 0x3F, 0xE7, 0xF8, 0x03, 0xF1,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x07, 0xEF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x01, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFE, 0x03, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFE, 0x01, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xF0,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xE1, 0xFF, 0x07,
  0x01, 0xFE, 0x08, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x01,
  0xF8, 0x07, 0x80, 0x3E, 0x03, 0xF0, 0x1F, 0xFC, 0x3E, 0x03, 0xE0, 0x7F,
  0xFE, 0x3F, 0x07, 0xE0, 0xFF, 0xFC, 0x3F, 0x07, 0xC1, 0xFF, 0xFC, 0x3F,
  0x0F, 0xC1, 0xF8, 0xFC, 0x3F, 0x0F, 0x83, 0xF0, 0xFC, 0x3E, 0x1F, 0x87,
  0xE0, 0xF8, 0x3E, 0x1F, 0x07, 0xE0, 0xF8, 0x3E, 0x1F, 0x0F, 0xC1, 0xF8,
  0x3E, 0x3F, 0x0F, 0xC1, 0xF8, 0x3E, 0x3E, 0x0F, 0x81, 0xF8, 0x3E, 0x3E,
  0x1F, 0x81, 0xF0, 0x7C, 0x3E, 0x1F, 0x83, 0xF0, 0x7C, 0x7E, 0x1F, 0x03,
  0xF0, 0x7C, 0x7C, 0x1F, 0x03, 0xF0, 0x7C, 0x7C, 0x1F, 0x03, 0xE0, 0xF8,
  0x7C, 0x3F, 0x07, 0xE0, 0xF8, 0x7C, 0x3F, 0x07, 0xE1, 0xF0, 0x7C, 0x3F,
  0x0F, 0xE1, 0xF0, 0x7C, 0x3F, 0x0F, 0xE3, 0xE0, 0xFC, 0x3F, 0x1F, 0xE7,
  0xE0, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFC, 0x1F, 0xFB, 0xFF, 0x80, 0xFC,
  0x1F, 0xF9, 0xFF, 0x00, 0x7C, 0x0F, 0xF1, 0xFE, 0x00, 0x7C, 0x03, 0xC0,
  0x78, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xC0, 0x00, 0x1F, 0xE0, 0x07, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFE, 0xFE, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01,
  0xFC, 0xFE, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFE,
  0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFF, 0x0F,
  0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x83, 0xF8,
  0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0x80,
  0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x7F, 0xC0, 0x0F,
  0xF1, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFC,
  0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x7F, 0xDF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0xFE,
  0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x01,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x3F,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x00,
  0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07,
  0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F,
  0x80, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC,
  0x0F, 0xFC, 0x0F, 0xF0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0xE0, 0x0F, 0xFC, 0x01, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x20, 0x07, 0xFE, 0x07, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0x3F, 0xFE, 0x00, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x01,
  0xFE, 0x03, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x03,
  0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x03,
  0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07,
  0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x07,
  0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F,
  0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xFC, 0x1F,
  0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x0F, 0xF8, 0x1F, 0xE0, 0x0F, 0xF8, 0x1F,
  0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xC0, 0x7F, 0xE0, 0x3F, 0xC0, 0xFF, 0xC0, 0x3F, 0xC1, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x3C,
  0x00, 0xFF, 0xC0, 0x06, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0x81,
  0xFF, 0xF0, 0x7F, 0xC0, 0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0xFC, 0x1F, 0xE0,
  0x7F, 0xFE, 0x1F, 0xF0, 0x3F, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x07, 0xFC,
  0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x1F,
  0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x01,
  0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x21, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xF0, 0x01,
  0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xE0,
  0x00, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x7F,
  0xC0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xF8,
  0xFF, 0x80, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03,
  0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07,
  0xFD, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x07, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFE,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0xFF, 0x80, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x80,
  0x0F, 0xF0, 0x1F, 0xF0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0xFE, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFB, 0xF0, 0x1F, 0xDF,
  0xC0, 0x0F, 0xEF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xBF, 0x01, 0xFB, 0xFC,
  0x01, 0xFE, 0xFC, 0x0F, 0xEF, 0xF0, 0x07, 0xFB, 0xF0, 0x3F, 0x3F, 0xC0,
  0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x87, 0xF7, 0xF8, 0x03,
  0xFC, 0xFE, 0x3F, 0x9F, 0xE0, 0x0F, 0xF3, 0xF8, 0xFE, 0x7F, 0x80, 0x3F,
  0x8F, 0xE7, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x9F, 0xC7, 0xF0, 0x03, 0xF8,
  0xFE, 0x7E, 0x3F, 0xC0, 0x1F, 0xE3, 0xFB, 0xF8, 0xFF, 0x00, 0x7F, 0x8F,
  0xEF, 0xC3, 0xFC, 0x01, 0xFC, 0x3F, 0xFF, 0x0F, 0xE0, 0x07, 0xF0, 0xFF,
  0xFC, 0x7F, 0x80, 0x1F, 0xC3, 0xFF, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xFF,
  0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0xFF, 0xF0,
  0x7F, 0x00, 0x3F, 0x83, 0xFF, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xFE, 0x0F,
  0xF0, 0x07, 0xF8, 0x3F, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0xFF, 0xC0, 0xFE,
  0x00, 0x7F, 0x03, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0,
  0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x00,
  0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x03,
  0xFF, 0x00, 0x1F, 0xC0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x03, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0xC0, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0xFC, 0x03, 0xF8, 0x03, 0xFF, 0xE0,
  0x3F, 0xC0, 0x1F, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xF0, 0x0F,
  0xEF, 0xE0, 0x7F, 0x00, 0x7F, 0x7F, 0x03, 0xF8, 0x03, 0xFB, 0xF8, 0x3F,
  0xC0, 0x1F, 0xDF, 0xC1, 0xFE, 0x01, 0xFE, 0xFE, 0x0F, 0xE0, 0x0F, 0xF3,
  0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0xFE, 0x3F, 0xC0,
  0x1F, 0xC7, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0x8F, 0xE0, 0x0F, 0xF0, 0xFE,
  0x7F, 0x00, 0x7F, 0x07, 0xF3, 0xF8, 0x03, 0xF8, 0x3F, 0xBF, 0xC0, 0x1F,
  0xC1, 0xFD, 0xFE, 0x01, 0xFE, 0x0F, 0xEF, 0xE0, 0x0F, 0xF0, 0x7F, 0x7F,
  0x00, 0x7F, 0x01, 0xFF, 0xF8, 0x03, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xC0,
  0x7F, 0xFC, 0x01, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xF0, 0x1F, 0xFF, 0x00,
  0x7F, 0x00, 0xFF, 0xF8, 0x03, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xE0, 0x07, 0xFF, 0x00, 0x7F,
  0x00, 0x3F, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xC0, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x83, 0xFE, 0x03,
  0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07,
  0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x1F,
  0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x1F, 0xE0, 0x01, 0xFF, 0x3F,
  0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x7F,
  0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F,
  0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0x80, 0x07, 0xFC, 0xFF,
  0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0xFF,
  0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF0, 0xFF,
  0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0x80, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0x87, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0,
  0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0x81, 0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x03,
  0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F,
  0xE0, 0x7F, 0x81, 0xFF, 0x80, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0x83, 0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x07, 0xFC,
  0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8,
  0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x1F, 0xE0,
  0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0,
  0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0,
  0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0x80,
  0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80,
  0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80,
  0x1F, 0xF8, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80,
  0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xE1,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xC3, 0xFF, 0x00, 0xFE, 0x07, 0xFC,
  0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0x81, 0xFF, 0x01,
  0xFE, 0x07, 0xFC, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x81,
  0xFF, 0x01, 0xFE, 0x0F, 0xFC, 0x07, 0xF8, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8,
  0xFF, 0x00, 0x1F, 0xC3, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F,
  0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x07, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xC3,
  0xE0, 0x07, 0xFE, 0x03, 0x80, 0x1F, 0xF0, 0x02, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x60, 0x01, 0xFF, 0x01, 0xE0, 0x0F,
  0xF8, 0x07, 0xE0, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xC0,
  0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC,
  0x07, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x07,
  0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x80,
  0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x07, 0xFC,
  0x03, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x07,
  0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x07, 0xFD,
  0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFE, 0x7F, 0x80, 0x1F, 0xE3, 0xFC,
  0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF8, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x07,
  0xFC, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0,
  0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF,
  0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x1F,
  0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x7F, 0x80,
  0x1F, 0xC3, 0xFC, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF1, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x7F,
  0x80, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x07, 0xFC, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE3, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x3F, 0x80, 0x3F, 0xE0,
  0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x87, 0xF8, 0x03, 0xFE, 0x01,
  0xFE, 0x1F, 0xE0, 0x1F, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0xE0, 0x3F,
  0xC1, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xFE, 0x03, 0xF8,
  0x1F, 0xE0, 0x3F, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xFC, 0x0F, 0xF0, 0x1F,
  0xE0, 0xFF, 0xF0, 0x3F, 0xC0, 0x7F, 0x83, 0xFF, 0xC1, 0xFE, 0x01, 0xFE,
  0x1F, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x7E, 0xFC, 0x1F, 0xC0, 0x1F, 0xE1,
  0xFB, 0xF0, 0xFF, 0x00, 0x7F, 0x8F, 0xEF, 0xC3, 0xFC, 0x01, 0xFC, 0x3F,
  0x3F, 0x1F, 0xE0, 0x07, 0xF1, 0xFC, 0xFC, 0x7F, 0x80, 0x1F, 0xC7, 0xF3,
  0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0x8F, 0xCF, 0xF0, 0x01, 0xFC, 0xFE, 0x3F,
  0x3F, 0xC0, 0x07, 0xF3, 0xF0, 0xFD, 0xFE, 0x00, 0x1F, 0xDF, 0xC3, 0xF7,
  0xF8, 0x00, 0x7F, 0x7F, 0x0F, 0xDF, 0xC0, 0x01, 0xFD, 0xF8, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x7F, 0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x07,
  0xF7, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x1F, 0xE3, 0xF8,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xFC,
  0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07,
  0xFB, 0xFC, 0x03, 0xFE, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0,
  0x1F, 0xE1, 0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xFC, 0x1F, 0xE1, 0xFE, 0x07,
  0xF8, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE7, 0xF8,
  0x07, 0xF9, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFE, 0x07,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0,
  0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8,
  0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x0F, 0xE0,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x8F, 0xF0, 0x07, 0xF1, 0xFC, 0x00,
  0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x80,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x7F, 0xC3, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F,
  0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0x08, 0x03, 0xFE, 0x3F,
  0x80, 0x3F, 0xF9, 0xFC, 0x03, 0xFF, 0xCF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0x8F, 0xFC, 0x0F, 0xF8,
  0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F,
  0x83, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x0F,
  0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0,
  0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F,
  0x83, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0x01, 0xFF, 0x07,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xBF,
  0x80, 0x3F, 0xF9, 0xFC, 0x01, 0xFF, 0x8F, 0xE0, 0x07, 0xF8, 0x7E, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x8F, 0x80, 0x03, 0xF9, 0xFF, 0x00, 0x3F,
  0xDF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0xFF, 0x81, 0xFF, 0x07, 0xFC,
  0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F,
  0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00,
  0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE,
  0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F,
  0xC0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x81,
  0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0x81, 0xFF, 0xCF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xF7, 0xFF, 0xC0, 0x3F,
  0xBF, 0xFC, 0x01, 0xF8, 0xFF, 0xC0, 0x0F, 0xC3, 0xFC, 0x00, 0x80, 0x07,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F,
  0xFC, 0x18, 0x0F, 0xF8, 0x08, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x40, 0x7F,
  0x80, 0xC0, 0x7F, 0xE7, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0xF3, 0xFC,
  0x00, 0x7F, 0xF7, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x01,
  0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x01, 0xFF, 0x00,
  0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF,
  0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xBF, 0x80,
  0x07, 0xFE, 0x7F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x1F, 0xF1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x0F, 0xF0, 0x3F, 0x87, 0xF0, 0x1F, 0xC7, 0xF8, 0x0F, 0xE3, 0xF8,
  0x0F, 0xF3, 0xFC, 0x07, 0xF1, 0xFE, 0x07, 0xF8, 0xFE, 0x1F, 0xF8, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x02, 0x07, 0xF8, 0x07, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x10, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x87, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x01, 0x00, 0x0F, 0xF8,
  0xFE, 0x00, 0x1F, 0xFC, 0xFE, 0x00, 0x3F, 0xFE, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x8F,
  0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07,
  0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F,
  0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0x7F, 0x80, 0x07, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0xFF,
  0x00, 0x00, 0xF0, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0xC0, 0x03, 0xFE, 0x00, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF1, 0xF8, 0x00, 0xFE, 0x7F, 0xC0, 0x1F, 0xEF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0,
  0x7F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0,
  0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC,
  0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE,
  0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F,
  0x83, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F,
  0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xF8, 0x1F,
  0xE0, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x01, 0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x10, 0x1F,
  0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0,
  0x7F, 0x80, 0x3F, 0x83, 0xFC, 0x00, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x7F,
  0x80, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFC, 0xFF, 0x00,
  0x07, 0xF3, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00,
  0x7F, 0x83, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F,
  0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0,
  0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xFC, 0x7F, 0xC1, 0xFF, 0x00, 0xFE,
  0x7F, 0xF3, 0xFF, 0xC0, 0x7F, 0x7F, 0xF9, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFC, 0x7F, 0xF1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xFC,
  0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0xFE, 0x03, 0xFC,
  0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x1F, 0xE0,
  0x3F, 0x80, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x83, 0xF8, 0x0F, 0xF0, 0x3F, 0xC1, 0xFC, 0x07, 0xF0, 0x1F, 0xE1,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x7F, 0x81,
  0xFE, 0x07, 0xF8, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x83, 0xF8, 0x0F, 0xF0, 0x3F, 0xC1, 0xFC, 0x07,
  0xF0, 0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x3F, 0x1F, 0xF0, 0x07, 0xE7, 0xFF, 0x01, 0xFD,
  0xFF, 0xF0, 0x3F, 0x7F, 0xFE, 0x07, 0xEF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xF1, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xE0,
  0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3,
  0xFC, 0x07, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07,
  0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF8, 0x7F,
  0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F,
  0x07, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8,
  0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0,
  0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xF1,
  0xFE, 0x0F, 0xF0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0xFF,
  0x80, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF7, 0xFC, 0x03, 0xFD,
  0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0x9F, 0xE0, 0x1F, 0xE7, 0xF8, 0x07,
  0xF9, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x3F, 0xEF, 0xF0,
  0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0x7F, 0x8F,
  0xF0, 0x3F, 0xE1, 0xFE, 0x1F, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x8F, 0xF8, 0x00, 0x3F, 0x9F, 0xFC, 0x00, 0x3F, 0xBF, 0xFE,
  0x00, 0x3F, 0xBF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x07, 0xF8,
  0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xFE, 0x1F, 0xF0,
  0x07, 0xFF, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xF7, 0xFF, 0x80, 0x0F, 0xF7, 0xFF, 0x00,
  0x0F, 0xE3, 0xFC, 0x00, 0x1F, 0xE0, 0x60, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFE, 0x3F, 0x00,
  0xFF, 0xE7, 0xF0, 0x1F, 0xFF, 0x7F, 0x01, 0xFF, 0xF7, 0xF0, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0x87, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0,
  0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0,
  0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xF8, 0x03, 0xF8,
  0x7F, 0x80, 0x3F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8,
  0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0xFF,
  0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF,
  0x01, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0xCF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFB, 0xFC, 0x03,
  0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x00, 0x30, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3E, 0x03, 0xF1, 0xFC, 0x0F, 0xE7, 0xF8, 0x1F, 0xDF, 0xF0, 0x3F,
  0xBF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x0F, 0xF0, 0x38, 0x0F, 0xF0, 0x08, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x80, 0x1F,
  0xE0, 0xC0, 0x3F, 0xE0, 0xFD, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xFF,
  0xC7, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0x9F, 0xFF, 0xE0,
  0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x20, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8,
  0x0F, 0xFC, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFE,
  0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x7F,
  0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0x01, 0xFC, 0x0F, 0xE0, 0x3F,
  0xC0, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xF8, 0x1F,
  0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x83, 0xFC, 0x07,
  0xF8, 0x3F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x03,
  0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFD, 0xF8, 0x07, 0xFF, 0x9F, 0x80, 0x3F, 0xF1, 0xF8,
  0x01, 0xFE, 0x1F, 0x80, 0x03, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFC, 0xFE,
  0x03, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF0, 0xFE,
  0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE,
  0x1F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE,
  0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x01, 0xFF, 0x01, 0xFE, 0xFE, 0x03, 0xFE, 0x03, 0xF9,
  0xFC, 0x0F, 0xFC, 0x0F, 0xF3, 0xF8, 0x1F, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F,
  0xF0, 0x7F, 0x8F, 0xE0, 0xFF, 0xE0, 0xFF, 0x1F, 0xC1, 0xFF, 0xC1, 0xFC,
  0x3F, 0x83, 0xFF, 0x87, 0xF8, 0x7F, 0x0F, 0xFF, 0x0F, 0xE0, 0xFE, 0x1F,
  0xFE, 0x1F, 0xC1, 0xFC, 0x7E, 0xFC, 0x7F, 0x83, 0xF8, 0xFD, 0xF8, 0xFE,
  0x07, 0xF1, 0xFB, 0xF3, 0xFC, 0x0F, 0xE7, 0xEF, 0xE7, 0xF0, 0x1F, 0xCF,
  0xDF, 0x8F, 0xE0, 0x3F, 0xBF, 0xBF, 0x3F, 0xC0, 0x7F, 0x7E, 0x7E, 0x7F,
  0x00, 0xFE, 0xFC, 0xFC, 0xFE, 0x01, 0xFF, 0xF9, 0xFB, 0xF8, 0x03, 0xF7,
  0xE3, 0xF7, 0xF0, 0x07, 0xEF, 0xC7, 0xEF, 0xE0, 0x0F, 0xDF, 0x0F, 0xFF,
  0x80, 0x1F, 0xFE, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0xC1, 0xFF,
  0xC0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0,
  0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFD, 0xFC,
  0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0,
  0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x07,
  0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00,
  0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x4F, 0xFF, 0x00, 0x37, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0x20, 0x00, 0x1F, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 18, 46, 16, 0, -45 },
  { 105, 22, 16, 25, 6, -45 },
  { 149, 32, 45, 30, 0, -45 },
  { 329, 28, 52, 27, 0, -48 },
  { 511, 40, 47, 44, 3, -46 },
  { 746, 32, 47, 33, 0, -46 },
  { 934, 11, 16, 15, 6, -45 },
  { 956, 21, 55, 17, 1, -45 },
  { 1101, 21, 56, 17, -5, -46 },
  { 1248, 23, 26, 26, 5, -48 },
  { 1323, 25, 30, 29, 3, -37 },
  { 1417, 14, 17, 15, -3, -8 },
  { 1447, 16, 8, 18, 1, -21 },
  { 1463, 10, 11, 15, 0, -10 },
  { 1477, 32, 45, 23, -3, -45 },
  { 1657, 26, 47, 27, 1, -46 },
  { 1810, 20, 45, 27, 6, -45 },
  { 1923, 30, 46, 27, -2, -46 },
  { 2096, 29, 47, 27, -1, -46 },
  { 2267, 29, 45, 27, -1, -45 },
  { 2431, 28, 46, 27, 0, -45 },
  { 2592, 27, 47, 27, 2, -46 },
  { 2751, 29, 45, 27, 2, -45 },
  { 2915, 28, 47, 27, 0, -46 },
  { 3080, 27, 47, 27, 0, -46 },
  { 3239, 15, 36, 15, 0, -35 },
  { 3307, 18, 44, 15, -3, -35 },
  { 3406, 26, 30, 29, 2, -38 },
  { 3504, 26, 19, 29, 2, -32 },
  { 3566, 25, 30, 29, 3, -38 },
  { 3660, 23, 47, 21, 1, -46 },
  { 3796, 40, 50, 41, 1, -45 },
  { 4046, 30, 45, 30, -4, -45 },
  { 4215, 31, 45, 30, 0, -45 },
  { 4390, 30, 47, 28, 2, -46 },
  { 4567, 32, 45, 32, 0, -45 },
  { 4747, 28, 45, 25, 0, -45 },
  { 4905, 28, 45, 24, 0, -45 },
  { 5063, 33, 47, 33, 2, -46 },
  { 5257, 36, 45, 34, 0, -45 },
  { 5460, 28, 45, 20, -3, -45 },
  { 5618, 28, 58, 16, -10, -45 },
  { 5821, 35, 45, 29, 0, -45 },
  { 6018, 20, 45, 24, 0, -45 },
  { 6131, 46, 45, 44, 0, -45 },
  { 6390, 37, 45, 35, 0, -45 },
  { 6599, 32, 47, 34, 2, -46 },
  { 6787, 31, 45, 29, 0, -45 },
  { 6962, 32, 57, 34, 2, -46 },
  { 7190, 30, 45, 29, 0, -45 },
  { 7359, 30, 47, 26, -1, -46 },
  { 7536, 26, 45, 25, 4, -45 },
  { 7683, 33, 46, 33, 2, -45 },
  { 7873, 29, 45, 29, 6, -45 },
  { 8037, 46, 45, 44, 4, -45 },
  { 8296, 36, 45, 28, -4, -45 },
  { 8499, 26, 45, 27, 6, -45 },
  { 8646, 32, 45, 25, -3, -45 },
  { 8826, 25, 55, 18, -3, -45 },
  { 8998, 13, 45, 24, 6, -45 },
  { 9072, 25, 55, 18, -5, -45 },
  { 9244, 27, 27, 27, 0, -45 },
  { 9336, 21, 5, 20, -6, 5 },
  { 9350, 12, 10, 19, 9, -48 },
  { 9365, 29, 36, 29, 1, -35 },
  { 9496, 29, 49, 29, -1, -48 },
  { 9674, 24, 36, 23, 1, -35 },
  { 9782, 31, 49, 29, 1, -48 },
  { 9972, 25, 36, 27, 1, -35 },
  { 10085, 32, 63, 18, -7, -48 },
  { 10337, 32, 50, 29, -2, -35 },
  { 10537, 28, 48, 29, -1, -48 },
  { 10705, 18, 48, 14, -1, -48 },
  { 10813, 25, 63, 14, -8, -48 },
  { 11010, 30, 48, 27, 0, -48 },
  { 11190, 19, 48, 14, -1, -48 },
  { 11304, 41, 35, 42, 0, -35 },
  { 11484, 27, 35, 29, 0, -35 },
  { 11603, 26, 36, 28, 1, -35 },
  { 11720, 32, 50, 29, -4, -35 },
  { 11920, 28, 50, 29, 1, -35 },
  { 12095, 23, 35, 20, 0, -35 },
  { 12196, 24, 36, 23, 0, -35 },
  { 12304, 18, 43, 18, 2, -42 },
  { 12401, 28, 35, 28, 1, -34 },
  { 12524, 24, 34, 25, 4, -34 },
  { 12626, 39, 34, 39, 3, -34 },
  { 12792, 31, 34, 26, -3, -34 },
  { 12924, 34, 49, 25, -5, -34 },
  { 13133, 25, 34, 21, -2, -34 },
  { 13240, 25, 55, 21, 1, -45 },
  { 13412, 7, 62, 24, 8, -48 },
  { 13467, 24, 55, 21, -4, -45 },
  { 13632, 26, 10, 29, 2, -27 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic63pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC63PT7B_H_
