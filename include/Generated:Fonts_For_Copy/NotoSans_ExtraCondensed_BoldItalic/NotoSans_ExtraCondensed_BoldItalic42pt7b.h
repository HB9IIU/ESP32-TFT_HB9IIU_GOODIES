#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC42PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0x3E, 0x7E,
  0xFC, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0x8F, 0x9F, 0x1E, 0x3E, 0x7C,
  0x7C, 0xF8, 0xF1, 0xE1, 0xE3, 0xC3, 0xC0, 0x00, 0x3C, 0x78, 0x03, 0xC7,
  0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03,
  0xC7, 0x80, 0x1C, 0x78, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF0, 0x3C, 0x78, 0x01, 0xE3, 0x80, 0x1E, 0x3C, 0x00, 0xF1,
  0xE0, 0x07, 0x8F, 0x00, 0x78, 0xF1, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0x8F, 0x00, 0x3C, 0x78,
  0x01, 0xE3, 0xC0, 0x0E, 0x1C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x1F, 0x80,
  0x0F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xD3, 0x81,
  0xF2, 0x10, 0x3E, 0xC0, 0x07, 0xD8, 0x00, 0xFB, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xBE, 0x00, 0x37, 0xC2, 0x04, 0xF8, 0x61,
  0xBF, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0x7F,
  0xE0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0xE0, 0x1E, 0x03, 0xF8, 0x07, 0x81, 0xFF, 0x03, 0xC0, 0x7B, 0xC1, 0xE0,
  0x3C, 0xF0, 0x78, 0x0E, 0x3C, 0x3C, 0x07, 0x8F, 0x0F, 0x01, 0xE3, 0xC7,
  0x80, 0x78, 0xF1, 0xE0, 0x1C, 0x3C, 0xF0, 0x0F, 0x1E, 0x3C, 0x03, 0xC7,
  0x9E, 0x00, 0xF1, 0xE7, 0x9F, 0xBC, 0xF3, 0xCF, 0xFF, 0x3C, 0xF7, 0xFF,
  0xFE, 0x79, 0xEF, 0x7F, 0x3C, 0xF1, 0xCF, 0x8F, 0x3C, 0x70, 0x07, 0x9E,
  0x3C, 0x01, 0xE7, 0x8F, 0x00, 0xF1, 0xE3, 0xC0, 0x3C, 0x78, 0xF0, 0x1E,
  0x1C, 0x3C, 0x07, 0x8F, 0x1E, 0x03, 0xC3, 0xC7, 0x80, 0xF0, 0xF1, 0xE0,
  0x78, 0x1E, 0xF0, 0x3C, 0x07, 0xF8, 0x0F, 0x01, 0xFE, 0x07, 0x80, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFD, 0xF0,
  0x03, 0xE7, 0xC0, 0x0F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07,
  0xC7, 0x80, 0x1F, 0x3E, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x8F, 0xC3, 0xFE, 0x3E, 0x1F, 0xF8, 0xF8,
  0xFF, 0xF7, 0xC7, 0xE7, 0xDF, 0x1F, 0x1F, 0xF8, 0x7C, 0x7F, 0xE3, 0xE0,
  0xFF, 0x0F, 0x83, 0xFC, 0x3E, 0x0F, 0xE0, 0xF8, 0x3F, 0x83, 0xF1, 0xFE,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xE7, 0xE0, 0xFF, 0x1F, 0x80,
  0x3E, 0xFD, 0xFB, 0xE7, 0xCF, 0x9F, 0x3C, 0xF9, 0xF3, 0xE0, 0x00, 0x7C,
  0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x21, 0xE0, 0x79, 0xE0, 0x7D, 0xEF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x0F, 0xE0, 0x1F, 0xF0, 0x3E, 0xF8,
  0x7E, 0xF8, 0x3C, 0x7C, 0x18, 0x78, 0x08, 0x60, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x0F, 0x8F, 0xC7, 0xC3, 0xE3, 0xF1, 0xF0, 0xF8, 0xF8,
  0x7C, 0x3C, 0x3E, 0x1E, 0x00, 0x7F, 0xF7, 0xFE, 0x7F, 0xE7, 0xFE, 0xFF,
  0xE0, 0x3C, 0xFF, 0xFF, 0xEF, 0xDF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF,
  0xF8, 0x7C, 0x7C, 0x7E, 0x3E, 0x3E, 0x1F, 0x3F, 0x0F, 0x9F, 0x07, 0xCF,
  0x83, 0xEF, 0xC1, 0xF7, 0xE1, 0xFB, 0xE0, 0xFD, 0xF0, 0x7D, 0xF8, 0x3E,
  0xFC, 0x1F, 0x7E, 0x1F, 0xBE, 0x0F, 0xDF, 0x07, 0xCF, 0x87, 0xE7, 0xC3,
  0xF3, 0xE1, 0xF1, 0xF1, 0xF8, 0xF8, 0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F,
  0xFC, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x81,
  0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xFF, 0x1F, 0xFC, 0xFD, 0xF1, 0xCF, 0xC2,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xF7, 0xF0,
  0x3C, 0x3F, 0x01, 0x81, 0xF0, 0x10, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xEF, 0xF0, 0x10, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0xC0, 0x3F, 0x0F, 0x9F, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07,
  0xFC, 0x00, 0x77, 0xC0, 0x0F, 0x7C, 0x01, 0xEF, 0x80, 0x1C, 0xF8, 0x03,
  0xCF, 0x80, 0x78, 0xF8, 0x07, 0x9F, 0x80, 0xF1, 0xF0, 0x1E, 0x1F, 0x01,
  0xE1, 0xF0, 0x3C, 0x1F, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFC,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x80, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xF0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xF8, 0xC1, 0xF8, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFB, 0xF0, 0x3F,
  0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFC, 0xFC, 0x7E, 0x3F, 0x3F, 0x0F,
  0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xF8, 0x3F, 0x3E, 0x0F, 0x8F, 0x83, 0xE3,
  0xE1, 0xF8, 0xFC, 0x7C, 0x3F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F,
  0xF0, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF1, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03,
  0xFF, 0xF0, 0xFC, 0x7E, 0x1F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F,
  0x87, 0xC1, 0xF1, 0xF8, 0x3F, 0x3E, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xEF, 0xC1, 0xF8,
  0xFC, 0x3E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0,
  0xF8, 0xFC, 0x3F, 0x1F, 0x8F, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF,
  0x80, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F,
  0xFF, 0x0F, 0xFF, 0xC3, 0xE1, 0xF1, 0xF8, 0x7C, 0x7C, 0x1F, 0x1F, 0x07,
  0xC7, 0xC1, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC7, 0xF3,
  0xF3, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFD, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x30, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0x00,
  0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x07, 0xC3,
  0xF8, 0xFC, 0x3F, 0x0F, 0x80, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3E, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x81, 0xF0, 0x1F,
  0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0,
  0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0x80, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x1F, 0xE0,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x00, 0xFE, 0x00,
  0x7C, 0x00, 0x38, 0x00, 0x10, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xF8, 0xFF,
  0xF0, 0xFF, 0xF1, 0xC7, 0xE2, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x00, 0xE0,
  0x78, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0E, 0x0F, 0xF3, 0xC7, 0x87, 0xFC,
  0x71, 0xC3, 0xFF, 0x1C, 0xF1, 0xE3, 0xCF, 0x38, 0x70, 0xE3, 0xDE, 0x3C,
  0x78, 0xF7, 0x8E, 0x1E, 0x3D, 0xC7, 0x87, 0x8E, 0x71, 0xE1, 0xC3, 0xBC,
  0x78, 0xF1, 0xEF, 0x1C, 0x3C, 0x73, 0xC7, 0x0F, 0x1C, 0xF1, 0xC7, 0x8F,
  0x3C, 0x7B, 0xE7, 0x8F, 0x1F, 0xFF, 0xC3, 0xC7, 0xF7, 0xE0, 0xF0, 0xF1,
  0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x60, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x7D, 0xF0, 0x07, 0xDF, 0x00, 0x7D, 0xF0, 0x0F, 0x9F, 0x00, 0xF9,
  0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x03, 0xE1, 0xF0, 0x3E,
  0x1F, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0x81, 0xF1, 0xF8, 0x1F, 0x1F, 0x01, 0xF3, 0xF0, 0x1F, 0x3F, 0x01, 0xF7,
  0xE0, 0x1F, 0x7E, 0x01, 0xFF, 0xC0, 0x1F, 0x03, 0xFF, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xE7, 0xF0, 0x7C, 0x3F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x0F, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8,
  0x7E, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x81, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3,
  0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xF8, 0x7C, 0x1F, 0x87, 0xFF, 0xF0,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x7E,
  0x04, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x04,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x03, 0xF1, 0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x3F, 0x0F, 0xC1,
  0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x03, 0xF0, 0xF8, 0x1F, 0x8F,
  0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x03, 0xF0, 0xF8, 0x1F,
  0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xE0, 0x7E, 0x1F, 0x03, 0xF1, 0xF8,
  0x3F, 0x0F, 0xC3, 0xF8, 0x7E, 0x3F, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x81,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x07,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xF0, 0x10,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x1F, 0xF3, 0xF0, 0xFF, 0x9F,
  0x87, 0xFC, 0xFC, 0x3F, 0xE7, 0xE3, 0xFE, 0x3E, 0x01, 0xF1, 0xF0, 0x1F,
  0x8F, 0x80, 0xFC, 0x7C, 0x07, 0xC3, 0xF0, 0x3E, 0x1F, 0x83, 0xF0, 0xFC,
  0x1F, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x07, 0xFE, 0x00, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x23, 0xF0, 0x0F, 0xFC, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x7E,
  0x07, 0xC1, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x0F, 0xC0, 0x7E, 0x3F, 0x00,
  0xF8, 0x7E, 0x01, 0xF1, 0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0xCF, 0x80, 0x1F,
  0xBF, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0xFD, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0,
  0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x7E, 0x01,
  0xF0, 0x7C, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C,
  0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFF, 0xF7, 0xFF, 0xBF,
  0xFE, 0xFF, 0xFB, 0xFF, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x07,
  0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F,
  0xC0, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0,
  0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0xC3, 0xDF, 0x03, 0xEF, 0x8F, 0xBE, 0x07,
  0xDF, 0x1E, 0xFC, 0x0F, 0xBE, 0x7D, 0xF0, 0x1F, 0x7C, 0xF3, 0xE0, 0x3E,
  0xFB, 0xE7, 0xC0, 0xF9, 0xF7, 0x9F, 0x81, 0xF3, 0xEF, 0x3E, 0x03, 0xE7,
  0xFE, 0x7C, 0x07, 0xCF, 0xF8, 0xF8, 0x1F, 0x1F, 0xF1, 0xF0, 0x3E, 0x1F,
  0xC7, 0xE0, 0x7C, 0x3F, 0x8F, 0x80, 0xF8, 0x7E, 0x1F, 0x01, 0xF0, 0xFC,
  0x3E, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x83, 0xE1, 0xF8, 0x1F, 0x07, 0xC3,
  0xE0, 0x00, 0x03, 0xF0, 0x0F, 0x81, 0xF8, 0x07, 0xC0, 0xFE, 0x07, 0xC0,
  0x7F, 0x03, 0xE0, 0x7F, 0x81, 0xF0, 0x3F, 0xC0, 0xF8, 0x1F, 0xE0, 0x7C,
  0x0F, 0xF0, 0x7C, 0x0F, 0xFC, 0x3E, 0x07, 0xFE, 0x1F, 0x03, 0xFF, 0x0F,
  0x81, 0xF7, 0x8F, 0x80, 0xF3, 0xC7, 0xC0, 0xF9, 0xF3, 0xE0, 0x7C, 0xF9,
  0xF0, 0x3E, 0x7C, 0xF8, 0x1F, 0x3E, 0xF8, 0x0F, 0x8F, 0x7C, 0x0F, 0x87,
  0xBE, 0x07, 0xC3, 0xFF, 0x03, 0xE1, 0xFF, 0x81, 0xF0, 0xFF, 0x81, 0xF0,
  0x7F, 0xC0, 0xF8, 0x1F, 0xE0, 0x7C, 0x0F, 0xF0, 0x3E, 0x07, 0xF8, 0x1F,
  0x03, 0xF8, 0x1F, 0x01, 0xFC, 0x0F, 0x80, 0xFE, 0x07, 0xC0, 0x3F, 0x00,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0x87, 0xE0, 0xFC, 0x0F, 0x87, 0xE0, 0x3F, 0x1F, 0x80,
  0xFC, 0x7E, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3E, 0x3F, 0x00, 0xF9,
  0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8,
  0x07, 0xC7, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x1F,
  0x87, 0xC0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0xC1, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x83, 0xF0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E,
  0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x03, 0xE0, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0,
  0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x87, 0xE0, 0xFC,
  0x0F, 0x87, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF3, 0xF0, 0x0F,
  0xCF, 0xC0, 0x3E, 0x3F, 0x00, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F,
  0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xC7, 0xC0, 0x3F, 0x3F, 0x00,
  0xFC, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x87, 0xC0, 0x7E, 0x1F, 0x83, 0xF0,
  0x7E, 0x1F, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF,
  0xF0, 0x7C, 0x3F, 0x07, 0xC3, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x0F, 0x87, 0xE1, 0xF9, 0xFC, 0x1F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0x7C, 0x03,
  0xE7, 0xE0, 0x3E, 0x7E, 0x03, 0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xE3, 0xE0,
  0x7C, 0x3F, 0x07, 0xC3, 0xF0, 0x7C, 0x1F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F,
  0x8F, 0x81, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x0C, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x04, 0x03, 0xF0, 0x70, 0x7F, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xCF, 0xFF, 0xEF, 0xFF, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x7C, 0x1F, 0x03, 0xF0, 0x7C, 0x0F, 0xC3, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8,
  0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF0, 0x7E,
  0x07, 0xC1, 0xF0, 0x3F, 0x07, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F,
  0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF8, 0x3E, 0x07, 0xE1, 0xF8, 0x1F, 0x07,
  0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0xC1, 0xF0, 0x3F, 0x0F, 0xC0,
  0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x3F, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x3F, 0x7C, 0x07, 0xEF, 0x80, 0xF9, 0xF0, 0x3F, 0x3E,
  0x07, 0xC7, 0xC1, 0xF8, 0xF8, 0x3F, 0x1F, 0x07, 0xC3, 0xE1, 0xF8, 0x7C,
  0x3E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xCF, 0x80, 0xF9,
  0xF0, 0x1F, 0x7E, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x7D, 0xF0, 0x1F, 0x03, 0xE7, 0xC0, 0xFC, 0x0F, 0x9F, 0x03, 0xF0, 0x7E,
  0x7C, 0x1F, 0x81, 0xF1, 0xF0, 0x7E, 0x07, 0xC7, 0xC1, 0xF8, 0x3F, 0x1F,
  0x0F, 0xE0, 0xF8, 0x7C, 0x3F, 0x87, 0xE3, 0xF1, 0xFE, 0x1F, 0x0F, 0x87,
  0xF8, 0x7C, 0x3E, 0x1F, 0xE3, 0xF0, 0xF8, 0xFF, 0x8F, 0x83, 0xE3, 0xDE,
  0x3E, 0x0F, 0x9F, 0x79, 0xF0, 0x3E, 0x79, 0xE7, 0xC0, 0xF9, 0xE7, 0xBF,
  0x03, 0xEF, 0x9E, 0xF8, 0x0F, 0xBC, 0x7B, 0xE0, 0x3F, 0xF1, 0xFF, 0x00,
  0xFF, 0xC7, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0x80, 0x3F,
  0xC1, 0xFE, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xE0,
  0xFF, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0xFC, 0x07, 0xC1, 0xF0, 0x0F,
  0x87, 0xC0, 0x1F, 0x1F, 0x80, 0x3F, 0x3E, 0x00, 0x3E, 0xFC, 0x00, 0x7D,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0xCF, 0x80, 0x1F,
  0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x0F, 0xC0,
  0xF8, 0x1F, 0x01, 0xF8, 0x00, 0xF8, 0x0F, 0xFE, 0x07, 0xEF, 0x81, 0xF3,
  0xE0, 0xFC, 0xFC, 0x3E, 0x3F, 0x1F, 0x87, 0xC7, 0xC1, 0xF3, 0xF0, 0x7C,
  0xF8, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x00, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x07,
  0x83, 0xC1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xC1, 0xE0, 0xF8,
  0x7C, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x7F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x0F, 0xFC, 0x03, 0xDF, 0x01, 0xF3, 0xC0, 0xF8, 0xF0, 0x3E, 0x3E, 0x1F,
  0x0F, 0x87, 0x81, 0xE3, 0xE0, 0x79, 0xF0, 0x1F, 0x78, 0x07, 0xFE, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x7E, 0x7E, 0x3E, 0x1E, 0x1F, 0x0F,
  0x03, 0xE3, 0xE0, 0xFE, 0x78, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xF9, 0xFC,
  0x7E, 0x3F, 0x8F, 0x83, 0xE3, 0xF0, 0x7C, 0x7E, 0x1F, 0x8F, 0x83, 0xF3,
  0xF0, 0x7E, 0x7E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF0, 0x7E, 0x3E, 0x0F, 0xC7,
  0xC1, 0xF0, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xF3, 0xF8, 0x7F, 0xFF, 0x0F,
  0xFF, 0xC0, 0xFE, 0xF8, 0x0F, 0x9F, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xFB, 0xE0, 0x3E, 0xFE, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0x9F, 0x87, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x07, 0xE3,
  0xE0, 0xF8, 0x7C, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x8F,
  0x83, 0xF3, 0xF0, 0x7C, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0xFC, 0x3F,
  0x1F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3E, 0xFE, 0x07, 0x9F, 0x80, 0x01,
  0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xCC, 0x3F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x10, 0xFE,
  0x70, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0xBF, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xCF, 0xE0, 0xFC, 0x7F,
  0x07, 0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xE0, 0xF8,
  0x3E, 0x0F, 0xC1, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0,
  0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x1F, 0x81, 0xF9, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x01, 0xFE, 0xF0, 0x07, 0xE7, 0x80, 0x01, 0xFC, 0x07,
  0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0x1F, 0x3E, 0x0F, 0x3E, 0x0F, 0x7C,
  0x1F, 0x7C, 0x3F, 0x7D, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x08, 0xFF,
  0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0xF8, 0x0F, 0xF7, 0x80, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7E, 0x7F, 0x07, 0xE3, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0x7C,
  0x1F, 0x87, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0x83, 0xF0,
  0x7C, 0x1F, 0x87, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF0, 0x3E, 0x1F, 0x81,
  0xF0, 0xFC, 0x0F, 0xCF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xEF,
  0x80, 0x3E, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x81, 0x00, 0xFC, 0x0F, 0xBF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xF7, 0xE0, 0xFB, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3,
  0xFB, 0xF1, 0xF8, 0x7C, 0x7E, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0,
  0xFC, 0xFC, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF9, 0xF8, 0x7E,
  0x7E, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0xFC, 0xFC, 0x3F, 0x3E,
  0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0x01, 0xE0, 0x3E, 0x03, 0xF0, 0x7E,
  0x03, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0xF8,
  0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0,
  0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x3F, 0x0F, 0x87, 0xE0, 0xF8, 0x7C, 0x0F, 0x8F, 0x80, 0xF9, 0xF8, 0x1F,
  0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x7C, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0,
  0x7E, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xE0, 0xF8, 0x7E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0x03, 0xF0, 0x3F, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F,
  0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F,
  0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0x0F, 0x9F, 0x0F, 0xC1,
  0xF7, 0xF3, 0xFC, 0x3D, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFC, 0xFF,
  0x7E, 0x3F, 0x0F, 0xC7, 0xC7, 0xE1, 0xF0, 0xF8, 0xF8, 0x7E, 0x1F, 0x1F,
  0x0F, 0x83, 0xE3, 0xE1, 0xF0, 0xFC, 0xF8, 0x3E, 0x1F, 0x1F, 0x07, 0xC3,
  0xE3, 0xE1, 0xF0, 0x7C, 0x7C, 0x3E, 0x0F, 0x8F, 0x87, 0xC3, 0xE3, 0xE0,
  0xF8, 0x7C, 0x7C, 0x1F, 0x0F, 0x8F, 0x87, 0xC1, 0xF1, 0xF0, 0xF8, 0x3E,
  0x7E, 0x1F, 0x0F, 0x8F, 0x83, 0xE1, 0xF1, 0xF0, 0x7C, 0x3E, 0x3E, 0x1F,
  0x07, 0xC0, 0x07, 0x1F, 0x03, 0xCF, 0xE0, 0xF7, 0xFC, 0x3F, 0xFF, 0x0F,
  0xEF, 0xC7, 0xE1, 0xF1, 0xF8, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC3,
  0xF3, 0xF0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE1, 0xF9,
  0xF8, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF3, 0xF0, 0xF8, 0xF8,
  0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE0, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0xE1, 0xFB, 0xF1, 0xF8, 0xFC, 0xF8, 0x3E, 0xFC, 0x1F, 0x7C,
  0x0F, 0xBE, 0x07, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xF7, 0xC0, 0xFB,
  0xE0, 0xFD, 0xF0, 0x7E, 0xF8, 0x3E, 0x7C, 0x3F, 0x3F, 0x3F, 0x0F, 0xFF,
  0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x00, 0x03, 0xE7, 0xE0, 0x1F, 0x7F,
  0x00, 0xF7, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x1F, 0x03, 0xF0, 0xFC, 0x1F,
  0x87, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x7C,
  0x1F, 0x03, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0x83, 0xF0,
  0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x7E, 0x07, 0xF7, 0xF0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF0, 0x1F, 0x7F, 0x80, 0xF9, 0xF0, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF3,
  0xE0, 0xFF, 0x78, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xF9, 0xFC, 0x7E, 0x3F,
  0x8F, 0x83, 0xE3, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x83, 0xF1, 0xF0, 0x7C,
  0x7E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC1, 0xF0,
  0xF8, 0x3E, 0x1F, 0x0F, 0xC3, 0xF3, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0,
  0xFE, 0xF8, 0x0F, 0x9F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x0F, 0x9F, 0x0F, 0xBE, 0x0F, 0xFE, 0x0F,
  0xFE, 0x0F, 0xFC, 0x1F, 0xE4, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F,
  0x0C, 0x3F, 0x04, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x81, 0xF8, 0xE3, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF,
  0x80, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xFC, 0xFF,
  0xCF, 0xFE, 0x7F, 0xF0, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x1F, 0x90, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x00, 0x1F,
  0x87, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x3F, 0x1F, 0x0F, 0x8F, 0x83,
  0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x1F, 0x1F, 0x87, 0xC7, 0xC1, 0xF1,
  0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x0F, 0x8F, 0xC3, 0xE3, 0xE0, 0xF8, 0xF8,
  0x7E, 0x3E, 0x1F, 0x8F, 0xCF, 0xC3, 0xFF, 0xF0, 0xFF, 0xBC, 0x1F, 0xDF,
  0x07, 0xE7, 0xC0, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8,
  0x7C, 0xF8, 0xFC, 0xF8, 0xF8, 0xF8, 0xF8, 0xF9, 0xF0, 0xF1, 0xF0, 0xF3,
  0xE0, 0xF3, 0xE0, 0xF3, 0xC0, 0xF7, 0xC0, 0xF7, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7C, 0x3F, 0x07, 0xDF, 0x0F, 0xC3, 0xE7, 0xC7, 0xF0, 0xF9, 0xE1,
  0xFC, 0x3E, 0x78, 0x7F, 0x1F, 0x1E, 0x3F, 0xC7, 0xC7, 0x8F, 0xF3, 0xE1,
  0xE3, 0xFC, 0xF8, 0xF9, 0xEF, 0x3E, 0x3E, 0x7B, 0xDF, 0x0F, 0xBE, 0xF7,
  0xC3, 0xEF, 0x7D, 0xE0, 0xFB, 0xDF, 0xF8, 0x3F, 0xE7, 0xBE, 0x0F, 0xF9,
  0xEF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F,
  0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x07, 0xE0,
  0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xC1, 0xF8, 0x3F, 0x1F, 0x80, 0xF8, 0xF8,
  0x07, 0xCF, 0xC0, 0x3E, 0x7C, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xBE,
  0x00, 0xFD, 0xF0, 0x07, 0xCF, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xF0, 0x3E,
  0x0F, 0x83, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x3E,
  0x0F, 0x80, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x3E,
  0x00, 0xF8, 0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0xF8, 0x00,
  0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x5F, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0x00, 0x0F, 0xE0, 0x0F, 0xF8,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x0C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFF,
  0x00, 0x7E, 0x00, 0x3E, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x80, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFC, 0x07, 0xFA, 0x00, 0x30,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 12, 30, 11, 0, -30 },
  { 46, 15, 11, 17, 4, -30 },
  { 67, 21, 30, 20, 0, -30 },
  { 146, 19, 34, 18, 0, -32 },
  { 227, 26, 30, 30, 2, -30 },
  { 325, 22, 30, 22, 0, -30 },
  { 408, 7, 11, 10, 4, -30 },
  { 418, 14, 37, 11, 1, -30 },
  { 483, 14, 38, 11, -3, -31 },
  { 550, 16, 17, 17, 3, -32 },
  { 584, 17, 20, 19, 2, -25 },
  { 627, 9, 12, 10, -2, -6 },
  { 641, 12, 5, 12, 0, -14 },
  { 649, 7, 6, 10, 0, -6 },
  { 655, 21, 30, 16, -2, -30 },
  { 734, 17, 30, 18, 1, -30 },
  { 798, 14, 30, 18, 4, -30 },
  { 851, 20, 30, 18, -2, -30 },
  { 926, 20, 30, 18, -1, -30 },
  { 1001, 20, 30, 18, -1, -30 },
  { 1076, 19, 30, 18, 0, -30 },
  { 1148, 18, 30, 18, 1, -30 },
  { 1216, 19, 30, 18, 1, -30 },
  { 1288, 19, 30, 18, 0, -30 },
  { 1360, 18, 30, 18, 0, -30 },
  { 1428, 10, 23, 10, 0, -23 },
  { 1457, 12, 29, 10, -2, -23 },
  { 1501, 17, 20, 19, 2, -25 },
  { 1544, 17, 13, 19, 2, -21 },
  { 1572, 17, 20, 19, 2, -25 },
  { 1615, 15, 30, 14, 1, -30 },
  { 1672, 26, 33, 27, 1, -30 },
  { 1780, 20, 30, 20, -3, -30 },
  { 1855, 20, 30, 20, 0, -30 },
  { 1930, 20, 30, 18, 1, -30 },
  { 2005, 21, 30, 22, 0, -30 },
  { 2084, 19, 30, 17, 0, -30 },
  { 2156, 19, 30, 16, 0, -30 },
  { 2228, 21, 30, 22, 2, -30 },
  { 2307, 24, 30, 22, 0, -30 },
  { 2397, 18, 30, 13, -2, -30 },
  { 2465, 18, 39, 10, -6, -30 },
  { 2553, 23, 30, 19, 0, -30 },
  { 2640, 14, 30, 16, 0, -30 },
  { 2693, 31, 30, 29, 0, -30 },
  { 2810, 25, 30, 24, 0, -30 },
  { 2904, 22, 30, 23, 1, -30 },
  { 2987, 21, 30, 19, 0, -30 },
  { 3066, 22, 37, 23, 1, -30 },
  { 3168, 20, 30, 19, 0, -30 },
  { 3243, 20, 30, 17, -1, -30 },
  { 3318, 17, 30, 17, 3, -30 },
  { 3382, 22, 30, 22, 1, -30 },
  { 3465, 19, 30, 19, 4, -30 },
  { 3537, 30, 30, 29, 3, -30 },
  { 3650, 23, 30, 18, -2, -30 },
  { 3737, 18, 30, 18, 4, -30 },
  { 3805, 21, 30, 16, -2, -30 },
  { 3884, 17, 37, 12, -2, -30 },
  { 3963, 9, 30, 16, 4, -30 },
  { 3997, 17, 37, 12, -3, -30 },
  { 4076, 18, 18, 18, 0, -30 },
  { 4117, 14, 2, 14, -4, 4 },
  { 4121, 8, 7, 13, 6, -32 },
  { 4128, 19, 23, 19, 1, -23 },
  { 4183, 19, 32, 19, 0, -32 },
  { 4259, 16, 23, 15, 1, -23 },
  { 4305, 21, 32, 19, 1, -32 },
  { 4389, 16, 23, 18, 1, -23 },
  { 4435, 22, 42, 12, -5, -32 },
  { 4551, 21, 33, 19, -1, -23 },
  { 4638, 18, 32, 19, 0, -32 },
  { 4710, 12, 32, 10, 0, -32 },
  { 4758, 17, 42, 10, -5, -32 },
  { 4848, 20, 32, 18, 0, -32 },
  { 4928, 12, 32, 10, 0, -32 },
  { 4976, 27, 23, 28, 0, -23 },
  { 5054, 18, 23, 19, 0, -23 },
  { 5106, 17, 23, 19, 1, -23 },
  { 5155, 21, 33, 19, -2, -23 },
  { 5242, 19, 33, 19, 1, -23 },
  { 5321, 16, 23, 14, 0, -23 },
  { 5367, 16, 23, 15, 0, -23 },
  { 5413, 13, 28, 12, 1, -28 },
  { 5459, 18, 23, 19, 1, -23 },
  { 5511, 16, 23, 17, 3, -23 },
  { 5557, 26, 23, 26, 2, -23 },
  { 5632, 21, 23, 17, -2, -23 },
  { 5693, 22, 33, 17, -3, -23 },
  { 5784, 18, 23, 14, -2, -23 },
  { 5836, 17, 37, 14, 0, -30 },
  { 5915, 5, 42, 16, 5, -32 },
  { 5942, 16, 37, 14, -2, -30 },
  { 6016, 17, 7, 19, 2, -18 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic42pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC42PT7B_H_
