#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC36PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x0F, 0xC3, 0xF0, 0xF8, 0x3C, 0x00, 0x3C, 0xF9,
  0xE7, 0xDF, 0x3C, 0xF9, 0xE7, 0x8F, 0x3C, 0x79, 0xE7, 0x8F, 0x3C, 0x71,
  0xE7, 0x8E, 0x00, 0x00, 0xF3, 0xC0, 0x38, 0xE0, 0x0E, 0x38, 0x07, 0x9E,
  0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7,
  0xFF, 0xF3, 0xFF, 0xFC, 0x1C, 0x70, 0x07, 0x1C, 0x03, 0xCF, 0x00, 0xE3,
  0x81, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE0, 0xF3, 0xC0,
  0x38, 0xE0, 0x0E, 0x38, 0x03, 0x9E, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x3C,
  0xF0, 0x00, 0x00, 0x10, 0x00, 0x30, 0x00, 0x78, 0x03, 0xFF, 0x07, 0xFF,
  0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0x64, 0x1F, 0x40, 0x1F, 0x40, 0x1F, 0x40,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC,
  0x01, 0x7C, 0x01, 0x7C, 0x41, 0x7C, 0x63, 0x7C, 0x7F, 0xF8, 0xFF, 0xF8,
  0xFF, 0xF0, 0x7F, 0xE0, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0F, 0x00, 0xF0, 0x7E, 0x03, 0x83, 0xFC, 0x1E, 0x0E, 0x70, 0x70, 0x79,
  0xC3, 0x81, 0xC7, 0x1E, 0x07, 0x1C, 0x70, 0x3C, 0x73, 0xC0, 0xE3, 0xCE,
  0x03, 0x8E, 0x78, 0x0E, 0x39, 0xC7, 0x39, 0xEF, 0x3E, 0xE7, 0x39, 0xFF,
  0xFD, 0xEF, 0x77, 0xE7, 0x39, 0xDF, 0x3D, 0xE7, 0x00, 0xE7, 0x1C, 0x07,
  0x1C, 0x70, 0x3C, 0xF1, 0xC0, 0xE3, 0xCF, 0x07, 0x8E, 0x38, 0x1C, 0x38,
  0xE0, 0xF0, 0xE7, 0x83, 0x83, 0xFC, 0x1E, 0x07, 0xE0, 0xF0, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0x7C, 0x07, 0x9F, 0x01,
  0xE7, 0xC0, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0xBC, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x07, 0xF8, 0xF3, 0xFE, 0x7C, 0xF7, 0xDE,
  0x7D, 0xF7, 0x9E, 0x3F, 0xCF, 0x8F, 0xF3, 0xE1, 0xF8, 0xF0, 0x7E, 0x3E,
  0x3F, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xDF, 0x0F, 0xE7, 0xE0, 0x3E,
  0x78, 0xF3, 0xE7, 0xCF, 0x1E, 0x3C, 0x79, 0xE0, 0x00, 0xF8, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78,
  0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x00,
  0x04, 0x00, 0x3E, 0x01, 0xE0, 0x8F, 0x07, 0x78, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0x0F, 0xF8, 0xFC, 0x0F, 0xF1, 0xFB, 0x87, 0x9E, 0x18, 0xF8, 0x42,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x1F, 0x1F, 0x1E,
  0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0x78, 0xF0, 0x7F, 0xDF, 0xF7, 0xF9, 0xFE,
  0xFF, 0x80, 0x7B, 0xFF, 0xFE, 0xF0, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0x7F,
  0xE1, 0xF3, 0xC3, 0xC7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3C, 0x3C, 0xF8, 0x79,
  0xF0, 0xF3, 0xC1, 0xEF, 0x87, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3C, 0xF0,
  0xF9, 0xE1, 0xF3, 0xC3, 0xC7, 0x8F, 0x8F, 0x1F, 0x1E, 0x7C, 0x3F, 0xF8,
  0x7F, 0xE0, 0x7F, 0x80, 0x7E, 0x00, 0x00, 0xF0, 0x1F, 0x03, 0xF0, 0x7E,
  0x1F, 0xE3, 0xFE, 0x7F, 0xEF, 0xBC, 0x73, 0xC2, 0x3C, 0x07, 0xC0, 0x7C,
  0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x00, 0xFC, 0x01,
  0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x79, 0xF8, 0x30, 0x7C, 0x10, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0xE1, 0xFF, 0xF0,
  0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xE0,
  0xFF, 0xF0, 0x31, 0xF8, 0x10, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x1F, 0x80, 0x7F, 0x80, 0x3F, 0x00, 0x3F, 0xC0, 0x1F,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0xC6, 0x07, 0xE3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xBC, 0x07, 0xBC, 0x07, 0x7C, 0x0E,
  0x7C, 0x1E, 0x78, 0x1C, 0x78, 0x38, 0x78, 0x78, 0xF8, 0x70, 0xF8, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xFE, 0x07, 0xFE, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x80, 0xF8, 0xC1,
  0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x7F, 0x00,
  0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0xE0, 0x7D, 0xF0, 0x7F, 0xF8, 0x7F, 0xF8, 0x7E,
  0xF8, 0xFC, 0x7C, 0xF8, 0x7C, 0xF8, 0x78, 0xF8, 0x78, 0xF0, 0xF8, 0xF0,
  0xF8, 0xF0, 0xF8, 0xF9, 0xF0, 0xFF, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F,
  0x80, 0x1F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x03,
  0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1E, 0x0F, 0x3E, 0x0F, 0xFC, 0x07, 0xF8, 0x07, 0xE0, 0x0F,
  0xF0, 0x3F, 0xF8, 0x3E, 0xF8, 0x7C, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8,
  0x7C, 0xF8, 0x7C, 0xF8, 0x78, 0xFD, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F,
  0xC0, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xBE, 0x1F,
  0x1F, 0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x7E, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xBC, 0x0F, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0xFF, 0xE0, 0xFF,
  0xC0, 0xFF, 0x80, 0xFF, 0x00, 0x07, 0x07, 0xC7, 0xE3, 0xE1, 0xF0, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0xFC,
  0x7E, 0x3E, 0x1E, 0x00, 0x01, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xF0, 0x7F,
  0xC3, 0xFC, 0x1F, 0xE0, 0x7F, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0x80, 0x03, 0x00, 0x02, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x01, 0xE0, 0x03,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0x00,
  0x7E, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0x3E, 0x00,
  0x70, 0x00, 0x80, 0x00, 0x07, 0xC0, 0xFF, 0x8F, 0xFC, 0x7F, 0xF3, 0x0F,
  0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xF8, 0x1E, 0x07, 0x80,
  0x38, 0x3C, 0x00, 0x70, 0xE0, 0x01, 0xC7, 0x0F, 0xE7, 0x3C, 0x7F, 0x9C,
  0xE3, 0xDE, 0x73, 0x9E, 0x79, 0xDC, 0x71, 0xC7, 0x71, 0xC7, 0x1D, 0xCE,
  0x1C, 0x7E, 0x38, 0xF3, 0xB8, 0xE3, 0x8E, 0xE3, 0x8E, 0x3B, 0x9E, 0x79,
  0xCE, 0x39, 0xE7, 0x38, 0xFF, 0xF8, 0xE3, 0xE7, 0xC3, 0x87, 0x1E, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF0, 0x30, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xB8, 0x03, 0xFC, 0x01, 0xFF,
  0x01, 0xEF, 0x80, 0xF7, 0xC0, 0xFB, 0xE0, 0x79, 0xF0, 0x7C, 0xF8, 0x3E,
  0x7C, 0x1E, 0x3E, 0x1F, 0xFF, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3,
  0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xC0, 0x07, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0,
  0xF8, 0xF8, 0x7C, 0x3C, 0x3E, 0x1E, 0x1E, 0x0F, 0x0F, 0x0F, 0x8F, 0x87,
  0xC7, 0xCF, 0xC3, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xE0, 0xFB, 0xF8, 0x7C,
  0x7C, 0x3C, 0x1E, 0x1E, 0x0F, 0x1F, 0x07, 0x8F, 0x87, 0xC7, 0xC3, 0xE3,
  0xC3, 0xE1, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFC, 0x60, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x80,
  0x7F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0xC3, 0xE3, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07,
  0xC7, 0x81, 0xF3, 0xE0, 0xFC, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x07, 0xE7,
  0xC1, 0xF1, 0xF0, 0xFC, 0x7C, 0x7E, 0x1F, 0x3F, 0x07, 0xFF, 0xC3, 0xFF,
  0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFE, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x1F, 0x04, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8,
  0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x10, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0,
  0xFE, 0x18, 0x1F, 0x01, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC7, 0xF8, 0xF8, 0xFF, 0x1F,
  0x1F, 0xE7, 0xC3, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C,
  0x0F, 0x8F, 0xC1, 0xE0, 0xF8, 0x7C, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0xFC, 0x01, 0xFF, 0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x78, 0x1F, 0x0F, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x03, 0xE1, 0xF0, 0x3C, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x7C, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78,
  0x1F, 0x0F, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x03, 0xFF, 0x03,
  0xFF, 0x07, 0xFF, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF,
  0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x7F,
  0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xB8, 0x00, 0x07, 0xC1, 0xF0,
  0x7C, 0x3E, 0x07, 0x87, 0xC0, 0x78, 0x7C, 0x0F, 0x8F, 0x80, 0xF9, 0xF0,
  0x0F, 0x9F, 0x00, 0xF3, 0xE0, 0x0F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0xF8,
  0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x3E, 0xF8, 0x03, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xC7, 0x80, 0x7C,
  0x78, 0x07, 0x87, 0xC0, 0x78, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F,
  0x83, 0xE0, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7F,
  0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xF0,
  0x7E, 0x01, 0xFC, 0x1F, 0x80, 0xFF, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xFC,
  0x3F, 0xC1, 0xEF, 0x1E, 0xF0, 0x7B, 0xC7, 0xFC, 0x1E, 0xF3, 0xDF, 0x07,
  0xBC, 0xF7, 0x83, 0xEF, 0x39, 0xE0, 0xF3, 0xDE, 0x78, 0x3C, 0xF7, 0xBE,
  0x0F, 0x3F, 0xCF, 0x87, 0xCF, 0xF3, 0xC1, 0xF3, 0xF8, 0xF0, 0x78, 0xFE,
  0x7C, 0x1E, 0x3F, 0x1F, 0x07, 0x8F, 0xC7, 0x83, 0xE3, 0xE1, 0xE0, 0xF0,
  0xF8, 0x78, 0x3C, 0x3C, 0x3E, 0x00, 0x07, 0xC0, 0x78, 0x3F, 0x03, 0xC1,
  0xF8, 0x1E, 0x0F, 0xC1, 0xF0, 0xFE, 0x0F, 0x07, 0xF0, 0x78, 0x3F, 0xC3,
  0xC1, 0xFE, 0x1E, 0x0F, 0xF1, 0xF0, 0xFF, 0x8F, 0x07, 0xBC, 0x78, 0x3D,
  0xE3, 0xC1, 0xE7, 0xBE, 0x0F, 0x3D, 0xF0, 0xF9, 0xEF, 0x07, 0x8F, 0x78,
  0x3C, 0x7B, 0xC1, 0xE3, 0xDE, 0x1F, 0x0F, 0xF0, 0xF8, 0x7F, 0x07, 0x83,
  0xF8, 0x3C, 0x1F, 0xC1, 0xE0, 0xFE, 0x1F, 0x07, 0xE0, 0xF0, 0x1F, 0x07,
  0x80, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF,
  0x0F, 0xCF, 0xC7, 0xE1, 0xF1, 0xF0, 0x7C, 0xFC, 0x1F, 0x3E, 0x07, 0xCF,
  0x81, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x81, 0xF3, 0xE0, 0x7C,
  0xFC, 0x3E, 0x1F, 0x1F, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F,
  0x9F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x07, 0xC7, 0xC1,
  0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x3F, 0x07, 0xFF, 0xC3, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xE0, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0x0F, 0xCF,
  0xC7, 0xE1, 0xF1, 0xF0, 0x7C, 0xFC, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF7,
  0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x81, 0xF3, 0xE0, 0x7C, 0xFC, 0x3E,
  0x1F, 0x1F, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x07, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0xF9, 0xF8,
  0x7C, 0x7C, 0x3E, 0x3E, 0x1E, 0x1F, 0x0F, 0x0F, 0x8F, 0x87, 0xC7, 0xC7,
  0xC3, 0xC7, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3C,
  0xF0, 0x1E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xC7, 0x83, 0xC3, 0xC1,
  0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xEF, 0x03, 0xF0, 0x40, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x40, 0x7C, 0x1C, 0x3F, 0x07, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xF8, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E,
  0x0F, 0x07, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8,
  0x3C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xC1,
  0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07,
  0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x87, 0xC1, 0xF8, 0xF8, 0x3F, 0xFF,
  0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x0F, 0xFC, 0x07,
  0xBE, 0x07, 0xDF, 0x03, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xE1, 0xF1, 0xF0,
  0xF8, 0xF8, 0x78, 0x7C, 0x7C, 0x3E, 0x3C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07,
  0xCF, 0x03, 0xEF, 0x81, 0xF7, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3D, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x03, 0xDF, 0x07, 0xC1, 0xF7, 0xC1,
  0xF0, 0x79, 0xE0, 0x7C, 0x1E, 0x78, 0x3F, 0x0F, 0x9E, 0x0F, 0xC3, 0xC7,
  0x87, 0xE1, 0xF1, 0xE1, 0xF8, 0x7C, 0x78, 0x7E, 0x1E, 0x1E, 0x3F, 0x8F,
  0x87, 0x8E, 0xE3, 0xC1, 0xE7, 0xB9, 0xF0, 0x79, 0xEE, 0x7C, 0x1E, 0x73,
  0x9E, 0x07, 0xBD, 0xEF, 0x81, 0xEF, 0x7B, 0xC0, 0x7F, 0x9E, 0xF0, 0x1F,
  0xE7, 0xFC, 0x07, 0xF1, 0xFE, 0x01, 0xFC, 0x7F, 0x80, 0x7F, 0x1F, 0xC0,
  0x1F, 0x87, 0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x1F,
  0x80, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xC1, 0xF0, 0x3E, 0x1F, 0x03, 0xE3,
  0xE0, 0x3E, 0x3E, 0x03, 0xE7, 0xC0, 0x1E, 0x78, 0x01, 0xEF, 0x80, 0x1E,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x0F, 0xBC, 0x00, 0xF3, 0xC0, 0x1F, 0x3C, 0x01, 0xE3, 0xE0,
  0x3E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x0F, 0x81, 0xE0, 0xF8, 0x1F,
  0xF8, 0x3E, 0xF8, 0x3C, 0x78, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0x78, 0xF0,
  0x79, 0xF0, 0x7D, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xFF,
  0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x8F, 0x1E, 0x3C, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F,
  0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x07, 0xF8, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xBC, 0x0F, 0x3C, 0x0F,
  0x3C, 0x1E, 0x3C, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0xF8, 0xF9, 0xF1, 0xE3, 0xC3, 0xC0,
  0x07, 0x8F, 0x0F, 0xDF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3E, 0x7E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0xF8, 0xF9, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0,
  0xFE, 0xF0, 0x7C, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x3C, 0x0F, 0x7E, 0x1F, 0xFE,
  0x1F, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1F,
  0x3C, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C,
  0x7C, 0x7C, 0xFE, 0xF8, 0xFF, 0xF8, 0xF7, 0xF0, 0xF7, 0xE0, 0x03, 0xF0,
  0x7F, 0xC7, 0xFE, 0x3F, 0xE3, 0xE1, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xE0, 0x1F, 0x08,
  0xFF, 0xC7, 0xFE, 0x1F, 0xF0, 0x7F, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x0F, 0x3E,
  0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x87, 0xCF, 0xC3, 0xC3, 0xE3, 0xE1,
  0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0xF8, 0x3C, 0x7C, 0x3E, 0x3C, 0x1E, 0x1E,
  0x0F, 0x0F, 0x07, 0x87, 0x87, 0xC3, 0xC3, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0,
  0x3F, 0xF8, 0x1F, 0x3C, 0x00, 0x03, 0xE0, 0x1F, 0xE0, 0xFF, 0x87, 0xFF,
  0x3E, 0x3C, 0xF0, 0xF7, 0x83, 0xDE, 0x1E, 0xFF, 0xFB, 0xFF, 0xCF, 0xFC,
  0x3E, 0x80, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x63, 0xFF,
  0x87, 0xFE, 0x0F, 0xF0, 0x00, 0x03, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x80, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0xBF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0x60, 0x00, 0x00, 0x01, 0xF3, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x0F, 0x9F, 0x83, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x3E, 0x0F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x0F, 0x83,
  0xC3, 0xE0, 0xF9, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFB, 0xC0, 0x7D,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x82, 0x03, 0xE0, 0xE1, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x3C, 0x0F, 0x7E, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0x9F, 0x1F, 0x1F,
  0x1E, 0x1E, 0x3E, 0x1E, 0x3E, 0x1E, 0x3C, 0x3E, 0x3C, 0x3E, 0x3C, 0x3C,
  0x7C, 0x3C, 0x7C, 0x3C, 0x78, 0x7C, 0x78, 0x7C, 0xF8, 0x78, 0xF8, 0x78,
  0xF8, 0xF8, 0xF0, 0xF8, 0x03, 0xC1, 0xF0, 0x7C, 0x1E, 0x03, 0x00, 0x00,
  0x00, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x5F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0x80, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1E, 0x1F, 0x0F, 0x0F, 0x0F, 0x8F, 0x87, 0xCF, 0x83, 0xCF, 0x81,
  0xE7, 0x80, 0xF7, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x0F, 0xFE, 0x07, 0xDF, 0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xF1,
  0xF0, 0xF8, 0xF8, 0x78, 0x7C, 0x3C, 0x1E, 0x00, 0x07, 0xC1, 0xF0, 0x7C,
  0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E,
  0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1E, 0x07,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x00, 0x0E, 0x3C, 0x3C, 0x1D, 0xFD, 0xFC,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xF1, 0xF1, 0xE3, 0xE3, 0xE3, 0xC7,
  0x87, 0x87, 0x9F, 0x0F, 0x0F, 0x3E, 0x3E, 0x3E, 0x78, 0x78, 0x7C, 0xF0,
  0xF0, 0xF1, 0xE1, 0xE1, 0xE7, 0xC7, 0xC3, 0xCF, 0x8F, 0x8F, 0x9E, 0x1E,
  0x1E, 0x3C, 0x3C, 0x3C, 0xF8, 0x78, 0x79, 0xF1, 0xF1, 0xF3, 0xC3, 0xE3,
  0xE7, 0x87, 0x87, 0x80, 0x0E, 0x3C, 0x0E, 0x7E, 0x1E, 0xFE, 0x1F, 0xFF,
  0x1F, 0x9F, 0x1F, 0x1F, 0x1E, 0x1E, 0x3E, 0x1E, 0x3E, 0x1E, 0x3C, 0x3E,
  0x3C, 0x3E, 0x3C, 0x3C, 0x7C, 0x3C, 0x7C, 0x3C, 0x78, 0x7C, 0x78, 0x7C,
  0x78, 0x78, 0xF8, 0x78, 0xF8, 0x78, 0xF0, 0xF8, 0x03, 0xE0, 0x3F, 0xE1,
  0xFF, 0x87, 0xFF, 0x3E, 0x7D, 0xF0, 0xF7, 0xC3, 0xDE, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xEF, 0x0F, 0xBE, 0x7C,
  0xFF, 0xF1, 0xFF, 0x87, 0xFC, 0x0F, 0xE0, 0x03, 0x8F, 0x00, 0xE7, 0xE0,
  0x7B, 0xF8, 0x1F, 0xFF, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x78, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xC1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF1, 0xF0, 0x7C, 0x7C, 0x3F, 0xFE, 0x0F, 0xFF, 0x83,
  0xDF, 0xC0, 0xF3, 0xE0, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xCF, 0x0F, 0xEF, 0x1F, 0xFE, 0x1F, 0xFE, 0x3E, 0x7E, 0x3C,
  0x3E, 0x7C, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xF0,
  0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0xF8, 0xFF, 0xF0, 0xFF,
  0xF0, 0xFE, 0xF0, 0x7D, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x0E,
  0x38, 0x73, 0xC7, 0xBE, 0x3F, 0xE1, 0xFF, 0x0F, 0xC0, 0x7C, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0xC7,
  0xFE, 0x7F, 0xE3, 0xE1, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x90, 0x7C, 0xFF, 0xE7,
  0xFE, 0x3F, 0xE1, 0xFE, 0x00, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xFE,
  0x7F, 0x9F, 0xF3, 0xFE, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8,
  0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xA1, 0xFC, 0x1F,
  0x83, 0xF0, 0x1E, 0x1E, 0x3C, 0x3C, 0xF8, 0x79, 0xF0, 0xF3, 0xC3, 0xE7,
  0x87, 0x8F, 0x0F, 0x3E, 0x1E, 0x78, 0x7C, 0xF0, 0xF9, 0xE1, 0xE7, 0xC3,
  0xCF, 0x87, 0x9E, 0x1F, 0x3C, 0x3E, 0x78, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3,
  0xFB, 0xC3, 0xE7, 0x00, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xBC, 0x3E, 0xF0,
  0xF3, 0xC3, 0xCF, 0x1F, 0x3C, 0x78, 0xF3, 0xE3, 0xCF, 0x0F, 0x3C, 0x3D,
  0xE0, 0x77, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0xF8, 0x7C, 0x3F, 0xC3, 0xE1, 0xFF, 0x0F, 0x87, 0xBC,
  0x7E, 0x3E, 0xF1, 0xF8, 0xF3, 0xC7, 0xE3, 0xCF, 0x3F, 0x9E, 0x3C, 0xEE,
  0x78, 0xF7, 0xB9, 0xE3, 0xDE, 0xEF, 0x0F, 0x73, 0xBC, 0x3F, 0xDF, 0xE0,
  0xFF, 0x7F, 0x83, 0xF9, 0xFE, 0x0F, 0xE7, 0xF0, 0x3F, 0x1F, 0xC0, 0xFC,
  0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x00, 0x07, 0x87,
  0xC1, 0xE1, 0xE0, 0x7C, 0xF8, 0x1F, 0x3C, 0x07, 0xDF, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xF7, 0x80, 0x7D, 0xE0, 0x3E, 0x78,
  0x0F, 0x1F, 0x07, 0xC7, 0xC3, 0xE1, 0xF0, 0x07, 0xC1, 0xE0, 0xF8, 0x7C,
  0x1F, 0x0F, 0x03, 0xE1, 0xE0, 0x7C, 0x7C, 0x07, 0x8F, 0x00, 0xF3, 0xE0,
  0x1E, 0x78, 0x03, 0xDF, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x5F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC7, 0xFF, 0x00,
  0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x7F, 0xE3, 0xFF, 0x8F,
  0xFE, 0x3F, 0xF8, 0x00, 0x0E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xFC,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x0F,
  0x80, 0x3F, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0xC0,
  0x3E, 0x00, 0xF8, 0x0F, 0xE0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0xFE, 0x03,
  0xF8, 0x0F, 0xC0, 0x30, 0x00, 0x08, 0x02, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xF0, 0x1F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 10, 26, 9, 0, -26 },
  { 34, 13, 10, 14, 3, -26 },
  { 51, 18, 26, 17, 0, -26 },
  { 110, 16, 29, 15, 0, -27 },
  { 168, 22, 26, 25, 2, -26 },
  { 240, 18, 26, 19, 0, -26 },
  { 299, 7, 10, 9, 3, -26 },
  { 308, 13, 32, 10, 0, -26 },
  { 360, 12, 32, 10, -3, -26 },
  { 408, 13, 15, 15, 3, -28 },
  { 433, 15, 17, 17, 1, -21 },
  { 465, 8, 10, 9, -2, -5 },
  { 475, 10, 5, 10, 0, -12 },
  { 482, 6, 5, 9, 0, -5 },
  { 486, 18, 26, 13, -2, -26 },
  { 545, 15, 26, 15, 1, -26 },
  { 594, 12, 26, 16, 3, -26 },
  { 633, 17, 26, 15, -1, -26 },
  { 689, 17, 26, 15, -1, -26 },
  { 745, 16, 26, 16, 0, -26 },
  { 797, 16, 26, 15, 0, -26 },
  { 849, 16, 26, 15, 1, -26 },
  { 901, 17, 26, 15, 1, -26 },
  { 957, 16, 26, 15, 0, -26 },
  { 1009, 16, 26, 15, 0, -26 },
  { 1061, 9, 20, 9, 0, -20 },
  { 1084, 11, 25, 9, -2, -20 },
  { 1119, 15, 17, 17, 1, -21 },
  { 1151, 15, 11, 17, 1, -18 },
  { 1172, 15, 17, 17, 1, -21 },
  { 1204, 13, 26, 12, 1, -26 },
  { 1247, 22, 29, 23, 1, -26 },
  { 1327, 17, 26, 17, -2, -26 },
  { 1383, 17, 26, 17, 0, -26 },
  { 1439, 17, 26, 16, 1, -26 },
  { 1495, 18, 26, 18, 0, -26 },
  { 1554, 16, 26, 14, 0, -26 },
  { 1606, 16, 26, 14, 0, -26 },
  { 1658, 19, 26, 19, 1, -26 },
  { 1720, 20, 26, 19, 0, -26 },
  { 1785, 16, 26, 11, -2, -26 },
  { 1837, 16, 34, 9, -6, -26 },
  { 1905, 20, 26, 17, 0, -26 },
  { 1970, 12, 26, 14, 0, -26 },
  { 2009, 26, 26, 25, 0, -26 },
  { 2094, 21, 26, 20, 0, -26 },
  { 2163, 18, 26, 20, 1, -26 },
  { 2222, 18, 26, 17, 0, -26 },
  { 2281, 18, 32, 20, 1, -26 },
  { 2353, 17, 26, 17, 0, -26 },
  { 2409, 18, 26, 15, -1, -26 },
  { 2468, 14, 26, 14, 3, -26 },
  { 2514, 19, 26, 19, 1, -26 },
  { 2576, 17, 26, 17, 3, -26 },
  { 2632, 26, 26, 25, 2, -26 },
  { 2717, 20, 26, 16, -2, -26 },
  { 2782, 16, 26, 15, 3, -26 },
  { 2834, 17, 26, 14, -1, -26 },
  { 2890, 14, 32, 10, -1, -26 },
  { 2946, 7, 26, 14, 4, -26 },
  { 2969, 15, 32, 10, -3, -26 },
  { 3029, 16, 16, 16, 0, -26 },
  { 3061, 12, 3, 12, -3, 3 },
  { 3066, 7, 6, 11, 5, -28 },
  { 3072, 16, 20, 17, 1, -20 },
  { 3112, 16, 27, 17, 0, -27 },
  { 3166, 13, 20, 13, 1, -20 },
  { 3199, 17, 27, 17, 1, -27 },
  { 3257, 14, 20, 15, 1, -20 },
  { 3292, 18, 37, 10, -4, -28 },
  { 3376, 18, 29, 17, -1, -20 },
  { 3442, 16, 27, 17, 0, -27 },
  { 3496, 10, 27, 8, 0, -27 },
  { 3530, 15, 36, 8, -5, -27 },
  { 3598, 17, 27, 15, 0, -27 },
  { 3656, 10, 27, 8, 0, -27 },
  { 3690, 23, 20, 24, 0, -20 },
  { 3748, 16, 20, 17, 0, -20 },
  { 3788, 14, 20, 16, 1, -20 },
  { 3823, 18, 29, 17, -2, -20 },
  { 3889, 16, 29, 17, 1, -20 },
  { 3947, 13, 20, 12, 0, -20 },
  { 3980, 13, 20, 13, 0, -20 },
  { 4013, 11, 24, 11, 1, -24 },
  { 4046, 15, 20, 16, 1, -20 },
  { 4084, 14, 20, 14, 2, -20 },
  { 4119, 22, 20, 22, 2, -20 },
  { 4174, 18, 20, 15, -2, -20 },
  { 4219, 19, 29, 14, -3, -20 },
  { 4288, 14, 20, 12, -1, -20 },
  { 4323, 15, 32, 12, 0, -26 },
  { 4383, 4, 36, 13, 4, -28 },
  { 4401, 14, 32, 12, -2, -26 },
  { 4457, 15, 6, 17, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic36pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC36PT7B_H_
