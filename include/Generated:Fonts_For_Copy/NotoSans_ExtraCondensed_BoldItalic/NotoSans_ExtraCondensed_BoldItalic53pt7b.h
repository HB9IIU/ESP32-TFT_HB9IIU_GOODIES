#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC53PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x3F,
  0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0x80,
  0x04, 0x00, 0x00, 0x3F, 0x8F, 0xE7, 0xF3, 0xF8, 0xFC, 0x7F, 0x1F, 0x8F,
  0xE7, 0xF1, 0xF8, 0xFE, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x3F,
  0x0F, 0x87, 0xE1, 0xF0, 0xFC, 0x7E, 0x1F, 0x0F, 0xC3, 0xE1, 0xF0, 0x7C,
  0x00, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1E, 0x00,
  0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0x87,
  0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0x87, 0xC0, 0x3F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0x07, 0xC3, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E,
  0x1F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0xC3, 0xC0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x07, 0xC3, 0xE0, 0x00,
  0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF0, 0xF8,
  0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x3E,
  0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xF3, 0x38, 0x07, 0xE7, 0x18, 0x07, 0xE6,
  0x00, 0x07, 0xE6, 0x00, 0x07, 0xE6, 0x00, 0x07, 0xF6, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x33, 0xF8, 0x00, 0x33, 0xF8, 0x40, 0x33,
  0xF8, 0x60, 0x33, 0xF0, 0x70, 0x77, 0xF0, 0x7C, 0x6F, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xF8, 0x00, 0xF8, 0x03,
  0xFE, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7C, 0x03, 0xFF, 0xC0, 0x7C, 0x01,
  0xF3, 0xE0, 0x3E, 0x01, 0xF1, 0xF0, 0x3E, 0x00, 0xF8, 0xF8, 0x1F, 0x00,
  0xF8, 0x7C, 0x1F, 0x00, 0x7C, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x0F, 0x80,
  0x3E, 0x0F, 0x8F, 0x80, 0x1F, 0x0F, 0x87, 0xC0, 0x0F, 0x87, 0xC7, 0xC0,
  0x07, 0xC3, 0xE3, 0xE0, 0x03, 0xE1, 0xF3, 0xE0, 0x01, 0xF1, 0xF1, 0xF0,
  0xF8, 0xF8, 0xF9, 0xF1, 0xFE, 0x7C, 0xF8, 0xF9, 0xFF, 0xBE, 0x7C, 0xF9,
  0xFF, 0xDF, 0xFC, 0xFC, 0xFB, 0xFF, 0xFE, 0x7C, 0xF8, 0xFB, 0xFE, 0x7C,
  0x7C, 0x7C, 0xFC, 0x3E, 0x7C, 0x3E, 0x00, 0x3E, 0x3E, 0x1F, 0x00, 0x1F,
  0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x07, 0xC0, 0x0F, 0x8F, 0x87, 0xC0, 0x0F,
  0x87, 0xC3, 0xE0, 0x07, 0xC3, 0xE1, 0xF0, 0x07, 0xC1, 0xF0, 0xF8, 0x03,
  0xE0, 0xF8, 0xF8, 0x03, 0xE0, 0x7C, 0x7C, 0x03, 0xE0, 0x3E, 0x7C, 0x01,
  0xF0, 0x1F, 0x3E, 0x01, 0xF0, 0x0F, 0xFE, 0x00, 0xF8, 0x07, 0xFF, 0x00,
  0xF8, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xEF,
  0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01,
  0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0xFE,
  0x00, 0x1F, 0x9F, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x1F,
  0x83, 0xFF, 0x87, 0xF0, 0xFF, 0xF8, 0xFC, 0x3F, 0xFF, 0x1F, 0x8F, 0xEF,
  0xE7, 0xF1, 0xF8, 0xFE, 0xFC, 0x7F, 0x1F, 0xFF, 0x8F, 0xC1, 0xFF, 0xE3,
  0xF8, 0x3F, 0xFC, 0x7F, 0x07, 0xFF, 0x0F, 0xE0, 0x7F, 0xC1, 0xFC, 0x0F,
  0xF8, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x7F, 0xC0, 0xFF, 0x1F, 0xFC, 0x1F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0x7F, 0x03, 0xFF, 0xCF,
  0xF0, 0x3F, 0xE1, 0xFE, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xE7,
  0xE3, 0xF3, 0xF9, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x1F, 0x8F, 0xC7, 0xE0,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x20, 0xFC,
  0x03, 0x0F, 0xC0, 0x7C, 0xF8, 0x17, 0xFF, 0x8E, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xC0, 0x0F,
  0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xBF, 0x07, 0xF3, 0xF0, 0x3F, 0x1F, 0x81,
  0xE1, 0xF8, 0x0C, 0x1E, 0x00, 0x40, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xC1,
  0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F,
  0xC0, 0x7F, 0xFD, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0xC0,
  0x1E, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x10, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x7F,
  0x1F, 0xC1, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x1F,
  0xC7, 0xF0, 0x7F, 0x1F, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xCF,
  0xE0, 0x7E, 0x3F, 0x01, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0,
  0xFE, 0x7F, 0x03, 0xF9, 0xF8, 0x0F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xFC,
  0xFE, 0x07, 0xF3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFC,
  0x1F, 0xC3, 0xF0, 0x7F, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFF, 0xFF,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F,
  0xFE, 0x3F, 0xBF, 0x3F, 0xFF, 0x8F, 0x9F, 0xC3, 0x8F, 0xC1, 0x87, 0xE0,
  0x47, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xE1,
  0xFE, 0x01, 0xE0, 0x7F, 0x00, 0xC0, 0x3F, 0x80, 0x20, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0x81, 0xFE,
  0x01, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC2,
  0x00, 0x3F, 0xC1, 0xC0, 0x3F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1E,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3D, 0xFC, 0x00, 0x7D, 0xFC, 0x00, 0xF9,
  0xF8, 0x00, 0xF1, 0xF8, 0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xF8, 0x03, 0xE3,
  0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x87, 0xF0, 0x1F, 0x07,
  0xF0, 0x3E, 0x07, 0xF0, 0x3E, 0x07, 0xE0, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x06, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x80, 0x1F, 0xE0, 0xE0, 0x3F, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC3,
  0x00, 0x1F, 0x9F, 0xC0, 0x3F, 0xBF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xE7, 0xF0, 0x7F, 0x87, 0xF0, 0x7F, 0x87,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xF8, 0xFF, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0xFE, 0x07, 0xF0, 0xFC, 0x07, 0xF1, 0xFC, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xCF, 0xE0,
  0x3F, 0x87, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0xFE, 0x03, 0xF8,
  0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFE, 0x07, 0xF0,
  0xFE, 0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x0F,
  0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC,
  0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0x8F, 0xE0, 0xFF, 0x1F, 0xC3,
  0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x9F, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0x81, 0xFF, 0xBF, 0x03, 0xFF, 0xFE, 0x03, 0xF9, 0xFC, 0x00, 0xC7, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFB, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x01, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFC, 0x07, 0xC0, 0x08, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0x80,
  0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x03,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0xFF, 0xFE, 0x1F, 0x3F, 0xC3, 0x03, 0xF8, 0x40, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x3F, 0xE1, 0xE0, 0xF0, 0x3F, 0xF8,
  0xF0, 0xF8, 0x7F, 0xF8, 0x78, 0x78, 0x3F, 0xFC, 0x3C, 0x7C, 0x3E, 0x3E,
  0x1E, 0x3C, 0x3E, 0x1F, 0x0F, 0x3E, 0x1E, 0x0F, 0x0F, 0x9F, 0x1F, 0x07,
  0x87, 0xCF, 0x0F, 0x87, 0xC3, 0xCF, 0x87, 0x83, 0xE1, 0xE7, 0xC7, 0xC1,
  0xE0, 0xF3, 0xC3, 0xE1, 0xF0, 0xF9, 0xE1, 0xF0, 0xF8, 0x78, 0xF0, 0xF0,
  0x7C, 0x3C, 0xF8, 0x78, 0x7C, 0x1E, 0x7C, 0x3C, 0x3E, 0x1E, 0x3E, 0x1E,
  0x1F, 0x1F, 0x1F, 0x0F, 0x9F, 0x8F, 0x0F, 0x87, 0xFD, 0xFF, 0x07, 0xC3,
  0xFE, 0xFF, 0x83, 0xE0, 0xFE, 0x7F, 0x81, 0xF0, 0x3C, 0x1F, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x40, 0x01, 0xFC, 0x01, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xFF,
  0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x01, 0xF9,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7F,
  0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F,
  0xC1, 0xF8, 0x0F, 0xE0, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFE, 0x03, 0xF8,
  0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x80, 0x7F, 0x3F, 0x80, 0x3F,
  0x9F, 0xC0, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x3F, 0x83, 0xFC, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x1F, 0xC0, 0x7E, 0x0F, 0xF0, 0x1F, 0x8F, 0xF8, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x07, 0xF0, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0x80,
  0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F,
  0x81, 0xFC, 0x0F, 0xC0, 0x7F, 0x07, 0xF0, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xF8, 0x30, 0x0F, 0xF0, 0x08, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x03, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x7F, 0xF0, 0x1F, 0xC1,
  0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x83,
  0xFC, 0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x07,
  0xF8, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x03, 0xF8, 0x3F,
  0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0x7F,
  0x87, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x87, 0xF8,
  0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0,
  0x7F, 0x07, 0xF8, 0x1F, 0xC1, 0xFF, 0x03, 0xF9, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x10, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xE0, 0x3F, 0xE0, 0x0C, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0xF1, 0xFC, 0x1F, 0xFC, 0x7F,
  0x83, 0xFF, 0x8F, 0xF0, 0x7F, 0xF1, 0xFE, 0x0F, 0xFE, 0x3F, 0x83, 0xFF,
  0xC7, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8,
  0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFE, 0x03, 0xF8,
  0x3F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0x0F, 0xF0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x3F,
  0x80, 0x7F, 0x03, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00,
  0xFC, 0x1F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8,
  0xFF, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xE7, 0xF8,
  0x00, 0x7F, 0x3F, 0x80, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xBF, 0xC0, 0x00,
  0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8,
  0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE,
  0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0xC0, 0x1F, 0x80, 0xFE, 0x01,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x00,
  0xFD, 0xF0, 0x3F, 0xFE, 0x01, 0xFB, 0xE0, 0x7F, 0xFC, 0x03, 0xF7, 0xC1,
  0xFB, 0xF0, 0x0F, 0xEF, 0x83, 0xF7, 0xE0, 0x1F, 0xDF, 0x07, 0xDF, 0xC0,
  0x3F, 0x3E, 0x1F, 0xBF, 0x80, 0x7E, 0x7C, 0x3E, 0x7E, 0x00, 0xFC, 0xF8,
  0xFC, 0xFC, 0x03, 0xF9, 0xF1, 0xF1, 0xF8, 0x07, 0xE3, 0xE7, 0xE7, 0xF0,
  0x0F, 0xC7, 0xCF, 0xCF, 0xE0, 0x1F, 0x8F, 0xBF, 0x1F, 0x80, 0x3F, 0x1F,
  0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0xF8, 0xFE, 0x01, 0xF8, 0x7F, 0xF1, 0xFC,
  0x03, 0xF0, 0xFF, 0xC3, 0xF8, 0x07, 0xE1, 0xFF, 0x87, 0xE0, 0x1F, 0xC3,
  0xFE, 0x0F, 0xC0, 0x3F, 0x87, 0xFC, 0x3F, 0x80, 0x7E, 0x0F, 0xF8, 0x7F,
  0x00, 0xFC, 0x1F, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0xC1, 0xF8, 0x07, 0xF0,
  0x7F, 0x03, 0xF0, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x1F, 0x81, 0xF8, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x01, 0xFE, 0x00, 0xFC, 0x07, 0xFC,
  0x01, 0xF8, 0x0F, 0xF8, 0x07, 0xF0, 0x1F, 0xF0, 0x0F, 0xE0, 0x3F, 0xE0,
  0x1F, 0x80, 0x7F, 0xC0, 0x3F, 0x01, 0xFF, 0xC0, 0x7E, 0x03, 0xFF, 0x81,
  0xFC, 0x07, 0xFF, 0x03, 0xF0, 0x0F, 0xFE, 0x07, 0xE0, 0x3F, 0xFC, 0x0F,
  0xC0, 0x7E, 0xFC, 0x1F, 0x80, 0xFD, 0xF8, 0x7F, 0x01, 0xFB, 0xF0, 0xFC,
  0x03, 0xF7, 0xE1, 0xF8, 0x0F, 0xEF, 0xC3, 0xF0, 0x1F, 0x9F, 0x8F, 0xE0,
  0x3F, 0x1F, 0x9F, 0xC0, 0x7E, 0x3F, 0x3F, 0x00, 0xFC, 0x7E, 0x7E, 0x03,
  0xF8, 0xFC, 0xFC, 0x07, 0xE1, 0xF9, 0xF8, 0x0F, 0xC1, 0xF7, 0xE0, 0x1F,
  0x83, 0xFF, 0xC0, 0x3F, 0x07, 0xFF, 0x80, 0xFE, 0x0F, 0xFF, 0x01, 0xF8,
  0x1F, 0xFE, 0x03, 0xF0, 0x3F, 0xF8, 0x07, 0xE0, 0x3F, 0xF0, 0x1F, 0xC0,
  0x7F, 0xE0, 0x3F, 0x80, 0xFF, 0xC0, 0x7E, 0x01, 0xFF, 0x80, 0xFC, 0x03,
  0xFE, 0x01, 0xF8, 0x07, 0xFC, 0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xC0, 0x0F,
  0xF0, 0x1F, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x1F,
  0xC1, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xF3, 0xFC,
  0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF3, 0xFC, 0x00, 0xFE,
  0x7F, 0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0xFF, 0x7F, 0x80,
  0x1F, 0xEF, 0xF0, 0x03, 0xF9, 0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x1F, 0xE7,
  0xF0, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03,
  0xFC, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x07, 0xF8, 0x3F,
  0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x3F, 0x87, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F,
  0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0,
  0x7F, 0x83, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x0F,
  0xE0, 0x0F, 0xF3, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07,
  0xF3, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC,
  0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xF9, 0xFE, 0x00, 0x7F,
  0x3F, 0xC0, 0x1F, 0xE7, 0xF0, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0x1F, 0xC0,
  0x0F, 0xE3, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xE1,
  0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xE1, 0xFE, 0x07,
  0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0,
  0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xFC,
  0x0F, 0xC1, 0xFE, 0x0F, 0xE1, 0xFE, 0x07, 0xF3, 0xFF, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xBF, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xF0, 0x0F, 0xE3,
  0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xF8, 0x3F, 0x01, 0xFC,
  0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F,
  0x81, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFC, 0x78, 0x07, 0xF8,
  0x0C, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x02, 0x00, 0x3F, 0x81, 0x80, 0x3F,
  0xC0, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x01,
  0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x0F,
  0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x3F,
  0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC,
  0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8,
  0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0,
  0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x83,
  0xF8, 0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07,
  0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0xFC, 0x01, 0xFC,
  0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x07, 0xF0,
  0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x80,
  0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFE, 0x00,
  0xFC, 0xFE, 0x00, 0xFC, 0xFC, 0x00, 0xFD, 0xFC, 0x00, 0xFD, 0xF8, 0x00,
  0xFD, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xF0, 0x0F, 0xE7, 0xE0, 0x1F,
  0xC0, 0x3F, 0x9F, 0x80, 0x7F, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x07, 0xF1,
  0xF8, 0x0F, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0xC0, 0x7E, 0x1F, 0x81, 0xFF,
  0x03, 0xF8, 0xFE, 0x07, 0xFC, 0x0F, 0xC3, 0xF8, 0x1F, 0xF0, 0x7F, 0x0F,
  0xE0, 0xFF, 0xC1, 0xFC, 0x3F, 0x83, 0xFF, 0x07, 0xE0, 0xFE, 0x1F, 0xFC,
  0x3F, 0x83, 0xF8, 0x7F, 0xF0, 0xFC, 0x0F, 0xE1, 0xFF, 0xC3, 0xF0, 0x3F,
  0x8F, 0xFE, 0x1F, 0xC0, 0xFE, 0x3E, 0xF8, 0x7E, 0x03, 0xF8, 0xFB, 0xE3,
  0xF8, 0x0F, 0xE7, 0xEF, 0x8F, 0xE0, 0x3F, 0x1F, 0x3E, 0x3F, 0x00, 0xFC,
  0xFC, 0xF9, 0xFC, 0x03, 0xF3, 0xF3, 0xE7, 0xE0, 0x0F, 0xCF, 0x8F, 0xBF,
  0x80, 0x3F, 0x7E, 0x3E, 0xFE, 0x00, 0xFD, 0xF0, 0xFB, 0xF0, 0x03, 0xFF,
  0xC3, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x03, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x7F, 0xC0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F,
  0x80, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0x80,
  0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF8, 0x7F,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0,
  0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xBF, 0x81, 0xFC, 0xFE,
  0x07, 0xF3, 0xF8, 0x3F, 0x87, 0xE0, 0xFE, 0x1F, 0x87, 0xF0, 0x7E, 0x1F,
  0xC1, 0xF8, 0xFE, 0x07, 0xE3, 0xF8, 0x1F, 0xDF, 0xC0, 0x7F, 0x7E, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x81, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xCF, 0x80, 0x3F, 0x1F, 0x80, 0x7C, 0x3F,
  0x01, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8,
  0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xE0, 0x07, 0xCF, 0xC0, 0x0F, 0xFF,
  0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x7F,
  0xBF, 0xCF, 0xE3, 0xF1, 0xFC, 0x7E, 0x1F, 0x0F, 0x80, 0x00, 0xFE, 0x3F,
  0x01, 0xFF, 0x7F, 0x03, 0xFF, 0x7E, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xF7, 0xFE, 0x1F, 0xE3, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0xC1, 0xFC,
  0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x01, 0xF8, 0x7F, 0x03, 0xF8,
  0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF0,
  0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFF, 0x3F, 0xE0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xEF, 0xC0, 0x3F, 0xCF, 0xC0, 0x1F, 0x8F, 0xC0,
  0x06, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x9F, 0xC0, 0x7F, 0x7F, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x07, 0xFD, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0x81, 0xF8, 0x7F, 0x03,
  0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC7, 0xF0, 0x3F, 0x8F, 0xC0, 0x7F,
  0x1F, 0x80, 0xFE, 0x3F, 0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x0F, 0xE3,
  0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F,
  0x83, 0xF8, 0xFF, 0x0F, 0xE1, 0xFF, 0x3F, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x1F, 0xBF, 0xF0, 0x3F, 0x7F, 0xC0, 0x7C, 0x7F, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC0, 0xFF, 0xBC, 0x1F, 0xE0, 0x41, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x06, 0x0F, 0xF9,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x03, 0xF9, 0xFC, 0x01, 0xFF, 0x7E, 0x00, 0xFF,
  0xDF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xF7, 0xFE, 0x07,
  0xF8, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x7F, 0x01,
  0xF8, 0x1F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xC0, 0xFE,
  0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80,
  0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xF3, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFD, 0xF0, 0x03, 0xFE, 0x7C, 0x00, 0x7F,
  0x1F, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xF0, 0xFC, 0x7F, 0x07,
  0xE3, 0xF0, 0x3F, 0x3F, 0x81, 0xF9, 0xF8, 0x1F, 0x8F, 0xC1, 0xFC, 0xFE,
  0x1F, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x02, 0x1F, 0xE0, 0x70, 0x7F, 0xFF, 0x83,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFE,
  0x20, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x04, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x1F, 0xF7, 0xF0, 0x0F,
  0xFD, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x7F, 0xE0,
  0x7F, 0x8F, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFC,
  0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFF, 0x7F, 0xE0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xBF, 0x00, 0x3F, 0xDF, 0xC0, 0x0F,
  0xE7, 0xF0, 0x00, 0x61, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x08, 0x01, 0xFC, 0x03, 0xC0, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x9F, 0xC0, 0x7F, 0x7F, 0xC0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xE1,
  0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xF8, 0x1F,
  0xC7, 0xF0, 0x3F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x03, 0xF8,
  0xFE, 0x07, 0xE1, 0xFC, 0x0F, 0xC3, 0xF8, 0x3F, 0x87, 0xE0, 0x7F, 0x0F,
  0xC0, 0xFE, 0x3F, 0x81, 0xF8, 0x7F, 0x03, 0xF0, 0xFE, 0x0F, 0xE1, 0xF8,
  0x1F, 0xC3, 0xF0, 0x3F, 0x8F, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x83,
  0xF8, 0x7E, 0x07, 0xF0, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x08, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x3F, 0x87, 0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0xC3, 0xF8, 0x07,
  0xE3, 0xF8, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xF9, 0xFC, 0x00,
  0xFD, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x3F,
  0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1,
  0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xF8,
  0x0F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7E, 0x00, 0x03, 0xE3, 0xF8, 0x3F, 0x01, 0xFB, 0xFF,
  0x3F, 0xE0, 0x7E, 0xFF, 0xDF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFE, 0x7F, 0xE7, 0xF0, 0xFF, 0x0F, 0xF0, 0xFC, 0x3F,
  0x83, 0xF8, 0x3F, 0x0F, 0xE0, 0xFE, 0x0F, 0xC3, 0xF0, 0x3F, 0x03, 0xF0,
  0xFC, 0x0F, 0xC1, 0xFC, 0x7F, 0x07, 0xF0, 0x7F, 0x1F, 0xC1, 0xF8, 0x1F,
  0x87, 0xE0, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x81, 0xF8, 0xFE, 0x0F, 0xE0,
  0xFE, 0x3F, 0x83, 0xF8, 0x3F, 0x8F, 0xE0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F,
  0x03, 0xF0, 0xFC, 0x0F, 0xC1, 0xFC, 0x7F, 0x07, 0xF0, 0x7F, 0x1F, 0xC1,
  0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x81, 0xF8, 0x7E,
  0x07, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x0F, 0xC3,
  0xF0, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xE3, 0xF8,
  0x07, 0xCF, 0xF8, 0x1F, 0xBF, 0xF0, 0x3E, 0xFF, 0xF0, 0x7D, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC3, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F,
  0xC1, 0xFC, 0x3F, 0x03, 0xF0, 0xFE, 0x07, 0xE1, 0xFC, 0x0F, 0xC3, 0xF8,
  0x3F, 0x87, 0xE0, 0x7F, 0x0F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8, 0x7F, 0x03,
  0xF0, 0xFC, 0x0F, 0xE1, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x0F, 0xE0, 0x7E,
  0x1F, 0xC1, 0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x07, 0xF1, 0xFC, 0x0F, 0xC3,
  0xF8, 0x1F, 0x87, 0xF0, 0x7F, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x04, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xF8, 0xFE, 0x07,
  0xE3, 0xF8, 0x1F, 0xDF, 0xC0, 0x7F, 0x7F, 0x01, 0xF9, 0xFC, 0x07, 0xE7,
  0xE0, 0x1F, 0x9F, 0x80, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0,
  0x3F, 0xBF, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0xFE,
  0x3F, 0x87, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x7C, 0x7F, 0x00, 0x3F, 0x3F, 0xE0, 0x0F, 0xDF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xC7, 0xF0, 0x1F, 0xE1, 0xFC, 0x07, 0xF0,
  0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xFC,
  0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x3F, 0xC0, 0xFF,
  0x0F, 0xE0, 0x3F, 0xE7, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x7E, 0x7F, 0xC0, 0x1F, 0x8F, 0xC0, 0x07, 0xE0, 0xC0,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x3F, 0x01, 0xFF, 0x3F, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF7, 0xFE, 0x1F, 0xC1,
  0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x01,
  0xFC, 0x7F, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x7E, 0x03,
  0xF8, 0x7E, 0x03, 0xF8, 0xFE, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFE, 0x03,
  0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFF, 0x3F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xEF,
  0xC0, 0x3F, 0xDF, 0xC0, 0x1F, 0x9F, 0xC0, 0x04, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xE3,
  0xF0, 0x7E, 0x7E, 0x07, 0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFE, 0x1C, 0x1F, 0xC0, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x80, 0x7F, 0x0F, 0xBF, 0xF0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0x20, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xFC, 0x03, 0xFF, 0x9F, 0xFF, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xF0, 0xFE,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x84, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x00, 0x40, 0x00, 0x07, 0xE0,
  0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x83, 0xF8, 0x7E, 0x07, 0xF0, 0xFC, 0x0F,
  0xC1, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x0F, 0xC0, 0xFE, 0x1F, 0x81, 0xFC,
  0x3F, 0x03, 0xF0, 0xFE, 0x07, 0xE1, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0x87,
  0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8, 0x7F, 0x07, 0xF0, 0xFC,
  0x0F, 0xE1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1,
  0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x9F, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x81, 0xFF, 0xBF, 0x03, 0xFF, 0x7E, 0x03, 0xF8, 0xF8, 0x00, 0x80, 0x00,
  0x00, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xCF,
  0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x1F, 0xC3, 0xF8, 0xFC, 0x1F,
  0x87, 0xE1, 0xFC, 0x3F, 0x0F, 0xC0, 0xF8, 0x7E, 0x07, 0xC7, 0xE0, 0x3E,
  0x3F, 0x01, 0xF3, 0xF0, 0x0F, 0x9F, 0x80, 0x7D, 0xFC, 0x03, 0xEF, 0xC0,
  0x1F, 0x7E, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x3F, 0xFE, 0x0F,
  0xF0, 0x7F, 0xFE, 0x0F, 0xF0, 0x7E, 0xFC, 0x1F, 0xF0, 0x7E, 0xFC, 0x1F,
  0xF0, 0xFE, 0xFC, 0x1F, 0xF0, 0xFC, 0xFC, 0x3F, 0xF1, 0xFC, 0xFC, 0x3F,
  0xF1, 0xF8, 0xFC, 0x7F, 0xE1, 0xF8, 0xFC, 0x7F, 0xE3, 0xF0, 0xFC, 0x7F,
  0xE3, 0xF0, 0xFC, 0xFB, 0xE3, 0xF0, 0xFC, 0xFB, 0xE7, 0xE0, 0xFD, 0xFB,
  0xE7, 0xE0, 0xFD, 0xF3, 0xEF, 0xC0, 0xFD, 0xF3, 0xEF, 0xC0, 0xFF, 0xF3,
  0xEF, 0xC0, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xC3,
  0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x07,
  0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0xFE,
  0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x3F,
  0xBF, 0x80, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x7E,
  0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x1F,
  0xC7, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x81, 0xFC,
  0x0F, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00,
  0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC1,
  0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC3, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC,
  0xFE, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFD, 0xFC, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x05, 0xFF, 0xC0, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xA0, 0x07,
  0xFC, 0x80, 0x00, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 15, 39, 13, 0, -38 },
  { 75, 19, 14, 21, 5, -38 },
  { 109, 27, 38, 25, 0, -38 },
  { 238, 24, 43, 22, 0, -40 },
  { 367, 33, 38, 37, 3, -38 },
  { 524, 27, 39, 27, 0, -38 },
  { 656, 9, 14, 13, 5, -38 },
  { 672, 17, 46, 14, 1, -38 },
  { 770, 18, 47, 14, -4, -39 },
  { 876, 20, 22, 22, 4, -41 },
  { 931, 22, 25, 25, 2, -31 },
  { 1000, 12, 14, 13, -3, -7 },
  { 1021, 14, 6, 15, 1, -17 },
  { 1032, 8, 9, 13, 0, -8 },
  { 1041, 27, 38, 20, -3, -38 },
  { 1170, 22, 39, 22, 1, -38 },
  { 1278, 17, 38, 23, 5, -38 },
  { 1359, 25, 38, 22, -2, -38 },
  { 1478, 25, 39, 22, -1, -38 },
  { 1600, 24, 38, 23, -1, -38 },
  { 1714, 24, 39, 22, 0, -38 },
  { 1831, 24, 39, 22, 1, -38 },
  { 1948, 25, 38, 22, 1, -38 },
  { 2067, 24, 39, 22, 0, -38 },
  { 2184, 23, 39, 22, 0, -38 },
  { 2297, 13, 30, 13, 0, -29 },
  { 2346, 16, 36, 13, -3, -29 },
  { 2418, 22, 26, 25, 2, -32 },
  { 2490, 22, 16, 25, 2, -27 },
  { 2534, 22, 26, 25, 2, -32 },
  { 2606, 19, 39, 18, 1, -38 },
  { 2699, 33, 42, 34, 1, -38 },
  { 2873, 25, 38, 25, -3, -38 },
  { 2992, 26, 38, 25, 0, -38 },
  { 3116, 25, 39, 23, 2, -38 },
  { 3238, 27, 38, 27, 0, -38 },
  { 3367, 24, 38, 21, 0, -38 },
  { 3481, 24, 38, 20, 0, -38 },
  { 3595, 27, 39, 28, 2, -38 },
  { 3727, 30, 38, 28, 0, -38 },
  { 3870, 23, 38, 17, -2, -38 },
  { 3980, 23, 49, 13, -8, -38 },
  { 4121, 29, 38, 24, 0, -38 },
  { 4259, 17, 38, 20, 0, -38 },
  { 4340, 39, 38, 37, 0, -38 },
  { 4526, 31, 38, 30, 0, -38 },
  { 4674, 27, 39, 29, 2, -38 },
  { 4806, 26, 38, 24, 0, -38 },
  { 4930, 27, 47, 29, 2, -38 },
  { 5089, 25, 38, 25, 0, -38 },
  { 5208, 25, 39, 22, -1, -38 },
  { 5330, 21, 38, 21, 4, -38 },
  { 5430, 27, 39, 27, 2, -38 },
  { 5562, 24, 38, 25, 5, -38 },
  { 5676, 38, 38, 37, 4, -38 },
  { 5857, 30, 38, 23, -3, -38 },
  { 6000, 22, 38, 23, 5, -38 },
  { 6105, 26, 38, 21, -2, -38 },
  { 6229, 21, 46, 15, -2, -38 },
  { 6350, 11, 38, 20, 5, -38 },
  { 6403, 21, 46, 15, -4, -38 },
  { 6524, 23, 23, 23, 0, -38 },
  { 6591, 18, 3, 17, -5, 5 },
  { 6598, 9, 9, 16, 8, -41 },
  { 6609, 24, 30, 24, 1, -29 },
  { 6699, 23, 41, 24, 0, -40 },
  { 6817, 20, 30, 19, 1, -29 },
  { 6892, 26, 41, 24, 1, -40 },
  { 7026, 21, 30, 22, 1, -29 },
  { 7105, 27, 54, 15, -6, -41 },
  { 7288, 26, 42, 24, -1, -29 },
  { 7425, 23, 40, 24, 0, -40 },
  { 7540, 15, 40, 12, 0, -40 },
  { 7615, 22, 53, 12, -7, -40 },
  { 7761, 25, 40, 23, 0, -40 },
  { 7886, 15, 40, 12, 0, -40 },
  { 7961, 34, 29, 36, 0, -29 },
  { 8085, 23, 29, 24, 0, -29 },
  { 8169, 22, 31, 24, 1, -30 },
  { 8255, 26, 42, 24, -3, -29 },
  { 8392, 24, 42, 24, 1, -29 },
  { 8518, 20, 29, 17, 0, -29 },
  { 8591, 20, 30, 19, 0, -29 },
  { 8666, 15, 36, 15, 2, -35 },
  { 8734, 23, 30, 24, 1, -29 },
  { 8821, 21, 29, 21, 3, -29 },
  { 8898, 32, 29, 32, 3, -29 },
  { 9014, 27, 29, 21, -3, -29 },
  { 9112, 28, 42, 21, -4, -29 },
  { 9259, 22, 29, 18, -2, -29 },
  { 9339, 21, 46, 18, 1, -38 },
  { 9460, 6, 53, 20, 6, -41 },
  { 9500, 20, 46, 18, -3, -38 },
  { 9615, 22, 9, 25, 2, -23 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic53pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC53PT7B_H_
