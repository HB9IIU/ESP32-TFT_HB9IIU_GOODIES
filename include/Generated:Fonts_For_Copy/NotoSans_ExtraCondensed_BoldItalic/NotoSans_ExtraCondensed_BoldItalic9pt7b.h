#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC9PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x21, 0x00, 0xB8, 0x33, 0xD5, 0xEA, 0x50, 0x27, 0x66, 0x3A,
  0x44, 0x21, 0xAB, 0x2F, 0x6C, 0xD4, 0x80, 0x22, 0x94, 0xDB, 0x5B, 0xC0,
  0xC0, 0x69, 0x49, 0x20, 0x24, 0x92, 0x56, 0x5F, 0x70, 0x2F, 0x22, 0xE0,
  0xC0, 0x80, 0x12, 0x64, 0x88, 0x27, 0x5D, 0xBA, 0xE0, 0x79, 0x25, 0x00,
  0x27, 0x12, 0x6C, 0xE0, 0x27, 0x16, 0x22, 0xE0, 0x33, 0x6A, 0xF2, 0x74,
  0x62, 0x2E, 0x17, 0x4F, 0xBA, 0xE0, 0x71, 0x22, 0x4C, 0x25, 0x56, 0xEA,
  0xE0, 0x27, 0x5F, 0x72, 0xC0, 0x40, 0x80, 0x20, 0x15, 0x80, 0x3C, 0x61,
  0xF0, 0xF0, 0xC3, 0x68, 0x2C, 0xA4, 0x30, 0x10, 0xB5, 0xED, 0xB6, 0xE8,
  0x1C, 0x19, 0x4A, 0xF4, 0xEC, 0x75, 0x6D, 0x9E, 0x1B, 0x90, 0x8C, 0x61,
  0x80, 0x72, 0xD5, 0xAB, 0x70, 0x74, 0x6C, 0x8E, 0x74, 0x6C, 0x88, 0x13,
  0xD1, 0xBF, 0x69, 0xC0, 0x6A, 0xDD, 0xA9, 0x48, 0x74, 0x44, 0x4C, 0x32,
  0x22, 0x64, 0x48, 0x5B, 0x98, 0xCA, 0x58, 0x69, 0x69, 0xC0, 0x66, 0xD9,
  0xB3, 0xAB, 0xD5, 0x00, 0x6B, 0x5A, 0xFB, 0x48, 0x13, 0xD3, 0x9D, 0xE9,
  0x80, 0x75, 0x5E, 0x88, 0x13, 0xD3, 0x9D, 0xE9, 0x84, 0x30, 0x75, 0x76,
  0xAB, 0x27, 0x46, 0x2A, 0xE0, 0xEB, 0x49, 0x00, 0x6A, 0xD5, 0xAD, 0x30,
  0xBA, 0xAC, 0xC8, 0xA6, 0xAE, 0xBE, 0xB2, 0xC0, 0x2C, 0xC3, 0x0C, 0x73,
  0x40, 0xBE, 0xC8, 0x88, 0x72, 0x64, 0x8E, 0x69, 0x69, 0x30, 0xAA, 0x50,
  0x33, 0x22, 0x22, 0xC0, 0x26, 0xD0, 0xE0, 0xD0, 0x75, 0x9A, 0xE0, 0x64,
  0x75, 0xDB, 0xE0, 0x74, 0x88, 0xE0, 0x18, 0x9C, 0xA9, 0x53, 0x80, 0x75,
  0xE8, 0xE0, 0x19, 0x1C, 0x42, 0x31, 0x08, 0xC0, 0x75, 0x9B, 0xE2, 0xE0,
  0x64, 0x75, 0xDA, 0xA0, 0x45, 0xE8, 0x20, 0x96, 0x92, 0xC0, 0x44, 0x56,
  0xEA, 0xA0, 0x69, 0x2D, 0x20, 0x7D, 0x5D, 0x6A, 0xA8, 0x75, 0xDA, 0xA0,
  0x75, 0x9B, 0xE0, 0x39, 0x5A, 0xB7, 0x23, 0x00, 0x75, 0x9A, 0xE2, 0x20,
  0x6B, 0x48, 0x79, 0x9C, 0x5D, 0x29, 0x80, 0x55, 0xDA, 0xE0, 0xBB, 0x68,
  0x75, 0xE7, 0x96, 0xD0, 0x56, 0x66, 0xA0, 0x29, 0x8C, 0x62, 0x13, 0x00,
  0x65, 0x4E, 0x36, 0x48, 0x44, 0xC0, 0xFF, 0x80, 0x32, 0x21, 0x26, 0xC0,
  0xF9,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 6, 2, 0, -6 },
  { 4, 3, 2, 4, 1, -6 },
  { 5, 5, 6, 4, 0, -6 },
  { 9, 4, 8, 4, 0, -7 },
  { 13, 6, 7, 6, 0, -7 },
  { 19, 5, 7, 5, 0, -7 },
  { 24, 1, 2, 2, 1, -6 },
  { 25, 3, 7, 2, 0, -6 },
  { 28, 3, 8, 2, -1, -7 },
  { 31, 3, 4, 4, 1, -7 },
  { 33, 4, 4, 4, 0, -5 },
  { 35, 2, 2, 2, 0, -1 },
  { 36, 2, 1, 3, 0, -3 },
  { 37, 1, 1, 2, 0, -1 },
  { 38, 4, 6, 3, 0, -6 },
  { 41, 4, 7, 4, 0, -7 },
  { 45, 3, 6, 4, 1, -6 },
  { 48, 4, 7, 4, 0, -7 },
  { 52, 4, 7, 4, 0, -7 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 4, 6, 4, 0, -6 },
  { 62, 4, 7, 4, 0, -7 },
  { 66, 4, 6, 4, 0, -6 },
  { 69, 4, 7, 4, 0, -7 },
  { 73, 4, 7, 4, 0, -7 },
  { 77, 2, 5, 2, 0, -5 },
  { 79, 3, 6, 2, -1, -5 },
  { 82, 4, 4, 4, 0, -5 },
  { 84, 4, 3, 4, 0, -5 },
  { 86, 4, 4, 4, 0, -5 },
  { 88, 3, 7, 3, 0, -7 },
  { 91, 6, 8, 6, 0, -7 },
  { 97, 5, 6, 4, -1, -6 },
  { 101, 4, 6, 4, 0, -6 },
  { 104, 5, 7, 4, 0, -7 },
  { 109, 5, 6, 5, 0, -6 },
  { 113, 4, 6, 4, 0, -6 },
  { 116, 4, 6, 3, 0, -6 },
  { 119, 5, 7, 5, 0, -7 },
  { 124, 5, 6, 5, 0, -6 },
  { 128, 4, 6, 3, 0, -6 },
  { 131, 4, 8, 2, -1, -6 },
  { 135, 5, 6, 4, 0, -6 },
  { 139, 3, 6, 3, 0, -6 },
  { 142, 7, 6, 6, 0, -6 },
  { 148, 5, 6, 5, 0, -6 },
  { 152, 5, 7, 5, 0, -7 },
  { 157, 4, 6, 4, 0, -6 },
  { 160, 5, 9, 5, 0, -7 },
  { 166, 4, 6, 4, 0, -6 },
  { 169, 4, 7, 4, 0, -7 },
  { 173, 3, 6, 4, 1, -6 },
  { 176, 5, 6, 5, 0, -6 },
  { 180, 4, 6, 4, 1, -6 },
  { 183, 6, 6, 6, 1, -6 },
  { 188, 6, 6, 4, -1, -6 },
  { 193, 4, 6, 4, 1, -6 },
  { 196, 4, 6, 4, 0, -6 },
  { 199, 3, 7, 3, 0, -6 },
  { 202, 2, 6, 3, 1, -6 },
  { 204, 4, 7, 3, -1, -6 },
  { 208, 4, 3, 4, 0, -6 },
  { 210, 3, 1, 3, -1, 1 },
  { 211, 2, 2, 3, 1, -7 },
  { 212, 4, 5, 4, 0, -5 },
  { 215, 4, 7, 4, 0, -7 },
  { 219, 4, 5, 3, 0, -5 },
  { 222, 5, 7, 4, 0, -7 },
  { 227, 4, 5, 4, 0, -5 },
  { 230, 5, 9, 3, -1, -7 },
  { 236, 4, 7, 4, 0, -5 },
  { 240, 4, 7, 4, 0, -7 },
  { 244, 2, 7, 2, 0, -7 },
  { 246, 3, 9, 2, -1, -7 },
  { 250, 4, 7, 4, 0, -7 },
  { 254, 3, 7, 2, 0, -7 },
  { 257, 6, 5, 6, 0, -5 },
  { 261, 4, 5, 4, 0, -5 },
  { 264, 4, 5, 4, 0, -5 },
  { 267, 5, 7, 4, -1, -5 },
  { 272, 4, 7, 4, 0, -5 },
  { 276, 3, 5, 3, 0, -5 },
  { 278, 3, 5, 3, 0, -5 },
  { 280, 3, 6, 3, 0, -6 },
  { 283, 4, 5, 4, 0, -5 },
  { 286, 3, 5, 4, 1, -5 },
  { 288, 6, 5, 6, 0, -5 },
  { 292, 4, 5, 4, 0, -5 },
  { 295, 5, 7, 4, -1, -5 },
  { 300, 3, 5, 3, 0, -5 },
  { 302, 4, 7, 3, 0, -6 },
  { 306, 1, 9, 3, 1, -7 },
  { 308, 4, 7, 3, -1, -6 },
  { 312, 4, 2, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic9pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC9PT7B_H_
