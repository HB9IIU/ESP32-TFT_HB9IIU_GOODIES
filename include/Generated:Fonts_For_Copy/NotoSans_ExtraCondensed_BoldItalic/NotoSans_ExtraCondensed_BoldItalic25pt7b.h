#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC25PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x78, 0xE1, 0xC3, 0x8F, 0x1C, 0x38, 0x70, 0xE1, 0x84,
  0x00, 0x18, 0x78, 0xF1, 0xC0, 0x7B, 0xB9, 0xDC, 0xCE, 0xE6, 0x73, 0x3B,
  0x98, 0x03, 0x30, 0x39, 0x81, 0x9C, 0x0C, 0xC0, 0x66, 0x1F, 0xFC, 0xFF,
  0xC1, 0x98, 0x1D, 0xC0, 0xCC, 0x06, 0x61, 0xFF, 0xCF, 0xFE, 0x19, 0x81,
  0xCC, 0x0C, 0xE0, 0x66, 0x07, 0x70, 0x00, 0x01, 0x80, 0x20, 0x1F, 0x8F,
  0xF1, 0xFC, 0x74, 0x8E, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x7D, 0x0B, 0xB2, 0xF7, 0xFC, 0xFF, 0x0F, 0xC0, 0x20, 0x08, 0x00, 0x1E,
  0x0C, 0x3E, 0x18, 0x36, 0x38, 0x66, 0x30, 0x66, 0x70, 0x66, 0x60, 0xE6,
  0xE0, 0xEE, 0xCE, 0xED, 0xDF, 0x7D, 0xBB, 0x7B, 0xB3, 0x03, 0x73, 0x06,
  0x67, 0x0E, 0x66, 0x0C, 0x66, 0x1C, 0x6E, 0x18, 0x7C, 0x38, 0x38, 0x07,
  0xC0, 0x7F, 0x03, 0xB8, 0x39, 0xC1, 0xCE, 0x0E, 0xE0, 0x7F, 0x01, 0xF0,
  0x1F, 0x01, 0xFB, 0xDF, 0xDC, 0xEF, 0xEE, 0x3E, 0x71, 0xF3, 0x8F, 0x1E,
  0xF8, 0xFF, 0xE3, 0xE7, 0x00, 0x7B, 0x9C, 0xE7, 0x33, 0x80, 0x03, 0x83,
  0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x07,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x07, 0x03, 0x80, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F,
  0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0xE0, 0x0E, 0x06, 0x13,
  0x1F, 0xFF, 0xF8, 0xFC, 0xF9, 0xEC, 0x67, 0x13, 0x00, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x3F, 0xFF, 0xFF, 0xFF, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x3B, 0xDC, 0xEE, 0x70, 0x7E, 0xFB, 0xF0, 0x6F, 0xFE, 0x00, 0x70, 0x07,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00,
  0x07, 0xC1, 0xF8, 0x7F, 0x8E, 0x73, 0x8E, 0x71, 0xCE, 0x3B, 0xCF, 0x71,
  0xCE, 0x39, 0xC7, 0x38, 0xEF, 0x39, 0xE7, 0x3D, 0xE3, 0xF8, 0x7E, 0x07,
  0x80, 0x07, 0x0F, 0x1F, 0x3F, 0xFF, 0x6E, 0x4E, 0x0E, 0x0E, 0x1C, 0x1C,
  0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x03, 0xC0, 0xFE, 0x1F, 0xF0,
  0xCF, 0x08, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0xFC, 0xFF, 0x8F, 0xF8, 0x0F, 0xC3,
  0xFC, 0x7F, 0x88, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x3C, 0x1F, 0x03, 0xF0,
  0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x21, 0xE7, 0xFC, 0xFF, 0x1F, 0x80, 0x00,
  0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x7C, 0x1F, 0x83, 0x70, 0xDE, 0x3B, 0x86,
  0x71, 0x8E, 0x71, 0xCF, 0xFD, 0xFF, 0x81, 0xC0, 0x38, 0x07, 0x01, 0xC0,
  0x0F, 0xE1, 0xFC, 0x7F, 0x8E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xFC, 0x3F,
  0x87, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x21, 0xE7, 0xF8, 0xFF, 0x1F,
  0x80, 0x03, 0xE1, 0xF8, 0x7F, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x83, 0xF8,
  0xFF, 0x9E, 0x73, 0x8E, 0x71, 0xCE, 0x39, 0xCF, 0x39, 0xC7, 0xF8, 0xFE,
  0x0F, 0x80, 0x3F, 0xE7, 0xFD, 0xFF, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80,
  0xF0, 0x1C, 0x00, 0x07, 0xC3, 0xFC, 0x7F, 0x9E, 0x73, 0x8E, 0x71, 0xCF,
  0x70, 0xFC, 0x0F, 0x07, 0xE1, 0xEE, 0x39, 0xEE, 0x1D, 0xC3, 0xB8, 0xE7,
  0xBC, 0x7F, 0x0F, 0xC0, 0x07, 0x83, 0xF8, 0x7F, 0x9E, 0xF3, 0x8E, 0x71,
  0xDE, 0x7B, 0xCF, 0x7B, 0xCF, 0xF8, 0xFF, 0x0D, 0xE0, 0x38, 0x0F, 0x01,
  0xC7, 0xF8, 0xFE, 0x1F, 0x80, 0x18, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x3C, 0xF3, 0x80, 0x0C, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC7, 0x8E, 0x1C, 0x70, 0xE0, 0x00, 0x40, 0x70, 0x7C, 0x7E,
  0x7E, 0x3E, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1C, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x0F, 0x81,
  0xF8, 0x1F, 0x81, 0xF0, 0x3C, 0x7E, 0x7E, 0x3E, 0x0E, 0x02, 0x00, 0x1E,
  0x7F, 0x7F, 0x47, 0x07, 0x07, 0x0E, 0x1E, 0x3C, 0x38, 0x70, 0x70, 0x00,
  0x00, 0x40, 0xE0, 0xE0, 0xE0, 0x01, 0xF0, 0x0F, 0xF8, 0x38, 0x30, 0xE0,
  0x73, 0x80, 0x66, 0x7E, 0xD9, 0xF9, 0xB3, 0x33, 0xEC, 0x67, 0x99, 0xCF,
  0x33, 0x36, 0x66, 0x6D, 0xDC, 0xD9, 0xFF, 0x33, 0x9C, 0x60, 0x00, 0xC0,
  0x01, 0xC0, 0x81, 0xFF, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x03, 0xF0, 0x3F, 0x07, 0x70, 0x77, 0x0F, 0x70, 0xE7, 0x0E, 0x71,
  0xFF, 0x1F, 0xF3, 0xC7, 0x38, 0x73, 0x87, 0x70, 0x7F, 0x07, 0x0F, 0xC1,
  0xFE, 0x1F, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x3C, 0xE3, 0xFE, 0x3F, 0x83,
  0xFC, 0x79, 0xC7, 0x1E, 0x71, 0xE7, 0x1E, 0x71, 0xCF, 0xFC, 0xFF, 0x8F,
  0xE0, 0x07, 0xE0, 0xFF, 0x1F, 0xE3, 0xC4, 0x38, 0x07, 0x80, 0x78, 0x07,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF1, 0x0F,
  0xF0, 0x7F, 0x03, 0xF0, 0x0F, 0xC0, 0xFF, 0x07, 0xFC, 0x39, 0xE1, 0xC7,
  0x8E, 0x3C, 0xF1, 0xE7, 0x0F, 0x38, 0x71, 0xC3, 0x9E, 0x3C, 0xF1, 0xE7,
  0x0E, 0x38, 0xF1, 0xCF, 0x1F, 0xF0, 0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xE3,
  0xFC, 0x7F, 0x8E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xFC, 0x3F, 0x87, 0xF1,
  0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0xF8, 0xFF, 0x1F, 0xE0, 0x0F,
  0xE3, 0xFC, 0x7F, 0x8E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x3F, 0x87,
  0xF1, 0xFE, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x00,
  0x03, 0xF0, 0x7F, 0xC7, 0xFC, 0x7C, 0x23, 0xC0, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0xF3, 0xF7, 0x9F, 0x38, 0xF9, 0xC1, 0xCE, 0x1E, 0x70, 0xE3, 0xC7,
  0x1F, 0xF8, 0x7F, 0xC1, 0xFC, 0x00, 0x0E, 0x1C, 0x78, 0xF1, 0xE3, 0xC7,
  0x0E, 0x1C, 0x38, 0x70, 0xE3, 0xC7, 0x8F, 0xFE, 0x3F, 0xF0, 0xFF, 0xC7,
  0x87, 0x1E, 0x3C, 0x70, 0xF1, 0xC3, 0x87, 0x0E, 0x3C, 0x38, 0xF1, 0xE3,
  0x87, 0x00, 0x0F, 0xE3, 0xF8, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0,
  0xFE, 0x1F, 0xC0, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x07, 0xC1, 0xF8, 0x3E, 0x00, 0x0E,
  0x3C, 0x79, 0xE1, 0xC7, 0x07, 0x3C, 0x1D, 0xE0, 0x77, 0x03, 0xFC, 0x0E,
  0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x1E, 0xE0, 0x73, 0x81, 0xCE, 0x07,
  0x38, 0x3C, 0xF0, 0xE3, 0xC3, 0x87, 0x00, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C,
  0x1C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0x70, 0xFF, 0xFF,
  0xFF, 0x0F, 0x03, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x3F, 0x1F, 0x0F,
  0x87, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x6E, 0x3F, 0x3F, 0x0E, 0xCD, 0xC3,
  0xB7, 0x71, 0xCD, 0x9C, 0x73, 0xEF, 0x1C, 0xFB, 0x87, 0x3C, 0xE3, 0x8F,
  0x38, 0xE3, 0x8E, 0x38, 0xE7, 0x80, 0x0E, 0x0E, 0x3C, 0x1C, 0x7C, 0x70,
  0xF8, 0xE1, 0xF1, 0xC3, 0xE3, 0x8E, 0xCE, 0x1D, 0xDC, 0x3B, 0xB8, 0x77,
  0x70, 0xCE, 0xE3, 0x9D, 0x87, 0x1F, 0x0E, 0x3E, 0x1C, 0x7C, 0x70, 0xF8,
  0xE1, 0xE1, 0xC3, 0xC0, 0x07, 0xC0, 0xFE, 0x1F, 0xF3, 0xC7, 0x38, 0x77,
  0x87, 0x70, 0x77, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0xFE, 0x0E, 0xE0, 0xEE,
  0x1E, 0xF3, 0xCF, 0xFC, 0x7F, 0x83, 0xE0, 0x0F, 0xC1, 0xFF, 0x1F, 0xF1,
  0xC7, 0x1C, 0x71, 0xC7, 0x3C, 0x73, 0x8F, 0x39, 0xE3, 0xFE, 0x7F, 0xC7,
  0xF0, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0xC0,
  0xFE, 0x1F, 0xF3, 0xC7, 0x38, 0x77, 0x87, 0x70, 0x77, 0x07, 0xF0, 0x7F,
  0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xEE, 0x1E, 0xF3, 0xCF, 0xFC, 0x7F, 0x83,
  0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x0F, 0x81, 0xFE, 0x1F, 0xF1,
  0xCF, 0x1C, 0x71, 0xCF, 0x3C, 0xF3, 0x8E, 0x3F, 0xE3, 0xFC, 0x3F, 0x07,
  0x78, 0x73, 0x87, 0x38, 0x73, 0x8F, 0x3C, 0xE3, 0xCE, 0x1C, 0x03, 0xE0,
  0xFF, 0x0F, 0xF1, 0xE2, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x43, 0xC7, 0xF8, 0x7F, 0x8F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38,
  0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x00,
  0x1C, 0x79, 0xE3, 0xCE, 0x1C, 0x70, 0xE3, 0x87, 0x3C, 0x79, 0xE3, 0x8E,
  0x1C, 0x70, 0xE3, 0x8F, 0x3C, 0x79, 0xE3, 0x8E, 0x1C, 0x70, 0xE3, 0x8F,
  0x1F, 0xF0, 0xFF, 0x03, 0xF0, 0x00, 0xE0, 0xFE, 0x0E, 0xE1, 0xEE, 0x1C,
  0xE1, 0xCE, 0x38, 0xE3, 0x8E, 0x78, 0xE7, 0x0E, 0x70, 0xEE, 0x0E, 0xE0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xE1, 0xC3, 0xF8,
  0x70, 0xEE, 0x1C, 0x3B, 0x8F, 0x1C, 0xE3, 0xC7, 0x39, 0xF3, 0xCE, 0x7C,
  0xE3, 0x9F, 0x38, 0xEF, 0xDC, 0x3B, 0xF7, 0x0E, 0xDD, 0xC3, 0xF7, 0xE0,
  0xF9, 0xF8, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xC7, 0xC0, 0xF1, 0xE0, 0x38,
  0x78, 0x00, 0x0E, 0x3C, 0x38, 0xE0, 0xE7, 0x03, 0x9C, 0x0E, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0xEF, 0x03, 0x9C, 0x1C, 0x70, 0xF1, 0xC3, 0x87, 0x00, 0xF1, 0xFE,
  0x39, 0xCF, 0x39, 0xC7, 0x70, 0xEE, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x80,
  0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x00, 0x0F,
  0xF0, 0xFF, 0x1F, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07,
  0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0xF8, 0xFF,
  0x8F, 0xF8, 0x07, 0xC3, 0xF0, 0xF8, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xF0, 0xFC, 0x3E, 0x00, 0xE1, 0x87, 0x1C, 0x71, 0xC7, 0x1C,
  0x30, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x18, 0x70, 0x07, 0xC1, 0xF0, 0xFC,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC1, 0xF0, 0xFC, 0x3F, 0x00,
  0x03, 0x00, 0x70, 0x1E, 0x07, 0xC0, 0xF8, 0x3B, 0x86, 0x71, 0xCE, 0x70,
  0xCE, 0x1F, 0x83, 0x80, 0xFF, 0xFF, 0xEF, 0x73, 0x0E, 0x71, 0xF7, 0x3F,
  0xE3, 0x9E, 0x79, 0xE7, 0x1E, 0x71, 0xC7, 0x1C, 0x71, 0xCF, 0x3C, 0xF3,
  0xC7, 0xF8, 0x7F, 0x87, 0xB8, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x3B, 0x8F, 0xF9, 0xFF, 0x3C, 0xE7, 0x1C, 0xE3, 0xB8, 0x77, 0x1E, 0xE3,
  0x9C, 0x73, 0x9E, 0xFF, 0x9F, 0xF3, 0xBC, 0x00, 0x0F, 0x1F, 0xCF, 0xCF,
  0x2F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x9F, 0xCF, 0xE3, 0xE0,
  0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x07, 0x38, 0x7F, 0x87,
  0xFC, 0x39, 0xE1, 0xC7, 0x1C, 0x78, 0xE3, 0x87, 0x1C, 0x38, 0xE3, 0xC7,
  0x1E, 0x78, 0x7F, 0x83, 0xFC, 0x1E, 0xE0, 0x0F, 0x1F, 0xCF, 0xEE, 0x77,
  0x3F, 0x3F, 0xFD, 0xFC, 0xE0, 0x60, 0x38, 0x1C, 0x4F, 0xE3, 0xF0, 0x00,
  0xF8, 0x0F, 0x80, 0x7C, 0x07, 0x80, 0x38, 0x01, 0xF0, 0x3F, 0x81, 0xFC,
  0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x00, 0x07, 0x38, 0x7D, 0x87, 0xFC, 0x39, 0xE1, 0xCF,
  0x1E, 0x78, 0xE3, 0x87, 0x1C, 0x38, 0xE3, 0xCF, 0x1E, 0x78, 0xFF, 0x83,
  0xFC, 0x1E, 0xE0, 0x07, 0x00, 0x70, 0x83, 0x87, 0xFC, 0x3F, 0xC0, 0xFC,
  0x00, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x3B, 0x8E, 0xF9, 0xFF,
  0x3C, 0xE7, 0x1C, 0xE7, 0xBC, 0xE7, 0x1C, 0xE3, 0x9C, 0x73, 0x9E, 0xF3,
  0x9C, 0x73, 0x8E, 0x00, 0x0E, 0x3C, 0x78, 0x60, 0x03, 0x8F, 0x1C, 0x38,
  0x70, 0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0xF1, 0xC3, 0x80, 0x01, 0xC0, 0xF0,
  0x3C, 0x06, 0x00, 0x00, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E,
  0x0F, 0x83, 0xE0, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xCF, 0x38, 0xE3, 0x9C, 0x3B, 0xC3, 0xB8, 0x3F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x77, 0x07, 0x70, 0xE3, 0x8E, 0x38, 0xE3, 0x80, 0x0E, 0x1C,
  0x78, 0xE1, 0xC3, 0x8F, 0x1C, 0x38, 0x70, 0xE3, 0xC7, 0x0E, 0x1C, 0x38,
  0xF1, 0xC3, 0x80, 0x19, 0xCE, 0x3F, 0xDF, 0x3F, 0xFF, 0x3D, 0xE7, 0x39,
  0xE7, 0x39, 0xC7, 0x71, 0xC7, 0x71, 0xCE, 0x71, 0xCE, 0x73, 0x8E, 0x73,
  0x8E, 0xE3, 0x8E, 0xE3, 0x9C, 0xE7, 0x9C, 0x19, 0xC7, 0x7C, 0xFF, 0x9E,
  0x73, 0x8E, 0x73, 0xDE, 0x73, 0x8E, 0x71, 0xCE, 0x39, 0xCF, 0x71, 0xCE,
  0x39, 0xC7, 0x00, 0x0F, 0x0F, 0xE7, 0xF9, 0xCF, 0xF1, 0xF8, 0xFE, 0x3F,
  0x8E, 0xE3, 0xB8, 0xEE, 0x7B, 0xFC, 0xFE, 0x1F, 0x00, 0x0C, 0xE1, 0xDF,
  0x1F, 0xF1, 0xE7, 0x1C, 0x71, 0xC7, 0x38, 0x73, 0x8F, 0x38, 0xE3, 0x8E,
  0x39, 0xE7, 0xFC, 0x7F, 0xC7, 0x78, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x0F, 0x71, 0xF6, 0x1F, 0xE3, 0x9E, 0x38, 0xE7, 0x1E,
  0x71, 0xC7, 0x1C, 0x71, 0xCF, 0x1C, 0xF3, 0xC7, 0xF8, 0x7F, 0x87, 0xB8,
  0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x19, 0x9D, 0xCF,
  0xE7, 0xE3, 0xC1, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0E, 0x07,
  0x00, 0x0F, 0x1F, 0xCF, 0xEF, 0x17, 0x83, 0xC0, 0xF8, 0x3C, 0x0F, 0x07,
  0xA3, 0xDF, 0xCF, 0xE7, 0xE0, 0x1C, 0x30, 0x61, 0xFF, 0xFF, 0xDC, 0x38,
  0x70, 0xE3, 0x87, 0x0E, 0x1C, 0x3A, 0x7C, 0xF8, 0x39, 0xDC, 0x77, 0x1D,
  0xC7, 0x71, 0xDC, 0xEE, 0x3B, 0x8E, 0xE3, 0xB9, 0xEE, 0x73, 0xBC, 0xFF,
  0x3D, 0xC0, 0xF1, 0xDC, 0x77, 0x39, 0x8E, 0x67, 0x19, 0xC6, 0x71, 0xB8,
  0x6E, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1C, 0x00, 0x73, 0xC7, 0x73, 0xCE,
  0x63, 0xCE, 0x67, 0xDC, 0xE7, 0xDC, 0xEF, 0xDC, 0xED, 0xF8, 0xED, 0xB8,
  0xFD, 0xB0, 0xF9, 0xF0, 0xF9, 0xF0, 0xF9, 0xE0, 0xF1, 0xE0, 0xF1, 0xC0,
  0x1C, 0x71, 0xCF, 0x1C, 0xE1, 0xDC, 0x0F, 0xC0, 0xF8, 0x0F, 0x00, 0xF0,
  0x1F, 0x01, 0xF0, 0x3B, 0x87, 0xB8, 0x73, 0x8E, 0x38, 0x0E, 0x38, 0x71,
  0xC3, 0x9C, 0x1C, 0xE0, 0xEF, 0x07, 0x70, 0x3B, 0x81, 0xF8, 0x0F, 0xC0,
  0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C,
  0x07, 0xE0, 0x3E, 0x01, 0xE0, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x0E, 0x07,
  0x81, 0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x07, 0x81, 0xFC, 0xFF, 0x3F, 0xC0,
  0x01, 0xC1, 0xF0, 0x7C, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x0F,
  0x07, 0x83, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x81,
  0xF0, 0x3C, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0C, 0x0F, 0x87, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E,
  0x07, 0x81, 0xE0, 0xF1, 0xF8, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x1F,
  0x0F, 0x07, 0x00, 0x78, 0x7F, 0xBF, 0xFE, 0x1F,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 7, 18, 6, 0, -18 },
  { 17, 9, 7, 10, 2, -18 },
  { 25, 13, 18, 12, 0, -18 },
  { 55, 11, 20, 11, 0, -19 },
  { 83, 16, 18, 18, 1, -18 },
  { 119, 13, 18, 13, 0, -18 },
  { 149, 5, 7, 6, 2, -18 },
  { 154, 9, 22, 7, 0, -18 },
  { 179, 8, 22, 7, -2, -18 },
  { 201, 9, 10, 10, 2, -19 },
  { 213, 10, 12, 12, 1, -15 },
  { 228, 5, 6, 6, -1, -3 },
  { 232, 7, 3, 7, 0, -8 },
  { 235, 4, 4, 6, 0, -4 },
  { 237, 12, 18, 9, -1, -18 },
  { 264, 11, 18, 11, 0, -18 },
  { 289, 8, 18, 11, 2, -18 },
  { 307, 12, 18, 11, -1, -18 },
  { 334, 11, 18, 11, 0, -18 },
  { 359, 11, 18, 11, 0, -18 },
  { 384, 11, 18, 11, 0, -18 },
  { 409, 11, 18, 11, 1, -18 },
  { 434, 11, 18, 11, 1, -18 },
  { 459, 11, 18, 11, 0, -18 },
  { 484, 11, 18, 11, 0, -18 },
  { 509, 6, 14, 6, 0, -14 },
  { 520, 7, 17, 6, -1, -14 },
  { 535, 10, 12, 12, 1, -15 },
  { 550, 10, 8, 12, 1, -13 },
  { 560, 10, 12, 12, 1, -15 },
  { 575, 8, 18, 8, 1, -18 },
  { 593, 15, 20, 16, 1, -18 },
  { 631, 12, 18, 12, -2, -18 },
  { 658, 12, 18, 12, 0, -18 },
  { 685, 12, 18, 11, 1, -18 },
  { 712, 13, 18, 13, 0, -18 },
  { 742, 11, 18, 10, 0, -18 },
  { 767, 11, 18, 10, 0, -18 },
  { 792, 13, 18, 13, 1, -18 },
  { 822, 14, 18, 13, 0, -18 },
  { 854, 11, 18, 8, -1, -18 },
  { 879, 11, 23, 6, -4, -18 },
  { 911, 14, 18, 12, 0, -18 },
  { 943, 8, 18, 10, 0, -18 },
  { 961, 18, 18, 17, 0, -18 },
  { 1002, 15, 18, 14, 0, -18 },
  { 1036, 12, 18, 14, 1, -18 },
  { 1063, 12, 18, 12, 0, -18 },
  { 1090, 12, 22, 14, 1, -18 },
  { 1123, 12, 18, 12, 0, -18 },
  { 1150, 12, 18, 10, -1, -18 },
  { 1177, 10, 18, 10, 2, -18 },
  { 1200, 13, 18, 13, 1, -18 },
  { 1230, 12, 18, 12, 2, -18 },
  { 1257, 18, 18, 18, 2, -18 },
  { 1298, 14, 18, 11, -1, -18 },
  { 1330, 11, 18, 11, 2, -18 },
  { 1355, 12, 18, 10, -1, -18 },
  { 1382, 10, 22, 7, -1, -18 },
  { 1410, 6, 18, 9, 2, -18 },
  { 1424, 10, 22, 7, -2, -18 },
  { 1452, 11, 11, 11, 0, -18 },
  { 1468, 8, 2, 8, -2, 2 },
  { 1470, 4, 4, 7, 4, -19 },
  { 1472, 12, 14, 12, 0, -14 },
  { 1493, 11, 19, 11, 0, -19 },
  { 1520, 9, 14, 9, 1, -14 },
  { 1536, 13, 19, 12, 0, -19 },
  { 1567, 9, 14, 11, 1, -14 },
  { 1583, 13, 25, 7, -3, -19 },
  { 1624, 13, 20, 12, -1, -14 },
  { 1657, 11, 19, 11, 0, -19 },
  { 1684, 7, 19, 6, 0, -19 },
  { 1701, 10, 25, 6, -3, -19 },
  { 1733, 12, 19, 11, 0, -19 },
  { 1762, 7, 19, 6, 0, -19 },
  { 1779, 16, 14, 17, 0, -14 },
  { 1807, 11, 14, 11, 0, -14 },
  { 1827, 10, 14, 11, 1, -14 },
  { 1845, 12, 20, 11, -1, -14 },
  { 1875, 12, 20, 12, 0, -14 },
  { 1905, 9, 14, 8, 0, -14 },
  { 1921, 9, 14, 9, 0, -14 },
  { 1937, 7, 17, 7, 1, -17 },
  { 1952, 10, 14, 11, 1, -14 },
  { 1970, 10, 14, 10, 1, -14 },
  { 1988, 16, 14, 15, 1, -14 },
  { 2016, 12, 14, 10, -1, -14 },
  { 2037, 13, 20, 10, -2, -14 },
  { 2070, 10, 14, 8, -1, -14 },
  { 2088, 10, 22, 8, 0, -18 },
  { 2116, 3, 25, 9, 3, -19 },
  { 2126, 9, 22, 8, -1, -18 },
  { 2151, 10, 4, 12, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic25pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC25PT7B_H_
