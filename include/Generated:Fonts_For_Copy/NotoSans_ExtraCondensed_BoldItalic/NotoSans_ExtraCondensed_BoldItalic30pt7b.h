#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC30PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E,
  0x0F, 0x07, 0x83, 0x81, 0xC0, 0x00, 0x00, 0x20, 0x3C, 0x3E, 0x1E, 0x0F,
  0x00, 0x7B, 0xDC, 0xF7, 0x3F, 0xCE, 0xF3, 0xB8, 0xEE, 0x70, 0x01, 0xCE,
  0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x33, 0x87, 0xFF, 0xCF, 0xFF, 0x9F,
  0xFF, 0x0E, 0x70, 0x1C, 0xE0, 0x31, 0x80, 0xE7, 0x0F, 0xFF, 0x9F, 0xFF,
  0x3F, 0xFE, 0x1C, 0xE0, 0x39, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x0E,
  0x70, 0x00, 0x00, 0x40, 0x01, 0x00, 0x0E, 0x01, 0xFF, 0x0F, 0xF8, 0x7F,
  0xE1, 0xEB, 0x07, 0x60, 0x1D, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xBC, 0x82, 0xF1, 0x1B, 0x8F, 0xFE, 0x3F,
  0xF8, 0xFF, 0xC0, 0xFC, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x0F, 0x81, 0xC3, 0xF0, 0xE1, 0xDC, 0x38, 0x67, 0x1C, 0x39, 0xC6, 0x0E,
  0x73, 0x83, 0x9D, 0xC0, 0xC6, 0x70, 0x33, 0xB9, 0xEC, 0xEE, 0xFF, 0xF7,
  0x7F, 0xF9, 0xDC, 0xDC, 0xE6, 0x30, 0x3B, 0x9C, 0x1C, 0xE7, 0x07, 0x39,
  0xC3, 0x8E, 0x70, 0xC3, 0x38, 0x70, 0xEE, 0x38, 0x3F, 0x0E, 0x07, 0x80,
  0x00, 0xE0, 0x07, 0xE0, 0x1F, 0xE0, 0x7B, 0xC0, 0xE3, 0x81, 0xCF, 0x03,
  0x9C, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0xF3, 0xFD,
  0xEF, 0x7B, 0x9C, 0xFF, 0x78, 0xFC, 0xF1, 0xF9, 0xE3, 0xE3, 0xC7, 0xC7,
  0xFF, 0xC7, 0xFF, 0x87, 0xCF, 0x80, 0x7B, 0xDD, 0xEF, 0x73, 0x80, 0x03,
  0xC0, 0xE0, 0x78, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x03,
  0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x78, 0x1E, 0x00, 0x07, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03,
  0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x00, 0x07, 0x80, 0x70, 0x47, 0x07, 0x71,
  0x7F, 0xEF, 0xFE, 0x0F, 0xF1, 0xF0, 0x3F, 0x87, 0xB8, 0x33, 0xC1, 0x18,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x1E,
  0x3C, 0xF1, 0xE3, 0x8F, 0x1C, 0x78, 0x7F, 0x7F, 0x7F, 0xFF, 0x23, 0xFF,
  0xEF, 0x00, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x7E, 0x0F, 0xF1, 0xFF, 0x3C, 0xF3, 0xCF, 0x38, 0xF7, 0x8F, 0x78, 0xF7,
  0x0F, 0xF0, 0xFF, 0x1E, 0xF1, 0xEF, 0x1E, 0xE1, 0xEE, 0x3C, 0xE3, 0xCE,
  0x38, 0xF7, 0x8F, 0xF0, 0xFF, 0x07, 0xC0, 0x07, 0xC3, 0xE1, 0xF8, 0xFE,
  0x7F, 0x3D, 0xC6, 0xF1, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x00, 0x00, 0xE0,
  0x0F, 0xE0, 0xFF, 0xC3, 0xFF, 0x0E, 0x3C, 0x10, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF,
  0x80, 0x01, 0xC0, 0x7F, 0x87, 0xFE, 0x1F, 0xF0, 0x87, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0xF0, 0x7F, 0x03, 0xF0, 0x1F, 0x81, 0xFE, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x21, 0xF9, 0xFF, 0x8F, 0xF8, 0x7F,
  0x80, 0x00, 0x38, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x0F,
  0xC0, 0xFE, 0x0E, 0xF0, 0x67, 0x07, 0x38, 0x73, 0xC3, 0x1E, 0x38, 0xF3,
  0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0x80, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70,
  0x03, 0xA0, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0x80, 0x3C, 0x83, 0xE6, 0x3E, 0x3F, 0xF1, 0xFF, 0x0F, 0xF0, 0x00,
  0x00, 0x78, 0x1F, 0xC1, 0xFC, 0x1F, 0xE1, 0xF0, 0x0F, 0x00, 0xF0, 0x07,
  0x00, 0x7B, 0x83, 0xFE, 0x1F, 0xF9, 0xFF, 0xCF, 0x1E, 0x78, 0xF3, 0xC7,
  0x9E, 0x3C, 0xE1, 0xE7, 0x9E, 0x3D, 0xF1, 0xFF, 0x07, 0xF8, 0x1F, 0x00,
  0x3F, 0xFC, 0xFF, 0xE3, 0xFF, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x3F, 0x83, 0xFE, 0x3F, 0xF1, 0xE3, 0x8E, 0x1C, 0x71,
  0xE3, 0xCF, 0x1E, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x83, 0xFE, 0x3C, 0xF1,
  0xE3, 0x9E, 0x1E, 0xF0, 0xF7, 0x87, 0x3C, 0x79, 0xFF, 0x87, 0xFC, 0x1F,
  0x80, 0x01, 0xC0, 0x3F, 0x83, 0xFC, 0x3F, 0xF1, 0xE7, 0x9E, 0x3C, 0xF1,
  0xE7, 0x8F, 0x3C, 0x79, 0xC7, 0xCF, 0x3E, 0x7F, 0xE3, 0xFF, 0x0F, 0x78,
  0x03, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x21, 0xF1, 0xFF, 0x0F, 0xF0, 0x7F,
  0x00, 0x04, 0x3C, 0x78, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x0F, 0x3E, 0x78, 0xF0, 0x01, 0x03, 0xC1, 0xE0, 0xF0, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x78, 0x3C, 0x1C,
  0x1E, 0x0E, 0x0F, 0x00, 0x00, 0x10, 0x03, 0x00, 0xF0, 0x3F, 0x0F, 0xE7,
  0xF0, 0xFC, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x00, 0x70,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x07, 0x00, 0x3E, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0xFE, 0x1F, 0xC1, 0xF8, 0x0F, 0x00,
  0x60, 0x00, 0x07, 0x0F, 0xF7, 0xFC, 0xFF, 0x21, 0xC0, 0x70, 0x3C, 0x0E,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x0E, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xC0, 0x3F,
  0xF8, 0x1C, 0x0E, 0x0E, 0x01, 0xC7, 0x00, 0x33, 0x8F, 0xCC, 0xE7, 0xF3,
  0x73, 0x9C, 0xDC, 0xE6, 0x36, 0x71, 0x8F, 0x9C, 0xE7, 0xE6, 0x39, 0xF1,
  0x8E, 0x6C, 0xE7, 0x3B, 0x39, 0xCC, 0xC7, 0xFF, 0x31, 0xEF, 0x8C, 0x10,
  0x83, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x04, 0x03, 0xFF, 0x00, 0x7F, 0x80,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0x70, 0x1D,
  0xC0, 0xF7, 0x03, 0x9C, 0x1E, 0x70, 0x79, 0xC1, 0xC7, 0x0F, 0x1C, 0x3F,
  0xF1, 0xFF, 0xC7, 0xFF, 0x3F, 0xFC, 0xF0, 0xF3, 0xC3, 0xDE, 0x0F, 0x78,
  0x3F, 0xC0, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x71, 0xF1, 0xE1,
  0xE3, 0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0xC1,
  0xE7, 0x83, 0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0xF0, 0xE3,
  0xE3, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0xE0, 0x0F, 0xF0, 0x7F,
  0xC3, 0xFE, 0x1F, 0x08, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xE0, 0x0F, 0x8C, 0x1F, 0xF0, 0x7F, 0xC0, 0xFE, 0x00, 0x0F, 0xF8,
  0x1F, 0xF8, 0x3F, 0xF0, 0x79, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F,
  0x0F, 0x1E, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE1, 0xF3, 0xC3, 0xCF, 0x87,
  0x9E, 0x1F, 0x3C, 0x3C, 0x78, 0xF0, 0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1E, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xC0, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xFE, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x01, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xC0, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0x04, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0xFC, 0xF8, 0xFC,
  0xF1, 0xFC, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF8, 0x78,
  0x7C, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x0F, 0x07, 0x87, 0x83,
  0xC3, 0xC3, 0xC1, 0xE1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x3C,
  0x3C, 0x1F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0x83, 0xC3, 0xC3,
  0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x3C, 0x3C, 0x3C, 0x1E,
  0x1E, 0x0F, 0x0F, 0x0F, 0x80, 0x0F, 0xF8, 0x7F, 0x80, 0xF0, 0x07, 0x80,
  0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x81,
  0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3E, 0x09, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x00,
  0x0F, 0x0F, 0x87, 0x8F, 0x03, 0xC7, 0x81, 0xC7, 0x81, 0xE7, 0x80, 0xF7,
  0xC0, 0x7B, 0xC0, 0x3F, 0xC0, 0x1D, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xDC, 0x01, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0,
  0x38, 0xF0, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x00, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0xFF, 0xFE, 0xFF, 0x80,
  0x0F, 0x80, 0xFC, 0x3F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x07, 0x71, 0xDC, 0x1D, 0xC7,
  0xF0, 0xF7, 0x3B, 0xC3, 0xDC, 0xEF, 0x0F, 0x77, 0xB8, 0x39, 0xDD, 0xE0,
  0xE7, 0xF7, 0x87, 0x9F, 0x9E, 0x1E, 0x7E, 0x70, 0x71, 0xF1, 0xC1, 0xC7,
  0xCF, 0x0F, 0x1E, 0x3C, 0x3C, 0x78, 0xF0, 0xF1, 0xC3, 0x80, 0x0F, 0x83,
  0xC3, 0xE0, 0xE0, 0xF8, 0x38, 0x3E, 0x1E, 0x1F, 0xC7, 0x87, 0xF1, 0xE1,
  0xDC, 0x70, 0x77, 0x1C, 0x1D, 0xCF, 0x0F, 0x73, 0xC3, 0xDE, 0xF0, 0xE7,
  0xB8, 0x38, 0xEE, 0x0E, 0x3F, 0x87, 0x8F, 0xE1, 0xE3, 0xF0, 0x70, 0xFC,
  0x1C, 0x3F, 0x0F, 0x07, 0xC3, 0xC1, 0xF0, 0xF0, 0x78, 0x00, 0x00, 0xE0,
  0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xF3, 0xE7, 0xC3, 0xCF, 0x07, 0xBE,
  0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xDE, 0x07,
  0xBC, 0x0F, 0x78, 0x3E, 0xF0, 0x79, 0xE1, 0xF3, 0xE7, 0xC3, 0xFF, 0x07,
  0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x79, 0xF1,
  0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x1F, 0x1E, 0x3C, 0x78, 0xF8, 0xFF,
  0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x07, 0xF0,
  0x1F, 0xF0, 0x7F, 0xF1, 0xF3, 0xE7, 0xC3, 0xCF, 0x07, 0xBE, 0x0F, 0x78,
  0x1E, 0xF0, 0x3D, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xDE, 0x07, 0xBC, 0x0F,
  0x78, 0x3E, 0xF0, 0x79, 0xE1, 0xF3, 0xE7, 0xC3, 0xFF, 0x07, 0xFC, 0x07,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0xF0, 0x3F, 0xE0, 0xFF, 0xC3, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1C, 0x78, 0xFF, 0xE3, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xE7, 0x07,
  0x9E, 0x1E, 0x78, 0x79, 0xE1, 0xC7, 0x8F, 0x0F, 0x3C, 0x3C, 0xF0, 0xF0,
  0x00, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xF8, 0x81, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x83, 0xE1, 0xEF, 0x83,
  0xFF, 0x0F, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0xF7, 0xFF, 0xFF, 0xF0, 0xF0,
  0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00,
  0xF0, 0x00, 0x1E, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x1E, 0x3C, 0x1E,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x3C, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xFB, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0xF0, 0x7F, 0xC1, 0xEF,
  0x0F, 0x3C, 0x3C, 0xE0, 0xE3, 0x87, 0x8E, 0x1E, 0x38, 0xF0, 0xE3, 0xC3,
  0x9E, 0x0E, 0x78, 0x39, 0xC0, 0xEF, 0x03, 0xBC, 0x0E, 0xE0, 0x3F, 0x80,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x70, 0x78, 0x7D,
  0xC1, 0xE1, 0xE7, 0x0F, 0x87, 0x1C, 0x3E, 0x3C, 0x70, 0xF8, 0xF1, 0xC7,
  0xE3, 0x8F, 0x1F, 0x9E, 0x3C, 0xFC, 0x78, 0xF3, 0xF3, 0xC3, 0xCF, 0xCF,
  0x0F, 0x77, 0x38, 0x3D, 0xDD, 0xE0, 0xFF, 0x77, 0x83, 0xF9, 0xDC, 0x0F,
  0xE7, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0x87,
  0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x78, 0x00, 0x07, 0x87, 0x83, 0xC7, 0x80,
  0xE3, 0xC0, 0x7B, 0xC0, 0x3D, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x1C, 0xE0, 0x1E, 0x70, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F,
  0x0F, 0x0F, 0x87, 0x80, 0xF0, 0xFF, 0x1E, 0xF1, 0xEF, 0x3C, 0xF3, 0xCF,
  0x78, 0x77, 0x87, 0xF0, 0x7F, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00,
  0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xFF, 0x87,
  0xFF, 0x0F, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x70, 0x0F, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03,
  0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07,
  0x00, 0xF0, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xE3, 0xCF, 0x3C, 0xF1, 0xC7,
  0x1C, 0x71, 0xE7, 0x9E, 0x38, 0xE3, 0x8E, 0x38, 0xF3, 0xCF, 0x1C, 0x70,
  0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C,
  0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x0F, 0xE0,
  0xFC, 0x0F, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x07,
  0x70, 0x3B, 0xC3, 0x8E, 0x3C, 0x71, 0xC3, 0x9C, 0x1F, 0xE0, 0x70, 0xFF,
  0xFF, 0xF0, 0xF9, 0xE3, 0x8F, 0x1C, 0x06, 0x00, 0xFB, 0xCF, 0xFE, 0x7F,
  0xE7, 0xCF, 0x3C, 0x7B, 0xE3, 0xDE, 0x1E, 0xF0, 0xE7, 0x8F, 0x3C, 0x79,
  0xE3, 0xCF, 0x3E, 0x79, 0xE3, 0xFF, 0x1F, 0xF8, 0x7B, 0xC0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x79, 0x83, 0xFE, 0x1F,
  0xF8, 0xFF, 0xCF, 0x9E, 0x78, 0xF3, 0xC7, 0x9C, 0x3C, 0xE1, 0xEF, 0x0F,
  0x78, 0x73, 0xC7, 0x9E, 0x3D, 0xF3, 0xCF, 0xFE, 0x77, 0xE3, 0xBE, 0x00,
  0x03, 0x81, 0xFC, 0x7F, 0x1F, 0xE7, 0xC0, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE2, 0x3F, 0xC7, 0xF8, 0x7E, 0x00,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x67,
  0x87, 0xFE, 0x3F, 0xF8, 0xFF, 0xC7, 0x8F, 0x1E, 0x3C, 0x70, 0xF3, 0xC3,
  0xCF, 0x0E, 0x3C, 0x38, 0xF1, 0xE3, 0x87, 0x8E, 0x1E, 0x3C, 0xF0, 0xFF,
  0xC3, 0xF7, 0x07, 0x9C, 0x00, 0x03, 0x01, 0xF8, 0x7F, 0x9E, 0x77, 0x8E,
  0xE1, 0xFC, 0x7F, 0xFE, 0xFF, 0x9F, 0xC3, 0x80, 0x70, 0x0E, 0x01, 0xE1,
  0x3F, 0xE3, 0xFC, 0x3F, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xA0, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1E,
  0x00, 0x00, 0x01, 0x80, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE1, 0xE3, 0xC3,
  0xC7, 0x87, 0x0F, 0x1E, 0x1E, 0x3C, 0x38, 0x78, 0xF0, 0xF1, 0xE1, 0xE3,
  0xC3, 0xCF, 0x87, 0x9E, 0x0F, 0xFC, 0x1F, 0xF8, 0x1E, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x0C, 0x3E, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0x07,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x79, 0x83, 0xFE,
  0x1F, 0xF8, 0xFF, 0xCF, 0x9E, 0x78, 0xF3, 0xC7, 0x9E, 0x3C, 0xE1, 0xCF,
  0x1E, 0x78, 0xF3, 0xC7, 0x9E, 0x3D, 0xE1, 0xCF, 0x1E, 0x78, 0xF3, 0xC7,
  0x80, 0x07, 0x0F, 0x0F, 0x0F, 0x04, 0x00, 0x00, 0x1E, 0x1E, 0x1C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0xF0,
  0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1E,
  0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x1E, 0x01, 0xE0, 0x1E, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x8F, 0x1C,
  0x78, 0x73, 0xC3, 0xDE, 0x0F, 0x78, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F,
  0xE0, 0x7F, 0xC1, 0xEF, 0x07, 0x3C, 0x1C, 0x70, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x00, 0x07, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF0,
  0xF0, 0x00, 0x60, 0x81, 0xDF, 0x3E, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x3E,
  0x78, 0xE3, 0xC7, 0x8E, 0x3C, 0x71, 0xE3, 0x87, 0x1E, 0x38, 0xF1, 0xE7,
  0x8F, 0x1E, 0x78, 0xF1, 0xC7, 0x8E, 0x3C, 0x70, 0xE3, 0xC7, 0x1E, 0x3C,
  0xF1, 0xE3, 0x8F, 0x1E, 0x38, 0xF1, 0xC7, 0x80, 0x00, 0x40, 0xEF, 0x87,
  0xFE, 0x3F, 0xF3, 0xE7, 0x9E, 0x3C, 0xF1, 0xE7, 0x8F, 0x38, 0x73, 0xC7,
  0x9E, 0x3C, 0xF1, 0xE7, 0x0E, 0x38, 0x73, 0xC7, 0x9E, 0x3C, 0xF1, 0xE0,
  0x03, 0x80, 0xFC, 0x3F, 0xE3, 0xFE, 0x78, 0xF7, 0x8F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0E, 0xE1, 0xEE, 0x1E, 0xE1, 0xEF, 0x3C, 0xFF, 0x87, 0xF8,
  0x3E, 0x00, 0x00, 0x18, 0x0E, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0xF9, 0xE1,
  0xE3, 0xC3, 0xC7, 0x87, 0x0F, 0x0E, 0x1E, 0x3C, 0x3C, 0x78, 0x70, 0xF1,
  0xE1, 0xE3, 0xC3, 0xCF, 0x0F, 0xFE, 0x1F, 0xF8, 0x3D, 0xE0, 0x70, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x06,
  0x00, 0xFD, 0xC7, 0xFE, 0x7F, 0xE7, 0x8F, 0x3C, 0x79, 0xC3, 0xDE, 0x1E,
  0xF0, 0xE7, 0x87, 0x38, 0x79, 0xC3, 0xCE, 0x1E, 0x79, 0xE3, 0xFF, 0x1F,
  0xF8, 0x7B, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x00, 0x63, 0xBC, 0x77, 0x8F, 0xE3, 0xF4, 0x7C, 0x0F, 0x01,
  0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x00, 0x07, 0x03, 0xFC, 0xFF, 0x9F, 0xE3, 0xC4, 0x78, 0x0F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x79, 0x0F, 0x3F, 0xE7, 0xF8,
  0xFE, 0x00, 0x0E, 0x07, 0x07, 0x03, 0x87, 0xFB, 0xFB, 0xFC, 0x70, 0x38,
  0x3C, 0x1E, 0x0F, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7E, 0x3F, 0x0F,
  0x80, 0x3C, 0x79, 0xC3, 0x8E, 0x1C, 0xF1, 0xE7, 0x8F, 0x3C, 0x79, 0xC3,
  0x8E, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0x71, 0xC7, 0x8F, 0x3C, 0x7F, 0xE3,
  0xFF, 0x0F, 0x70, 0xE1, 0xFE, 0x1E, 0xE1, 0xCE, 0x3C, 0xE3, 0x8E, 0x78,
  0xE7, 0x0E, 0x70, 0xEF, 0x0E, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0x80,
  0xF8, 0x0F, 0x00, 0xE1, 0xE3, 0xF8, 0xF8, 0xEE, 0x3E, 0x7B, 0x9F, 0x9C,
  0xE7, 0xE7, 0x39, 0xBB, 0xCE, 0xEE, 0xE3, 0xBB, 0xF8, 0xFC, 0xFC, 0x3F,
  0x37, 0x0F, 0xDF, 0xC3, 0xE7, 0xE0, 0xF9, 0xF8, 0x3E, 0x7C, 0x0F, 0x1F,
  0x03, 0xC7, 0xC0, 0x1E, 0x3C, 0x39, 0xE0, 0xE7, 0x83, 0xFC, 0x0F, 0xE0,
  0x3F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x0F, 0x70,
  0x39, 0xC1, 0xE7, 0x8F, 0x1E, 0x3C, 0x78, 0x0F, 0x0F, 0x0F, 0x1E, 0x0F,
  0x1C, 0x0F, 0x3C, 0x0F, 0x38, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x0F,
  0xF0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x1F, 0xE0, 0x1E, 0x03,
  0xC0, 0x38, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78,
  0x4F, 0xF8, 0xFF, 0x8F, 0xF8, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x7C, 0x07,
  0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x07, 0xE0, 0x70,
  0x0F, 0xC0, 0x7C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x7C, 0x07,
  0xC0, 0x3C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03,
  0xC0, 0x3F, 0x00, 0xE0, 0x3E, 0x07, 0xC0, 0xF0, 0x0F, 0x00, 0xF0, 0x0E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0E, 0x00, 0x7C,
  0x0F, 0xF9, 0xFF, 0xFF, 0x8F, 0xE8, 0x1E, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 9, 21, 8, 0, -21 },
  { 25, 10, 7, 12, 3, -21 },
  { 34, 15, 21, 14, 0, -21 },
  { 74, 14, 25, 13, 0, -23 },
  { 118, 18, 22, 21, 2, -22 },
  { 168, 15, 22, 15, 0, -22 },
  { 210, 5, 7, 7, 3, -21 },
  { 215, 10, 26, 8, 0, -21 },
  { 248, 10, 27, 8, -2, -22 },
  { 282, 12, 12, 12, 2, -23 },
  { 300, 12, 15, 14, 1, -18 },
  { 323, 7, 8, 7, -2, -4 },
  { 330, 8, 4, 9, 0, -10 },
  { 334, 5, 5, 7, 0, -5 },
  { 338, 16, 22, 11, -2, -22 },
  { 382, 12, 22, 13, 1, -22 },
  { 415, 10, 21, 13, 3, -21 },
  { 442, 14, 22, 13, -1, -22 },
  { 481, 13, 22, 13, 0, -22 },
  { 517, 13, 22, 13, 0, -22 },
  { 553, 13, 21, 13, 0, -21 },
  { 588, 13, 22, 13, 1, -22 },
  { 624, 14, 21, 13, 1, -21 },
  { 661, 13, 22, 13, 0, -22 },
  { 697, 13, 22, 13, 0, -22 },
  { 733, 7, 17, 7, 0, -17 },
  { 748, 9, 21, 7, -2, -17 },
  { 772, 12, 14, 14, 1, -18 },
  { 793, 12, 9, 14, 1, -15 },
  { 807, 13, 14, 14, 1, -18 },
  { 830, 10, 22, 10, 1, -22 },
  { 858, 18, 24, 19, 1, -22 },
  { 912, 14, 22, 14, -2, -22 },
  { 951, 15, 21, 14, 0, -21 },
  { 991, 14, 22, 13, 1, -22 },
  { 1030, 15, 21, 15, 0, -21 },
  { 1070, 13, 21, 12, 0, -21 },
  { 1105, 13, 21, 11, 0, -21 },
  { 1140, 16, 22, 16, 1, -22 },
  { 1184, 17, 21, 16, 0, -21 },
  { 1229, 13, 21, 10, -1, -21 },
  { 1264, 13, 27, 7, -5, -21 },
  { 1308, 17, 21, 14, 0, -21 },
  { 1353, 10, 21, 12, 0, -21 },
  { 1380, 22, 21, 21, 0, -21 },
  { 1438, 18, 21, 17, 0, -21 },
  { 1486, 15, 22, 16, 1, -22 },
  { 1528, 15, 21, 14, 0, -21 },
  { 1568, 15, 27, 16, 1, -22 },
  { 1619, 14, 21, 14, 0, -21 },
  { 1656, 15, 22, 12, -1, -22 },
  { 1698, 12, 21, 12, 2, -21 },
  { 1730, 16, 21, 15, 1, -21 },
  { 1772, 14, 21, 14, 3, -21 },
  { 1809, 22, 21, 21, 2, -21 },
  { 1867, 17, 21, 13, -2, -21 },
  { 1912, 12, 21, 13, 3, -21 },
  { 1944, 15, 21, 12, -1, -21 },
  { 1984, 12, 26, 8, -1, -21 },
  { 2023, 6, 22, 11, 3, -22 },
  { 2040, 12, 26, 8, -2, -21 },
  { 2079, 13, 12, 13, 0, -21 },
  { 2099, 10, 2, 10, -3, 3 },
  { 2102, 6, 5, 9, 4, -23 },
  { 2106, 13, 17, 14, 1, -17 },
  { 2134, 13, 23, 14, 0, -23 },
  { 2172, 11, 17, 11, 1, -17 },
  { 2196, 14, 23, 14, 1, -23 },
  { 2237, 11, 17, 13, 1, -17 },
  { 2261, 15, 30, 8, -3, -23 },
  { 2318, 15, 24, 14, -1, -17 },
  { 2363, 13, 23, 14, 0, -23 },
  { 2401, 8, 23, 7, 0, -23 },
  { 2424, 12, 30, 7, -4, -23 },
  { 2469, 14, 23, 13, 0, -23 },
  { 2510, 8, 23, 7, 0, -23 },
  { 2533, 20, 17, 20, 0, -17 },
  { 2576, 13, 17, 14, 0, -17 },
  { 2604, 12, 17, 13, 1, -17 },
  { 2630, 15, 24, 14, -2, -17 },
  { 2675, 13, 24, 14, 1, -17 },
  { 2714, 11, 17, 10, 0, -17 },
  { 2738, 11, 17, 11, 0, -17 },
  { 2762, 9, 20, 9, 1, -20 },
  { 2785, 13, 16, 14, 1, -16 },
  { 2811, 12, 16, 12, 2, -16 },
  { 2835, 18, 16, 18, 2, -16 },
  { 2871, 14, 16, 12, -1, -16 },
  { 2899, 16, 23, 12, -2, -16 },
  { 2945, 12, 16, 10, -1, -16 },
  { 2969, 12, 26, 10, 0, -21 },
  { 3008, 3, 30, 11, 4, -23 },
  { 3020, 12, 26, 10, -2, -21 },
  { 3059, 13, 5, 14, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic30pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC30PT7B_H_
