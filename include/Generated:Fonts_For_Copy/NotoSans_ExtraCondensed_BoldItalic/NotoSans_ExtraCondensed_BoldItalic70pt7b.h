#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC70PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xE1, 0xFF,
  0x3F, 0xE1, 0xFF, 0x3F, 0xE1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC3, 0xFE,
  0x3F, 0xC3, 0xFE, 0x7F, 0xC3, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC,
  0x7F, 0x83, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x07, 0xF8, 0xFF, 0x07, 0xF8,
  0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0,
  0xFE, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x00,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x3F,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x0F,
  0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xBB, 0xF8, 0x01, 0xFF, 0x38, 0xF0, 0x01, 0xFE, 0x30, 0x20, 0x03, 0xFE,
  0x70, 0x00, 0x03, 0xFE, 0x70, 0x00, 0x03, 0xFE, 0x70, 0x00, 0x03, 0xFE,
  0x70, 0x00, 0x03, 0xFF, 0x60, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0x3F, 0xE0, 0x00, 0x03, 0x3F, 0xE0, 0x00, 0x07, 0x3F, 0xE0, 0x00, 0x07,
  0x3F, 0xE0, 0x20, 0x07, 0x3F, 0xE0, 0x30, 0x06, 0x3F, 0xE0, 0x7C, 0x0E,
  0x7F, 0xE0, 0x7F, 0x0E, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xE0, 0x01, 0xFF,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xC0,
  0x0F, 0xE0, 0x03, 0xFB, 0xF8, 0x01, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x7F,
  0x00, 0x1F, 0x87, 0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x00,
  0xFC, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0x83, 0xF8, 0x1F, 0xC0, 0x07, 0xF0,
  0x7E, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0x81, 0xF8,
  0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xE1, 0xFC,
  0x00, 0x1F, 0x81, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x0F, 0xE0, 0x00,
  0x7E, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC1, 0xFC, 0x7F, 0x01, 0xC1, 0xF8,
  0x3F, 0x0F, 0xC1, 0xFE, 0x3F, 0x0F, 0xE3, 0xF8, 0x7F, 0xE7, 0xE1, 0xFC,
  0xFE, 0x1F, 0xFE, 0xFC, 0x7F, 0x1F, 0xC7, 0xFF, 0xFF, 0xDF, 0xE7, 0xF1,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x7F, 0xBF, 0xFF, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF7, 0xFF, 0x87, 0xE3, 0xF8, 0x7E, 0x7F, 0xE1, 0xFC, 0x7E, 0x0F, 0xC7,
  0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x38, 0x0F, 0xE3, 0xF8, 0x3F, 0x00, 0x01,
  0xF8, 0x7E, 0x07, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0xC3,
  0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xC0,
  0xFE, 0x00, 0x1F, 0xC1, 0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x03, 0xF0,
  0x00, 0xFC, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0x07,
  0xE0, 0x3F, 0x83, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x00,
  0xFE, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0x01, 0xFD,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xE0,
  0x3F, 0xFF, 0xC3, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF, 0xE3,
  0xFC, 0x1F, 0xF3, 0xFE, 0x7F, 0xC1, 0xFE, 0x3F, 0xE7, 0xF8, 0x3F, 0xE1,
  0xFF, 0xFF, 0x83, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0x07,
  0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF,
  0xC0, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0x80,
  0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x0F,
  0xFC, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE7, 0xFE, 0x01, 0xFF, 0xFC, 0x7F, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3F, 0xF3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3,
  0xFC, 0x3F, 0xC7, 0xFC, 0x7F, 0xC7, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x03, 0x03, 0xF8,
  0x00, 0xF0, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x9F, 0xEF, 0xE1, 0xE7, 0xFF,
  0xF7, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFB,
  0xFC, 0x07, 0xFE, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x1F, 0x87, 0xFC, 0x03,
  0xE0, 0xFF, 0x00, 0x70, 0x3F, 0x00, 0x08, 0x0F, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC,
  0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00,
  0xFF, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFE, 0x7F,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x07, 0x03, 0xF8, 0xFF,
  0xBF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xDF, 0xF1, 0xFC, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x7F, 0xC0, 0x7F,
  0xC1, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x83, 0xFE, 0x03,
  0xFC, 0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8,
  0x7F, 0xC0, 0x7F, 0xC3, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF1, 0xFF,
  0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xE7, 0xFC, 0x03,
  0xFE, 0x3F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFC,
  0xFF, 0x80, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF1, 0xFF,
  0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xC3, 0xFC, 0x03,
  0xFE, 0x3F, 0xE0, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8,
  0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF,
  0x83, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xE1, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0x7F, 0x8F, 0xF9, 0xFE,
  0x1F, 0xCF, 0xF8, 0x3C, 0x3F, 0xE0, 0x60, 0xFF, 0x01, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xF7, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0xF0, 0x01, 0xF0, 0x0F, 0xFC,
  0x00, 0x78, 0x03, 0xFF, 0x00, 0x0C, 0x00, 0xFF, 0xC0, 0x02, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xDF, 0xFF, 0x00, 0x3C, 0x03, 0xFF, 0x00, 0x18, 0x03, 0xFF, 0x00, 0x20,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x80, 0x00,
  0xFF, 0xC0, 0xE0, 0x03, 0xFF, 0xC0, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xF7, 0xF8, 0x00, 0x03, 0xF7, 0xF8, 0x00, 0x07, 0xEF, 0xF8, 0x00, 0x0F,
  0xCF, 0xF0, 0x00, 0x0F, 0xCF, 0xF0, 0x00, 0x1F, 0x8F, 0xF0, 0x00, 0x3F,
  0x9F, 0xF0, 0x00, 0x3F, 0x1F, 0xF0, 0x00, 0x7E, 0x1F, 0xE0, 0x00, 0xFE,
  0x1F, 0xE0, 0x00, 0xFC, 0x1F, 0xE0, 0x01, 0xF8, 0x3F, 0xE0, 0x03, 0xF8,
  0x3F, 0xE0, 0x03, 0xF0, 0x3F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0,
  0x7F, 0xC0, 0x0F, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x7F, 0xC0, 0x3F, 0x80,
  0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF1, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0x0F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x40, 0x00, 0xFF,
  0xC0, 0xC0, 0x03, 0xFF, 0x81, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x18, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x1F,
  0xE7, 0xFF, 0x00, 0xFF, 0xBF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xCF,
  0xFC, 0x1F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC3, 0xFF, 0x01, 0xFF,
  0x0F, 0xFC, 0x07, 0xFC, 0x3F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3,
  0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xF0, 0xFF,
  0x80, 0xFF, 0x83, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0,
  0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x7F,
  0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0,
  0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x07, 0xFC, 0x7F, 0xE0, 0x0F, 0xFD, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F,
  0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x87, 0xFE,
  0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0,
  0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00,
  0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xCF, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0,
  0x7F, 0xC1, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F,
  0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x0F, 0xFC,
  0x3F, 0xE0, 0x3F, 0xF0, 0xFF, 0x81, 0xFF, 0xC3, 0xFE, 0x07, 0xFE, 0x0F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xFB, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFD,
  0xFF, 0x00, 0xFF, 0xEF, 0xF8, 0x00, 0xFE, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x38, 0x0F,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x07, 0xC1, 0xFF, 0x83, 0x80, 0x7F, 0xC1, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x1F,
  0xC0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x01,
  0xFF, 0x81, 0xF8, 0x1F, 0x80, 0xFF, 0xFC, 0x3F, 0x07, 0xE0, 0x3F, 0xFF,
  0x87, 0xE0, 0xFC, 0x0F, 0xFF, 0xF0, 0xFC, 0x3F, 0x03, 0xFF, 0xFE, 0x1F,
  0x87, 0xE0, 0xFE, 0x1F, 0x83, 0xF1, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x3F,
  0x07, 0xE0, 0x7E, 0x0F, 0xCF, 0xC0, 0xFC, 0x1F, 0xC1, 0xF9, 0xF8, 0x3F,
  0x03, 0xF0, 0x3F, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xCF, 0xC1, 0xFC, 0x0F,
  0xC1, 0xF9, 0xF8, 0x3F, 0x03, 0xF8, 0x3F, 0x3F, 0x07, 0xE0, 0x7E, 0x07,
  0xE7, 0xE1, 0xFC, 0x0F, 0xC0, 0xF8, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x3F,
  0x07, 0xE0, 0x7F, 0x07, 0xE7, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0xFC, 0x1F,
  0x81, 0xF8, 0x1F, 0x1F, 0x83, 0xF0, 0x7F, 0x07, 0xE3, 0xF0, 0x7E, 0x0F,
  0xE0, 0xF8, 0x7E, 0x0F, 0xC3, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0x7F, 0x8F,
  0xC1, 0xF0, 0x3F, 0x9F, 0xF3, 0xF8, 0x3E, 0x07, 0xFF, 0xBF, 0xFE, 0x07,
  0xC0, 0xFF, 0xF7, 0xFF, 0x80, 0xFC, 0x0F, 0xFC, 0xFF, 0xE0, 0x1F, 0x80,
  0xFF, 0x0F, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x7F,
  0xC0, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0xDF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x03, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x7F, 0xC3, 0xFC,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xFC, 0x0F,
  0xF0, 0x07, 0xFC, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0,
  0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8,
  0x01, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC7, 0xFE,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x0F, 0xFD, 0xFF,
  0x80, 0x07, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0x1F, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC,
  0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F,
  0xF0, 0x1F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFC, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x0E, 0x00, 0x7F, 0xF0, 0x02, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x01, 0x00, 0x1F, 0xFC, 0x03, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xC7, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x03, 0xFE, 0x03, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x81,
  0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF,
  0xC0, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF0, 0x03, 0xFF, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x83,
  0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x0F, 0xFC, 0x0F, 0xF8, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xF0, 0x07,
  0xFC, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xE0, 0x7F, 0xFF, 0x0F,
  0xFC, 0x07, 0xFF, 0xF0, 0xFF, 0xC0, 0x7F, 0xFF, 0x0F, 0xFC, 0x07, 0xFF,
  0xE0, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0x80,
  0xFF, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF,
  0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x31, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F,
  0x81, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xFC,
  0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x1F,
  0xE1, 0xFF, 0x80, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0xC0, 0x00, 0x07,
  0xF9, 0xFF, 0x00, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x3F, 0xBF, 0xC0, 0x07, 0xFF, 0xF8, 0x0F, 0xF7, 0xF8,
  0x01, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x3F, 0xBF,
  0xE0, 0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x81, 0xFC,
  0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x7F, 0xBF, 0xE0, 0x07, 0xFD, 0xFE, 0x0F,
  0xE7, 0xFC, 0x00, 0xFF, 0x3F, 0xC3, 0xFC, 0xFF, 0x80, 0x1F, 0xE7, 0xF8,
  0x7F, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x8F,
  0xE3, 0xF8, 0xFF, 0x80, 0x1F, 0xE1, 0xFC, 0x7F, 0x1F, 0xF0, 0x03, 0xFC,
  0x3F, 0x9F, 0xE3, 0xFC, 0x00, 0x7F, 0x87, 0xF3, 0xF8, 0x7F, 0x80, 0x0F,
  0xF0, 0xFE, 0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xDF, 0xC3, 0xFE, 0x00,
  0x7F, 0x83, 0xFF, 0xF8, 0x7F, 0xC0, 0x0F, 0xF0, 0x7F, 0xFE, 0x0F, 0xF0,
  0x01, 0xFE, 0x0F, 0xFF, 0xC1, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0xF0, 0x7F,
  0xC0, 0x0F, 0xF8, 0x3F, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x07, 0xFF, 0xC1,
  0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xFE,
  0x07, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F,
  0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x0F, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0,
  0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xC0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0xFC,
  0x01, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x3F,
  0xC0, 0x07, 0xFF, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xFC, 0x00,
  0x7F, 0xBF, 0x81, 0xFF, 0x00, 0x1F, 0xEF, 0xE0, 0x7F, 0xC0, 0x0F, 0xF3,
  0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x3F, 0xC1,
  0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0xFF, 0x80, 0x1F, 0xF1, 0xFC, 0x3F, 0xE0,
  0x07, 0xFC, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x1F, 0xE3, 0xFC, 0x00, 0x7F,
  0x87, 0xF8, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F,
  0x9F, 0xE0, 0x03, 0xFC, 0x0F, 0xE7, 0xF8, 0x00, 0xFF, 0x03, 0xFD, 0xFE,
  0x00, 0x3F, 0xC0, 0xFF, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xDF, 0xE0, 0x07,
  0xFC, 0x0F, 0xFF, 0xF0, 0x01, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0x80,
  0x7F, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xF8, 0x07, 0xFF,
  0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xF0,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x03, 0xFF, 0x1F,
  0xF8, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x7F,
  0xE3, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFC, 0x7F,
  0xE0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0xFF,
  0xC7, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x8F, 0xFC, 0x00,
  0x1F, 0xF8, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF,
  0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x07, 0xFE,
  0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x02, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xC1, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x7F, 0xC0, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x1F,
  0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x3F,
  0xE3, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xE3, 0xFF, 0x00,
  0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x7F,
  0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0xFF,
  0xC7, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0xC7, 0xFC, 0x00,
  0x1F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF8, 0xFF,
  0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x07, 0xFE, 0x07, 0xFC, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x83, 0xFF, 0x80,
  0x7F, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFE,
  0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x7F,
  0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x0F, 0xF1,
  0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFE,
  0x1F, 0xF0, 0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x3E, 0x00, 0x7F, 0xF0, 0x07, 0x00, 0x3F,
  0xF0, 0x01, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x80, 0x00, 0xFF, 0x80, 0x60, 0x00,
  0xFF, 0xC0, 0x3C, 0x00, 0xFF, 0xE0, 0x1F, 0x81, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0x80, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF8,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F,
  0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0x40, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xBF,
  0xE0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x7F, 0xE7,
  0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC,
  0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x3F,
  0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x0F,
  0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x3F, 0xC3,
  0xFE, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFF,
  0x7F, 0xC0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0xDF, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF9, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0x80,
  0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xF8,
  0x03, 0xFE, 0x1F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFF,
  0x80, 0x7F, 0xC1, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0x7F,
  0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x0F,
  0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0x81,
  0xFF, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0xFE, 0x07, 0xF8, 0x07, 0xF8,
  0x1F, 0xFF, 0x83, 0xFE, 0x01, 0xFE, 0x0F, 0xEF, 0xE0, 0xFF, 0x00, 0x7F,
  0x83, 0xFB, 0xF8, 0x7F, 0xC0, 0x1F, 0xE1, 0xFE, 0xFE, 0x1F, 0xF0, 0x07,
  0xF8, 0x7F, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xDF, 0xE3, 0xFE, 0x00,
  0x7F, 0x8F, 0xF7, 0xF8, 0xFF, 0x80, 0x1F, 0xE3, 0xF9, 0xFC, 0x7F, 0xC0,
  0x0F, 0xF9, 0xFE, 0x7F, 0x1F, 0xF0, 0x03, 0xFE, 0x7F, 0x1F, 0xC7, 0xF8,
  0x00, 0xFF, 0x9F, 0xC7, 0xF3, 0xFE, 0x00, 0x3F, 0xEF, 0xF1, 0xFC, 0xFF,
  0x80, 0x0F, 0xFB, 0xF8, 0x7F, 0x3F, 0xC0, 0x03, 0xFC, 0xFE, 0x1F, 0xDF,
  0xF0, 0x00, 0xFF, 0x7F, 0x07, 0xF7, 0xF8, 0x00, 0x3F, 0xDF, 0xC1, 0xFD,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x81,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0xFF, 0x00,
  0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xDF,
  0xE0, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xE7, 0xFC, 0x01, 0xFF, 0x9F, 0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xF1,
  0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0,
  0x7F, 0xC0, 0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x7F,
  0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0xBF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x1F, 0xC7, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80,
  0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F,
  0xE0, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x1F, 0xE0,
  0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0xFF, 0x7F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xC7, 0xFE, 0x1F, 0xF8, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x7F, 0xF9, 0xFF, 0x00, 0xFF, 0xF9, 0xFE,
  0x01, 0xFF, 0xFD, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC,
  0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8,
  0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF0,
  0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0,
  0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xE0,
  0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0xC0,
  0xFF, 0xE3, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0x00,
  0x1F, 0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x83, 0xE0,
  0x00, 0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0xBF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x81, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF,
  0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF,
  0x07, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x03, 0xFE, 0x07, 0xF8, 0x03, 0xFE,
  0x07, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE,
  0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xFC,
  0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF0,
  0x3F, 0xF8, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xBF, 0xFF, 0x00, 0x7F, 0xBF, 0xFE, 0x00,
  0x7F, 0x1F, 0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0x07, 0x00, 0xFF, 0xC0, 0x20, 0x3F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x20, 0x1F, 0xF0, 0x0C, 0x03, 0xFF, 0x07, 0x80,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x8F,
  0xF8, 0x00, 0x7F, 0xF9, 0xFE, 0x00, 0x1F, 0xFF, 0xBF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xE0,
  0x0F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xEF, 0xE0, 0x00, 0xFF, 0xF9, 0xFC, 0x00, 0x0F, 0xFE,
  0x3F, 0x80, 0x00, 0xFF, 0x87, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F,
  0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x1F, 0xF0, 0x0F, 0xE1, 0xFE, 0x01,
  0xFE, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0x3F, 0xCF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x04,
  0x07, 0xFC, 0x00, 0xC0, 0x7F, 0xF0, 0x7C, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x87,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC3,
  0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0x00, 0x0F, 0xFF, 0xDF, 0xE0, 0x01, 0xFF,
  0xFB, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xF0,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F,
  0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x3F, 0xE0, 0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x3F,
  0xF0, 0x7F, 0xF0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE7, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xEF, 0xF8, 0x00, 0x7F, 0xFD, 0xFE, 0x00, 0x07, 0xFF,
  0x7F, 0xC0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x03, 0x81, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0x00, 0x01, 0xFF,
  0x00, 0x30, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x87, 0xE0, 0x00, 0xFF, 0x9F,
  0xF8, 0x00, 0xFF, 0xBF, 0xFC, 0x00, 0xFF, 0x7F, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xC7, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x03,
  0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07,
  0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F,
  0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x08, 0x7F, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x01,
  0xFF, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0,
  0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x07, 0xF8,
  0x7F, 0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFE,
  0x7F, 0xC0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xEF, 0xF8, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8, 0x3F, 0xE0,
  0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xF8, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x07, 0xF0, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xC7,
  0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0x3F, 0xFE, 0x7F, 0xFE, 0x01, 0xFD, 0xFF,
  0xFB, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x8F, 0xFF,
  0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0,
  0x7F, 0x81, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0x80, 0xFF,
  0x83, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0,
  0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x03,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F,
  0xC0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xF8,
  0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x01, 0xFF,
  0x01, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x81, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F,
  0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC,
  0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x03,
  0xF0, 0x7F, 0x80, 0x1F, 0xC7, 0xFF, 0x80, 0x7F, 0x3F, 0xFE, 0x01, 0xFD,
  0xFF, 0xFC, 0x07, 0xF7, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0x87, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0,
  0x7F, 0xC0, 0x7F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x3F,
  0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFC, 0x03, 0xFE, 0x0F, 0xF0,
  0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x07,
  0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0x83, 0xFE, 0x01, 0xFE,
  0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x87,
  0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFE,
  0x01, 0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0x80,
  0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0x83, 0xFE,
  0x03, 0xFE, 0x3F, 0xF0, 0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x07,
  0xFC, 0xFF, 0x80, 0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xFB,
  0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xFC, 0xFF, 0x80, 0x1F, 0xE7, 0xFC,
  0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x03,
  0xFE, 0x7F, 0x80, 0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xF9,
  0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0xE1, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0x1F, 0xFE,
  0x00, 0x0F, 0xE7, 0xFF, 0xC0, 0x01, 0xFC, 0xFF, 0xFC, 0x00, 0x3F, 0xBF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFF,
  0xC1, 0xFF, 0x80, 0x3F, 0xFC, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xBF, 0xFE, 0x00, 0x1F, 0xE3, 0xFF, 0x80, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0xFF, 0x81, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0xFF,
  0x00, 0x3F, 0xF8, 0xFE, 0x00, 0x7F, 0xFD, 0xFE, 0x00, 0xFF, 0xFD, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFE, 0x1F, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8,
  0x1F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0,
  0x3F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0,
  0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0,
  0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFE, 0xFF, 0x00, 0x3F, 0xFE, 0xFF, 0x00, 0x1F, 0xFD, 0xFF, 0x00,
  0x0F, 0xF1, 0xFF, 0x00, 0x03, 0x81, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xC7, 0xFC, 0x07, 0xF3,
  0xFE, 0x01, 0xFC, 0xFF, 0x80, 0x7F, 0x7F, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xF8, 0xFC, 0x0F, 0xFC, 0x06,
  0x03, 0xFE, 0x00, 0x80, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x20, 0x03, 0xFE, 0x0C, 0x01, 0xFF, 0x83,
  0xE0, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x08, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFC, 0x03,
  0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0xC1, 0xFE, 0x01, 0xFE,
  0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83,
  0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xC1, 0xFF,
  0x01, 0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80,
  0x7F, 0x83, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F,
  0xE0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0,
  0x7F, 0xC0, 0x7F, 0xC1, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F,
  0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xF0,
  0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x0F,
  0xFC, 0x0F, 0xF8, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFB, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x7F, 0x80,
  0x7F, 0xF9, 0xFC, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xCF, 0xF8,
  0x07, 0xFC, 0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF,
  0x8F, 0xF8, 0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F,
  0x83, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x7F,
  0x80, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0xFF, 0x80, 0x7F, 0x0F, 0xF0, 0x07,
  0xF1, 0xFF, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x3F,
  0xC0, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x07, 0xF7, 0xF8, 0x00,
  0x7F, 0x7F, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xF8, 0x07, 0xFB,
  0xFE, 0x03, 0xFF, 0x01, 0xFE, 0x7F, 0xC0, 0xFF, 0xE0, 0x3F, 0xCF, 0xF8,
  0x1F, 0xFC, 0x0F, 0xF9, 0xFE, 0x07, 0xFF, 0x81, 0xFE, 0x3F, 0xC0, 0xFF,
  0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xFF, 0xC1,
  0xFE, 0x1F, 0xE0, 0xFF, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xFF, 0x0F, 0xF0,
  0x7F, 0x87, 0xFF, 0xE1, 0xFE, 0x0F, 0xF0, 0xFD, 0xFC, 0x7F, 0x81, 0xFE,
  0x3F, 0xBF, 0x8F, 0xF0, 0x3F, 0xC7, 0xF7, 0xF1, 0xFE, 0x07, 0xF8, 0xFC,
  0xFC, 0x7F, 0x80, 0xFF, 0x3F, 0x9F, 0x8F, 0xF0, 0x1F, 0xE7, 0xF3, 0xF3,
  0xFC, 0x03, 0xFC, 0xFC, 0xFE, 0x7F, 0x80, 0x7F, 0xBF, 0x9F, 0xCF, 0xF0,
  0x0F, 0xF7, 0xF3, 0xFB, 0xFC, 0x01, 0xFF, 0xFC, 0x7F, 0x7F, 0x80, 0x3F,
  0xFF, 0x8F, 0xEF, 0xE0, 0x07, 0xF7, 0xE1, 0xFF, 0xFC, 0x00, 0xFE, 0xFC,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0xFF,
  0xFC, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x07,
  0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x1F, 0xF0,
  0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xFB, 0xFC,
  0x00, 0x03, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x8F,
  0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x00, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0xFF, 0x80, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x7F, 0x83, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE1, 0xFF,
  0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0xFF,
  0x80, 0x00, 0x5F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xA0, 0x00, 0xFF, 0xF1, 0x00,
  0x00, 0xFE, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 20, 51, 18, 0, -50 },
  { 129, 24, 18, 28, 7, -50 },
  { 183, 35, 50, 33, 0, -50 },
  { 402, 32, 57, 30, 0, -53 },
  { 630, 43, 52, 49, 4, -51 },
  { 910, 36, 52, 36, 0, -51 },
  { 1144, 12, 18, 17, 7, -50 },
  { 1171, 23, 61, 19, 1, -50 },
  { 1347, 23, 62, 19, -5, -51 },
  { 1526, 26, 29, 29, 6, -54 },
  { 1621, 28, 34, 32, 3, -42 },
  { 1740, 16, 19, 17, -4, -9 },
  { 1778, 18, 8, 20, 1, -23 },
  { 1796, 11, 12, 17, 0, -11 },
  { 1813, 36, 50, 26, -4, -50 },
  { 2038, 29, 52, 30, 1, -51 },
  { 2227, 22, 50, 30, 7, -50 },
  { 2365, 34, 51, 30, -3, -51 },
  { 2582, 32, 52, 30, -1, -51 },
  { 2790, 32, 50, 30, -1, -50 },
  { 2990, 31, 51, 30, 0, -50 },
  { 3188, 30, 52, 30, 2, -51 },
  { 3383, 32, 50, 30, 2, -50 },
  { 3583, 31, 52, 30, 0, -51 },
  { 3785, 30, 52, 30, 0, -51 },
  { 3980, 17, 40, 17, 0, -39 },
  { 4065, 21, 49, 17, -4, -39 },
  { 4194, 28, 34, 32, 3, -42 },
  { 4313, 28, 21, 32, 3, -35 },
  { 4387, 29, 34, 32, 3, -42 },
  { 4511, 25, 52, 23, 2, -51 },
  { 4674, 43, 57, 45, 2, -51 },
  { 4981, 33, 50, 33, -4, -50 },
  { 5188, 34, 50, 33, 0, -50 },
  { 5401, 33, 52, 31, 2, -51 },
  { 5616, 35, 50, 36, 0, -50 },
  { 5835, 31, 50, 28, 0, -50 },
  { 6029, 31, 50, 27, 0, -50 },
  { 6223, 36, 52, 37, 3, -51 },
  { 6457, 40, 50, 37, 0, -50 },
  { 6707, 30, 50, 22, -3, -50 },
  { 6895, 31, 65, 17, -11, -50 },
  { 7147, 39, 50, 32, 0, -50 },
  { 7391, 23, 50, 27, 0, -50 },
  { 7535, 51, 50, 49, 0, -50 },
  { 7854, 42, 50, 39, 0, -50 },
  { 8117, 36, 52, 38, 2, -51 },
  { 8351, 35, 50, 32, 0, -50 },
  { 8570, 36, 63, 38, 2, -51 },
  { 8854, 33, 50, 32, 0, -50 },
  { 9061, 33, 52, 29, -1, -51 },
  { 9276, 28, 50, 28, 5, -50 },
  { 9451, 37, 51, 36, 2, -50 },
  { 9687, 33, 50, 32, 6, -50 },
  { 9894, 50, 50, 49, 5, -50 },
  { 10207, 40, 50, 31, -4, -50 },
  { 10457, 30, 50, 30, 6, -50 },
  { 10645, 35, 50, 27, -3, -50 },
  { 10864, 28, 61, 20, -3, -50 },
  { 11078, 14, 50, 26, 7, -50 },
  { 11166, 28, 61, 20, -5, -50 },
  { 11380, 30, 30, 30, 0, -50 },
  { 11493, 24, 5, 23, -7, 6 },
  { 11508, 13, 12, 21, 10, -54 },
  { 11528, 32, 40, 32, 1, -39 },
  { 11688, 32, 54, 32, -1, -53 },
  { 11904, 27, 40, 26, 1, -39 },
  { 12039, 35, 54, 32, 1, -53 },
  { 12276, 28, 40, 30, 1, -39 },
  { 12416, 36, 71, 19, -8, -54 },
  { 12736, 35, 56, 32, -2, -39 },
  { 12981, 32, 53, 32, -1, -53 },
  { 13193, 20, 53, 16, -1, -53 },
  { 13326, 28, 70, 16, -9, -53 },
  { 13571, 33, 53, 30, 0, -53 },
  { 13790, 21, 53, 16, -1, -53 },
  { 13930, 46, 39, 47, 0, -39 },
  { 14155, 30, 39, 32, 0, -39 },
  { 14302, 29, 40, 31, 1, -39 },
  { 14447, 35, 56, 32, -4, -39 },
  { 14692, 32, 56, 32, 1, -39 },
  { 14916, 26, 39, 23, 0, -39 },
  { 15043, 26, 40, 25, 0, -39 },
  { 15173, 21, 47, 20, 2, -46 },
  { 15297, 30, 39, 32, 2, -38 },
  { 15444, 28, 38, 28, 4, -38 },
  { 15577, 43, 38, 43, 4, -38 },
  { 15782, 34, 38, 28, -3, -38 },
  { 15944, 37, 55, 28, -5, -38 },
  { 16199, 29, 38, 24, -3, -38 },
  { 16337, 28, 61, 24, 1, -50 },
  { 16551, 7, 70, 26, 9, -54 },
  { 16613, 27, 61, 24, -4, -50 },
  { 16819, 29, 12, 32, 3, -31 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic70pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC70PT7B_H_
