#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC45PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF0, 0x1F, 0x00, 0x3F, 0x3F, 0x3E, 0x3F, 0x3E, 0x3E, 0x7E,
  0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78,
  0x78, 0xF8, 0xF8, 0x00, 0x3E, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xE0,
  0x03, 0xE3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00,
  0x78, 0x78, 0x00, 0xF1, 0xE0, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xC0, 0x78, 0x78, 0x00, 0xF1, 0xF0, 0x01, 0xE3,
  0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x3C, 0x03, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x0F, 0x0F, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xE0, 0x03,
  0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x3E, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xEB, 0xC0, 0xFD, 0x8C,
  0x0F, 0x98, 0x00, 0xF9, 0x80, 0x0F, 0xD8, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x6F, 0xC0, 0x04, 0xFC, 0x40,
  0xCF, 0x86, 0x0C, 0xF8, 0x78, 0xDF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x78, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x81, 0xF0, 0x1E, 0x78,
  0x1E, 0x03, 0xE7, 0x83, 0xE0, 0x3C, 0x78, 0x3C, 0x03, 0xC7, 0x87, 0xC0,
  0x78, 0x78, 0x78, 0x07, 0x87, 0x8F, 0x80, 0x78, 0x78, 0xF0, 0x07, 0x8F,
  0x9E, 0x00, 0xF8, 0xF1, 0xE0, 0x0F, 0x0F, 0x3C, 0x38, 0xF1, 0xF7, 0xCF,
  0xEF, 0x1E, 0x79, 0xFF, 0xFB, 0xEF, 0x9F, 0xF7, 0xFC, 0xF3, 0xCF, 0x7F,
  0x9F, 0x3C, 0xF3, 0xF1, 0xE7, 0x8F, 0x08, 0x3E, 0x78, 0xF0, 0x03, 0xCF,
  0x8F, 0x00, 0x78, 0xF0, 0xF0, 0x07, 0x8F, 0x0F, 0x00, 0xF0, 0xF0, 0xF0,
  0x0F, 0x0F, 0x1E, 0x01, 0xE0, 0xF1, 0xE0, 0x3E, 0x0F, 0x1E, 0x03, 0xC0,
  0xF3, 0xC0, 0x7C, 0x0F, 0xFC, 0x07, 0x80, 0xFF, 0x80, 0xF8, 0x0F, 0xF0,
  0x1F, 0x00, 0x7E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3E, 0x7E, 0x00, 0xF8, 0xFC,
  0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x9F, 0x00,
  0x1F, 0x7E, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xFC, 0x7E, 0x1F, 0xF8, 0xFC, 0x7F, 0xF1, 0xF1, 0xFB,
  0xF7, 0xE3, 0xE7, 0xEF, 0x8F, 0xCF, 0xFF, 0x1F, 0x0F, 0xFC, 0x7E, 0x1F,
  0xF8, 0xFC, 0x1F, 0xE1, 0xF8, 0x3F, 0xC3, 0xF0, 0x7F, 0x07, 0xE1, 0xFE,
  0x0F, 0xEF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xF9, 0xF8,
  0x1F, 0xC3, 0xF8, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C,
  0x7C, 0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0x02, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x43, 0xE0, 0x73, 0xE0,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0x07, 0xFF, 0x0F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xF0, 0xFE, 0xF8, 0x7C, 0xFC, 0x38, 0x7C, 0x18, 0x70,
  0x00, 0x60, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0xC7, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0xC3,
  0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0x3F, 0xF7, 0xFF, 0x7F, 0xF7,
  0xFF, 0x7F, 0xEF, 0xFE, 0x1C, 0xFD, 0xFF, 0xFF, 0xFF, 0x9E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xC0,
  0x1F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xFC, 0x7C, 0x3E,
  0x1F, 0x1F, 0x87, 0xC7, 0xE1, 0xF3, 0xF0, 0x7C, 0xFC, 0x1F, 0x3F, 0x07,
  0xCF, 0x83, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0x03, 0xFF,
  0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC3, 0xF3, 0xE0,
  0xFC, 0xF8, 0x3F, 0x3E, 0x1F, 0x8F, 0x87, 0xE3, 0xF3, 0xF0, 0xFF, 0xFC,
  0x3F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0x7E,
  0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x87, 0xFE, 0x3F,
  0xFC, 0xFF, 0xF8, 0xFB, 0xF0, 0xE7, 0xE1, 0x8F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0x06,
  0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x1E, 0x1F, 0xC0, 0x70, 0x3F, 0x00, 0x80, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x06, 0x0F, 0xE0,
  0x20, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x20, 0x07, 0xE1, 0x80, 0x7F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3B, 0xE0, 0x03, 0xFF, 0x00, 0x3D,
  0xF8, 0x01, 0xEF, 0x80, 0x1E, 0x7C, 0x01, 0xE3, 0xE0, 0x0F, 0x3F, 0x00,
  0xF1, 0xF8, 0x0F, 0x0F, 0x80, 0x78, 0x7C, 0x07, 0x87, 0xE0, 0x7C, 0x3F,
  0x03, 0xC1, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE4, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x88, 0x03,
  0xF0, 0xC0, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xEE, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x3C,
  0x03, 0xF7, 0xF0, 0x3E, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xF9,
  0xF8, 0x7E, 0x1F, 0x8F, 0xE1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC,
  0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC7, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0x80,
  0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x06, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x3F,
  0xFE, 0x07, 0xFF, 0xF0, 0x7E, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0xFC, 0x7E, 0x07, 0xEF, 0xC0,
  0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0x03, 0xFB, 0xF0, 0x7F, 0x1F, 0x87, 0xE1, 0xF8, 0xFC, 0x0F,
  0x8F, 0xC0, 0xF8, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1,
  0xF8, 0xFE, 0x7F, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F,
  0xF0, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0x1F, 0x83, 0xE3,
  0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF,
  0xC3, 0xF9, 0xF8, 0x7F, 0x3F, 0x9F, 0xE3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F,
  0xFF, 0xE0, 0xFE, 0xFC, 0x06, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x3F,
  0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0xF8, 0x00, 0x00, 0xF0, 0x0F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3F,
  0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F,
  0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x38,
  0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F,
  0xC0, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x40, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x1E, 0x7F, 0x18,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xE0, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x3E,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x0F, 0x0F, 0x03, 0xF0,
  0xF0, 0xF0, 0xFF, 0xCF, 0x1E, 0x1F, 0xF8, 0xF1, 0xE3, 0xE7, 0x8F, 0x3C,
  0x3C, 0x78, 0xF3, 0xC7, 0x87, 0x8F, 0x38, 0x78, 0xF0, 0xF7, 0x8F, 0x0F,
  0x0E, 0x78, 0xF0, 0xF0, 0xE7, 0x8F, 0x0F, 0x1E, 0x71, 0xE1, 0xE1, 0xEF,
  0x1E, 0x1E, 0x1C, 0xF1, 0xE1, 0xE3, 0xCF, 0x1E, 0x3E, 0x38, 0xF1, 0xE3,
  0xE7, 0x8F, 0x1F, 0xFE, 0xF0, 0xF1, 0xFE, 0xFF, 0x0F, 0x0F, 0xCF, 0xE0,
  0xF0, 0x78, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x20, 0x03, 0xE0, 0x0C, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3E, 0xF8, 0x01,
  0xF7, 0xC0, 0x1F, 0xBE, 0x00, 0xF9, 0xF0, 0x0F, 0xCF, 0x80, 0x7C, 0x7C,
  0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x87, 0xC0, 0xFC,
  0x3E, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x1F, 0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xE0, 0x3E, 0x7E, 0x03,
  0xF3, 0xF0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x1F, 0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC7, 0xF0, 0x3F,
  0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x01, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE1,
  0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xC1, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x18, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFC, 0x7F, 0x81,
  0xF8, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x3F,
  0x03, 0xF8, 0x7E, 0x07, 0xF0, 0xFC, 0x0F, 0xE1, 0xF8, 0x1F, 0xC3, 0xF0,
  0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x07,
  0xF1, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x7F, 0x0F, 0xC0, 0xFC,
  0x1F, 0x83, 0xF8, 0x7E, 0x0F, 0xE0, 0xFC, 0x3F, 0xC1, 0xF9, 0xFF, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFC, 0x06, 0x07, 0xF0, 0x04, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x0F, 0xFC, 0xFE, 0x1F, 0xF1, 0xF8, 0x3F, 0xE3, 0xF0, 0x7F,
  0xC7, 0xE1, 0xFF, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8,
  0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0x83, 0xF8, 0x3F, 0x07,
  0xF0, 0x7E, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC0,
  0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xF8,
  0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8,
  0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F,
  0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x01, 0xFF, 0xF0,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x01,
  0x00, 0x00, 0x01, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x80,
  0x7E, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0,
  0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xF3, 0xF0,
  0x01, 0xFB, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xF7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC,
  0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F,
  0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xC1, 0xFC, 0x07, 0xE0, 0x7E, 0x03,
  0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x0B, 0xFF, 0xE7, 0xFF,
  0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xE0, 0x3F,
  0xC0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x81, 0xF7, 0xC1, 0xFF, 0x80, 0xFB, 0xE1, 0xF7, 0xC0,
  0x7D, 0xF0, 0xFF, 0xE0, 0x3E, 0xF8, 0xFB, 0xF0, 0x3F, 0x7C, 0x7D, 0xF0,
  0x1F, 0xBE, 0x7C, 0xF8, 0x0F, 0x9F, 0x3E, 0xFC, 0x07, 0xCF, 0x9E, 0x7E,
  0x03, 0xE7, 0xDF, 0x3F, 0x03, 0xF3, 0xEF, 0x1F, 0x01, 0xF1, 0xFF, 0x8F,
  0x80, 0xF8, 0xFF, 0xCF, 0xC0, 0x7C, 0x7F, 0xC7, 0xE0, 0x7E, 0x3F, 0xE3,
  0xF0, 0x3F, 0x1F, 0xE1, 0xF0, 0x1F, 0x0F, 0xF0, 0xF8, 0x0F, 0x87, 0xF0,
  0xFC, 0x07, 0xC3, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x3E, 0x03, 0xF0, 0xFC,
  0x1F, 0x01, 0xF0, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x7F, 0x00,
  0xF8, 0x0F, 0xF0, 0x1F, 0x01, 0xFE, 0x03, 0xE0, 0x3F, 0xC0, 0xFC, 0x07,
  0xF8, 0x1F, 0x81, 0xFF, 0x03, 0xE0, 0x3F, 0xE0, 0x7C, 0x07, 0xFE, 0x0F,
  0x80, 0xFF, 0xC3, 0xF0, 0x3F, 0xF8, 0x7C, 0x07, 0xDF, 0x0F, 0x80, 0xFB,
  0xE1, 0xF0, 0x1F, 0x7C, 0x7E, 0x03, 0xE7, 0xCF, 0xC0, 0xFC, 0xF9, 0xF0,
  0x1F, 0x9F, 0x3E, 0x03, 0xE3, 0xE7, 0xC0, 0x7C, 0x7D, 0xF8, 0x0F, 0x8F,
  0xBF, 0x03, 0xF0, 0xFF, 0xC0, 0x7C, 0x1F, 0xF8, 0x0F, 0x83, 0xFF, 0x01,
  0xF0, 0x7F, 0xE0, 0x7E, 0x0F, 0xFC, 0x0F, 0xC1, 0xFF, 0x01, 0xF0, 0x1F,
  0xE0, 0x3E, 0x03, 0xFC, 0x07, 0xC0, 0x7F, 0x81, 0xF8, 0x0F, 0xE0, 0x3F,
  0x01, 0xFC, 0x07, 0xC0, 0x3F, 0x80, 0x00, 0x06, 0x00, 0x01, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFE,
  0x1F, 0xC7, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0xFE, 0x03, 0xF3, 0xF0, 0x0F,
  0xCF, 0xC0, 0x3F, 0x7F, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00,
  0x7E, 0xFC, 0x03, 0xFB, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x01, 0xFC,
  0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x8F, 0xC1, 0xFC, 0x3F, 0x8F, 0xF0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x1F, 0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC1,
  0xFC, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x06, 0x00, 0x01, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFE, 0x1F,
  0xC7, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0xFE, 0x03, 0xF3, 0xF0, 0x0F, 0xCF,
  0xC0, 0x3F, 0x7F, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E,
  0xFC, 0x03, 0xFB, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x01, 0xFC, 0xFC,
  0x07, 0xE3, 0xF0, 0x3F, 0x8F, 0xC1, 0xFC, 0x3F, 0x8F, 0xF0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x81,
  0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3E, 0x0F,
  0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x3F, 0x07, 0xC3, 0xF8, 0x3E,
  0x3F, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x3E, 0x7C, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xC7,
  0xE0, 0x7E, 0x1F, 0x03, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xF8, 0x3F, 0x07,
  0xC1, 0xF8, 0x7E, 0x0F, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0x00, 0x07,
  0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0x87, 0x01, 0xFC, 0x08, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x06, 0x01, 0xF8,
  0x1E, 0x1F, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD,
  0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F,
  0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0,
  0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x7F, 0x03, 0xF0, 0xFC, 0x07,
  0xE1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0xFC,
  0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x87,
  0xE0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E,
  0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0xFE, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x0F, 0xCF,
  0xC0, 0x7E, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x1F,
  0x87, 0xE0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xE0, 0x7E,
  0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xC0,
  0x3F, 0x7E, 0x01, 0xFB, 0xE0, 0x0F, 0xBF, 0x00, 0x7D, 0xF0, 0x03, 0xEF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x03, 0xE0, 0x3F, 0x7C, 0x03, 0xE0, 0x3F, 0x7C, 0x07, 0xE0,
  0x3E, 0x7C, 0x07, 0xE0, 0x7E, 0x7C, 0x0F, 0xE0, 0x7E, 0x7C, 0x0F, 0xE0,
  0x7C, 0x7C, 0x0F, 0xE0, 0xFC, 0x7C, 0x1F, 0xE0, 0xF8, 0x7C, 0x1F, 0xE1,
  0xF8, 0x7C, 0x3F, 0xE1, 0xF8, 0x7C, 0x3F, 0xE1, 0xF0, 0x7C, 0x3F, 0xE3,
  0xF0, 0x7C, 0x7F, 0xE3, 0xE0, 0x7C, 0x7F, 0xE7, 0xE0, 0x7C, 0x7B, 0xE7,
  0xE0, 0x7C, 0xFB, 0xE7, 0xC0, 0x7C, 0xF3, 0xEF, 0xC0, 0xFD, 0xF3, 0xCF,
  0xC0, 0xFD, 0xF3, 0xCF, 0x80, 0xFD, 0xE3, 0xDF, 0x80, 0xFF, 0xE3, 0xDF,
  0x00, 0xFF, 0xE3, 0xDF, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC3, 0xFE,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0x83, 0xFC,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF8,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7C,
  0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xCF, 0xC0, 0x01, 0xFB, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0x7C, 0x00,
  0x0F, 0x9F, 0x00, 0x07, 0xE7, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E,
  0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0,
  0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xFF, 0x81, 0xFB, 0xF0, 0x3F,
  0x7E, 0x0F, 0xC7, 0xC1, 0xF8, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xE3, 0xF0,
  0x7E, 0x7C, 0x0F, 0xDF, 0x81, 0xFB, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFE, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC2, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0xFC, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFC,
  0x1F, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xC7, 0x80, 0xFC, 0x7C, 0x0F,
  0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0xC3, 0xE0, 0x3E, 0x7E, 0x03, 0xE7,
  0xC0, 0x3E, 0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC,
  0xFC, 0x7E, 0x7E, 0x3E, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x3F, 0x9F, 0x07,
  0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF0, 0xFE, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC,
  0xFC, 0x0F, 0xCF, 0xC0, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F,
  0x8F, 0xC3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC7, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFE, 0x07, 0xFB, 0xE0, 0x3F, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x78, 0x07, 0xDF,
  0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xE3, 0xF0, 0xFC,
  0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x03, 0xF1, 0xF0, 0x3F, 0x1F,
  0x03, 0xF3, 0xF0, 0x3E, 0x3F, 0x07, 0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xE7,
  0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7F, 0x1F, 0x87, 0xF3, 0xF8,
  0xFF, 0xFF, 0x0F, 0xBF, 0xE0, 0xFB, 0xFC, 0x0F, 0x1F, 0x80, 0x00, 0xFE,
  0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE0, 0xFE, 0x30, 0xFE,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x83, 0x0F, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F,
  0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0xCF, 0xC0, 0x3F, 0xBF, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xF8, 0xFE, 0x0F, 0xC3, 0xF8,
  0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C,
  0x0F, 0xC3, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8, 0x3F, 0x03, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03,
  0xFB, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xF7, 0x80, 0x7F, 0x9E, 0x00, 0xFC,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F,
  0xCF, 0x87, 0xE3, 0xF3, 0xF0, 0x7C, 0xF8, 0x3E, 0x7E, 0x0F, 0x9F, 0x87,
  0xE7, 0xCF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x10, 0xFC,
  0x0C, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x4F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x7C,
  0x03, 0xF9, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F,
  0x8F, 0xE0, 0xFC, 0x3F, 0x83, 0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x83, 0xF0,
  0xFC, 0x0F, 0xC7, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8,
  0x07, 0xFB, 0xE0, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x02, 0x01, 0xFC, 0x0E, 0x0F, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x78, 0x07, 0xDF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F,
  0xE7, 0xF0, 0xFC, 0x3F, 0x1F, 0x83, 0xE1, 0xF8, 0x3E, 0x1F, 0x87, 0xE1,
  0xF0, 0x7E, 0x1F, 0x07, 0xE3, 0xF0, 0x7C, 0x3F, 0x07, 0xC3, 0xF0, 0xFC,
  0x3E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0x87, 0xE0, 0xF8, 0x7C, 0x1F,
  0x87, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF0, 0xFC, 0x1F, 0x0F, 0x83,
  0xF0, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x02, 0x7F, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x0F,
  0xC1, 0xF0, 0x7E, 0x1F, 0x87, 0xE0, 0xFC, 0x7E, 0x07, 0xC7, 0xE0, 0x3E,
  0x3F, 0x01, 0xF3, 0xF0, 0x1F, 0xBF, 0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x80,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFE, 0x03, 0xFB, 0xF0, 0x1F, 0x9F, 0x80, 0xF8, 0x7C, 0x07,
  0xC3, 0xE0, 0x3E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xF8, 0x1F,
  0x07, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x00,
  0x07, 0x8F, 0x83, 0xE0, 0x3C, 0xFE, 0x3F, 0x83, 0xEF, 0xFB, 0xFE, 0x1F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xF3, 0xFC, 0xFC, 0x3F, 0x1F,
  0xC3, 0xE3, 0xF0, 0xFC, 0x3F, 0x1F, 0x87, 0xE1, 0xF8, 0xF8, 0x3F, 0x0F,
  0xC7, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xE3, 0xF0, 0x7C, 0x1F, 0x1F,
  0x87, 0xE1, 0xF8, 0xF8, 0x3F, 0x0F, 0xC7, 0xC1, 0xF0, 0x7C, 0x7E, 0x0F,
  0x83, 0xE3, 0xF0, 0xFC, 0x1F, 0x1F, 0x87, 0xE1, 0xF8, 0xF8, 0x3E, 0x0F,
  0xC7, 0xC1, 0xF0, 0x7C, 0x7E, 0x0F, 0x83, 0xE3, 0xF0, 0xFC, 0x3F, 0x1F,
  0x07, 0xE1, 0xF8, 0xF8, 0x3E, 0x0F, 0x80, 0x07, 0x87, 0x80, 0x79, 0xFC,
  0x07, 0xBF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFE, 0x7F, 0x0F, 0xC3,
  0xF1, 0xF8, 0x3E, 0x1F, 0x83, 0xE1, 0xF8, 0x3E, 0x1F, 0x07, 0xE1, 0xF0,
  0x7E, 0x3F, 0x07, 0xC3, 0xF0, 0x7C, 0x3E, 0x0F, 0xC3, 0xE0, 0xFC, 0x3E,
  0x0F, 0xC7, 0xE0, 0xF8, 0x7E, 0x0F, 0x87, 0xC1, 0xF8, 0x7C, 0x1F, 0x8F,
  0xC1, 0xF8, 0xFC, 0x1F, 0x0F, 0xC1, 0xF0, 0xF8, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0xC7, 0xE3, 0xF3,
  0xF0, 0xFC, 0xFC, 0x3F, 0x7E, 0x07, 0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F,
  0xBF, 0x07, 0xEF, 0xC3, 0xF3, 0xF1, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0x87,
  0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0xF0,
  0x01, 0xE7, 0xF0, 0x07, 0xDF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x3F, 0x8F, 0xC0, 0x7E, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07,
  0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0xFC,
  0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x83,
  0xF0, 0x3F, 0x0F, 0xE0, 0x7F, 0x1F, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0x3F, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF1, 0xF0, 0x3F, 0x9F, 0x07, 0xFD,
  0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xF8, 0xFE, 0x3F, 0x0F, 0xE3, 0xF0,
  0x7E, 0x3E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xC0, 0xFC, 0xFC,
  0x0F, 0xCF, 0xC0, 0xF8, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x1F, 0x8F,
  0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFE, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x07, 0xFB, 0xE0, 0x3F, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x07,
  0x8F, 0x83, 0xCF, 0x83, 0xEF, 0xC1, 0xF7, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0,
  0x3F, 0xC8, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xE3,
  0xFF, 0xE1, 0xFF, 0xF0, 0xFC, 0x30, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x10, 0x3F, 0x8F,
  0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0xF1, 0xFF, 0x8F,
  0xFE, 0x3F, 0xF9, 0xFF, 0xE1, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xFB, 0x0F, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0x83, 0xF0, 0xF8, 0x3E, 0x1F, 0x83, 0xE1,
  0xF8, 0x3E, 0x1F, 0x07, 0xE1, 0xF0, 0x7E, 0x1F, 0x07, 0xC3, 0xF0, 0x7C,
  0x3F, 0x07, 0xC3, 0xE0, 0xFC, 0x3E, 0x0F, 0xC7, 0xE0, 0xF8, 0x7E, 0x0F,
  0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x87, 0xC1, 0xF0, 0xFC, 0x1F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC7, 0xF0, 0xFE, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x07, 0xFB, 0xE0, 0x3F, 0x3E, 0x00, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE,
  0x07, 0xDF, 0x07, 0xEF, 0x83, 0xF7, 0xC1, 0xF3, 0xE1, 0xF9, 0xF0, 0xF8,
  0xF8, 0xFC, 0x7C, 0x7C, 0x3E, 0x7E, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xDF,
  0x03, 0xEF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x1F, 0x81, 0xF7, 0xC1, 0xF8, 0x3F, 0x7C, 0x3F, 0x83, 0xE7,
  0xC3, 0xF8, 0x7E, 0x7C, 0x3F, 0x87, 0xC7, 0xC7, 0xF8, 0x7C, 0x7C, 0x7F,
  0x8F, 0xC7, 0xC7, 0xF8, 0xF8, 0x7C, 0xF7, 0x9F, 0x87, 0xCF, 0x79, 0xF0,
  0x7D, 0xF7, 0x9F, 0x07, 0xDE, 0xFB, 0xF0, 0x7D, 0xEF, 0xBE, 0x07, 0xFE,
  0xFB, 0xE0, 0x7B, 0xCF, 0xFC, 0x07, 0xBC, 0xFF, 0xC0, 0x7F, 0xCF, 0xF8,
  0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF,
  0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x3E,
  0x1F, 0x80, 0xF8, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0x80, 0x1F, 0x7C,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFB, 0xF0, 0x07, 0xE7, 0xC0,
  0x1F, 0x1F, 0x00, 0xFC, 0x7C, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0xFC,
  0x1F, 0x80, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x7E, 0x03, 0xE0, 0x7E, 0x03,
  0xE0, 0x7C, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0xF8, 0x03, 0xE1, 0xF8, 0x03,
  0xE1, 0xF0, 0x03, 0xE3, 0xF0, 0x03, 0xE3, 0xE0, 0x03, 0xE3, 0xE0, 0x03,
  0xE7, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xEF, 0xC0, 0x03, 0xEF, 0x80, 0x01,
  0xEF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xF0, 0x00, 0x7F,
  0x00, 0x3F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x0F, 0xC0, 0x00, 0x08, 0x00, 0x5F, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xFA, 0x00, 0x78,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 13, 32, 11, 0, -32 },
  { 53, 16, 11, 18, 4, -32 },
  { 75, 23, 32, 22, 0, -32 },
  { 167, 20, 37, 19, 0, -34 },
  { 260, 28, 33, 32, 2, -33 },
  { 376, 23, 33, 23, 0, -33 },
  { 471, 8, 11, 11, 4, -32 },
  { 482, 15, 39, 12, 1, -32 },
  { 556, 16, 40, 12, -4, -33 },
  { 636, 16, 19, 18, 4, -35 },
  { 674, 18, 22, 21, 2, -27 },
  { 724, 10, 12, 11, -2, -6 },
  { 739, 12, 6, 13, 0, -15 },
  { 748, 7, 7, 11, 0, -7 },
  { 755, 23, 32, 17, -2, -32 },
  { 847, 18, 33, 19, 1, -33 },
  { 922, 15, 32, 20, 4, -32 },
  { 982, 22, 33, 19, -2, -33 },
  { 1073, 21, 33, 19, -1, -33 },
  { 1160, 21, 32, 20, -1, -32 },
  { 1244, 20, 32, 19, 0, -32 },
  { 1324, 20, 33, 19, 1, -33 },
  { 1407, 21, 32, 19, 1, -32 },
  { 1491, 20, 33, 19, 0, -33 },
  { 1574, 19, 33, 19, 0, -33 },
  { 1653, 11, 25, 11, 0, -25 },
  { 1688, 13, 31, 11, -2, -25 },
  { 1739, 18, 22, 21, 2, -27 },
  { 1789, 18, 14, 21, 2, -23 },
  { 1821, 18, 22, 21, 2, -27 },
  { 1871, 16, 33, 15, 1, -33 },
  { 1937, 28, 36, 29, 1, -32 },
  { 2063, 21, 32, 21, -3, -32 },
  { 2147, 22, 32, 21, 0, -32 },
  { 2235, 21, 33, 20, 2, -33 },
  { 2322, 23, 32, 23, 0, -32 },
  { 2414, 20, 32, 18, 0, -32 },
  { 2494, 20, 32, 17, 0, -32 },
  { 2574, 23, 33, 24, 2, -33 },
  { 2669, 25, 32, 24, 0, -32 },
  { 2769, 20, 32, 14, -2, -32 },
  { 2849, 20, 42, 11, -7, -32 },
  { 2954, 25, 32, 21, 0, -32 },
  { 3054, 15, 32, 17, 0, -32 },
  { 3114, 33, 32, 31, 0, -32 },
  { 3246, 27, 32, 25, 0, -32 },
  { 3354, 22, 33, 24, 2, -33 },
  { 3445, 22, 32, 21, 0, -32 },
  { 3533, 22, 41, 24, 2, -33 },
  { 3646, 21, 32, 21, 0, -32 },
  { 3730, 22, 33, 19, -1, -33 },
  { 3821, 18, 32, 18, 3, -32 },
  { 3893, 23, 32, 23, 2, -32 },
  { 3985, 21, 32, 21, 4, -32 },
  { 4069, 32, 32, 32, 3, -32 },
  { 4197, 26, 32, 20, -3, -32 },
  { 4301, 19, 32, 19, 4, -32 },
  { 4377, 23, 32, 18, -2, -32 },
  { 4469, 18, 39, 13, -2, -32 },
  { 4557, 10, 32, 17, 4, -32 },
  { 4597, 18, 39, 13, -3, -32 },
  { 4685, 20, 19, 20, 0, -32 },
  { 4733, 15, 3, 15, -4, 4 },
  { 4739, 8, 7, 13, 7, -34 },
  { 4746, 20, 25, 21, 1, -25 },
  { 4809, 20, 34, 21, 0, -34 },
  { 4894, 17, 25, 16, 1, -25 },
  { 4948, 22, 34, 21, 1, -34 },
  { 5042, 18, 25, 19, 1, -25 },
  { 5099, 23, 45, 13, -5, -34 },
  { 5229, 22, 36, 21, -1, -25 },
  { 5328, 20, 34, 21, 0, -34 },
  { 5413, 12, 34, 10, 0, -34 },
  { 5464, 18, 45, 10, -6, -34 },
  { 5566, 21, 34, 19, 0, -34 },
  { 5656, 13, 34, 10, 0, -34 },
  { 5712, 29, 25, 30, 0, -25 },
  { 5803, 20, 25, 21, 0, -25 },
  { 5866, 18, 26, 20, 1, -25 },
  { 5925, 23, 36, 21, -3, -25 },
  { 6029, 20, 36, 21, 1, -25 },
  { 6119, 17, 25, 14, 0, -25 },
  { 6173, 17, 25, 16, 0, -25 },
  { 6227, 14, 30, 13, 1, -30 },
  { 6280, 20, 25, 20, 1, -25 },
  { 6343, 17, 25, 18, 3, -25 },
  { 6397, 28, 25, 28, 2, -25 },
  { 6485, 22, 25, 18, -2, -25 },
  { 6554, 24, 36, 18, -3, -25 },
  { 6662, 19, 25, 15, -2, -25 },
  { 6722, 18, 39, 15, 0, -32 },
  { 6810, 5, 45, 17, 5, -35 },
  { 6839, 18, 39, 15, -3, -32 },
  { 6927, 18, 8, 21, 2, -20 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic45pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC45PT7B_H_
