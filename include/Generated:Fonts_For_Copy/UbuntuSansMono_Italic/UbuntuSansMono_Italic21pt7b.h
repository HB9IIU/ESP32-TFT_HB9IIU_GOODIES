#ifndef _UBUNTUSANSMONO_ITALIC21PT7B_H_
#define _UBUNTUSANSMONO_ITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x21, 0x86, 0x18, 0x41, 0x0C, 0x30, 0x80, 0x00, 0x63, 0x8E,
  0x00, 0xCF, 0x28, 0xA6, 0x92, 0x40, 0x01, 0x18, 0x19, 0x80, 0x8C, 0x0C,
  0x43, 0xFF, 0x1F, 0xF8, 0x23, 0x03, 0x10, 0x19, 0x80, 0x8C, 0x3F, 0xF8,
  0x46, 0x06, 0x20, 0x23, 0x03, 0x30, 0x00, 0x01, 0x80, 0x20, 0x1F, 0x0F,
  0xF1, 0x80, 0x60, 0x04, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x19, 0x07, 0x3F, 0xC0, 0xC0, 0x18, 0x02, 0x00, 0x0E, 0x04, 0x6C, 0x21,
  0x31, 0x84, 0xCC, 0x33, 0x60, 0x4B, 0x01, 0xE8, 0x00, 0x40, 0x02, 0xE0,
  0x1A, 0xC0, 0xD1, 0x06, 0x44, 0x31, 0x30, 0x84, 0x8C, 0x1E, 0x00, 0x07,
  0x0F, 0xC4, 0x66, 0x33, 0x11, 0x98, 0x78, 0x71, 0x6C, 0xE2, 0xF1, 0xD0,
  0x68, 0x76, 0x79, 0xE6, 0x6D, 0xA5, 0x80, 0x03, 0x06, 0x0C, 0x18, 0x30,
  0x20, 0x60, 0x40, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0xC0, 0xC0, 0xC0,
  0x60, 0x30, 0x20, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x03, 0x01, 0x01, 0x01,
  0x03, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x80, 0x0C,
  0x06, 0x03, 0x0D, 0xBF, 0xF8, 0x60, 0x78, 0x66, 0x22, 0x00, 0x06, 0x01,
  0x80, 0x40, 0x10, 0x7F, 0xFF, 0xF0, 0xC0, 0x20, 0x18, 0x06, 0x00, 0x33,
  0xCE, 0x66, 0x60, 0x7F, 0xE0, 0x6F, 0xE0, 0x00, 0x18, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x07, 0x83, 0xF1, 0x8C, 0xC1, 0x20, 0x58, 0x16,
  0xED, 0x3B, 0xCC, 0xF0, 0x2C, 0x1B, 0x06, 0xC3, 0x19, 0x87, 0xC0, 0x00,
  0x81, 0xC1, 0xC3, 0xE1, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x00,
  0x80, 0xC0, 0x63, 0xFC, 0x07, 0x87, 0xF1, 0x0C, 0x01, 0x00, 0x40, 0x30,
  0x18, 0x0E, 0x06, 0x03, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x2F, 0xF0, 0x0F,
  0x87, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x78, 0x3C, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0xA1, 0xCF, 0xE0, 0x00, 0x60, 0x1C, 0x07, 0x01, 0xA0,
  0x6C, 0x19, 0x86, 0x21, 0x84, 0x21, 0x8C, 0x33, 0xFF, 0x00, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x0F, 0xE1, 0xFC, 0x30, 0x04, 0x01, 0x80, 0x30, 0x07,
  0x01, 0x78, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x19, 0x0E, 0x3F, 0x80,
  0x00, 0xC1, 0xF0, 0xC0, 0x60, 0x30, 0x18, 0x05, 0xE3, 0xFC, 0xC1, 0xA0,
  0x68, 0x1A, 0x04, 0x83, 0x31, 0x87, 0xC0, 0x7F, 0xDF, 0xF0, 0x18, 0x0C,
  0x06, 0x01, 0x00, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30,
  0x08, 0x00, 0x07, 0x81, 0xF8, 0x61, 0x98, 0x33, 0x06, 0x61, 0x86, 0x60,
  0xF8, 0x33, 0x8C, 0x33, 0x02, 0x60, 0x4C, 0x19, 0x86, 0x1F, 0x80, 0x07,
  0x83, 0xF8, 0xC1, 0x18, 0x32, 0x06, 0x40, 0xC8, 0x11, 0x86, 0x1F, 0xC0,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x78, 0x3C, 0x00, 0x19, 0xCE, 0x00, 0x00,
  0x00, 0x67, 0xB8, 0x0C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x31, 0xE3, 0x8C,
  0x63, 0x00, 0x00, 0x40, 0x30, 0x78, 0xF0, 0xF0, 0x38, 0x07, 0x80, 0x78,
  0x03, 0x80, 0x40, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x40,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0xF0, 0xF1, 0xE0, 0xC0, 0x20, 0x00,
  0x3E, 0x37, 0x01, 0x01, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x20, 0x00, 0x00,
  0x40, 0xE0, 0xE0, 0x03, 0xC1, 0xFC, 0x61, 0x98, 0x13, 0x02, 0xC7, 0xD9,
  0x9E, 0x63, 0xC8, 0x5B, 0x1B, 0x63, 0x6C, 0x6C, 0xC9, 0x8F, 0x30, 0x03,
  0x00, 0x72, 0x07, 0xC0, 0x00, 0xC0, 0x38, 0x05, 0x01, 0xA0, 0x64, 0x08,
  0xC3, 0x18, 0x43, 0x18, 0x62, 0x0C, 0xFF, 0x90, 0x36, 0x06, 0x80, 0xF0,
  0x18, 0x0F, 0x83, 0xFC, 0x61, 0x8C, 0x11, 0x02, 0x60, 0xCC, 0x71, 0xFC,
  0x20, 0xCC, 0x09, 0x81, 0x30, 0x24, 0x0C, 0x87, 0x3F, 0x80, 0x03, 0xC0,
  0xFF, 0x18, 0x23, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x40, 0x07, 0x10, 0x3F, 0x80, 0x0F, 0x03, 0xF8,
  0x61, 0x88, 0x33, 0x02, 0x60, 0x4C, 0x09, 0x01, 0x60, 0x6C, 0x0D, 0x81,
  0x20, 0x64, 0x19, 0x8E, 0x3F, 0x00, 0x1F, 0xE3, 0xFC, 0x60, 0x08, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0xFC, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01,
  0x80, 0x3F, 0xE0, 0x1F, 0xF1, 0xFE, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0xF8, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x00, 0x03, 0xC1, 0xFC, 0x60, 0x98, 0x06, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0xC0, 0xD8, 0x13, 0x06, 0x60, 0xCC, 0x18, 0xC2, 0x0F, 0xC0, 0x18,
  0x18, 0xC0, 0x86, 0x0C, 0x20, 0x61, 0x03, 0x18, 0x10, 0xC0, 0x87, 0xFC,
  0x20, 0x63, 0x02, 0x18, 0x10, 0x81, 0x84, 0x0C, 0x60, 0x43, 0x06, 0x00,
  0x0F, 0xE3, 0xF8, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C,
  0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x3F, 0x80, 0x0F, 0xE1, 0xFC,
  0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x31, 0x8E, 0x3F, 0x80, 0x08, 0x18, 0x41, 0x86, 0x18, 0x31,
  0x81, 0x18, 0x0B, 0x80, 0xF0, 0x07, 0x00, 0x2C, 0x01, 0x30, 0x18, 0xC0,
  0xC2, 0x06, 0x18, 0x20, 0x43, 0x03, 0x00, 0x0C, 0x04, 0x06, 0x03, 0x01,
  0x80, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x03, 0xFE,
  0x0C, 0x10, 0xC3, 0x0C, 0x71, 0x47, 0x14, 0xF3, 0x4A, 0x35, 0x22, 0x52,
  0x26, 0x66, 0x06, 0x40, 0x64, 0x04, 0xC0, 0x4C, 0x0C, 0x80, 0xC0, 0x08,
  0x18, 0xE0, 0x87, 0x04, 0x28, 0x61, 0x63, 0x1B, 0x10, 0xC8, 0x84, 0x44,
  0x23, 0x63, 0x1B, 0x18, 0x50, 0xC2, 0x84, 0x1C, 0x20, 0xE3, 0x06, 0x00,
  0x07, 0x81, 0xF8, 0x61, 0x98, 0x32, 0x06, 0xC0, 0xD0, 0x1A, 0x03, 0xC0,
  0x58, 0x1B, 0x03, 0x60, 0xCC, 0x18, 0xC6, 0x1F, 0x80, 0x07, 0x80, 0xFE,
  0x18, 0x31, 0x83, 0x18, 0x31, 0x02, 0x10, 0x63, 0x0C, 0x3F, 0x82, 0x00,
  0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x00, 0x07, 0x81, 0xF8, 0x61,
  0x98, 0x32, 0x06, 0xC0, 0xD0, 0x1A, 0x03, 0xC0, 0x58, 0x1B, 0x03, 0x60,
  0xCC, 0x18, 0xC6, 0x1F, 0x80, 0xC0, 0x18, 0x01, 0xE0, 0x08, 0x00, 0x0F,
  0x83, 0xFC, 0x61, 0x8C, 0x11, 0x02, 0x20, 0x4C, 0x19, 0x8E, 0x3F, 0x04,
  0x61, 0x84, 0x30, 0xC4, 0x18, 0x83, 0x30, 0x30, 0x07, 0xC3, 0xFC, 0x60,
  0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x06, 0x00,
  0xC0, 0x19, 0x86, 0x3F, 0x80, 0xFF, 0xFF, 0xF0, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x00,
  0x10, 0x33, 0x02, 0x30, 0x22, 0x06, 0x20, 0x66, 0x04, 0x60, 0x46, 0x0C,
  0x40, 0xCC, 0x08, 0xC0, 0x8C, 0x18, 0xC1, 0x86, 0x30, 0x7E, 0x00, 0xC0,
  0x38, 0x0F, 0x01, 0x60, 0x6C, 0x08, 0x83, 0x10, 0x42, 0x18, 0x42, 0x08,
  0xC1, 0x30, 0x36, 0x07, 0x80, 0xE0, 0x1C, 0x00, 0x30, 0x12, 0x03, 0x20,
  0x36, 0x02, 0x60, 0x66, 0x06, 0x44, 0x44, 0xE4, 0x5E, 0xCD, 0x28, 0xF2,
  0x8A, 0x38, 0xE3, 0x0C, 0x30, 0x83, 0x00, 0x0C, 0x0C, 0x18, 0x30, 0x61,
  0x80, 0x8C, 0x03, 0x60, 0x0D, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1B,
  0x00, 0xCC, 0x06, 0x10, 0x30, 0x60, 0xC1, 0x8E, 0x06, 0x00, 0x80, 0x70,
  0x1B, 0x02, 0x60, 0xCC, 0x30, 0x8C, 0x19, 0x03, 0x60, 0x38, 0x06, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x23, 0xFE, 0x00, 0x07, 0xE0, 0x80, 0x10,
  0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x7E, 0x00,
  0xCC, 0x44, 0x46, 0x66, 0x66, 0x66, 0x66, 0x62, 0x22, 0x33, 0x0F, 0xC0,
  0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20,
  0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC3, 0xE0, 0x06,
  0x03, 0x03, 0xC3, 0x63, 0x13, 0x09, 0x07, 0x81, 0xFF, 0xFF, 0xF0, 0xC6,
  0x31, 0x0F, 0xC7, 0x33, 0x0D, 0x82, 0xC1, 0xB0, 0x6C, 0x1B, 0x04, 0xC1,
  0x31, 0xC7, 0xD0, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0F, 0xE3, 0x9C,
  0x83, 0x60, 0xD8, 0x36, 0x0D, 0x02, 0x41, 0xB0, 0xCC, 0xE3, 0xF0, 0x0F,
  0xCE, 0x16, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0xC0, 0x38, 0x47,
  0xF0, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFC, 0x1C, 0x43,
  0x0C, 0x60, 0xC4, 0x08, 0xC0, 0x8C, 0x18, 0xC1, 0x8C, 0x10, 0x63, 0x07,
  0xD8, 0x0F, 0x8E, 0x76, 0x0D, 0x83, 0xC1, 0xBF, 0xCF, 0x02, 0x00, 0xC0,
  0x38, 0x47, 0xF0, 0x00, 0xF8, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x0F,
  0xF8, 0x7F, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x2C, 0x01, 0xC0, 0x00,
  0x03, 0xF0, 0xE2, 0x18, 0x63, 0x06, 0x30, 0x66, 0x04, 0x60, 0xC6, 0x0C,
  0x60, 0xC3, 0xF8, 0x1C, 0x80, 0x18, 0x03, 0x0C, 0xF0, 0x7C, 0x00, 0x0C,
  0x02, 0x01, 0x80, 0x60, 0x18, 0x07, 0xE3, 0x9C, 0xC3, 0x30, 0x48, 0x36,
  0x0D, 0x83, 0x60, 0x90, 0x64, 0x1B, 0x06, 0x0C, 0x1C, 0x30, 0x00, 0x0F,
  0xBE, 0x0C, 0x18, 0x30, 0x41, 0x83, 0x06, 0x0E, 0x8F, 0x00, 0x60, 0x1C,
  0x03, 0x80, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x06, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x43, 0xB8, 0x3C,
  0x00, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x61, 0xCC, 0x61, 0x18,
  0x6E, 0x0F, 0x01, 0xE0, 0x26, 0x04, 0x61, 0x84, 0x30, 0xC4, 0x0C, 0xF8,
  0x8C, 0x63, 0x11, 0x8C, 0x62, 0x11, 0x8C, 0x63, 0x2F, 0x3F, 0xE6, 0x6C,
  0xC8, 0x91, 0x36, 0x66, 0xCC, 0xD9, 0x12, 0x02, 0x40, 0xD8, 0x1B, 0x02,
  0x00, 0x3F, 0x0C, 0x62, 0x0C, 0x83, 0x60, 0xD8, 0x24, 0x09, 0x06, 0xC1,
  0xB0, 0x48, 0x30, 0x0F, 0x8E, 0x73, 0x0D, 0x83, 0x40, 0xF0, 0x3C, 0x0F,
  0x06, 0xC1, 0x99, 0xC7, 0xE0, 0x1F, 0xC3, 0x18, 0x41, 0x98, 0x33, 0x06,
  0x60, 0xC8, 0x1B, 0x06, 0x61, 0x8C, 0x71, 0xF8, 0x60, 0x0C, 0x01, 0x80,
  0x20, 0x00, 0x0F, 0xC7, 0x33, 0x0D, 0x83, 0x40, 0xB0, 0x6C, 0x1B, 0x06,
  0xC1, 0x38, 0xC7, 0xF0, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x1F, 0xC6, 0x13,
  0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x00, 0x0F,
  0xC6, 0x23, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x04, 0x01, 0x10, 0xCF,
  0xE0, 0x18, 0x10, 0x30, 0xFF, 0xFF, 0x20, 0x60, 0x60, 0x60, 0x40, 0xC0,
  0xC0, 0x42, 0x7C, 0x20, 0xD8, 0x36, 0x0D, 0x82, 0x41, 0x90, 0x6C, 0x1B,
  0x04, 0xC1, 0x31, 0xC7, 0xD8, 0xC0, 0xD0, 0x64, 0x19, 0x04, 0x43, 0x19,
  0x86, 0x61, 0xB0, 0x68, 0x1C, 0x03, 0x00, 0x60, 0x34, 0x02, 0x40, 0x64,
  0x44, 0xCC, 0x4C, 0xEC, 0xD6, 0x8F, 0x78, 0xE3, 0x0E, 0x30, 0xC3, 0x00,
  0x38, 0x31, 0x86, 0x0C, 0xC0, 0xD8, 0x07, 0x00, 0x60, 0x0F, 0x01, 0xB0,
  0x31, 0x86, 0x18, 0xC0, 0xC0, 0x18, 0x18, 0x40, 0x82, 0x0C, 0x18, 0x60,
  0xC6, 0x06, 0x30, 0x31, 0x00, 0x98, 0x06, 0x80, 0x3C, 0x01, 0xC0, 0x04,
  0x00, 0x40, 0x7C, 0x03, 0xC0, 0x00, 0x3F, 0xCF, 0xE0, 0x30, 0x18, 0x0C,
  0x06, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x0F, 0xF0, 0x03, 0xF0, 0x60, 0x04,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x0F, 0x00, 0x30,
  0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x30,
  0x03, 0xE0, 0x04, 0x30, 0xC2, 0x08, 0x61, 0x84, 0x10, 0xC3, 0x08, 0x21,
  0x86, 0x10, 0x43, 0x0C, 0x30, 0x07, 0xC0, 0x08, 0x01, 0x00, 0x60, 0x0C,
  0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x1C, 0x06, 0x00, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x70, 0x7C, 0x00, 0x30, 0x5F, 0x3C,
  0x78,
};

const GFXglyph UbuntuSansMono_Italic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 6, 15, 12, 3, -15 },
  { 13, 6, 6, 12, 5, -16 },
  { 18, 13, 15, 12, 0, -15 },
  { 43, 11, 18, 12, 1, -16 },
  { 68, 14, 15, 12, -1, -15 },
  { 95, 9, 15, 12, 1, -15 },
  { 112, 3, 6, 12, 6, -16 },
  { 115, 8, 20, 12, 3, -16 },
  { 135, 8, 20, 12, 1, -16 },
  { 155, 9, 9, 12, 2, -15 },
  { 166, 10, 10, 12, 1, -11 },
  { 179, 5, 6, 12, 2, -3 },
  { 183, 6, 2, 12, 3, -7 },
  { 185, 4, 3, 12, 3, -3 },
  { 187, 13, 20, 12, -1, -16 },
  { 220, 10, 15, 12, 1, -15 },
  { 239, 9, 15, 12, 1, -15 },
  { 256, 10, 15, 12, 1, -15 },
  { 275, 10, 15, 12, 1, -15 },
  { 294, 11, 15, 12, 0, -15 },
  { 315, 11, 15, 12, 1, -15 },
  { 336, 10, 15, 12, 2, -15 },
  { 355, 10, 15, 12, 3, -15 },
  { 374, 11, 15, 12, 1, -15 },
  { 395, 11, 15, 12, 1, -15 },
  { 416, 5, 11, 12, 3, -11 },
  { 423, 6, 14, 12, 2, -11 },
  { 434, 10, 10, 12, 1, -11 },
  { 447, 10, 6, 12, 1, -9 },
  { 455, 10, 10, 12, 1, -11 },
  { 468, 8, 15, 12, 3, -15 },
  { 483, 11, 18, 12, 1, -15 },
  { 508, 11, 15, 12, -1, -15 },
  { 529, 11, 15, 12, 0, -15 },
  { 550, 12, 15, 12, 1, -15 },
  { 573, 11, 15, 12, 0, -15 },
  { 594, 11, 15, 12, 1, -15 },
  { 615, 12, 15, 12, 1, -15 },
  { 638, 11, 15, 12, 1, -15 },
  { 659, 13, 15, 12, 0, -15 },
  { 684, 11, 15, 12, 1, -15 },
  { 705, 11, 15, 12, 1, -15 },
  { 726, 13, 15, 12, 0, -15 },
  { 751, 9, 15, 12, 0, -15 },
  { 768, 12, 15, 12, 0, -15 },
  { 791, 13, 15, 12, 0, -15 },
  { 816, 11, 15, 12, 1, -15 },
  { 837, 12, 15, 12, 0, -15 },
  { 860, 11, 19, 12, 1, -15 },
  { 887, 11, 15, 12, 0, -15 },
  { 908, 11, 15, 12, 1, -15 },
  { 929, 10, 15, 12, 3, -15 },
  { 948, 12, 15, 12, 1, -15 },
  { 971, 11, 15, 12, 2, -15 },
  { 992, 12, 15, 12, 1, -15 },
  { 1015, 14, 15, 12, -1, -15 },
  { 1042, 11, 15, 12, 3, -15 },
  { 1063, 13, 15, 12, 0, -15 },
  { 1088, 11, 20, 12, 1, -16 },
  { 1116, 4, 20, 12, 4, -16 },
  { 1126, 10, 20, 12, 0, -16 },
  { 1151, 9, 8, 12, 2, -15 },
  { 1160, 10, 2, 12, -1, 2 },
  { 1163, 4, 4, 12, 5, -16 },
  { 1165, 10, 11, 12, 1, -11 },
  { 1179, 10, 16, 12, 1, -16 },
  { 1199, 10, 11, 12, 1, -11 },
  { 1213, 12, 16, 12, 1, -16 },
  { 1237, 10, 11, 12, 1, -11 },
  { 1251, 13, 20, 12, 0, -16 },
  { 1284, 12, 15, 12, 0, -11 },
  { 1307, 10, 16, 12, 0, -16 },
  { 1327, 7, 16, 12, 2, -16 },
  { 1341, 11, 20, 12, 0, -16 },
  { 1369, 11, 16, 12, 1, -16 },
  { 1391, 5, 16, 12, 4, -16 },
  { 1401, 11, 11, 12, 0, -11 },
  { 1417, 10, 11, 12, 1, -11 },
  { 1431, 10, 11, 12, 1, -11 },
  { 1445, 11, 15, 12, 0, -11 },
  { 1466, 10, 15, 12, 1, -11 },
  { 1485, 10, 11, 12, 1, -11 },
  { 1499, 10, 11, 12, 1, -11 },
  { 1513, 8, 14, 12, 3, -14 },
  { 1527, 10, 11, 12, 1, -11 },
  { 1541, 10, 11, 12, 2, -11 },
  { 1555, 12, 11, 12, 1, -11 },
  { 1572, 12, 11, 12, 0, -11 },
  { 1589, 13, 15, 12, -1, -11 },
  { 1614, 10, 11, 12, 1, -11 },
  { 1628, 12, 20, 12, 1, -16 },
  { 1658, 6, 20, 12, 3, -16 },
  { 1673, 11, 20, 12, -1, -16 },
  { 1701, 10, 3, 12, 1, -8 },
};

const GFXfont UbuntuSansMono_Italic21pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic21pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic21pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _UBUNTUSANSMONO_ITALIC21PT7B_H_
