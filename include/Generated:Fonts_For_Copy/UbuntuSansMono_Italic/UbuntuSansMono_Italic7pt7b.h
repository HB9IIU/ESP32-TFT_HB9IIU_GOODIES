#ifndef _UBUNTUSANSMONO_ITALIC7PT7B_H_
#define _UBUNTUSANSMONO_ITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x54, 0x80, 0xE0, 0x37, 0x6F, 0xC0, 0x34, 0x21, 0xE4, 0x5D, 0x25,
  0xA0, 0x6D, 0xDE, 0xC0, 0x72, 0x49, 0x00, 0x24, 0x95, 0x80, 0x5F, 0x00,
  0x23, 0xC4, 0xC0, 0xC0, 0x80, 0x12, 0x44, 0x88, 0x35, 0xB9, 0xE0, 0x2C,
  0x9E, 0x71, 0x24, 0xE0, 0x71, 0x21, 0xE0, 0x35, 0x6E, 0x20, 0x34, 0x21,
  0xE0, 0x73, 0x5C, 0xE5, 0x48, 0x35, 0x69, 0xE0, 0x75, 0x52, 0xC0, 0x42,
  0x42, 0x80, 0x16, 0xC2, 0x7E, 0x87, 0x68, 0x65, 0x08, 0x35, 0xFD, 0xA6,
  0x2D, 0xFA, 0x75, 0x69, 0xE0, 0x34, 0x88, 0x60, 0x65, 0x99, 0xE0, 0x74,
  0x68, 0xE0, 0x74, 0x68, 0x80, 0x34, 0x89, 0x60, 0x55, 0x79, 0xA0, 0x72,
  0x24, 0xE0, 0x31, 0x12, 0xE0, 0x56, 0x4A, 0xA0, 0x49, 0x4E, 0x55, 0xB9,
  0x90, 0x55, 0xBA, 0xA0, 0x35, 0x99, 0xE0, 0x75, 0x78, 0x80, 0x35, 0x99,
  0xA6, 0x75, 0xEA, 0xA0, 0x74, 0x21, 0xE0, 0xE9, 0x48, 0x55, 0x99, 0xE0,
  0xB7, 0x68, 0x55, 0xBE, 0xA0, 0x55, 0x26, 0xA0, 0x9A, 0xC8, 0x80, 0x72,
  0x24, 0xE0, 0x34, 0x44, 0x4C, 0xA9, 0x50, 0x64, 0x95, 0x80, 0x56, 0x80,
  0xE0, 0x80, 0x79, 0xAE, 0x46, 0x59, 0xE0, 0x78, 0x8E, 0x13, 0x59, 0xE0,
  0x69, 0xEE, 0x37, 0x44, 0x4C, 0x35, 0x96, 0xE0, 0x4E, 0xDA, 0x6A, 0xC0,
  0x16, 0x22, 0x2E, 0x45, 0x6C, 0xA0, 0xDA, 0xC0, 0x7B, 0xDA, 0x65, 0x9A,
  0x69, 0x9E, 0x65, 0x9E, 0x80, 0x35, 0x9E, 0x20, 0x74, 0x48, 0x34, 0x2E,
  0x5E, 0x4E, 0x59, 0xAE, 0xB7, 0x40, 0x9B, 0xEA, 0x56, 0x6A, 0x55, 0x66,
  0xC0, 0x72, 0x4E, 0x34, 0xC4, 0x46, 0x56, 0xA0, 0x64, 0x95, 0x80, 0xF0,
};

const GFXglyph UbuntuSansMono_Italic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 5, 4, 1, -5 },
  { 3, 2, 2, 4, 2, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 6, 4, 0, -5 },
  { 10, 4, 5, 4, 0, -5 },
  { 13, 3, 5, 4, 0, -5 },
  { 15, 1, 2, 4, 2, -5 },
  { 16, 3, 6, 4, 1, -5 },
  { 19, 3, 6, 4, 0, -5 },
  { 22, 3, 3, 4, 1, -5 },
  { 24, 4, 4, 4, 0, -4 },
  { 26, 1, 2, 4, 1, -1 },
  { 27, 2, 1, 4, 1, -2 },
  { 28, 1, 1, 4, 1, -1 },
  { 29, 4, 6, 4, 0, -5 },
  { 32, 4, 5, 4, 0, -5 },
  { 35, 3, 5, 4, 0, -5 },
  { 37, 4, 5, 4, 0, -5 },
  { 40, 4, 5, 4, 0, -5 },
  { 43, 4, 5, 4, 0, -5 },
  { 46, 4, 5, 4, 0, -5 },
  { 49, 3, 5, 4, 1, -5 },
  { 51, 3, 5, 4, 1, -5 },
  { 53, 4, 5, 4, 0, -5 },
  { 56, 4, 5, 4, 0, -5 },
  { 59, 2, 4, 4, 1, -4 },
  { 60, 2, 5, 4, 1, -4 },
  { 62, 4, 4, 4, 0, -4 },
  { 64, 4, 2, 4, 0, -3 },
  { 65, 4, 4, 4, 0, -4 },
  { 67, 3, 5, 4, 1, -5 },
  { 69, 4, 6, 4, 0, -5 },
  { 72, 3, 5, 4, 0, -5 },
  { 74, 4, 5, 4, 0, -5 },
  { 77, 4, 5, 4, 0, -5 },
  { 80, 4, 5, 4, 0, -5 },
  { 83, 4, 5, 4, 0, -5 },
  { 86, 4, 5, 4, 0, -5 },
  { 89, 4, 5, 4, 0, -5 },
  { 92, 4, 5, 4, 0, -5 },
  { 95, 4, 5, 4, 0, -5 },
  { 98, 4, 5, 4, 0, -5 },
  { 101, 4, 5, 4, 0, -5 },
  { 104, 3, 5, 4, 0, -5 },
  { 106, 4, 5, 4, 0, -5 },
  { 109, 4, 5, 4, 0, -5 },
  { 112, 4, 5, 4, 0, -5 },
  { 115, 4, 5, 4, 0, -5 },
  { 118, 4, 6, 4, 0, -5 },
  { 121, 4, 5, 4, 0, -5 },
  { 124, 4, 5, 4, 0, -5 },
  { 127, 3, 5, 4, 1, -5 },
  { 129, 4, 5, 4, 0, -5 },
  { 132, 3, 5, 4, 1, -5 },
  { 134, 4, 5, 4, 0, -5 },
  { 137, 4, 5, 4, 0, -5 },
  { 140, 4, 5, 4, 1, -5 },
  { 143, 4, 5, 4, 0, -5 },
  { 146, 4, 6, 4, 0, -5 },
  { 149, 2, 6, 4, 1, -5 },
  { 151, 3, 6, 4, 0, -5 },
  { 154, 3, 3, 4, 1, -5 },
  { 156, 3, 1, 4, 0, 1 },
  { 157, 1, 1, 4, 2, -5 },
  { 158, 4, 4, 4, 0, -4 },
  { 160, 4, 5, 4, 0, -5 },
  { 163, 4, 4, 4, 0, -4 },
  { 165, 4, 5, 4, 0, -5 },
  { 168, 4, 4, 4, 0, -4 },
  { 170, 4, 6, 4, 0, -5 },
  { 173, 4, 5, 4, 0, -4 },
  { 176, 3, 5, 4, 0, -5 },
  { 178, 2, 5, 4, 1, -5 },
  { 180, 4, 6, 4, 0, -5 },
  { 183, 4, 5, 4, 0, -5 },
  { 186, 2, 5, 4, 1, -5 },
  { 188, 4, 4, 4, 0, -4 },
  { 190, 4, 4, 4, 0, -4 },
  { 192, 4, 4, 4, 0, -4 },
  { 194, 4, 5, 4, 0, -4 },
  { 197, 4, 5, 4, 0, -4 },
  { 200, 4, 4, 4, 0, -4 },
  { 202, 4, 4, 4, 0, -4 },
  { 204, 3, 5, 4, 1, -5 },
  { 206, 4, 4, 4, 0, -4 },
  { 208, 3, 4, 4, 1, -4 },
  { 210, 4, 4, 4, 0, -4 },
  { 212, 4, 4, 4, 0, -4 },
  { 214, 4, 5, 4, 0, -4 },
  { 217, 4, 4, 4, 0, -4 },
  { 219, 4, 6, 4, 0, -5 },
  { 222, 2, 6, 4, 1, -5 },
  { 224, 3, 6, 4, 0, -5 },
  { 227, 4, 1, 4, 0, -3 },
};

const GFXfont UbuntuSansMono_Italic7pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic7pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic7pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _UBUNTUSANSMONO_ITALIC7PT7B_H_
