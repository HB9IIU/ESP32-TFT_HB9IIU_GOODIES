#ifndef _UBUNTUSANSMONO_ITALIC64PT7B_H_
#define _UBUNTUSANSMONO_ITALIC64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x00, 0xFF, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x1E, 0x03, 0xC7, 0x80, 0xF3,
  0xE0, 0x3C, 0xF8, 0x1F, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x79, 0xF0,
  0x3E, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xC0, 0x38, 0xF0, 0x0E,
  0x3C, 0x07, 0x8E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x03, 0xE1, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x03, 0xE0, 0x03, 0xF8, 0x00,
  0x30, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x10, 0x00, 0x03, 0xF0, 0x0E, 0x00, 0x07, 0xF0,
  0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0xF8, 0x00, 0xF1, 0xF0, 0x00, 0x7C, 0x00, 0x78, 0x3C, 0x00,
  0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x01, 0xE0, 0x07, 0x80,
  0x03, 0xC0, 0x78, 0x03, 0xE0, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x00, 0x78,
  0x0F, 0x80, 0xF8, 0x00, 0x1E, 0x03, 0xC0, 0x7C, 0x00, 0x07, 0x80, 0xF0,
  0x3E, 0x00, 0x01, 0xE0, 0x3C, 0x1F, 0x00, 0x00, 0x78, 0x0F, 0x07, 0x80,
  0x00, 0x1E, 0x07, 0xC3, 0xE0, 0x00, 0x07, 0x81, 0xE1, 0xF0, 0x00, 0x01,
  0xE0, 0xF8, 0xF8, 0x00, 0x00, 0x78, 0x3C, 0x7C, 0x00, 0x00, 0x1F, 0xBE,
  0x3E, 0x00, 0x00, 0x03, 0xFF, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0x87, 0x80,
  0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x3F, 0x80, 0x00, 0x00,
  0x3E, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0x87,
  0x8F, 0x80, 0x00, 0x03, 0xE3, 0xC1, 0xE0, 0x00, 0x01, 0xF1, 0xF0, 0x78,
  0x00, 0x00, 0xF8, 0x78, 0x1F, 0x00, 0x00, 0x7C, 0x1E, 0x07, 0xC0, 0x00,
  0x3E, 0x0F, 0x01, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x7C, 0x00, 0x07, 0x80,
  0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0x01, 0xF0, 0x0F, 0x01,
  0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x78, 0x00, 0x7C, 0x01, 0xF0, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x07, 0xC0, 0x07, 0x80,
  0x03, 0xC1, 0xE0, 0x03, 0xE0, 0x00, 0xFD, 0xF0, 0x01, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xF8, 0x07, 0xC0,
  0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8,
  0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF3, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x01, 0xC0,
  0x1F, 0xF8, 0x07, 0xC0, 0xFF, 0xE0, 0x1E, 0x07, 0xEF, 0xC0, 0xF8, 0x3F,
  0x1F, 0x83, 0xE1, 0xF8, 0x3E, 0x0F, 0x0F, 0xC0, 0xFC, 0x7C, 0x3E, 0x01,
  0xF1, 0xE1, 0xF0, 0x03, 0xEF, 0x87, 0xC0, 0x0F, 0xFE, 0x3F, 0x00, 0x1F,
  0xF0, 0xFC, 0x00, 0x7F, 0xC3, 0xE0, 0x00, 0xFE, 0x0F, 0x80, 0x03, 0xF8,
  0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3F, 0x83, 0xE0, 0x01, 0xFE, 0x0F,
  0xC0, 0x0F, 0xF8, 0x3F, 0x00, 0x7F, 0xF0, 0x7F, 0x07, 0xF7, 0xC1, 0xFF,
  0xFF, 0x9F, 0x03, 0xFF, 0xFC, 0x7E, 0x07, 0xFF, 0xC0, 0xF8, 0x0F, 0xFC,
  0x03, 0xF0, 0x02, 0x00, 0x00, 0x00, 0x0F, 0x8F, 0xC7, 0xC3, 0xE1, 0xF1,
  0xF8, 0xF8, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0,
  0xF0, 0x78, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x20, 0x0F, 0x00, 0x43, 0x80, 0xF0, 0x1C,
  0x3E, 0x0F, 0x07, 0xE7, 0xFC, 0xF1, 0xFE, 0x7F, 0xF7, 0x7F, 0xEF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x07,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0x80, 0x18, 0x00,
  0x08, 0x01, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x01, 0xF8, 0x01, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x04, 0x0F, 0xC7, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xC1, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xFC, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0xFC,
  0x00, 0x3E, 0x01, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x80,
  0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x3F, 0x1F, 0x00, 0x00,
  0x7C, 0x7E, 0x07, 0x00, 0xF8, 0xF8, 0x3F, 0x81, 0xF1, 0xF0, 0x7F, 0x03,
  0xE7, 0xE1, 0xFF, 0x07, 0xCF, 0x83, 0xFE, 0x1F, 0x9F, 0x07, 0xFC, 0x3E,
  0x3E, 0x0F, 0xF0, 0x7C, 0xFC, 0x1F, 0xE0, 0xF9, 0xF8, 0x1F, 0x83, 0xF3,
  0xE0, 0x08, 0x07, 0xC7, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3F, 0x1F,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x3F, 0x80, 0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xDF, 0x00,
  0x7F, 0xCF, 0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xC0, 0xF8, 0x00, 0x80, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0x01,
  0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x20, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0x81,
  0xFE, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x10, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x20, 0x00, 0x1F, 0xE0, 0x3C, 0x00, 0x7F,
  0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xBE, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0xFC,
  0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x01,
  0xF0, 0x01, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x07,
  0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x07,
  0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x08, 0x00, 0x0F, 0xF0, 0x03, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x8F,
  0xF8, 0x00, 0x1F, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x7C, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xF0,
  0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xFC,
  0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xF8, 0xFE,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xF8, 0x7F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x03, 0xF0, 0x03,
  0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F,
  0x80, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x07,
  0xF8, 0x00, 0x3F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x21, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x38, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0x80, 0x0F,
  0xF0, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x3F, 0x80, 0x00, 0x7C,
  0x0F, 0xC0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x03, 0xFC, 0x3E, 0x00, 0x3F, 0xFF, 0x1F, 0x80, 0x3F,
  0xFF, 0xC7, 0xC0, 0x3F, 0xFF, 0xE3, 0xF0, 0x1F, 0xFF, 0xF8, 0xFC, 0x0F,
  0xE0, 0x3E, 0x3E, 0x07, 0xE0, 0x0F, 0x9F, 0x81, 0xF0, 0x07, 0xC7, 0xE0,
  0xFC, 0x01, 0xF1, 0xF0, 0x3E, 0x00, 0x7C, 0x7C, 0x1F, 0x80, 0x1F, 0x3F,
  0x07, 0xC0, 0x0F, 0x8F, 0xC1, 0xF0, 0x03, 0xE3, 0xE0, 0xFC, 0x00, 0xF8,
  0xF8, 0x3E, 0x00, 0x3E, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0x83, 0xE0, 0x07,
  0xC3, 0xE0, 0xF8, 0x01, 0xF0, 0xF8, 0x3E, 0x00, 0x7C, 0x3E, 0x0F, 0xC0,
  0x3E, 0x0F, 0x81, 0xF0, 0x0F, 0x83, 0xE0, 0x7C, 0x03, 0xE0, 0xF8, 0x1F,
  0x80, 0xF8, 0x3E, 0x03, 0xFC, 0xFC, 0x0F, 0x80, 0x7F, 0xFF, 0x03, 0xE0,
  0x0F, 0xFF, 0xC0, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x04, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00,
  0x7C, 0x78, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x00, 0x3F, 0x3E, 0x00,
  0x00, 0x07, 0xE7, 0xC0, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xEF,
  0xFF, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x07, 0xC0, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x03, 0xF0, 0x0F,
  0x80, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F,
  0xC0, 0x0F, 0x80, 0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0x80,
  0x07, 0xF8, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7E,
  0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x78, 0x00, 0x7F, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0x00, 0x1F, 0x80, 0x00, 0x40, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x08, 0x00, 0x3F,
  0xC0, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x01, 0xF8, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xF0, 0x1F,
  0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x1F, 0x00, 0x07, 0xF0, 0x03, 0xE0, 0x03, 0xFC, 0x00, 0x7C, 0x03, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x01, 0xC0, 0x07,
  0xE0, 0x00, 0x10, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x03, 0xE0, 0x1F, 0x80,
  0x01, 0xF0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x1F,
  0xC0, 0x07, 0xC0, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x08, 0x00, 0x0F, 0xC0, 0x07, 0x00, 0x07, 0xF0, 0x01,
  0xF0, 0x03, 0xF8, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x3E, 0x07, 0xF0, 0x00, 0x01,
  0xF0, 0x3F, 0x80, 0x00, 0x07, 0xC1, 0xFC, 0x00, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0x0F,
  0x9F, 0x80, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x01, 0xF7, 0xF0, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x1D, 0xF0, 0x0F,
  0x78, 0x00, 0xF7, 0xC0, 0x3D, 0xE0, 0x03, 0xDF, 0x01, 0xE7, 0x80, 0x0F,
  0x3C, 0x0F, 0x3C, 0x00, 0x78, 0xF0, 0x3C, 0xF0, 0x01, 0xE3, 0xC1, 0xE3,
  0xC0, 0x07, 0x8F, 0x07, 0x8F, 0x00, 0x3E, 0x3C, 0x3C, 0x3C, 0x00, 0xF0,
  0xF0, 0xF1, 0xF0, 0x03, 0xC3, 0xC7, 0x87, 0xC0, 0x1F, 0x0F, 0x1C, 0x1E,
  0x00, 0x78, 0x3C, 0xF0, 0x78, 0x01, 0xE0, 0xF7, 0x81, 0xE0, 0x0F, 0x81,
  0xDE, 0x0F, 0x80, 0x3E, 0x07, 0xF0, 0x3E, 0x00, 0xF0, 0x1F, 0xC0, 0xF8,
  0x07, 0xC0, 0x7E, 0x03, 0xC0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0x7C, 0x07,
  0xC0, 0x7C, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x7F, 0x80, 0x00, 0xF8, 0x01,
  0xFE, 0x00, 0x03, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0x00, 0x3F, 0xF0, 0x00,
  0x7C, 0x00, 0xFF, 0xC0, 0x01, 0xF0, 0x03, 0xCF, 0x00, 0x07, 0x80, 0x0F,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0x01, 0xF1, 0xE0, 0x03,
  0xE0, 0x07, 0x87, 0xC0, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x3C, 0x01, 0xF0, 0x03, 0xE0, 0xF0, 0x07, 0xC0, 0x0F, 0x03, 0xE0, 0x1E,
  0x00, 0x3C, 0x0F, 0x80, 0x78, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x07, 0xC0,
  0x78, 0x0F, 0x80, 0x1E, 0x01, 0xF0, 0x3C, 0x00, 0x78, 0x07, 0xC0, 0xF0,
  0x03, 0xE0, 0x0F, 0x07, 0xC0, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x3E, 0x00,
  0xF0, 0x78, 0x00, 0xF0, 0x03, 0xE1, 0xE0, 0x07, 0xC0, 0x07, 0x8F, 0x80,
  0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0xF8, 0x01, 0xE0, 0x01,
  0xE3, 0xC0, 0x07, 0x80, 0x07, 0xDF, 0x00, 0x3E, 0x00, 0x0F, 0x7C, 0x00,
  0xF8, 0x00, 0x3D, 0xF0, 0x03, 0xC0, 0x00, 0xF7, 0x80, 0x0F, 0x00, 0x03,
  0xDE, 0x00, 0x7C, 0x00, 0x0F, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x07,
  0x80, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x07,
  0xF0, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x0F,
  0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x03, 0xC7, 0xE0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0xF8,
  0x3F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7E,
  0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xF3, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xF8,
  0x00, 0x7C, 0x00, 0x7F, 0x80, 0x0F, 0x80, 0x03, 0xF0, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xF0, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00,
  0xF8, 0x7E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0x03, 0xC7, 0xE0, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0x7E,
  0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xF3, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF7, 0xFF,
  0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x07, 0xC0, 0x01, 0xF8, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1E, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7F,
  0x00, 0x7C, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3E, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x1F,
  0x80, 0x0F, 0xE0, 0x00, 0x40, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0xC0, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x07, 0xF0, 0x00, 0x1F, 0xE7, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x3F,
  0x3E, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x1F, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0xF0, 0x0F,
  0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x7C, 0x00,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x3C, 0x07, 0xE0, 0x3E, 0x00,
  0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0xFE, 0x03, 0xC0, 0x1F, 0x03, 0xF8,
  0x1F, 0x00, 0x78, 0x1F, 0xE0, 0x7C, 0x01, 0xE0, 0x7F, 0x81, 0xE0, 0x07,
  0x83, 0xCE, 0x07, 0x80, 0x1E, 0x1F, 0x38, 0x3E, 0x00, 0xF8, 0x78, 0xE0,
  0xF0, 0x03, 0xC3, 0xE3, 0x83, 0xC0, 0x0F, 0x0F, 0x0F, 0x0F, 0x00, 0x3C,
  0x78, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0xF1, 0xE0, 0x03, 0xCF, 0x03, 0xC7,
  0x80, 0x1E, 0x3C, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x3C, 0xF0, 0x01, 0xEF,
  0x80, 0xF3, 0xC0, 0x07, 0xBC, 0x03, 0xCE, 0x00, 0x1F, 0xE0, 0x0F, 0x78,
  0x00, 0x77, 0x80, 0x3D, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x3E,
  0x00, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x01,
  0xF0, 0x03, 0xE0, 0x00, 0x3C, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x1F, 0x9E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0xFC, 0x0F, 0x00, 0x1F, 0x80, 0xF8, 0x03, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0x78, 0x07, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0x3C, 0x1F,
  0x80, 0x03, 0xC1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x1E, 0xFC, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0x30, 0x00, 0x00, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xE0, 0x10, 0x07, 0x01, 0xE0, 0x7E, 0x07, 0xE0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x18, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xC0, 0x3F, 0xE0, 0x0F, 0x80, 0xFF,
  0x00, 0x1F, 0x03, 0xF8, 0x00, 0x3C, 0x0F, 0xE0, 0x00, 0xF8, 0x1F, 0x80,
  0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x07, 0x83, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0xF0, 0xFC, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xFC, 0x0F,
  0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF1, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFB, 0xC0, 0x1F, 0xFF, 0xC7, 0xC0, 0x0F, 0xFE, 0x0F, 0x80, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x7F, 0x00, 0x00,
  0xFB, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0x87, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7E, 0x0F,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x01, 0xF8, 0x1E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x3E,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xE0, 0x3C, 0x00, 0x3F, 0xC0, 0x7C,
  0x00, 0x7F, 0x80, 0x7C, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x03, 0xC0, 0x3F,
  0xC0, 0x00, 0x80, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x04, 0x07, 0xF8, 0x00, 0x78, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x7E, 0x00, 0x0F, 0xF8, 0x03, 0xE0, 0x01, 0xFE,
  0x00, 0x3C, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x07, 0xF0, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x78, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x1F, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xE3,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE3, 0xC0, 0x00,
  0x3F, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFE, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0xFE, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7C,
  0x7E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xF8, 0x7C,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x04, 0x07, 0xF8, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x10, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x30, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xCF, 0xF0, 0x00, 0xFF, 0x80, 0x3E, 0x00, 0x1F,
  0xE0, 0x03, 0xE0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00,
  0x7C, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0xF8, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xCF, 0x80, 0x00, 0x0F, 0xE0, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x02, 0x00, 0x00, 0xFC, 0x00, 0x38, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x3E, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF0,
  0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x3F,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0xF8, 0x7E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x10, 0x1F,
  0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x08, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x07,
  0xE0, 0x00, 0x7F, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x07, 0xF0, 0x0F, 0x80, 0x03, 0xF0, 0x07, 0xC0, 0x01,
  0xF8, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x1F, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x7F, 0x00, 0x03, 0xE0, 0x3F, 0x80, 0x00, 0xF8,
  0x1F, 0xC0, 0x00, 0x3E, 0x1F, 0xC0, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x07,
  0xCF, 0xF0, 0x00, 0x01, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xF9, 0xFC, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x03, 0xE0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x1F,
  0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x8F, 0xF3, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0x80,
  0x3E, 0x00, 0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x1F, 0xFF, 0x3F, 0xF0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xDF, 0xFD, 0xFC,
  0x03, 0xC0, 0xFE, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0,
  0x3F, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x1F, 0x01,
  0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x0F,
  0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C,
  0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0x7C, 0x07, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x3F, 0x00, 0xF8,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0x3F, 0x00, 0xFE, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x3E, 0x0F, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xF8, 0x7E, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7C,
  0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF8, 0x07,
  0xF0, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x7C, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0x00, 0x07, 0xF0, 0x07, 0xC0, 0x01,
  0xFC, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xF8, 0x7E, 0x00, 0xFF, 0x00, 0x3E, 0x01, 0xFC, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x00,
  0x7C, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F,
  0x80, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x80, 0x3F, 0xE3, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xDF,
  0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF2, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0x80, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0xFF, 0x00, 0xFE, 0x00, 0x10, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x06, 0x00, 0x03, 0xF0, 0x3C, 0x00,
  0x3F, 0x03, 0xFF, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0xF8, 0x3E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C,
  0x0F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFE, 0x01, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0xF0, 0x0F, 0xFF, 0xE3, 0xE0, 0x0F,
  0xFE, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x1F, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0x7C,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x03,
  0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0x7E, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x03,
  0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x3E,
  0x1E, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0xE0, 0x0F, 0x83, 0xE0, 0x1E, 0x00, 0xF0,
  0x3C, 0x03, 0xE0, 0x1F, 0x03, 0xC0, 0x3F, 0x01, 0xF0, 0x7C, 0x07, 0xF0,
  0x3E, 0x07, 0xC0, 0x7F, 0x03, 0xE0, 0x7C, 0x0F, 0xF0, 0x3C, 0x07, 0xC0,
  0xFF, 0x07, 0xC0, 0x7C, 0x1E, 0xF0, 0x7C, 0x07, 0xC3, 0xEF, 0x0F, 0x80,
  0x7C, 0x3C, 0xF0, 0xF8, 0x07, 0xC7, 0x8F, 0x0F, 0x00, 0x7C, 0x78, 0xF1,
  0xF0, 0x07, 0xCF, 0x0F, 0x9E, 0x00, 0x79, 0xF0, 0x7B, 0xE0, 0x07, 0x9E,
  0x07, 0xBE, 0x00, 0x7B, 0xC0, 0x7F, 0xC0, 0x07, 0xBC, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0xF8, 0x00, 0x00, 0x0F, 0xE7,
  0xC0, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x10, 0x07,
  0xF0, 0x00, 0x00, 0x71, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x38, 0x3F, 0xFC, 0x00, 0x78, 0xFF,
  0xFC, 0x01, 0xE3, 0xFF, 0xFE, 0x07, 0xC7, 0xC0, 0xFE, 0x1F, 0x1F, 0x00,
  0xFF, 0xFE, 0x3C, 0x00, 0xFF, 0xF8, 0xF0, 0x00, 0x7F, 0xC0, 0x20, 0x00,
  0x7F, 0x00,
};

const GFXglyph UbuntuSansMono_Italic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 16, 45, 36, 10, -44 },
  { 91, 18, 17, 36, 14, -49 },
  { 130, 38, 44, 36, 0, -44 },
  { 339, 33, 57, 36, 3, -50 },
  { 575, 42, 46, 36, -2, -45 },
  { 817, 30, 46, 36, 2, -45 },
  { 990, 9, 19, 36, 19, -49 },
  { 1012, 27, 62, 36, 8, -50 },
  { 1222, 26, 62, 36, 2, -50 },
  { 1424, 28, 26, 36, 7, -44 },
  { 1515, 29, 32, 36, 4, -35 },
  { 1631, 15, 19, 36, 5, -9 },
  { 1667, 15, 4, 36, 11, -20 },
  { 1675, 10, 11, 36, 10, -10 },
  { 1689, 40, 62, 36, -4, -50 },
  { 1999, 31, 46, 36, 4, -45 },
  { 2178, 26, 44, 36, 4, -44 },
  { 2321, 32, 45, 36, 3, -45 },
  { 2501, 32, 46, 36, 2, -45 },
  { 2685, 32, 44, 36, 1, -44 },
  { 2861, 35, 45, 36, 2, -44 },
  { 3058, 32, 46, 36, 5, -45 },
  { 3242, 32, 44, 36, 8, -44 },
  { 3418, 33, 46, 36, 3, -45 },
  { 3608, 33, 45, 36, 3, -45 },
  { 3794, 16, 35, 36, 10, -34 },
  { 3864, 21, 44, 36, 5, -34 },
  { 3980, 31, 28, 36, 3, -32 },
  { 4089, 33, 18, 36, 2, -28 },
  { 4164, 31, 28, 36, 2, -32 },
  { 4273, 25, 46, 36, 9, -45 },
  { 4417, 34, 54, 36, 3, -45 },
  { 4647, 35, 44, 36, -4, -44 },
  { 4840, 34, 45, 36, 1, -45 },
  { 5032, 35, 46, 36, 4, -45 },
  { 5234, 35, 45, 36, 0, -45 },
  { 5431, 35, 44, 36, 3, -44 },
  { 5624, 35, 44, 36, 3, -44 },
  { 5817, 34, 46, 36, 3, -45 },
  { 6013, 38, 44, 36, 0, -44 },
  { 6222, 32, 44, 36, 3, -44 },
  { 6398, 34, 45, 36, 3, -44 },
  { 6590, 38, 44, 36, 1, -44 },
  { 6799, 26, 44, 36, 1, -44 },
  { 6942, 38, 44, 36, -1, -44 },
  { 7151, 38, 44, 36, 1, -44 },
  { 7360, 33, 46, 36, 3, -45 },
  { 7550, 35, 45, 36, 1, -45 },
  { 7747, 33, 57, 36, 3, -45 },
  { 7983, 34, 45, 36, 1, -45 },
  { 8175, 34, 46, 36, 2, -45 },
  { 8371, 30, 44, 36, 9, -44 },
  { 8536, 36, 45, 36, 3, -44 },
  { 8739, 34, 44, 36, 7, -44 },
  { 8926, 38, 44, 36, 2, -44 },
  { 9135, 43, 44, 36, -2, -44 },
  { 9372, 34, 44, 36, 8, -44 },
  { 9559, 38, 44, 36, 0, -44 },
  { 9768, 31, 62, 36, 5, -50 },
  { 10009, 10, 62, 36, 13, -50 },
  { 10087, 32, 62, 36, -1, -50 },
  { 10335, 28, 23, 36, 6, -44 },
  { 10416, 33, 4, 36, -4, 8 },
  { 10433, 11, 13, 36, 17, -50 },
  { 10451, 31, 35, 36, 3, -34 },
  { 10587, 32, 51, 36, 2, -50 },
  { 10791, 31, 35, 36, 2, -34 },
  { 10927, 36, 51, 36, 3, -50 },
  { 11157, 31, 35, 36, 2, -34 },
  { 11293, 41, 62, 36, -1, -50 },
  { 11611, 36, 46, 36, -1, -34 },
  { 11818, 30, 50, 36, 1, -50 },
  { 12006, 20, 49, 36, 7, -49 },
  { 12129, 35, 61, 36, -1, -49 },
  { 12396, 34, 50, 36, 2, -50 },
  { 12609, 18, 50, 36, 11, -49 },
  { 12722, 35, 34, 36, 0, -34 },
  { 12871, 31, 34, 36, 2, -34 },
  { 13003, 31, 35, 36, 3, -34 },
  { 13139, 35, 46, 36, -1, -34 },
  { 13341, 32, 46, 36, 3, -34 },
  { 13525, 31, 34, 36, 4, -34 },
  { 13657, 29, 35, 36, 4, -34 },
  { 13784, 26, 45, 36, 8, -44 },
  { 13931, 30, 34, 36, 4, -33 },
  { 14059, 28, 33, 36, 7, -33 },
  { 14175, 36, 33, 36, 3, -33 },
  { 14324, 37, 33, 36, -1, -33 },
  { 14477, 38, 45, 36, -3, -33 },
  { 14691, 31, 33, 36, 2, -33 },
  { 14819, 34, 62, 36, 4, -50 },
  { 15083, 19, 62, 36, 9, -50 },
  { 15231, 35, 62, 36, -3, -50 },
  { 15503, 31, 10, 36, 3, -24 },
};

const GFXfont UbuntuSansMono_Italic64pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic64pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic64pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _UBUNTUSANSMONO_ITALIC64PT7B_H_
