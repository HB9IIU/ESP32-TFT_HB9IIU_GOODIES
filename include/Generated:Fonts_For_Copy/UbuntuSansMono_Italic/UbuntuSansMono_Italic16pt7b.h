#ifndef _UBUNTUSANSMONO_ITALIC16PT7B_H_
#define _UBUNTUSANSMONO_ITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Italic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Italic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x84, 0x62, 0x10, 0x80, 0x03, 0x38, 0x4A, 0x55, 0x20, 0x04,
  0xC2, 0x20, 0x91, 0xFE, 0x12, 0x0C, 0x82, 0x63, 0xFC, 0x44, 0x12, 0x0D,
  0x80, 0x04, 0x0E, 0x3F, 0x20, 0x20, 0x30, 0x1C, 0x04, 0x06, 0x06, 0xDC,
  0x70, 0x20, 0x20, 0x1C, 0x64, 0x88, 0x92, 0x12, 0x83, 0xA0, 0x08, 0x02,
  0xE0, 0xD4, 0x14, 0x84, 0x93, 0x0C, 0x00, 0x1E, 0x13, 0x32, 0x16, 0x1C,
  0x39, 0x6A, 0x46, 0xC6, 0x4E, 0x7A, 0x7A, 0x02, 0x0C, 0x20, 0x82, 0x0C,
  0x10, 0x60, 0x81, 0x02, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x08, 0x18, 0x10,
  0x30, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x41, 0x86, 0x18, 0x60, 0x10,
  0x23, 0x79, 0x82, 0x89, 0x80, 0x08, 0x10, 0x20, 0x8F, 0xE2, 0x04, 0x10,
  0x33, 0x3E, 0x80, 0xF0, 0xF0, 0x00, 0x40, 0x30, 0x08, 0x04, 0x01, 0x00,
  0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x00, 0x40, 0x20, 0x18, 0x04, 0x03,
  0x00, 0x1E, 0x23, 0x63, 0x43, 0xDB, 0xDA, 0x82, 0x86, 0x84, 0x8C, 0x78,
  0x04, 0x73, 0x43, 0x08, 0x20, 0x86, 0x10, 0x4F, 0xC0, 0x3E, 0x23, 0x03,
  0x02, 0x06, 0x0C, 0x18, 0x20, 0x40, 0xC0, 0xFC, 0x3E, 0x02, 0x03, 0x02,
  0x0C, 0x1C, 0x06, 0x06, 0x06, 0x8C, 0xF8, 0x03, 0x07, 0x0F, 0x1A, 0x32,
  0x22, 0x46, 0xFF, 0x04, 0x04, 0x0C, 0x0F, 0x84, 0x06, 0x02, 0x01, 0x81,
  0x30, 0x0C, 0x06, 0x03, 0x03, 0x3F, 0x00, 0x07, 0x18, 0x30, 0x60, 0x5C,
  0x66, 0xC2, 0x82, 0x82, 0xC4, 0x78, 0x7F, 0x02, 0x04, 0x08, 0x18, 0x10,
  0x20, 0x60, 0x40, 0xC0, 0x80, 0x1E, 0x21, 0x61, 0x63, 0x26, 0x3C, 0x46,
  0x82, 0x82, 0x84, 0xF8, 0x3E, 0x23, 0x61, 0x41, 0x43, 0x7F, 0x1A, 0x06,
  0x0C, 0x18, 0xE0, 0x6C, 0x00, 0x36, 0x18, 0xC0, 0x00, 0x00, 0xC6, 0x37,
  0x20, 0x03, 0x0E, 0x70, 0x80, 0x60, 0x18, 0x04, 0xFF, 0x00, 0x00, 0xFE,
  0xFE, 0x20, 0x18, 0x06, 0x03, 0x0E, 0x70, 0xC0, 0x3C, 0x0C, 0x10, 0x21,
  0x86, 0x08, 0x20, 0x01, 0x83, 0x00, 0x1F, 0x31, 0x61, 0x47, 0xD9, 0x93,
  0xB3, 0xB2, 0xB2, 0x9E, 0x80, 0xC0, 0x78, 0x03, 0x02, 0x81, 0x41, 0x20,
  0x90, 0x88, 0xC4, 0x7F, 0x61, 0xA0, 0xF0, 0x60, 0x1F, 0x18, 0xC8, 0x64,
  0x22, 0x33, 0xF1, 0x0C, 0x82, 0x43, 0x63, 0x3F, 0x00, 0x1F, 0x98, 0x18,
  0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x61, 0x1F, 0x00, 0x3E, 0x11,
  0x88, 0x64, 0x36, 0x1A, 0x0D, 0x04, 0x82, 0x42, 0x62, 0x3E, 0x00, 0x3F,
  0x20, 0x20, 0x20, 0x60, 0x7E, 0x40, 0x40, 0xC0, 0x80, 0xFC, 0x3F, 0x90,
  0x08, 0x04, 0x04, 0x03, 0xF1, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x00, 0x1F,
  0x20, 0x40, 0x40, 0x80, 0x80, 0x82, 0x86, 0x86, 0xC4, 0x7C, 0x10, 0xCC,
  0x22, 0x08, 0x82, 0x21, 0x9F, 0xC4, 0x11, 0x04, 0x43, 0x30, 0x88, 0x20,
  0x3F, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x30, 0x20, 0xF8, 0x1F,
  0x01, 0x03, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x8C, 0xF8, 0x10, 0xCC,
  0x42, 0x20, 0xB0, 0x38, 0x0C, 0x06, 0x81, 0x30, 0x44, 0x10, 0x8C, 0x30,
  0x10, 0x20, 0xC1, 0x02, 0x04, 0x18, 0x20, 0x40, 0x83, 0xF8, 0x18, 0x8C,
  0xCA, 0x65, 0x52, 0xCA, 0x69, 0x24, 0x82, 0xC1, 0x41, 0xA0, 0xC0, 0x10,
  0xCE, 0x22, 0x88, 0xA2, 0x29, 0x99, 0x44, 0x51, 0x14, 0x47, 0x31, 0x88,
  0x20, 0x1E, 0x23, 0x41, 0x41, 0xC1, 0x81, 0x82, 0x82, 0x86, 0xC4, 0x78,
  0x1F, 0x08, 0xCC, 0x24, 0x12, 0x11, 0x19, 0xF0, 0x80, 0x40, 0x20, 0x30,
  0x00, 0x1E, 0x23, 0x41, 0x41, 0xC1, 0x81, 0x82, 0x82, 0x86, 0xC4, 0x78,
  0x20, 0x30, 0x1C, 0x1F, 0x18, 0xC8, 0x24, 0x32, 0x11, 0x71, 0xF0, 0x88,
  0x46, 0x21, 0x30, 0x80, 0x0F, 0x88, 0x0C, 0x02, 0x01, 0x80, 0x70, 0x08,
  0x06, 0x03, 0x21, 0x3F, 0x00, 0xFF, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20,
  0x20, 0x60, 0x40, 0x40, 0x21, 0xB0, 0x90, 0x48, 0x24, 0x36, 0x12, 0x09,
  0x04, 0x86, 0x42, 0x1E, 0x00, 0x81, 0x82, 0x82, 0x84, 0x84, 0x88, 0x88,
  0x90, 0xB0, 0xE0, 0xC0, 0x30, 0x48, 0x32, 0x08, 0x82, 0x6C, 0x93, 0x45,
  0x51, 0x54, 0x66, 0x19, 0x8C, 0x60, 0x10, 0xC6, 0x20, 0x90, 0x28, 0x0E,
  0x03, 0x01, 0xC0, 0xC8, 0x22, 0x10, 0x88, 0x30, 0x81, 0xC1, 0x11, 0x88,
  0x84, 0x83, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x10, 0x00, 0x1F, 0xC0, 0x60,
  0x30, 0x08, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x10, 0x0F, 0xE0, 0x0F,
  0x08, 0x18, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40,
  0x40, 0xC8, 0xF0, 0xDB, 0x24, 0x92, 0x49, 0x26, 0xDB, 0x0F, 0x12, 0x02,
  0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10,
  0xF0, 0x0C, 0x38, 0x59, 0x14, 0x38, 0x40, 0xFF, 0xC8, 0x80, 0x3E, 0xC7,
  0x0C, 0x38, 0x50, 0xA3, 0x7A, 0x30, 0x40, 0x81, 0x47, 0xE8, 0x50, 0xA1,
  0xC3, 0x0E, 0x37, 0x80, 0x04, 0x7D, 0x06, 0x08, 0x10, 0x20, 0x40, 0x7C,
  0x01, 0x80, 0x80, 0x40, 0x63, 0xF3, 0x11, 0x09, 0x04, 0x86, 0x42, 0x21,
  0x0F, 0x80, 0x3E, 0x87, 0x0C, 0x6F, 0x10, 0x21, 0x3E, 0x03, 0xC1, 0x00,
  0x40, 0x30, 0x3F, 0x82, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x08, 0x0E, 0x00, 0x1F, 0x98, 0x88, 0x48, 0x24, 0x32, 0x11, 0x98,
  0x74, 0x06, 0x46, 0x3E, 0x00, 0x10, 0x10, 0x30, 0x20, 0x3E, 0x23, 0x61,
  0x43, 0x42, 0x42, 0xC2, 0x86, 0x39, 0x80, 0x0F, 0x10, 0x84, 0x62, 0x18,
  0x70, 0x03, 0x03, 0x00, 0x00, 0x1F, 0x02, 0x02, 0x02, 0x06, 0x06, 0x04,
  0x04, 0x04, 0x88, 0xF0, 0x30, 0x20, 0x20, 0x21, 0x66, 0x4C, 0x58, 0x60,
  0xD0, 0x88, 0x8C, 0x84, 0xF2, 0x26, 0x44, 0x44, 0xC8, 0x8F, 0x11, 0x1F,
  0xCB, 0x69, 0x24, 0x92, 0x49, 0x0D, 0x04, 0x82, 0x00, 0x7E, 0x85, 0x0A,
  0x1C, 0x70, 0xE1, 0x42, 0x3E, 0xC7, 0x0C, 0x18, 0x30, 0xE3, 0x3C, 0x3F,
  0x21, 0x21, 0x21, 0x61, 0x43, 0x46, 0x7C, 0xC0, 0x80, 0x80, 0x3F, 0x62,
  0xC2, 0x82, 0x86, 0x84, 0x84, 0x7C, 0x0C, 0x08, 0x08, 0x3F, 0x20, 0x60,
  0x40, 0x40, 0x40, 0xC0, 0x80, 0x3E, 0x41, 0x81, 0xC0, 0xC0, 0xA1, 0x7C,
  0x10, 0xC2, 0x3F, 0x21, 0x84, 0x10, 0x41, 0x07, 0x80, 0x43, 0x42, 0xC2,
  0x86, 0x84, 0x84, 0x8C, 0xF4, 0x87, 0x0A, 0x34, 0x4D, 0x9A, 0x18, 0x20,
  0xC1, 0xC0, 0xA6, 0xD3, 0x4A, 0xA5, 0x63, 0x31, 0x18, 0x31, 0x89, 0x07,
  0x81, 0x81, 0xC1, 0xA1, 0x99, 0x84, 0x10, 0xC4, 0x21, 0x08, 0x66, 0x09,
  0x02, 0xC0, 0xA0, 0x30, 0x0C, 0x06, 0x0F, 0x00, 0x3F, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0xFE, 0x03, 0x86, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x40, 0xE0, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0xF0, 0x08, 0x46,
  0x21, 0x08, 0xC4, 0x21, 0x08, 0x84, 0x21, 0x10, 0x0C, 0x01, 0x80, 0x40,
  0x20, 0x30, 0x10, 0x08, 0x04, 0x03, 0x83, 0x01, 0x00, 0x80, 0xC0, 0x40,
  0x21, 0xE0, 0x73, 0x9E, 0x04,
};

const GFXglyph UbuntuSansMono_Italic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 11, 9, 2, -11 },
  { 8, 5, 4, 9, 3, -12 },
  { 11, 10, 11, 9, 0, -11 },
  { 25, 8, 14, 9, 1, -12 },
  { 39, 11, 11, 9, -1, -11 },
  { 55, 8, 11, 9, 0, -11 },
  { 66, 2, 4, 9, 5, -12 },
  { 67, 7, 16, 9, 2, -13 },
  { 81, 7, 16, 9, 0, -13 },
  { 95, 7, 6, 9, 2, -11 },
  { 101, 7, 8, 9, 1, -9 },
  { 108, 4, 5, 9, 1, -2 },
  { 111, 4, 1, 9, 3, -5 },
  { 112, 2, 2, 9, 3, -2 },
  { 113, 10, 16, 9, -1, -13 },
  { 133, 8, 11, 9, 1, -11 },
  { 144, 6, 11, 9, 1, -11 },
  { 153, 8, 11, 9, 1, -11 },
  { 164, 8, 11, 9, 1, -11 },
  { 175, 8, 11, 9, 0, -11 },
  { 186, 9, 11, 9, 0, -11 },
  { 199, 8, 11, 9, 1, -11 },
  { 210, 8, 11, 9, 2, -11 },
  { 221, 8, 11, 9, 1, -11 },
  { 232, 8, 11, 9, 1, -11 },
  { 243, 3, 8, 9, 3, -8 },
  { 246, 5, 11, 9, 1, -8 },
  { 253, 8, 7, 9, 1, -8 },
  { 260, 8, 5, 9, 1, -7 },
  { 265, 8, 7, 9, 0, -8 },
  { 272, 7, 11, 9, 2, -11 },
  { 282, 8, 13, 9, 1, -11 },
  { 295, 9, 11, 9, -1, -11 },
  { 308, 9, 11, 9, 0, -11 },
  { 321, 9, 11, 9, 1, -11 },
  { 334, 9, 11, 9, 0, -11 },
  { 347, 8, 11, 9, 1, -11 },
  { 358, 9, 11, 9, 1, -11 },
  { 371, 8, 11, 9, 1, -11 },
  { 382, 10, 11, 9, 0, -11 },
  { 396, 8, 11, 9, 1, -11 },
  { 407, 8, 11, 9, 1, -11 },
  { 418, 10, 11, 9, 0, -11 },
  { 432, 7, 11, 9, 0, -11 },
  { 442, 9, 11, 9, 0, -11 },
  { 455, 10, 11, 9, 0, -11 },
  { 469, 8, 11, 9, 1, -11 },
  { 480, 9, 11, 9, 0, -11 },
  { 493, 8, 14, 9, 1, -11 },
  { 507, 9, 11, 9, 0, -11 },
  { 520, 9, 11, 9, 0, -11 },
  { 533, 8, 11, 9, 2, -11 },
  { 544, 9, 11, 9, 1, -11 },
  { 557, 8, 11, 9, 2, -11 },
  { 568, 10, 11, 9, 0, -11 },
  { 582, 10, 11, 9, 0, -11 },
  { 596, 9, 11, 9, 2, -11 },
  { 609, 10, 11, 9, 0, -11 },
  { 623, 8, 16, 9, 1, -13 },
  { 639, 3, 16, 9, 3, -13 },
  { 645, 8, 16, 9, 0, -13 },
  { 661, 7, 6, 9, 1, -11 },
  { 667, 8, 1, 9, -1, 2 },
  { 668, 3, 3, 9, 4, -12 },
  { 670, 7, 8, 9, 1, -8 },
  { 677, 7, 12, 9, 1, -12 },
  { 688, 7, 9, 9, 1, -9 },
  { 696, 9, 12, 9, 1, -12 },
  { 710, 7, 8, 9, 1, -8 },
  { 717, 10, 15, 9, 0, -12 },
  { 736, 9, 11, 9, 0, -8 },
  { 749, 8, 12, 9, 0, -12 },
  { 761, 5, 12, 9, 2, -12 },
  { 769, 8, 15, 9, 0, -12 },
  { 784, 8, 12, 9, 1, -12 },
  { 796, 4, 12, 9, 3, -12 },
  { 802, 9, 9, 9, 0, -9 },
  { 813, 7, 8, 9, 1, -8 },
  { 820, 7, 8, 9, 1, -8 },
  { 827, 8, 11, 9, 0, -8 },
  { 838, 8, 11, 9, 1, -8 },
  { 849, 8, 8, 9, 1, -8 },
  { 857, 7, 8, 9, 1, -8 },
  { 864, 6, 11, 9, 2, -11 },
  { 873, 8, 8, 9, 1, -8 },
  { 881, 7, 8, 9, 2, -8 },
  { 888, 9, 8, 9, 1, -8 },
  { 897, 9, 8, 9, 0, -8 },
  { 906, 10, 11, 9, -1, -8 },
  { 920, 8, 8, 9, 0, -8 },
  { 928, 9, 16, 9, 1, -13 },
  { 946, 5, 16, 9, 2, -13 },
  { 956, 9, 16, 9, -1, -13 },
  { 974, 8, 3, 9, 1, -6 },
};

const GFXfont UbuntuSansMono_Italic16pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Italic16pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Italic16pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _UBUNTUSANSMONO_ITALIC16PT7B_H_
